    gate_r = sigmoid((1.3634942770004272) + (-0.056222405284643173) * emb_t1_0 + (-0.90043377876281738) * emb_t1_1 + (0.14871729910373688) * emb_t1_2 + (0.81509596109390259) * emb_t1_3 + (-1.0132437944412231) * emb_t1_4 + (-1.3146908283233643) * emb_t1_5 + (-1.1923024654388428) * emb_t1_6 + (-1.0540844202041626) * emb_t1_7 + (0.28570744395256042) * emb_t1_8 + (0.64994561672210693) * emb_t1_9 + (0.32622694969177246) * emb_t1_10 + (0.41002455353736877) * emb_t1_11 + (0.39588391780853271) * emb_t1_12 + (-0.82721132040023804) * emb_t1_13 + (0.34960439801216125) * emb_t1_14 + (-0.65033972263336182) * emb_t1_15 + (0.80080020427703857) * emb_t1_16 + (-0.41169336438179016) * emb_t1_17 + (0.29242280125617981) * emb_t1_18 + (-0.74909293651580811) * emb_t1_19 + (0.35264158248901367) * emb_t1_20 + (-0.36563953757286072) * emb_t1_21 + (0.12845835089683533) * emb_t1_22 + (-0.0042146192863583565) * emb_t1_23 + (0.056114397943019867) * emb_t1_24 + (0.55274033546447754) * emb_t1_25 + (0.99801844358444214) * emb_t1_26 + (0.73413902521133423) * emb_t1_27 + (1.0847474336624146) * emb_t1_28 + (-0.87734442949295044) * emb_t1_29 + (1.007982611656189) * emb_t1_30 + (-0.5187227725982666) * emb_t1_31 + (-0.6661791205406189) * gru_0_fwd_t0_h_0 + (-0.25041276216506958) * gru_0_fwd_t0_h_1 + (-0.12346621602773666) * gru_0_fwd_t0_h_2 + (-0.79780864715576172) * gru_0_fwd_t0_h_3 + (-0.73847734928131104) * gru_0_fwd_t0_h_4 + (-0.44822749495506287) * gru_0_fwd_t0_h_5 + (0.45567899942398071) * gru_0_fwd_t0_h_6 + (-0.37372899055480957) * gru_0_fwd_t0_h_7 + (-3.5865321159362793) * gru_0_fwd_t0_h_8 + (-2.8938295841217041) * gru_0_fwd_t0_h_9 + (0.62683761119842529) * gru_0_fwd_t0_h_10 + (1.5945019721984863) * gru_0_fwd_t0_h_11 + (-0.66199398040771484) * gru_0_fwd_t0_h_12 + (-0.020994732156395912) * gru_0_fwd_t0_h_13 + (2.1936030387878418) * gru_0_fwd_t0_h_14 + (-0.13972392678260803) * gru_0_fwd_t0_h_15 + (-3.8492581844329834) * gru_0_fwd_t0_h_16 + (-5.7116146087646484) * gru_0_fwd_t0_h_17 + (-0.27653229236602783) * gru_0_fwd_t0_h_18 + (-1.1225560903549194) * gru_0_fwd_t0_h_19 + (-4.0217747688293457) * gru_0_fwd_t0_h_20 + (-1.6410280466079712) * gru_0_fwd_t0_h_21 + (-0.2692897617816925) * gru_0_fwd_t0_h_22 + (5.0880932807922363) * gru_0_fwd_t0_h_23 + (2.1827061176300049) * gru_0_fwd_t0_h_24 + (-3.0956466197967529) * gru_0_fwd_t0_h_25 + (1.6472270488739014) * gru_0_fwd_t0_h_26 + (-2.9991559982299805) * gru_0_fwd_t0_h_27 + (0.50273555517196655) * gru_0_fwd_t0_h_28 + (-1.400140643119812) * gru_0_fwd_t0_h_29 + (-0.16161012649536133) * gru_0_fwd_t0_h_30 + (2.6617364883422852) * gru_0_fwd_t0_h_31);
    gate_z = sigmoid((-0.033420410007238388) + (0.0064380182884633541) * emb_t1_0 + (-0.36172717809677124) * emb_t1_1 + (-0.0055471537634730339) * emb_t1_2 + (-0.20949901640415192) * emb_t1_3 + (-0.14390110969543457) * emb_t1_4 + (0.0017085226718336344) * emb_t1_5 + (0.19041195511817932) * emb_t1_6 + (-0.0082351481541991234) * emb_t1_7 + (0.038002565503120422) * emb_t1_8 + (0.37232178449630737) * emb_t1_9 + (0.64640152454376221) * emb_t1_10 + (0.082609288394451141) * emb_t1_11 + (0.1782267689704895) * emb_t1_12 + (-0.18052464723587036) * emb_t1_13 + (-0.017151672393083572) * emb_t1_14 + (-0.014069987460970879) * emb_t1_15 + (-0.0068942955695092678) * emb_t1_16 + (-0.031040454283356667) * emb_t1_17 + (0.25211223959922791) * emb_t1_18 + (-0.21565334498882294) * emb_t1_19 + (0.025725236162543297) * emb_t1_20 + (-0.00059418560704216361) * emb_t1_21 + (0.29571840167045593) * emb_t1_22 + (-0.0073421113193035126) * emb_t1_23 + (0.0049376604147255421) * emb_t1_24 + (-0.022504758089780807) * emb_t1_25 + (0.13833615183830261) * emb_t1_26 + (-0.0049349567852914333) * emb_t1_27 + (0.08759000152349472) * emb_t1_28 + (0.12952020764350891) * emb_t1_29 + (-0.11354436725378036) * emb_t1_30 + (0.35968726873397827) * emb_t1_31 + (-0.5234827995300293) * gru_0_fwd_t0_h_0 + (-0.75930380821228027) * gru_0_fwd_t0_h_1 + (0.23536282777786255) * gru_0_fwd_t0_h_2 + (-0.20003423094749451) * gru_0_fwd_t0_h_3 + (-0.89727324247360229) * gru_0_fwd_t0_h_4 + (0.19947317242622375) * gru_0_fwd_t0_h_5 + (-0.55144459009170532) * gru_0_fwd_t0_h_6 + (-0.19658015668392181) * gru_0_fwd_t0_h_7 + (-0.11698223650455475) * gru_0_fwd_t0_h_8 + (-0.082482509315013885) * gru_0_fwd_t0_h_9 + (-0.3781915009021759) * gru_0_fwd_t0_h_10 + (-0.81994861364364624) * gru_0_fwd_t0_h_11 + (0.97556012868881226) * gru_0_fwd_t0_h_12 + (0.86488986015319824) * gru_0_fwd_t0_h_13 + (0.070089027285575867) * gru_0_fwd_t0_h_14 + (0.99436193704605103) * gru_0_fwd_t0_h_15 + (0.3084876537322998) * gru_0_fwd_t0_h_16 + (0.20581619441509247) * gru_0_fwd_t0_h_17 + (-0.86727488040924072) * gru_0_fwd_t0_h_18 + (-0.10319950431585312) * gru_0_fwd_t0_h_19 + (0.32673987746238708) * gru_0_fwd_t0_h_20 + (-0.25143009424209595) * gru_0_fwd_t0_h_21 + (0.5033947229385376) * gru_0_fwd_t0_h_22 + (-0.22281058132648468) * gru_0_fwd_t0_h_23 + (0.56214594841003418) * gru_0_fwd_t0_h_24 + (0.12110262364149094) * gru_0_fwd_t0_h_25 + (-0.01768973283469677) * gru_0_fwd_t0_h_26 + (1.0673447847366333) * gru_0_fwd_t0_h_27 + (-1.3145279884338379) * gru_0_fwd_t0_h_28 + (-0.048735242336988449) * gru_0_fwd_t0_h_29 + (-0.034720852971076965) * gru_0_fwd_t0_h_30 + (-0.99321061372756958) * gru_0_fwd_t0_h_31);
    gate_n = tanh((0.40442636609077454) + (0.059626400470733643) * emb_t1_0 + (-0.097424276173114777) * emb_t1_1 + (0.0076822992414236069) * emb_t1_2 + (0.086698137223720551) * emb_t1_3 + (-0.47075149416923523) * emb_t1_4 + (-0.033074695616960526) * emb_t1_5 + (-0.16545090079307556) * emb_t1_6 + (-0.021484445780515671) * emb_t1_7 + (0.3537864089012146) * emb_t1_8 + (-0.082181729376316071) * emb_t1_9 + (-0.10835350304841995) * emb_t1_10 + (0.2522473931312561) * emb_t1_11 + (0.4435955286026001) * emb_t1_12 + (-0.22137553989887238) * emb_t1_13 + (-0.021348340436816216) * emb_t1_14 + (0.051935482770204544) * emb_t1_15 + (0.022021180018782616) * emb_t1_16 + (-0.23186801373958588) * emb_t1_17 + (-0.6292957067489624) * emb_t1_18 + (-0.1941601037979126) * emb_t1_19 + (0.23594163358211517) * emb_t1_20 + (-0.008351876400411129) * emb_t1_21 + (-0.42310482263565063) * emb_t1_22 + (-0.0052936812862753868) * emb_t1_23 + (-0.0021497618872672319) * emb_t1_24 + (-0.021310068666934967) * emb_t1_25 + (0.14420174062252045) * emb_t1_26 + (0.024472739547491074) * emb_t1_27 + (-0.20820614695549011) * emb_t1_28 + (0.0054779555648565292) * emb_t1_29 + (-0.019656142219901085) * emb_t1_30 + (-0.60367149114608765) * emb_t1_31 + gate_r * ((0.66925060749053955) + (-0.27853310108184814) * gru_0_fwd_t0_h_0 + (-0.10380613058805466) * gru_0_fwd_t0_h_1 + (-0.0054271132685244083) * gru_0_fwd_t0_h_2 + (0.27972781658172607) * gru_0_fwd_t0_h_3 + (-0.060516022145748138) * gru_0_fwd_t0_h_4 + (0.063562795519828796) * gru_0_fwd_t0_h_5 + (0.61955720186233521) * gru_0_fwd_t0_h_6 + (0.016443360596895218) * gru_0_fwd_t0_h_7 + (0.097532466053962708) * gru_0_fwd_t0_h_8 + (-0.25765687227249146) * gru_0_fwd_t0_h_9 + (0.39379838109016418) * gru_0_fwd_t0_h_10 + (-0.36339232325553894) * gru_0_fwd_t0_h_11 + (0.18765503168106079) * gru_0_fwd_t0_h_12 + (0.21706663072109222) * gru_0_fwd_t0_h_13 + (-0.27371245622634888) * gru_0_fwd_t0_h_14 + (0.096289582550525665) * gru_0_fwd_t0_h_15 + (0.14562420547008514) * gru_0_fwd_t0_h_16 + (0.29114526510238647) * gru_0_fwd_t0_h_17 + (-0.1404486745595932) * gru_0_fwd_t0_h_18 + (2.7993574142456055) * gru_0_fwd_t0_h_19 + (-1.0938600301742554) * gru_0_fwd_t0_h_20 + (0.015156141482293606) * gru_0_fwd_t0_h_21 + (-0.4472515881061554) * gru_0_fwd_t0_h_22 + (0.071304410696029663) * gru_0_fwd_t0_h_23 + (-0.23107630014419556) * gru_0_fwd_t0_h_24 + (0.023721644654870033) * gru_0_fwd_t0_h_25 + (0.026057315990328789) * gru_0_fwd_t0_h_26 + (-0.0056411502882838249) * gru_0_fwd_t0_h_27 + (-0.30286586284637451) * gru_0_fwd_t0_h_28 + (0.17545744776725769) * gru_0_fwd_t0_h_29 + (-0.18913552165031433) * gru_0_fwd_t0_h_30 + (1.0454243421554565) * gru_0_fwd_t0_h_31));
    gru_0_fwd_t1_h_27 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t0_h_27;
    // h=28
    gate_r = sigmoid((-1.292569637298584) + (0.053969614207744598) * emb_t1_0 + (0.84029549360275269) * emb_t1_1 + (-1.751328706741333) * emb_t1_2 + (-0.44191840291023254) * emb_t1_3 + (0.54275029897689819) * emb_t1_4 + (0.28760188817977905) * emb_t1_5 + (0.65396994352340698) * emb_t1_6 + (0.88202369213104248) * emb_t1_7 + (-0.63079744577407837) * emb_t1_8 + (-0.62787461280822754) * emb_t1_9 + (-0.019234701991081238) * emb_t1_10 + (-0.53413426876068115) * emb_t1_11 + (-0.34742468595504761) * emb_t1_12 + (0.73544913530349731) * emb_t1_13 + (-0.50395351648330688) * emb_t1_14 + (1.5419316291809082) * emb_t1_15 + (-0.53303635120391846) * emb_t1_16 + (0.90656989812850952) * emb_t1_17 + (-0.47902229428291321) * emb_t1_18 + (-0.19090864062309265) * emb_t1_19 + (-0.17996221780776978) * emb_t1_20 + (0.40649709105491638) * emb_t1_21 + (0.60855847597122192) * emb_t1_22 + (0.67197114229202271) * emb_t1_23 + (-0.062262497842311859) * emb_t1_24 + (0.05978093296289444) * emb_t1_25 + (-0.56690949201583862) * emb_t1_26 + (-0.24178600311279297) * emb_t1_27 + (-0.81900542974472046) * emb_t1_28 + (0.97798550128936768) * emb_t1_29 + (-0.14322385191917419) * emb_t1_30 + (0.608226478099823) * emb_t1_31 + (0.025221085175871849) * gru_0_fwd_t0_h_0 + (0.049941185861825943) * gru_0_fwd_t0_h_1 + (0.088683575391769409) * gru_0_fwd_t0_h_2 + (-0.38951092958450317) * gru_0_fwd_t0_h_3 + (0.53304773569107056) * gru_0_fwd_t0_h_4 + (1.048098087310791) * gru_0_fwd_t0_h_5 + (-1.0918179750442505) * gru_0_fwd_t0_h_6 + (-0.5610041618347168) * gru_0_fwd_t0_h_7 + (0.68512958288192749) * gru_0_fwd_t0_h_8 + (0.18700028955936432) * gru_0_fwd_t0_h_9 + (0.092129983007907867) * gru_0_fwd_t0_h_10 + (0.065248891711235046) * gru_0_fwd_t0_h_11 + (-0.0082201473414897919) * gru_0_fwd_t0_h_12 + (-0.27918216586112976) * gru_0_fwd_t0_h_13 + (-1.161197304725647) * gru_0_fwd_t0_h_14 + (0.23061954975128174) * gru_0_fwd_t0_h_15 + (0.88139182329177856) * gru_0_fwd_t0_h_16 + (0.13258109986782074) * gru_0_fwd_t0_h_17 + (-0.15281245112419128) * gru_0_fwd_t0_h_18 + (-0.55834925174713135) * gru_0_fwd_t0_h_19 + (-0.20168487727642059) * gru_0_fwd_t0_h_20 + (0.84790438413619995) * gru_0_fwd_t0_h_21 + (0.30727106332778931) * gru_0_fwd_t0_h_22 + (-0.20956370234489441) * gru_0_fwd_t0_h_23 + (-0.33019140362739563) * gru_0_fwd_t0_h_24 + (0.035808708518743515) * gru_0_fwd_t0_h_25 + (-0.012295838445425034) * gru_0_fwd_t0_h_26 + (-0.10886805504560471) * gru_0_fwd_t0_h_27 + (0.43562328815460205) * gru_0_fwd_t0_h_28 + (-0.12479058653116226) * gru_0_fwd_t0_h_29 + (-0.44247058033943176) * gru_0_fwd_t0_h_30 + (1.023451566696167) * gru_0_fwd_t0_h_31);
    gate_z = sigmoid((0.80183142423629761) + (0.037749048322439194) * emb_t1_0 + (-1.3777821063995361) * emb_t1_1 + (-0.3930060863494873) * emb_t1_2 + (0.38262185454368591) * emb_t1_3 + (-1.0268763303756714) * emb_t1_4 + (-0.44091349840164185) * emb_t1_5 + (-1.0418828725814819) * emb_t1_6 + (0.2112157940864563) * emb_t1_7 + (0.13275355100631714) * emb_t1_8 + (0.42874050140380859) * emb_t1_9 + (0.42819133400917053) * emb_t1_10 + (0.4522298276424408) * emb_t1_11 + (0.3910057544708252) * emb_t1_12 + (-1.7797743082046509) * emb_t1_13 + (0.062521956861019135) * emb_t1_14 + (-0.2064393013715744) * emb_t1_15 + (0.32217961549758911) * emb_t1_16 + (-0.88105738162994385) * emb_t1_17 + (0.073882870376110077) * emb_t1_18 + (-0.11560744792222977) * emb_t1_19 + (0.94725418090820312) * emb_t1_20 + (-0.16107381880283356) * emb_t1_21 + (-0.093473196029663086) * emb_t1_22 + (1.3574447631835938) * emb_t1_23 + (0.48626694083213806) * emb_t1_24 + (0.70945572853088379) * emb_t1_25 + (1.0981122255325317) * emb_t1_26 + (0.72538602352142334) * emb_t1_27 + (1.787631630897522) * emb_t1_28 + (-2.3084738254547119) * emb_t1_29 + (1.2363383769989014) * emb_t1_30 + (0.22205078601837158) * emb_t1_31 + (0.36775466799736023) * gru_0_fwd_t0_h_0 + (0.22176246345043182) * gru_0_fwd_t0_h_1 + (-0.44520357251167297) * gru_0_fwd_t0_h_2 + (0.044741537421941757) * gru_0_fwd_t0_h_3 + (0.58238863945007324) * gru_0_fwd_t0_h_4 + (-0.94655632972717285) * gru_0_fwd_t0_h_5 + (0.74089521169662476) * gru_0_fwd_t0_h_6 + (1.0737566947937012) * gru_0_fwd_t0_h_7 + (-0.71389651298522949) * gru_0_fwd_t0_h_8 + (0.37089678645133972) * gru_0_fwd_t0_h_9 + (0.44034215807914734) * gru_0_fwd_t0_h_10 + (0.48689711093902588) * gru_0_fwd_t0_h_11 + (0.35777571797370911) * gru_0_fwd_t0_h_12 + (0.40952318906784058) * gru_0_fwd_t0_h_13 + (0.32340788841247559) * gru_0_fwd_t0_h_14 + (-0.26525449752807617) * gru_0_fwd_t0_h_15 + (-1.1085613965988159) * gru_0_fwd_t0_h_16 + (-0.73834836483001709) * gru_0_fwd_t0_h_17 + (-0.26148673892021179) * gru_0_fwd_t0_h_18 + (-1.0798720121383667) * gru_0_fwd_t0_h_19 + (0.044556822627782822) * gru_0_fwd_t0_h_20 + (-1.1963039636611938) * gru_0_fwd_t0_h_21 + (-0.8264126181602478) * gru_0_fwd_t0_h_22 + (0.77406275272369385) * gru_0_fwd_t0_h_23 + (0.012892594560980797) * gru_0_fwd_t0_h_24 + (0.50934898853302002) * gru_0_fwd_t0_h_25 + (0.36857566237449646) * gru_0_fwd_t0_h_26 + (-0.47647750377655029) * gru_0_fwd_t0_h_27 + (-0.34616562724113464) * gru_0_fwd_t0_h_28 + (0.038031734526157379) * gru_0_fwd_t0_h_29 + (0.50173258781433105) * gru_0_fwd_t0_h_30 + (-1.8020660877227783) * gru_0_fwd_t0_h_31);
    gate_n = tanh((-0.057754348963499069) + (0.23920117318630219) * emb_t1_0 + (-2.5100808143615723) * emb_t1_1 + (0.46204259991645813) * emb_t1_2 + (-0.029308877885341644) * emb_t1_3 + (-0.43936541676521301) * emb_t1_4 + (0.99328601360321045) * emb_t1_5 + (-0.76978802680969238) * emb_t1_6 + (0.52340561151504517) * emb_t1_7 + (-0.17568124830722809) * emb_t1_8 + (1.6829434633255005) * emb_t1_9 + (0.97307509183883667) * emb_t1_10 + (-0.12742845714092255) * emb_t1_11 + (-0.22464659810066223) * emb_t1_12 + (-1.2527275085449219) * emb_t1_13 + (-0.4431215226650238) * emb_t1_14 + (-0.88653063774108887) * emb_t1_15 + (0.11366888135671616) * emb_t1_16 + (0.15872882306575775) * emb_t1_17 + (0.67116409540176392) * emb_t1_18 + (-1.0426526069641113) * emb_t1_19 + (-0.076840460300445557) * emb_t1_20 + (0.33484953641891479) * emb_t1_21 + (0.25041815638542175) * emb_t1_22 + (-0.84799081087112427) * emb_t1_23 + (-0.011975551024079323) * emb_t1_24 + (-0.47233113646507263) * emb_t1_25 + (-0.2212168425321579) * emb_t1_26 + (0.047423329204320908) * emb_t1_27 + (2.3713116645812988) * emb_t1_28 + (-1.3745518922805786) * emb_t1_29 + (0.42232599854469299) * emb_t1_30 + (0.56859183311462402) * emb_t1_31 + gate_r * ((-0.098516441881656647) + (-0.23088675737380981) * gru_0_fwd_t0_h_0 + (-0.68228960037231445) * gru_0_fwd_t0_h_1 + (0.37348487973213196) * gru_0_fwd_t0_h_2 + (-1.6243604421615601) * gru_0_fwd_t0_h_3 + (-1.1399021148681641) * gru_0_fwd_t0_h_4 + (-0.8140413761138916) * gru_0_fwd_t0_h_5 + (0.43853938579559326) * gru_0_fwd_t0_h_6 + (-0.11266043782234192) * gru_0_fwd_t0_h_7 + (-0.41289544105529785) * gru_0_fwd_t0_h_8 + (0.14110228419303894) * gru_0_fwd_t0_h_9 + (-0.43223839998245239) * gru_0_fwd_t0_h_10 + (0.055673964321613312) * gru_0_fwd_t0_h_11 + (-0.72240167856216431) * gru_0_fwd_t0_h_12 + (0.63826394081115723) * gru_0_fwd_t0_h_13 + (1.0867960453033447) * gru_0_fwd_t0_h_14 + (-0.92242056131362915) * gru_0_fwd_t0_h_15 + (-0.3301178514957428) * gru_0_fwd_t0_h_16 + (-0.27486145496368408) * gru_0_fwd_t0_h_17 + (-1.1910151243209839) * gru_0_fwd_t0_h_18 + (0.32932460308074951) * gru_0_fwd_t0_h_19 + (-0.14576353132724762) * gru_0_fwd_t0_h_20 + (-0.34404507279396057) * gru_0_fwd_t0_h_21 + (0.13158722221851349) * gru_0_fwd_t0_h_22 + (0.23220203816890717) * gru_0_fwd_t0_h_23 + (0.045593172311782837) * gru_0_fwd_t0_h_24 + (-0.058448214083909988) * gru_0_fwd_t0_h_25 + (-0.43583637475967407) * gru_0_fwd_t0_h_26 + (-0.3931058943271637) * gru_0_fwd_t0_h_27 + (-0.068734019994735718) * gru_0_fwd_t0_h_28 + (-0.30712255835533142) * gru_0_fwd_t0_h_29 + (-0.17921477556228638) * gru_0_fwd_t0_h_30 + (-0.75506126880645752) * gru_0_fwd_t0_h_31));
    gru_0_fwd_t1_h_28 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t0_h_28;
    // h=29
    gate_r = sigmoid((-2.7073235511779785) + (-0.94925135374069214) * emb_t1_0 + (0.47642731666564941) * emb_t1_1 + (-0.89598292112350464) * emb_t1_2 + (-1.2521011829376221) * emb_t1_3 + (0.97779101133346558) * emb_t1_4 + (0.94753819704055786) * emb_t1_5 + (1.122064471244812) * emb_t1_6 + (1.3330873250961304) * emb_t1_7 + (-1.1404660940170288) * emb_t1_8 + (0.90771013498306274) * emb_t1_9 + (1.3533643484115601) * emb_t1_10 + (-0.93836623430252075) * emb_t1_11 + (-1.4471783638000488) * emb_t1_12 + (0.81418299674987793) * emb_t1_13 + (0.43665635585784912) * emb_t1_14 + (0.64093393087387085) * emb_t1_15 + (-1.0563971996307373) * emb_t1_16 + (1.2846221923828125) * emb_t1_17 + (1.2511874437332153) * emb_t1_18 + (-1.3642784357070923) * emb_t1_19 + (-1.1827380657196045) * emb_t1_20 + (0.91577178239822388) * emb_t1_21 + (1.0097044706344604) * emb_t1_22 + (-0.61382186412811279) * emb_t1_23 + (0.41742041707038879) * emb_t1_24 + (0.55784028768539429) * emb_t1_25 + (-1.0337615013122559) * emb_t1_26 + (-0.84527939558029175) * emb_t1_27 + (-0.32469251751899719) * emb_t1_28 + (0.66467571258544922) * emb_t1_29 + (-1.0546854734420776) * emb_t1_30 + (1.537489652633667) * emb_t1_31 + (-0.80361813306808472) * gru_0_fwd_t0_h_0 + (-0.57504624128341675) * gru_0_fwd_t0_h_1 + (-2.2439088821411133) * gru_0_fwd_t0_h_2 + (-0.28392288088798523) * gru_0_fwd_t0_h_3 + (-1.0859048366546631) * gru_0_fwd_t0_h_4 + (-0.41850793361663818) * gru_0_fwd_t0_h_5 + (0.48004212975502014) * gru_0_fwd_t0_h_6 + (0.17141380906105042) * gru_0_fwd_t0_h_7 + (0.12205420434474945) * gru_0_fwd_t0_h_8 + (-0.79070055484771729) * gru_0_fwd_t0_h_9 + (1.8991626501083374) * gru_0_fwd_t0_h_10 + (0.24836893379688263) * gru_0_fwd_t0_h_11 + (0.46768170595169067) * gru_0_fwd_t0_h_12 + (0.91601681709289551) * gru_0_fwd_t0_h_13 + (-1.7057197093963623) * gru_0_fwd_t0_h_14 + (-0.062965147197246552) * gru_0_fwd_t0_h_15 + (0.52966642379760742) * gru_0_fwd_t0_h_16 + (0.049649883061647415) * gru_0_fwd_t0_h_17 + (-0.25261175632476807) * gru_0_fwd_t0_h_18 + (-0.76427584886550903) * gru_0_fwd_t0_h_19 + (-1.0443379878997803) * gru_0_fwd_t0_h_20 + (1.242803692817688) * gru_0_fwd_t0_h_21 + (0.17352627217769623) * gru_0_fwd_t0_h_22 + (0.19701914489269257) * gru_0_fwd_t0_h_23 + (1.2348150014877319) * gru_0_fwd_t0_h_24 + (0.35278141498565674) * gru_0_fwd_t0_h_25 + (-0.08996235579252243) * gru_0_fwd_t0_h_26 + (-0.44341492652893066) * gru_0_fwd_t0_h_27 + (0.65234887599945068) * gru_0_fwd_t0_h_28 + (-0.8684159517288208) * gru_0_fwd_t0_h_29 + (-1.4730590581893921) * gru_0_fwd_t0_h_30 + (-0.046284548938274384) * gru_0_fwd_t0_h_31);
    gate_z = sigmoid((-0.056443262845277786) + (-0.03196324035525322) * emb_t1_0 + (-0.0229691993445158) * emb_t1_1 + (-0.18045066297054291) * emb_t1_2 + (0.27553969621658325) * emb_t1_3 + (-0.10216351598501205) * emb_t1_4 + (-0.25471451878547668) * emb_t1_5 + (-0.84951281547546387) * emb_t1_6 + (-0.032789483666419983) * emb_t1_7 + (-0.27887484431266785) * emb_t1_8 + (0.41600000858306885) * emb_t1_9 + (0.89267796277999878) * emb_t1_10 + (0.23763236403465271) * emb_t1_11 + (-0.062552072107791901) * emb_t1_12 + (-0.70800107717514038) * emb_t1_13 + (-0.067132025957107544) * emb_t1_14 + (0.14265495538711548) * emb_t1_15 + (0.067372404038906097) * emb_t1_16 + (-0.25397962331771851) * emb_t1_17 + (0.62374836206436157) * emb_t1_18 + (-0.6575474739074707) * emb_t1_19 + (-0.10580789297819138) * emb_t1_20 + (0.065436460077762604) * emb_t1_21 + (0.32486039400100708) * emb_t1_22 + (-0.075660750269889832) * emb_t1_23 + (0.1511588841676712) * emb_t1_24 + (0.074822284281253815) * emb_t1_25 + (-0.10156043618917465) * emb_t1_26 + (-0.12224345654249191) * emb_t1_27 + (0.39430534839630127) * emb_t1_28 + (-0.47580116987228394) * emb_t1_29 + (0.27572977542877197) * emb_t1_30 + (0.33399310708045959) * emb_t1_31 + (-0.36428603529930115) * gru_0_fwd_t0_h_0 + (-0.97782361507415771) * gru_0_fwd_t0_h_1 + (-0.57410454750061035) * gru_0_fwd_t0_h_2 + (0.6566736102104187) * gru_0_fwd_t0_h_3 + (-1.2112106084823608) * gru_0_fwd_t0_h_4 + (0.41262859106063843) * gru_0_fwd_t0_h_5 + (1.0171276330947876) * gru_0_fwd_t0_h_6 + (0.68784201145172119) * gru_0_fwd_t0_h_7 + (-0.81705474853515625) * gru_0_fwd_t0_h_8 + (-0.89226329326629639) * gru_0_fwd_t0_h_9 + (0.55755019187927246) * gru_0_fwd_t0_h_10 + (-0.44155105948448181) * gru_0_fwd_t0_h_11 + (1.1925638914108276) * gru_0_fwd_t0_h_12 + (1.0589302778244019) * gru_0_fwd_t0_h_13 + (0.049674276262521744) * gru_0_fwd_t0_h_14 + (1.0742425918579102) * gru_0_fwd_t0_h_15 + (-0.2486003190279007) * gru_0_fwd_t0_h_16 + (-0.19188736379146576) * gru_0_fwd_t0_h_17 + (-0.25937572121620178) * gru_0_fwd_t0_h_18 + (-0.50415164232254028) * gru_0_fwd_t0_h_19 + (-1.4578251838684082) * gru_0_fwd_t0_h_20 + (-1.1739803552627563) * gru_0_fwd_t0_h_21 + (-0.016172729432582855) * gru_0_fwd_t0_h_22 + (0.93428677320480347) * gru_0_fwd_t0_h_23 + (-1.0509359836578369) * gru_0_fwd_t0_h_24 + (0.62188982963562012) * gru_0_fwd_t0_h_25 + (-0.52237957715988159) * gru_0_fwd_t0_h_26 + (-0.53212374448776245) * gru_0_fwd_t0_h_27 + (1.122877836227417) * gru_0_fwd_t0_h_28 + (-0.63721579313278198) * gru_0_fwd_t0_h_29 + (-0.45199927687644958) * gru_0_fwd_t0_h_30 + (0.63762730360031128) * gru_0_fwd_t0_h_31);
    gate_n = tanh((0.0026651120278984308) + (-0.0007670973427593708) * emb_t1_0 + (0.30098393559455872) * emb_t1_1 + (-0.0033250201959162951) * emb_t1_2 + (-0.071036316454410553) * emb_t1_3 + (-0.26820725202560425) * emb_t1_4 + (0.019483672454953194) * emb_t1_5 + (0.12064753472805023) * emb_t1_6 + (-0.0051138438284397125) * emb_t1_7 + (0.17796516418457031) * emb_t1_8 + (-1.4751404523849487) * emb_t1_9 + (-0.99466776847839355) * emb_t1_10 + (-0.017730532214045525) * emb_t1_11 + (0.12764541804790497) * emb_t1_12 + (0.42036482691764832) * emb_t1_13 + (0.0020732586272060871) * emb_t1_14 + (0.011034803465008736) * emb_t1_15 + (0.0069487877190113068) * emb_t1_16 + (0.24754548072814941) * emb_t1_17 + (-0.69944238662719727) * emb_t1_18 + (0.25500887632369995) * emb_t1_19 + (-0.18170234560966492) * emb_t1_20 + (0.004214264452457428) * emb_t1_21 + (-0.22800268232822418) * emb_t1_22 + (-0.017809022217988968) * emb_t1_23 + (0.0039610196836292744) * emb_t1_24 + (0.00044058103230781853) * emb_t1_25 + (0.0024200116749852896) * emb_t1_26 + (-0.003990312572568655) * emb_t1_27 + (0.075013726949691772) * emb_t1_28 + (0.53727042675018311) * emb_t1_29 + (-0.13611550629138947) * emb_t1_30 + (0.19305303692817688) * emb_t1_31 + gate_r * ((0.25899869203567505) + (0.16288661956787109) * gru_0_fwd_t0_h_0 + (-0.35113167762756348) * gru_0_fwd_t0_h_1 + (-0.18958817422389984) * gru_0_fwd_t0_h_2 + (0.94292402267456055) * gru_0_fwd_t0_h_3 + (0.23965242505073547) * gru_0_fwd_t0_h_4 + (0.45363539457321167) * gru_0_fwd_t0_h_5 + (1.3372179269790649) * gru_0_fwd_t0_h_6 + (-0.12373480945825577) * gru_0_fwd_t0_h_7 + (-0.97690945863723755) * gru_0_fwd_t0_h_8 + (-0.55289578437805176) * gru_0_fwd_t0_h_9 + (0.34432458877563477) * gru_0_fwd_t0_h_10 + (-0.23434913158416748) * gru_0_fwd_t0_h_11 + (0.48187974095344543) * gru_0_fwd_t0_h_12 + (-0.27376341819763184) * gru_0_fwd_t0_h_13 + (-0.0036491365171968937) * gru_0_fwd_t0_h_14 + (0.022629210725426674) * gru_0_fwd_t0_h_15 + (-0.056529335677623749) * gru_0_fwd_t0_h_16 + (-0.22381070256233215) * gru_0_fwd_t0_h_17 + (0.40684634447097778) * gru_0_fwd_t0_h_18 + (0.50929147005081177) * gru_0_fwd_t0_h_19 + (-0.63804280757904053) * gru_0_fwd_t0_h_20 + (-0.69697868824005127) * gru_0_fwd_t0_h_21 + (0.19814963638782501) * gru_0_fwd_t0_h_22 + (0.24296677112579346) * gru_0_fwd_t0_h_23 + (-0.19607749581336975) * gru_0_fwd_t0_h_24 + (0.084557957947254181) * gru_0_fwd_t0_h_25 + (0.034659907221794128) * gru_0_fwd_t0_h_26 + (0.25299382209777832) * gru_0_fwd_t0_h_27 + (0.20477312803268433) * gru_0_fwd_t0_h_28 + (0.53523534536361694) * gru_0_fwd_t0_h_29 + (0.44081112742424011) * gru_0_fwd_t0_h_30 + (0.21616044640541077) * gru_0_fwd_t0_h_31));
    gru_0_fwd_t1_h_29 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t0_h_29;
    // h=30
    gate_r = sigmoid((-0.60926437377929688) + (-0.1737588495016098) * emb_t1_0 + (0.38025620579719543) * emb_t1_1 + (-0.23901283740997314) * emb_t1_2 + (0.14169171452522278) * emb_t1_3 + (0.3176858127117157) * emb_t1_4 + (0.54151701927185059) * emb_t1_5 + (0.0081971064209938049) * emb_t1_6 + (0.46974891424179077) * emb_t1_7 + (-0.13857337832450867) * emb_t1_8 + (0.36790543794631958) * emb_t1_9 + (-0.24031583964824677) * emb_t1_10 + (-0.1045849546790123) * emb_t1_11 + (-0.2426922470331192) * emb_t1_12 + (0.53255182504653931) * emb_t1_13 + (0.32064676284790039) * emb_t1_14 + (0.14229309558868408) * emb_t1_15 + (-0.67697983980178833) * emb_t1_16 + (0.34046971797943115) * emb_t1_17 + (0.57716649770736694) * emb_t1_18 + (-0.62413954734802246) * emb_t1_19 + (-0.75847715139389038) * emb_t1_20 + (0.26862534880638123) * emb_t1_21 + (0.46359333395957947) * emb_t1_22 + (-0.16749709844589233) * emb_t1_23 + (0.085932508111000061) * emb_t1_24 + (-0.041258085519075394) * emb_t1_25 + (-0.85725200176239014) * emb_t1_26 + (-0.67194253206253052) * emb_t1_27 + (-0.34857276082038879) * emb_t1_28 + (0.48101553320884705) * emb_t1_29 + (-0.35512596368789673) * emb_t1_30 + (0.039552904665470123) * emb_t1_31 + (-0.00027722973027266562) * gru_0_fwd_t0_h_0 + (0.13967601954936981) * gru_0_fwd_t0_h_1 + (-0.076582960784435272) * gru_0_fwd_t0_h_2 + (-0.031882289797067642) * gru_0_fwd_t0_h_3 + (-0.22067312896251678) * gru_0_fwd_t0_h_4 + (-0.15091697871685028) * gru_0_fwd_t0_h_5 + (-0.21777372062206268) * gru_0_fwd_t0_h_6 + (0.22374427318572998) * gru_0_fwd_t0_h_7 + (0.24008607864379883) * gru_0_fwd_t0_h_8 + (0.11101856082677841) * gru_0_fwd_t0_h_9 + (0.38299888372421265) * gru_0_fwd_t0_h_10 + (-0.074292056262493134) * gru_0_fwd_t0_h_11 + (-0.14499440789222717) * gru_0_fwd_t0_h_12 + (-0.28087863326072693) * gru_0_fwd_t0_h_13 + (-0.29889938235282898) * gru_0_fwd_t0_h_14 + (-0.049163069576025009) * gru_0_fwd_t0_h_15 + (0.60885560512542725) * gru_0_fwd_t0_h_16 + (-0.017051950097084045) * gru_0_fwd_t0_h_17 + (-0.29631364345550537) * gru_0_fwd_t0_h_18 + (-0.15292312204837799) * gru_0_fwd_t0_h_19 + (0.16586235165596008) * gru_0_fwd_t0_h_20 + (0.73832559585571289) * gru_0_fwd_t0_h_21 + (0.10271792113780975) * gru_0_fwd_t0_h_22 + (-0.25901055335998535) * gru_0_fwd_t0_h_23 + (-0.15158264338970184) * gru_0_fwd_t0_h_24 + (0.010116232559084892) * gru_0_fwd_t0_h_25 + (-0.15553593635559082) * gru_0_fwd_t0_h_26 + (0.14589026570320129) * gru_0_fwd_t0_h_27 + (0.015231951139867306) * gru_0_fwd_t0_h_28 + (0.11976413428783417) * gru_0_fwd_t0_h_29 + (-0.171246737241745) * gru_0_fwd_t0_h_30 + (-0.16328799724578857) * gru_0_fwd_t0_h_31);
    gate_z = sigmoid((3.5595059394836426) + (-0.11819758266210556) * emb_t1_0 + (0.46444812417030334) * emb_t1_1 + (0.099807538092136383) * emb_t1_2 + (1.3323699235916138) * emb_t1_3 + (0.063966400921344757) * emb_t1_4 + (-0.04518963024020195) * emb_t1_5 + (0.0052352412603795528) * emb_t1_6 + (-0.71445292234420776) * emb_t1_7 + (13.063044548034668) * emb_t1_8 + (-1.0494433641433716) * emb_t1_9 + (-1.3069334030151367) * emb_t1_10 + (2.086686372756958) * emb_t1_11 + (15.495023727416992) * emb_t1_12 + (0.13620203733444214) * emb_t1_13 + (0.10010219365358353) * emb_t1_14 + (0.039625681936740875) * emb_t1_15 + (0.29575812816619873) * emb_t1_16 + (-0.21675293147563934) * emb_t1_17 + (-1.9148987531661987) * emb_t1_18 + (1.6983498334884644) * emb_t1_19 + (0.72538363933563232) * emb_t1_20 + (-0.058488767594099045) * emb_t1_21 + (-3.0187828540802002) * emb_t1_22 + (-0.043490733951330185) * emb_t1_23 + (0.18401242792606354) * emb_t1_24 + (0.0079329926520586014) * emb_t1_25 + (0.3969980776309967) * emb_t1_26 + (0.10597033798694611) * emb_t1_27 + (-0.39887553453445435) * emb_t1_28 + (0.24764560163021088) * emb_t1_29 + (0.010339950211346149) * emb_t1_30 + (-26.064796447753906) * emb_t1_31 + (-0.03930971771478653) * gru_0_fwd_t0_h_0 + (-0.063254229724407196) * gru_0_fwd_t0_h_1 + (-0.17143750190734863) * gru_0_fwd_t0_h_2 + (-0.22121824324131012) * gru_0_fwd_t0_h_3 + (0.081121601164340973) * gru_0_fwd_t0_h_4 + (-0.17711508274078369) * gru_0_fwd_t0_h_5 + (0.053732555359601974) * gru_0_fwd_t0_h_6 + (-0.013868593610823154) * gru_0_fwd_t0_h_7 + (-0.21183019876480103) * gru_0_fwd_t0_h_8 + (-0.079803653061389923) * gru_0_fwd_t0_h_9 + (0.13144606351852417) * gru_0_fwd_t0_h_10 + (0.27198252081871033) * gru_0_fwd_t0_h_11 + (-0.26403969526290894) * gru_0_fwd_t0_h_12 + (0.09865175187587738) * gru_0_fwd_t0_h_13 + (-0.16335944831371307) * gru_0_fwd_t0_h_14 + (0.13145570456981659) * gru_0_fwd_t0_h_15 + (0.0071426434442400932) * gru_0_fwd_t0_h_16 + (-0.073695704340934753) * gru_0_fwd_t0_h_17 + (-0.04787876084446907) * gru_0_fwd_t0_h_18 + (-0.12485899031162262) * gru_0_fwd_t0_h_19 + (-0.0693960040807724) * gru_0_fwd_t0_h_20 + (-0.10138034075498581) * gru_0_fwd_t0_h_21 + (0.38854435086250305) * gru_0_fwd_t0_h_22 + (-0.085076592862606049) * gru_0_fwd_t0_h_23 + (-0.20835670828819275) * gru_0_fwd_t0_h_24 + (0.11841475963592529) * gru_0_fwd_t0_h_25 + (-0.21061988174915314) * gru_0_fwd_t0_h_26 + (-0.40929943323135376) * gru_0_fwd_t0_h_27 + (0.25362920761108398) * gru_0_fwd_t0_h_28 + (-0.31492403149604797) * gru_0_fwd_t0_h_29 + (-0.18786926567554474) * gru_0_fwd_t0_h_30 + (-0.36842077970504761) * gru_0_fwd_t0_h_31);
    gate_n = tanh((-0.08687765896320343) + (0.16526171565055847) * emb_t1_0 + (-0.32881477475166321) * emb_t1_1 + (0.27678346633911133) * emb_t1_2 + (0.027460221201181412) * emb_t1_3 + (-0.44662627577781677) * emb_t1_4 + (0.064712986350059509) * emb_t1_5 + (-0.75604557991027832) * emb_t1_6 + (0.64118564128875732) * emb_t1_7 + (-1.3876652717590332) * emb_t1_8 + (0.39513736963272095) * emb_t1_9 + (0.78433924913406372) * emb_t1_10 + (-0.50290870666503906) * emb_t1_11 + (-1.2582765817642212) * emb_t1_12 + (-0.48526936769485474) * emb_t1_13 + (-0.14105387032032013) * emb_t1_14 + (0.23871798813343048) * emb_t1_15 + (0.16358593106269836) * emb_t1_16 + (-0.46926319599151611) * emb_t1_17 + (0.3503749668598175) * emb_t1_18 + (-0.60224151611328125) * emb_t1_19 + (-0.038888074457645416) * emb_t1_20 + (-0.0082476558163762093) * emb_t1_21 + (0.71288597583770752) * emb_t1_22 + (0.18342132866382599) * emb_t1_23 + (0.063889488577842712) * emb_t1_24 + (-0.18233002722263336) * emb_t1_25 + (0.31547543406486511) * emb_t1_26 + (0.31835886836051941) * emb_t1_27 + (0.63821768760681152) * emb_t1_28 + (-0.47004371881484985) * emb_t1_29 + (0.2905077338218689) * emb_t1_30 + (1.4950629472732544) * emb_t1_31 + gate_r * ((-0.12416427582502365) + (0.14524014294147491) * gru_0_fwd_t0_h_0 + (-0.048091653734445572) * gru_0_fwd_t0_h_1 + (-0.20196244120597839) * gru_0_fwd_t0_h_2 + (-0.034997005015611649) * gru_0_fwd_t0_h_3 + (0.11581975966691971) * gru_0_fwd_t0_h_4 + (0.043937698006629944) * gru_0_fwd_t0_h_5 + (-0.24249815940856934) * gru_0_fwd_t0_h_6 + (0.072261504828929901) * gru_0_fwd_t0_h_7 + (0.28045105934143066) * gru_0_fwd_t0_h_8 + (0.10529207438230515) * gru_0_fwd_t0_h_9 + (0.084984160959720612) * gru_0_fwd_t0_h_10 + (0.074663154780864716) * gru_0_fwd_t0_h_11 + (0.012277777306735516) * gru_0_fwd_t0_h_12 + (-0.20052669942378998) * gru_0_fwd_t0_h_13 + (0.038231607526540756) * gru_0_fwd_t0_h_14 + (-0.14791277050971985) * gru_0_fwd_t0_h_15 + (0.33751910924911499) * gru_0_fwd_t0_h_16 + (0.037267103791236877) * gru_0_fwd_t0_h_17 + (-0.14503590762615204) * gru_0_fwd_t0_h_18 + (-0.30621060729026794) * gru_0_fwd_t0_h_19 + (0.16484667360782623) * gru_0_fwd_t0_h_20 + (0.40561693906784058) * gru_0_fwd_t0_h_21 + (0.11365178227424622) * gru_0_fwd_t0_h_22 + (-0.10142455995082855) * gru_0_fwd_t0_h_23 + (-0.070976734161376953) * gru_0_fwd_t0_h_24 + (0.11741837859153748) * gru_0_fwd_t0_h_25 + (0.21560783684253693) * gru_0_fwd_t0_h_26 + (-0.36539861559867859) * gru_0_fwd_t0_h_27 + (-0.032710321247577667) * gru_0_fwd_t0_h_28 + (0.00060825917171314359) * gru_0_fwd_t0_h_29 + (-0.14171038568019867) * gru_0_fwd_t0_h_30 + (-0.29205510020256042) * gru_0_fwd_t0_h_31));
    gru_0_fwd_t1_h_30 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t0_h_30;
    // h=31
    gate_r = sigmoid((1.1197860240936279) + (0.82189655303955078) * emb_t1_0 + (0.84979915618896484) * emb_t1_1 + (0.63162010908126831) * emb_t1_2 + (0.59661942720413208) * emb_t1_3 + (-0.26328656077384949) * emb_t1_4 + (-0.74788320064544678) * emb_t1_5 + (0.042410414665937424) * emb_t1_6 + (-0.86037814617156982) * emb_t1_7 + (0.69385504722595215) * emb_t1_8 + (-1.1680564880371094) * emb_t1_9 + (-0.36268532276153564) * emb_t1_10 + (0.5741237998008728) * emb_t1_11 + (0.80066180229187012) * emb_t1_12 + (0.3629651665687561) * emb_t1_13 + (-0.48242610692977905) * emb_t1_14 + (0.36558768153190613) * emb_t1_15 + (1.2318867444992065) * emb_t1_16 + (-0.26140722632408142) * emb_t1_17 + (-1.0478253364562988) * emb_t1_18 + (1.1572840213775635) * emb_t1_19 + (0.58639121055603027) * emb_t1_20 + (-0.42898482084274292) * emb_t1_21 + (-0.49490630626678467) * emb_t1_22 + (-0.025686496868729591) * emb_t1_23 + (-0.032259661704301834) * emb_t1_24 + (-0.58412003517150879) * emb_t1_25 + (0.042390689253807068) * emb_t1_26 + (-0.014617961831390858) * emb_t1_27 + (-0.45873472094535828) * emb_t1_28 + (0.76545733213424683) * emb_t1_29 + (-0.11830274760723114) * emb_t1_30 + (-0.82707095146179199) * emb_t1_31 + (-0.11377521604299545) * gru_0_fwd_t0_h_0 + (0.49484780430793762) * gru_0_fwd_t0_h_1 + (0.14865636825561523) * gru_0_fwd_t0_h_2 + (1.0188875198364258) * gru_0_fwd_t0_h_3 + (0.79360133409500122) * gru_0_fwd_t0_h_4 + (0.88067495822906494) * gru_0_fwd_t0_h_5 + (-3.5741405487060547) * gru_0_fwd_t0_h_6 + (-0.080673180520534515) * gru_0_fwd_t0_h_7 + (0.3026549220085144) * gru_0_fwd_t0_h_8 + (1.10136878490448) * gru_0_fwd_t0_h_9 + (0.030721839517354965) * gru_0_fwd_t0_h_10 + (0.24231904745101929) * gru_0_fwd_t0_h_11 + (-0.25698202848434448) * gru_0_fwd_t0_h_12 + (-0.79313129186630249) * gru_0_fwd_t0_h_13 + (0.38349774479866028) * gru_0_fwd_t0_h_14 + (0.88436049222946167) * gru_0_fwd_t0_h_15 + (0.047915004193782806) * gru_0_fwd_t0_h_16 + (0.10697253048419952) * gru_0_fwd_t0_h_17 + (1.5925276279449463) * gru_0_fwd_t0_h_18 + (0.94665277004241943) * gru_0_fwd_t0_h_19 + (2.1543376445770264) * gru_0_fwd_t0_h_20 + (0.22832992672920227) * gru_0_fwd_t0_h_21 + (0.074176594614982605) * gru_0_fwd_t0_h_22 + (-0.4923250675201416) * gru_0_fwd_t0_h_23 + (1.8622615337371826) * gru_0_fwd_t0_h_24 + (0.26764729619026184) * gru_0_fwd_t0_h_25 + (1.0227169990539551) * gru_0_fwd_t0_h_26 + (0.71264427900314331) * gru_0_fwd_t0_h_27 + (-0.56702607870101929) * gru_0_fwd_t0_h_28 + (1.5039618015289307) * gru_0_fwd_t0_h_29 + (0.42466428875923157) * gru_0_fwd_t0_h_30 + (-2.046318531036377) * gru_0_fwd_t0_h_31);
    gate_z = sigmoid((0.93570268154144287) + (0.027945071458816528) * emb_t1_0 + (-0.29999658465385437) * emb_t1_1 + (0.37092065811157227) * emb_t1_2 + (0.11785808950662613) * emb_t1_3 + (-0.42889499664306641) * emb_t1_4 + (0.025375081226229668) * emb_t1_5 + (-0.013721304945647717) * emb_t1_6 + (-0.28716537356376648) * emb_t1_7 + (0.52241778373718262) * emb_t1_8 + (0.20057013630867004) * emb_t1_9 + (0.043395094573497772) * emb_t1_10 + (0.33710560202598572) * emb_t1_11 + (0.53270399570465088) * emb_t1_12 + (-0.6542210578918457) * emb_t1_13 + (0.28734761476516724) * emb_t1_14 + (0.11672159284353256) * emb_t1_15 + (0.20078630745410919) * emb_t1_16 + (-0.63615882396697998) * emb_t1_17 + (0.022169522941112518) * emb_t1_18 + (0.61556482315063477) * emb_t1_19 + (0.56159460544586182) * emb_t1_20 + (0.2355131208896637) * emb_t1_21 + (-0.58501154184341431) * emb_t1_22 + (-0.23210981488227844) * emb_t1_23 + (0.043808095157146454) * emb_t1_24 + (-0.00083580572390928864) * emb_t1_25 + (0.48075786232948303) * emb_t1_26 + (0.1017712876200676) * emb_t1_27 + (0.35832160711288452) * emb_t1_28 + (-0.19724997878074646) * emb_t1_29 + (1.0564422607421875) * emb_t1_30 + (-0.51558518409729004) * emb_t1_31 + (-0.052631378173828125) * gru_0_fwd_t0_h_0 + (0.12540276348590851) * gru_0_fwd_t0_h_1 + (-0.40728402137756348) * gru_0_fwd_t0_h_2 + (0.45038846135139465) * gru_0_fwd_t0_h_3 + (0.0069151311181485653) * gru_0_fwd_t0_h_4 + (0.043897204101085663) * gru_0_fwd_t0_h_5 + (-0.51441150903701782) * gru_0_fwd_t0_h_6 + (0.54450982809066772) * gru_0_fwd_t0_h_7 + (0.93323218822479248) * gru_0_fwd_t0_h_8 + (-0.20096880197525024) * gru_0_fwd_t0_h_9 + (0.41260793805122375) * gru_0_fwd_t0_h_10 + (0.21722094714641571) * gru_0_fwd_t0_h_11 + (-0.21869494020938873) * gru_0_fwd_t0_h_12 + (-0.59330326318740845) * gru_0_fwd_t0_h_13 + (0.28238683938980103) * gru_0_fwd_t0_h_14 + (0.31732171773910522) * gru_0_fwd_t0_h_15 + (0.0050415699370205402) * gru_0_fwd_t0_h_16 + (-0.53080970048904419) * gru_0_fwd_t0_h_17 + (0.40165555477142334) * gru_0_fwd_t0_h_18 + (0.37447160482406616) * gru_0_fwd_t0_h_19 + (-0.41426545381546021) * gru_0_fwd_t0_h_20 + (-0.95179545879364014) * gru_0_fwd_t0_h_21 + (0.78936189413070679) * gru_0_fwd_t0_h_22 + (-1.1169302463531494) * gru_0_fwd_t0_h_23 + (-1.5654652118682861) * gru_0_fwd_t0_h_24 + (-0.13280864059925079) * gru_0_fwd_t0_h_25 + (-3.115680456161499) * gru_0_fwd_t0_h_26 + (0.34119254350662231) * gru_0_fwd_t0_h_27 + (-0.64078515768051147) * gru_0_fwd_t0_h_28 + (-0.21707659959793091) * gru_0_fwd_t0_h_29 + (0.17915607988834381) * gru_0_fwd_t0_h_30 + (0.49229168891906738) * gru_0_fwd_t0_h_31);
    gate_n = tanh((0.059556685388088226) + (0.0093570752069354057) * emb_t1_0 + (-0.14118006825447083) * emb_t1_1 + (0.27748677134513855) * emb_t1_2 + (0.13478186726570129) * emb_t1_3 + (-0.096241101622581482) * emb_t1_4 + (0.028125690296292305) * emb_t1_5 + (-0.21943745017051697) * emb_t1_6 + (-0.040820885449647903) * emb_t1_7 + (0.015611233189702034) * emb_t1_8 + (-0.026535511016845703) * emb_t1_9 + (0.11295320093631744) * emb_t1_10 + (0.1657504141330719) * emb_t1_11 + (0.30802986025810242) * emb_t1_12 + (-0.19599159061908722) * emb_t1_13 + (0.051283437758684158) * emb_t1_14 + (0.01581161841750145) * emb_t1_15 + (0.16965529322624207) * emb_t1_16 + (0.17486566305160522) * emb_t1_17 + (-0.3228529691696167) * emb_t1_18 + (0.04059198871254921) * emb_t1_19 + (0.10199558734893799) * emb_t1_20 + (0.044503945857286453) * emb_t1_21 + (-0.3532220721244812) * emb_t1_22 + (0.072760716080665588) * emb_t1_23 + (-0.031821347773075104) * emb_t1_24 + (-0.00347660924308002) * emb_t1_25 + (-0.068912975490093231) * emb_t1_26 + (0.12479005008935928) * emb_t1_27 + (0.0084166890010237694) * emb_t1_28 + (-0.074207529425621033) * emb_t1_29 + (-0.19051642715930939) * emb_t1_30 + (-0.29854661226272583) * emb_t1_31 + gate_r * ((0.093639783561229706) + (-0.26055413484573364) * gru_0_fwd_t0_h_0 + (-0.095837920904159546) * gru_0_fwd_t0_h_1 + (0.038966912776231766) * gru_0_fwd_t0_h_2 + (0.014310726895928383) * gru_0_fwd_t0_h_3 + (-0.049272693693637848) * gru_0_fwd_t0_h_4 + (0.22457613050937653) * gru_0_fwd_t0_h_5 + (1.4724425077438354) * gru_0_fwd_t0_h_6 + (-0.077588565647602081) * gru_0_fwd_t0_h_7 + (0.097471266984939575) * gru_0_fwd_t0_h_8 + (-0.55311673879623413) * gru_0_fwd_t0_h_9 + (-0.13370458781719208) * gru_0_fwd_t0_h_10 + (-0.25395268201828003) * gru_0_fwd_t0_h_11 + (0.4308381974697113) * gru_0_fwd_t0_h_12 + (0.25299379229545593) * gru_0_fwd_t0_h_13 + (-0.29430118203163147) * gru_0_fwd_t0_h_14 + (-0.014947656542062759) * gru_0_fwd_t0_h_15 + (0.022595809772610664) * gru_0_fwd_t0_h_16 + (0.54277259111404419) * gru_0_fwd_t0_h_17 + (-0.35988220572471619) * gru_0_fwd_t0_h_18 + (1.1189311742782593) * gru_0_fwd_t0_h_19 + (0.42105749249458313) * gru_0_fwd_t0_h_20 + (0.31713798642158508) * gru_0_fwd_t0_h_21 + (-0.59697574377059937) * gru_0_fwd_t0_h_22 + (0.041749343276023865) * gru_0_fwd_t0_h_23 + (-0.99520927667617798) * gru_0_fwd_t0_h_24 + (0.28341895341873169) * gru_0_fwd_t0_h_25 + (2.939974308013916) * gru_0_fwd_t0_h_26 + (0.26471617817878723) * gru_0_fwd_t0_h_27 + (-0.81368362903594971) * gru_0_fwd_t0_h_28 + (-0.32824662327766418) * gru_0_fwd_t0_h_29 + (-0.31704512238502502) * gru_0_fwd_t0_h_30 + (1.2399663925170898) * gru_0_fwd_t0_h_31));
    gru_0_fwd_t1_h_31 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t0_h_31;

    // FW step t=2
    // h=0
    gate_r = sigmoid((-0.63586723804473877) + (0.25612789392471313) * emb_t2_0 + (0.20511561632156372) * emb_t2_1 + (-0.059482339769601822) * emb_t2_2 + (-0.3379744291305542) * emb_t2_3 + (0.070997722446918488) * emb_t2_4 + (0.24011668562889099) * emb_t2_5 + (0.54058331251144409) * emb_t2_6 + (0.050093494355678558) * emb_t2_7 + (-0.20927594602108002) * emb_t2_8 + (0.62939280271530151) * emb_t2_9 + (0.040228515863418579) * emb_t2_10 + (0.049732539802789688) * emb_t2_11 + (-0.37557637691497803) * emb_t2_12 + (0.37011173367500305) * emb_t2_13 + (-0.30297467112541199) * emb_t2_14 + (0.062840230762958527) * emb_t2_15 + (-0.077686019241809845) * emb_t2_16 + (0.00018224099767394364) * emb_t2_17 + (0.64129030704498291) * emb_t2_18 + (-0.25011655688285828) * emb_t2_19 + (-0.35314306616783142) * emb_t2_20 + (-0.65542095899581909) * emb_t2_21 + (-0.026311812922358513) * emb_t2_22 + (0.22445248067378998) * emb_t2_23 + (-0.46241691708564758) * emb_t2_24 + (0.47750246524810791) * emb_t2_25 + (-0.23792253434658051) * emb_t2_26 + (-0.09793505072593689) * emb_t2_27 + (-0.60475265979766846) * emb_t2_28 + (0.27672046422958374) * emb_t2_29 + (-0.28143492341041565) * emb_t2_30 + (0.26639610528945923) * emb_t2_31 + (0.39939281344413757) * gru_0_fwd_t1_h_0 + (-0.45239430665969849) * gru_0_fwd_t1_h_1 + (0.51542329788208008) * gru_0_fwd_t1_h_2 + (1.1852349042892456) * gru_0_fwd_t1_h_3 + (-0.57260710000991821) * gru_0_fwd_t1_h_4 + (0.4299236536026001) * gru_0_fwd_t1_h_5 + (1.5196936130523682) * gru_0_fwd_t1_h_6 + (-0.62232279777526855) * gru_0_fwd_t1_h_7 + (-0.0047591947950422764) * gru_0_fwd_t1_h_8 + (-1.1724215745925903) * gru_0_fwd_t1_h_9 + (-0.089997418224811554) * gru_0_fwd_t1_h_10 + (0.98156434297561646) * gru_0_fwd_t1_h_11 + (0.43952465057373047) * gru_0_fwd_t1_h_12 + (-0.30990126729011536) * gru_0_fwd_t1_h_13 + (-0.19336289167404175) * gru_0_fwd_t1_h_14 + (1.0875648260116577) * gru_0_fwd_t1_h_15 + (0.31760719418525696) * gru_0_fwd_t1_h_16 + (0.037163529545068741) * gru_0_fwd_t1_h_17 + (-0.33116120100021362) * gru_0_fwd_t1_h_18 + (-0.68276423215866089) * gru_0_fwd_t1_h_19 + (-0.38833123445510864) * gru_0_fwd_t1_h_20 + (-0.2306981086730957) * gru_0_fwd_t1_h_21 + (-0.068562164902687073) * gru_0_fwd_t1_h_22 + (0.14103168249130249) * gru_0_fwd_t1_h_23 + (-0.29763594269752502) * gru_0_fwd_t1_h_24 + (-0.24194538593292236) * gru_0_fwd_t1_h_25 + (0.5872117280960083) * gru_0_fwd_t1_h_26 + (0.31708100438117981) * gru_0_fwd_t1_h_27 + (-0.027148989960551262) * gru_0_fwd_t1_h_28 + (-1.2354743480682373) * gru_0_fwd_t1_h_29 + (-0.48650023341178894) * gru_0_fwd_t1_h_30 + (2.7708353996276855) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-0.1805730015039444) + (-0.1730819046497345) * emb_t2_0 + (0.99021154642105103) * emb_t2_1 + (-0.19890351593494415) * emb_t2_2 + (-0.59255599975585938) * emb_t2_3 + (1.2440937757492065) * emb_t2_4 + (0.30739772319793701) * emb_t2_5 + (0.70177561044692993) * emb_t2_6 + (0.019682634621858597) * emb_t2_7 + (-0.077413111925125122) * emb_t2_8 + (-0.50500905513763428) * emb_t2_9 + (-0.67638945579528809) * emb_t2_10 + (-0.026483789086341858) * emb_t2_11 + (0.23927073180675507) * emb_t2_12 + (0.54627126455307007) * emb_t2_13 + (0.1137111634016037) * emb_t2_14 + (-0.038617175072431564) * emb_t2_15 + (-0.12933528423309326) * emb_t2_16 + (0.11861786246299744) * emb_t2_17 + (-0.36897361278533936) * emb_t2_18 + (0.26175644993782043) * emb_t2_19 + (-0.27793017029762268) * emb_t2_20 + (-0.24079181253910065) * emb_t2_21 + (0.38042914867401123) * emb_t2_22 + (0.0097168097272515297) * emb_t2_23 + (-0.063354566693305969) * emb_t2_24 + (0.13164801895618439) * emb_t2_25 + (-0.70986056327819824) * emb_t2_26 + (-0.030485551804304123) * emb_t2_27 + (-0.99285542964935303) * emb_t2_28 + (1.2676990032196045) * emb_t2_29 + (-1.3924852609634399) * emb_t2_30 + (-0.066610008478164673) * emb_t2_31 + (0.048599831759929657) * gru_0_fwd_t1_h_0 + (0.24509155750274658) * gru_0_fwd_t1_h_1 + (-1.980970025062561) * gru_0_fwd_t1_h_2 + (-1.600147008895874) * gru_0_fwd_t1_h_3 + (-0.054658118635416031) * gru_0_fwd_t1_h_4 + (-0.072297543287277222) * gru_0_fwd_t1_h_5 + (1.8688979148864746) * gru_0_fwd_t1_h_6 + (2.1074397563934326) * gru_0_fwd_t1_h_7 + (0.19694878160953522) * gru_0_fwd_t1_h_8 + (-1.5771154165267944) * gru_0_fwd_t1_h_9 + (1.4935240745544434) * gru_0_fwd_t1_h_10 + (0.013767411932349205) * gru_0_fwd_t1_h_11 + (0.17914442718029022) * gru_0_fwd_t1_h_12 + (0.033899158239364624) * gru_0_fwd_t1_h_13 + (0.050818316638469696) * gru_0_fwd_t1_h_14 + (-0.17568990588188171) * gru_0_fwd_t1_h_15 + (-0.38448107242584229) * gru_0_fwd_t1_h_16 + (-0.20525273680686951) * gru_0_fwd_t1_h_17 + (0.048907119780778885) * gru_0_fwd_t1_h_18 + (-0.4544963538646698) * gru_0_fwd_t1_h_19 + (-1.2446156740188599) * gru_0_fwd_t1_h_20 + (-0.46960261464118958) * gru_0_fwd_t1_h_21 + (0.057055030018091202) * gru_0_fwd_t1_h_22 + (-0.11502393335103989) * gru_0_fwd_t1_h_23 + (0.93711066246032715) * gru_0_fwd_t1_h_24 + (1.0189545154571533) * gru_0_fwd_t1_h_25 + (0.25243127346038818) * gru_0_fwd_t1_h_26 + (0.21382462978363037) * gru_0_fwd_t1_h_27 + (0.13708734512329102) * gru_0_fwd_t1_h_28 + (0.56444734334945679) * gru_0_fwd_t1_h_29 + (-0.042037498205900192) * gru_0_fwd_t1_h_30 + (-1.8988234996795654) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.098105855286121368) + (-0.006110471673309803) * emb_t2_0 + (-0.16757895052433014) * emb_t2_1 + (-0.0028194685000926256) * emb_t2_2 + (0.067232899367809296) * emb_t2_3 + (0.074285827577114105) * emb_t2_4 + (-0.060071688145399094) * emb_t2_5 + (-0.098569884896278381) * emb_t2_6 + (-0.044600673019886017) * emb_t2_7 + (0.14502266049385071) * emb_t2_8 + (0.61696690320968628) * emb_t2_9 + (0.60714042186737061) * emb_t2_10 + (-0.15376155078411102) * emb_t2_11 + (-0.14660400152206421) * emb_t2_12 + (-0.59865099191665649) * emb_t2_13 + (0.021863484755158424) * emb_t2_14 + (0.019111357629299164) * emb_t2_15 + (0.061020586639642715) * emb_t2_16 + (-0.17076332867145538) * emb_t2_17 + (0.45876485109329224) * emb_t2_18 + (-0.16259600222110748) * emb_t2_19 + (-0.09534762054681778) * emb_t2_20 + (0.063709385693073273) * emb_t2_21 + (0.45876595377922058) * emb_t2_22 + (-0.014692286029458046) * emb_t2_23 + (0.037582259625196457) * emb_t2_24 + (-0.029277998954057693) * emb_t2_25 + (-0.42821526527404785) * emb_t2_26 + (-0.00062267959583550692) * emb_t2_27 + (0.28537830710411072) * emb_t2_28 + (-0.16059227287769318) * emb_t2_29 + (0.58637130260467529) * emb_t2_30 + (-0.053730327636003494) * emb_t2_31 + gate_r * ((0.27915149927139282) + (-0.38889393210411072) * gru_0_fwd_t1_h_0 + (-0.092167168855667114) * gru_0_fwd_t1_h_1 + (-0.58291137218475342) * gru_0_fwd_t1_h_2 + (-1.1983227729797363) * gru_0_fwd_t1_h_3 + (0.088861025869846344) * gru_0_fwd_t1_h_4 + (-0.40719360113143921) * gru_0_fwd_t1_h_5 + (1.7541582584381104) * gru_0_fwd_t1_h_6 + (0.96002089977264404) * gru_0_fwd_t1_h_7 + (-0.020488433539867401) * gru_0_fwd_t1_h_8 + (-0.62128281593322754) * gru_0_fwd_t1_h_9 + (0.27136930823326111) * gru_0_fwd_t1_h_10 + (-1.2635856866836548) * gru_0_fwd_t1_h_11 + (0.10848518460988998) * gru_0_fwd_t1_h_12 + (0.5185091495513916) * gru_0_fwd_t1_h_13 + (0.29575502872467041) * gru_0_fwd_t1_h_14 + (0.21881890296936035) * gru_0_fwd_t1_h_15 + (-0.26780650019645691) * gru_0_fwd_t1_h_16 + (-0.17633502185344696) * gru_0_fwd_t1_h_17 + (-0.046199630945920944) * gru_0_fwd_t1_h_18 + (0.30445775389671326) * gru_0_fwd_t1_h_19 + (-0.46879208087921143) * gru_0_fwd_t1_h_20 + (-0.23298667371273041) * gru_0_fwd_t1_h_21 + (-0.38246411085128784) * gru_0_fwd_t1_h_22 + (0.017062928527593613) * gru_0_fwd_t1_h_23 + (1.7557300329208374) * gru_0_fwd_t1_h_24 + (0.053831141442060471) * gru_0_fwd_t1_h_25 + (-0.25340673327445984) * gru_0_fwd_t1_h_26 + (0.08145345002412796) * gru_0_fwd_t1_h_27 + (-0.56892961263656616) * gru_0_fwd_t1_h_28 + (1.0762699842453003) * gru_0_fwd_t1_h_29 + (0.33208164572715759) * gru_0_fwd_t1_h_30 + (-1.4441461563110352) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_0 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_0;
    // h=1
    gate_r = sigmoid((-0.47315943241119385) + (-0.20197930932044983) * emb_t2_0 + (0.3900463879108429) * emb_t2_1 + (-0.91626137495040894) * emb_t2_2 + (-0.80037456750869751) * emb_t2_3 + (0.54234069585800171) * emb_t2_4 + (0.56150758266448975) * emb_t2_5 + (0.086490333080291748) * emb_t2_6 + (0.11938868463039398) * emb_t2_7 + (-0.35315313935279846) * emb_t2_8 + (0.22998486459255219) * emb_t2_9 + (-0.21408471465110779) * emb_t2_10 + (-0.39615523815155029) * emb_t2_11 + (-0.06396804004907608) * emb_t2_12 + (0.24132311344146729) * emb_t2_13 + (0.40227016806602478) * emb_t2_14 + (0.26782363653182983) * emb_t2_15 + (-0.51870536804199219) * emb_t2_16 + (-0.1805369108915329) * emb_t2_17 + (-0.31617352366447449) * emb_t2_18 + (0.0055455435067415237) * emb_t2_19 + (-0.2888895571231842) * emb_t2_20 + (-0.50013643503189087) * emb_t2_21 + (0.32653516530990601) * emb_t2_22 + (-0.0013026917586103082) * emb_t2_23 + (0.13138106465339661) * emb_t2_24 + (-0.63240700960159302) * emb_t2_25 + (-0.5113060474395752) * emb_t2_26 + (-0.18826660513877869) * emb_t2_27 + (-0.18575501441955566) * emb_t2_28 + (0.38022315502166748) * emb_t2_29 + (-0.14143200218677521) * emb_t2_30 + (0.28079184889793396) * emb_t2_31 + (0.25332635641098022) * gru_0_fwd_t1_h_0 + (0.62572824954986572) * gru_0_fwd_t1_h_1 + (0.38907268643379211) * gru_0_fwd_t1_h_2 + (2.1785023212432861) * gru_0_fwd_t1_h_3 + (0.35492026805877686) * gru_0_fwd_t1_h_4 + (-0.55905872583389282) * gru_0_fwd_t1_h_5 + (-0.15405474603176117) * gru_0_fwd_t1_h_6 + (-0.60063296556472778) * gru_0_fwd_t1_h_7 + (-0.2269970029592514) * gru_0_fwd_t1_h_8 + (-0.66512209177017212) * gru_0_fwd_t1_h_9 + (-0.52616441249847412) * gru_0_fwd_t1_h_10 + (0.3572535514831543) * gru_0_fwd_t1_h_11 + (-0.51676905155181885) * gru_0_fwd_t1_h_12 + (-0.4776788055896759) * gru_0_fwd_t1_h_13 + (-0.049878422170877457) * gru_0_fwd_t1_h_14 + (-0.16086640954017639) * gru_0_fwd_t1_h_15 + (-0.23704136908054352) * gru_0_fwd_t1_h_16 + (-0.36966648697853088) * gru_0_fwd_t1_h_17 + (0.54794615507125854) * gru_0_fwd_t1_h_18 + (-0.4142346978187561) * gru_0_fwd_t1_h_19 + (-0.49277323484420776) * gru_0_fwd_t1_h_20 + (-0.045853972434997559) * gru_0_fwd_t1_h_21 + (0.55593365430831909) * gru_0_fwd_t1_h_22 + (0.3110499382019043) * gru_0_fwd_t1_h_23 + (0.86221796274185181) * gru_0_fwd_t1_h_24 + (-0.20161892473697662) * gru_0_fwd_t1_h_25 + (2.4296295642852783) * gru_0_fwd_t1_h_26 + (-0.08931434154510498) * gru_0_fwd_t1_h_27 + (0.23503243923187256) * gru_0_fwd_t1_h_28 + (-0.063249334692955017) * gru_0_fwd_t1_h_29 + (0.23077639937400818) * gru_0_fwd_t1_h_30 + (1.1132805347442627) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-0.081969015300273895) + (-0.040738023817539215) * emb_t2_0 + (1.3161453008651733) * emb_t2_1 + (0.094650112092494965) * emb_t2_2 + (-0.25734174251556396) * emb_t2_3 + (0.1212867945432663) * emb_t2_4 + (0.0084351236000657082) * emb_t2_5 + (1.317499041557312) * emb_t2_6 + (0.097850881516933441) * emb_t2_7 + (0.093310289084911346) * emb_t2_8 + (-0.55444943904876709) * emb_t2_9 + (-0.083038963377475739) * emb_t2_10 + (-0.079097941517829895) * emb_t2_11 + (0.19021616876125336) * emb_t2_12 + (1.1669929027557373) * emb_t2_13 + (-0.09754655510187149) * emb_t2_14 + (-0.20385529100894928) * emb_t2_15 + (0.099251508712768555) * emb_t2_16 + (0.18394295871257782) * emb_t2_17 + (-0.30976629257202148) * emb_t2_18 + (-0.094525299966335297) * emb_t2_19 + (0.0028359678108245134) * emb_t2_20 + (-0.24470433592796326) * emb_t2_21 + (0.055819042026996613) * emb_t2_22 + (0.4079681932926178) * emb_t2_23 + (-0.19975447654724121) * emb_t2_24 + (0.24829433858394623) * emb_t2_25 + (-0.37130647897720337) * emb_t2_26 + (0.1413697749376297) * emb_t2_27 + (-0.77388912439346313) * emb_t2_28 + (0.80072581768035889) * emb_t2_29 + (-0.39179623126983643) * emb_t2_30 + (-0.19549223780632019) * emb_t2_31 + (-0.26795434951782227) * gru_0_fwd_t1_h_0 + (0.031234243884682655) * gru_0_fwd_t1_h_1 + (0.91586369276046753) * gru_0_fwd_t1_h_2 + (0.90858215093612671) * gru_0_fwd_t1_h_3 + (-0.15372847020626068) * gru_0_fwd_t1_h_4 + (0.15217134356498718) * gru_0_fwd_t1_h_5 + (0.23932318389415741) * gru_0_fwd_t1_h_6 + (-0.37173047661781311) * gru_0_fwd_t1_h_7 + (0.19593939185142517) * gru_0_fwd_t1_h_8 + (0.58938449621200562) * gru_0_fwd_t1_h_9 + (-0.72226792573928833) * gru_0_fwd_t1_h_10 + (-0.33940699696540833) * gru_0_fwd_t1_h_11 + (0.097356140613555908) * gru_0_fwd_t1_h_12 + (0.2434549480676651) * gru_0_fwd_t1_h_13 + (-0.11584145575761795) * gru_0_fwd_t1_h_14 + (0.27383130788803101) * gru_0_fwd_t1_h_15 + (0.38127899169921875) * gru_0_fwd_t1_h_16 + (0.2095736563205719) * gru_0_fwd_t1_h_17 + (-0.17231328785419464) * gru_0_fwd_t1_h_18 + (1.8202539682388306) * gru_0_fwd_t1_h_19 + (1.2393923997879028) * gru_0_fwd_t1_h_20 + (0.77455723285675049) * gru_0_fwd_t1_h_21 + (-0.31859412789344788) * gru_0_fwd_t1_h_22 + (-0.44130885601043701) * gru_0_fwd_t1_h_23 + (-0.49387469887733459) * gru_0_fwd_t1_h_24 + (-0.73759704828262329) * gru_0_fwd_t1_h_25 + (0.065525583922863007) * gru_0_fwd_t1_h_26 + (0.022106176242232323) * gru_0_fwd_t1_h_27 + (-1.8341513872146606) * gru_0_fwd_t1_h_28 + (0.37840092182159424) * gru_0_fwd_t1_h_29 + (-0.056197434663772583) * gru_0_fwd_t1_h_30 + (1.3079894781112671) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.20379906892776489) + (0.076361149549484253) * emb_t2_0 + (-0.57323306798934937) * emb_t2_1 + (-0.19933471083641052) * emb_t2_2 + (-0.49378913640975952) * emb_t2_3 + (-0.44891390204429626) * emb_t2_4 + (0.34798762202262878) * emb_t2_5 + (-0.74374908208847046) * emb_t2_6 + (0.28492367267608643) * emb_t2_7 + (-0.6112217903137207) * emb_t2_8 + (0.91787612438201904) * emb_t2_9 + (0.87554305791854858) * emb_t2_10 + (-0.42015242576599121) * emb_t2_11 + (-1.1708619594573975) * emb_t2_12 + (-0.75946378707885742) * emb_t2_13 + (-0.043774008750915527) * emb_t2_14 + (-0.13453966379165649) * emb_t2_15 + (-0.0572701096534729) * emb_t2_16 + (-0.086511150002479553) * emb_t2_17 + (1.0237325429916382) * emb_t2_18 + (-1.0545214414596558) * emb_t2_19 + (-0.24128946661949158) * emb_t2_20 + (-0.34695819020271301) * emb_t2_21 + (2.3971941471099854) * emb_t2_22 + (0.23683333396911621) * emb_t2_23 + (-0.30926087498664856) * emb_t2_24 + (0.42572280764579773) * emb_t2_25 + (0.45578816533088684) * emb_t2_26 + (0.27811175584793091) * emb_t2_27 + (0.78862935304641724) * emb_t2_28 + (-0.4390127956867218) * emb_t2_29 + (0.66192138195037842) * emb_t2_30 + (0.86930453777313232) * emb_t2_31 + gate_r * ((0.038724146783351898) + (-0.48781463503837585) * gru_0_fwd_t1_h_0 + (-0.73099273443222046) * gru_0_fwd_t1_h_1 + (-0.0039540925063192844) * gru_0_fwd_t1_h_2 + (-0.14538967609405518) * gru_0_fwd_t1_h_3 + (-0.69688302278518677) * gru_0_fwd_t1_h_4 + (0.40897557139396667) * gru_0_fwd_t1_h_5 + (0.53698372840881348) * gru_0_fwd_t1_h_6 + (-0.22809559106826782) * gru_0_fwd_t1_h_7 + (0.069293059408664703) * gru_0_fwd_t1_h_8 + (0.093595832586288452) * gru_0_fwd_t1_h_9 + (0.14251042902469635) * gru_0_fwd_t1_h_10 + (-0.18195424973964691) * gru_0_fwd_t1_h_11 + (1.0426195859909058) * gru_0_fwd_t1_h_12 + (0.80717575550079346) * gru_0_fwd_t1_h_13 + (-0.53189635276794434) * gru_0_fwd_t1_h_14 + (0.37515166401863098) * gru_0_fwd_t1_h_15 + (0.29666870832443237) * gru_0_fwd_t1_h_16 + (0.40994295477867126) * gru_0_fwd_t1_h_17 + (0.15134435892105103) * gru_0_fwd_t1_h_18 + (0.11801391094923019) * gru_0_fwd_t1_h_19 + (0.36758047342300415) * gru_0_fwd_t1_h_20 + (0.097810804843902588) * gru_0_fwd_t1_h_21 + (0.074837684631347656) * gru_0_fwd_t1_h_22 + (-0.22011236846446991) * gru_0_fwd_t1_h_23 + (1.7738238573074341) * gru_0_fwd_t1_h_24 + (0.30645459890365601) * gru_0_fwd_t1_h_25 + (-1.9526984691619873) * gru_0_fwd_t1_h_26 + (0.065554156899452209) * gru_0_fwd_t1_h_27 + (-0.46253073215484619) * gru_0_fwd_t1_h_28 + (0.3682834804058075) * gru_0_fwd_t1_h_29 + (-0.23115412890911102) * gru_0_fwd_t1_h_30 + (1.5375627279281616) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_1 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_1;
    // h=2
    gate_r = sigmoid((-1.0380897521972656) + (-0.49953678250312805) * emb_t2_0 + (0.53072565793991089) * emb_t2_1 + (-0.30938267707824707) * emb_t2_2 + (-1.083149790763855) * emb_t2_3 + (0.34049257636070251) * emb_t2_4 + (-0.075188666582107544) * emb_t2_5 + (0.57378387451171875) * emb_t2_6 + (0.18540342152118683) * emb_t2_7 + (-0.41303351521492004) * emb_t2_8 + (-0.015425128862261772) * emb_t2_9 + (-0.26157167553901672) * emb_t2_10 + (-0.78672277927398682) * emb_t2_11 + (-0.54107207059860229) * emb_t2_12 + (0.2636360228061676) * emb_t2_13 + (0.26457589864730835) * emb_t2_14 + (0.18982620537281036) * emb_t2_15 + (-0.20015624165534973) * emb_t2_16 + (0.23595154285430908) * emb_t2_17 + (-0.33847025036811829) * emb_t2_18 + (-0.1027209460735321) * emb_t2_19 + (-0.08234848827123642) * emb_t2_20 + (0.1945563405752182) * emb_t2_21 + (0.13705295324325562) * emb_t2_22 + (-0.053252369165420532) * emb_t2_23 + (0.36643537878990173) * emb_t2_24 + (-0.54133164882659912) * emb_t2_25 + (-0.2030123770236969) * emb_t2_26 + (0.090528152883052826) * emb_t2_27 + (-0.39304694533348083) * emb_t2_28 + (0.51989978551864624) * emb_t2_29 + (-0.281951904296875) * emb_t2_30 + (0.82258868217468262) * emb_t2_31 + (0.53409236669540405) * gru_0_fwd_t1_h_0 + (0.1891348659992218) * gru_0_fwd_t1_h_1 + (-1.3408336639404297) * gru_0_fwd_t1_h_2 + (-0.71657174825668335) * gru_0_fwd_t1_h_3 + (0.50853520631790161) * gru_0_fwd_t1_h_4 + (-0.6813356876373291) * gru_0_fwd_t1_h_5 + (-1.8093869686126709) * gru_0_fwd_t1_h_6 + (0.40706777572631836) * gru_0_fwd_t1_h_7 + (0.6910858154296875) * gru_0_fwd_t1_h_8 + (-0.4596601128578186) * gru_0_fwd_t1_h_9 + (1.4270249605178833) * gru_0_fwd_t1_h_10 + (0.60212743282318115) * gru_0_fwd_t1_h_11 + (-0.45941388607025146) * gru_0_fwd_t1_h_12 + (-0.24103064835071564) * gru_0_fwd_t1_h_13 + (-0.81206357479095459) * gru_0_fwd_t1_h_14 + (-0.24250292778015137) * gru_0_fwd_t1_h_15 + (0.77786219120025635) * gru_0_fwd_t1_h_16 + (0.28454890847206116) * gru_0_fwd_t1_h_17 + (-0.19906607270240784) * gru_0_fwd_t1_h_18 + (-0.034979179501533508) * gru_0_fwd_t1_h_19 + (-0.67761313915252686) * gru_0_fwd_t1_h_20 + (1.5262935161590576) * gru_0_fwd_t1_h_21 + (0.92325437068939209) * gru_0_fwd_t1_h_22 + (-0.41080927848815918) * gru_0_fwd_t1_h_23 + (2.3788449764251709) * gru_0_fwd_t1_h_24 + (0.95587188005447388) * gru_0_fwd_t1_h_25 + (0.16162353754043579) * gru_0_fwd_t1_h_26 + (-0.5608445405960083) * gru_0_fwd_t1_h_27 + (0.28813251852989197) * gru_0_fwd_t1_h_28 + (0.041321095079183578) * gru_0_fwd_t1_h_29 + (-0.71289443969726562) * gru_0_fwd_t1_h_30 + (-0.025892132893204689) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.59557598829269409) + (-0.017392463982105255) * emb_t2_0 + (-0.45606103539466858) * emb_t2_1 + (0.21697993576526642) * emb_t2_2 + (0.049378287047147751) * emb_t2_3 + (-1.6374095139326528e-05) * emb_t2_4 + (0.11475842446088791) * emb_t2_5 + (-0.46809408068656921) * emb_t2_6 + (-0.036141060292720795) * emb_t2_7 + (-0.21556477248668671) * emb_t2_8 + (-0.19126288592815399) * emb_t2_9 + (0.41105896234512329) * emb_t2_10 + (0.40881797671318054) * emb_t2_11 + (-0.062162835150957108) * emb_t2_12 + (-0.1435941606760025) * emb_t2_13 + (-0.030776612460613251) * emb_t2_14 + (-0.082906909286975861) * emb_t2_15 + (0.14314372837543488) * emb_t2_16 + (-0.54513871669769287) * emb_t2_17 + (0.37482067942619324) * emb_t2_18 + (-0.20434349775314331) * emb_t2_19 + (0.39690586924552917) * emb_t2_20 + (0.025051642209291458) * emb_t2_21 + (0.22769370675086975) * emb_t2_22 + (0.07871323823928833) * emb_t2_23 + (-0.098954826593399048) * emb_t2_24 + (-0.29648685455322266) * emb_t2_25 + (0.21393376588821411) * emb_t2_26 + (0.21182559430599213) * emb_t2_27 + (0.10984400659799576) * emb_t2_28 + (-0.23499684035778046) * emb_t2_29 + (0.31506726145744324) * emb_t2_30 + (0.12899214029312134) * emb_t2_31 + (1.0552586317062378) * gru_0_fwd_t1_h_0 + (0.19757528603076935) * gru_0_fwd_t1_h_1 + (0.52107793092727661) * gru_0_fwd_t1_h_2 + (-2.1354260444641113) * gru_0_fwd_t1_h_3 + (0.43615192174911499) * gru_0_fwd_t1_h_4 + (-0.72494274377822876) * gru_0_fwd_t1_h_5 + (0.4647325873374939) * gru_0_fwd_t1_h_6 + (-0.3504166305065155) * gru_0_fwd_t1_h_7 + (-0.33796301484107971) * gru_0_fwd_t1_h_8 + (0.78930020332336426) * gru_0_fwd_t1_h_9 + (-0.50476491451263428) * gru_0_fwd_t1_h_10 + (-0.051537793129682541) * gru_0_fwd_t1_h_11 + (0.034409511834383011) * gru_0_fwd_t1_h_12 + (-0.26844742894172668) * gru_0_fwd_t1_h_13 + (0.8788037896156311) * gru_0_fwd_t1_h_14 + (-1.0153942108154297) * gru_0_fwd_t1_h_15 + (-0.34188517928123474) * gru_0_fwd_t1_h_16 + (-0.34899944067001343) * gru_0_fwd_t1_h_17 + (-0.095836363732814789) * gru_0_fwd_t1_h_18 + (0.57752382755279541) * gru_0_fwd_t1_h_19 + (1.1987779140472412) * gru_0_fwd_t1_h_20 + (-0.44032391905784607) * gru_0_fwd_t1_h_21 + (0.60819721221923828) * gru_0_fwd_t1_h_22 + (0.25165799260139465) * gru_0_fwd_t1_h_23 + (-0.56415039300918579) * gru_0_fwd_t1_h_24 + (-0.29410898685455322) * gru_0_fwd_t1_h_25 + (-0.57440894842147827) * gru_0_fwd_t1_h_26 + (-0.14908777177333832) * gru_0_fwd_t1_h_27 + (-0.66039663553237915) * gru_0_fwd_t1_h_28 + (0.3433452844619751) * gru_0_fwd_t1_h_29 + (1.1735707521438599) * gru_0_fwd_t1_h_30 + (0.20559163391590118) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.39140915870666504) + (-0.67698490619659424) * emb_t2_0 + (-0.80705404281616211) * emb_t2_1 + (1.0790296792984009) * emb_t2_2 + (1.0978012084960938) * emb_t2_3 + (-0.88060504198074341) * emb_t2_4 + (-0.84607565402984619) * emb_t2_5 + (-0.52532118558883667) * emb_t2_6 + (-0.53780955076217651) * emb_t2_7 + (-0.0068129743449389935) * emb_t2_8 + (-0.29163098335266113) * emb_t2_9 + (0.0051349555142223835) * emb_t2_10 + (0.40578261017799377) * emb_t2_11 + (0.15872283279895782) * emb_t2_12 + (-0.9215700626373291) * emb_t2_13 + (0.51005488634109497) * emb_t2_14 + (-0.72411704063415527) * emb_t2_15 + (0.96439224481582642) * emb_t2_16 + (-0.41004228591918945) * emb_t2_17 + (-0.27323082089424133) * emb_t2_18 + (-0.049840778112411499) * emb_t2_19 + (0.50790828466415405) * emb_t2_20 + (0.083430811762809753) * emb_t2_21 + (-0.32941734790802002) * emb_t2_22 + (-0.24746724963188171) * emb_t2_23 + (-0.11090182512998581) * emb_t2_24 + (0.16097165644168854) * emb_t2_25 + (0.74761050939559937) * emb_t2_26 + (-0.024324916303157806) * emb_t2_27 + (1.0168131589889526) * emb_t2_28 + (-0.6490330696105957) * emb_t2_29 + (0.58900725841522217) * emb_t2_30 + (-0.26816087961196899) * emb_t2_31 + gate_r * ((0.26287850737571716) + (-0.87151265144348145) * gru_0_fwd_t1_h_0 + (0.079764075577259064) * gru_0_fwd_t1_h_1 + (0.6464037299156189) * gru_0_fwd_t1_h_2 + (0.99149185419082642) * gru_0_fwd_t1_h_3 + (-0.4884907603263855) * gru_0_fwd_t1_h_4 + (0.81641274690628052) * gru_0_fwd_t1_h_5 + (0.70681911706924438) * gru_0_fwd_t1_h_6 + (-0.6423795223236084) * gru_0_fwd_t1_h_7 + (-0.55720096826553345) * gru_0_fwd_t1_h_8 + (-0.38112422823905945) * gru_0_fwd_t1_h_9 + (-0.67650300264358521) * gru_0_fwd_t1_h_10 + (-0.22080881893634796) * gru_0_fwd_t1_h_11 + (-0.14645957946777344) * gru_0_fwd_t1_h_12 + (0.058525077998638153) * gru_0_fwd_t1_h_13 + (0.11350750923156738) * gru_0_fwd_t1_h_14 + (0.98510921001434326) * gru_0_fwd_t1_h_15 + (-0.30893206596374512) * gru_0_fwd_t1_h_16 + (-0.34031704068183899) * gru_0_fwd_t1_h_17 + (0.28325998783111572) * gru_0_fwd_t1_h_18 + (-0.26171451807022095) * gru_0_fwd_t1_h_19 + (-0.13510438799858093) * gru_0_fwd_t1_h_20 + (-0.70780932903289795) * gru_0_fwd_t1_h_21 + (-1.1850879192352295) * gru_0_fwd_t1_h_22 + (0.39231094717979431) * gru_0_fwd_t1_h_23 + (0.41396823525428772) * gru_0_fwd_t1_h_24 + (-0.39159613847732544) * gru_0_fwd_t1_h_25 + (0.34244439005851746) * gru_0_fwd_t1_h_26 + (0.045419353991746902) * gru_0_fwd_t1_h_27 + (-0.37839597463607788) * gru_0_fwd_t1_h_28 + (-0.038326457142829895) * gru_0_fwd_t1_h_29 + (-0.55365782976150513) * gru_0_fwd_t1_h_30 + (-1.0095475912094116) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_2 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_2;
    // h=3
    gate_r = sigmoid((2.0616135597229004) + (0.71142196655273438) * emb_t2_0 + (-0.67579418420791626) * emb_t2_1 + (0.80988782644271851) * emb_t2_2 + (0.92023617029190063) * emb_t2_3 + (-0.54527401924133301) * emb_t2_4 + (-0.66617655754089355) * emb_t2_5 + (-0.41110676527023315) * emb_t2_6 + (-0.45798861980438232) * emb_t2_7 + (1.4377447366714478) * emb_t2_8 + (-0.54545134305953979) * emb_t2_9 + (-0.51568645238876343) * emb_t2_10 + (0.86354160308837891) * emb_t2_11 + (1.1853562593460083) * emb_t2_12 + (-0.44326707720756531) * emb_t2_13 + (-0.27643707394599915) * emb_t2_14 + (-0.39381590485572815) * emb_t2_15 + (0.98329824209213257) * emb_t2_16 + (-1.3900668621063232) * emb_t2_17 + (-0.73472511768341064) * emb_t2_18 + (0.62257307767868042) * emb_t2_19 + (1.1014494895935059) * emb_t2_20 + (-0.060367707163095474) * emb_t2_21 + (-0.88237887620925903) * emb_t2_22 + (0.83154028654098511) * emb_t2_23 + (-0.69370627403259277) * emb_t2_24 + (-0.026786744594573975) * emb_t2_25 + (1.432295560836792) * emb_t2_26 + (1.1666529178619385) * emb_t2_27 + (0.64240127801895142) * emb_t2_28 + (0.19445528090000153) * emb_t2_29 + (0.75998324155807495) * emb_t2_30 + (-1.4978399276733398) * emb_t2_31 + (0.0029225083999335766) * gru_0_fwd_t1_h_0 + (-0.15116763114929199) * gru_0_fwd_t1_h_1 + (-0.23434220254421234) * gru_0_fwd_t1_h_2 + (0.15430980920791626) * gru_0_fwd_t1_h_3 + (-0.041666973382234573) * gru_0_fwd_t1_h_4 + (-0.25092947483062744) * gru_0_fwd_t1_h_5 + (-0.29780954122543335) * gru_0_fwd_t1_h_6 + (0.30151170492172241) * gru_0_fwd_t1_h_7 + (-0.94460630416870117) * gru_0_fwd_t1_h_8 + (0.37143081426620483) * gru_0_fwd_t1_h_9 + (0.0040653105825185776) * gru_0_fwd_t1_h_10 + (0.15777058899402618) * gru_0_fwd_t1_h_11 + (-0.054552480578422546) * gru_0_fwd_t1_h_12 + (0.0010760886361822486) * gru_0_fwd_t1_h_13 + (0.59394961595535278) * gru_0_fwd_t1_h_14 + (-0.016164951026439667) * gru_0_fwd_t1_h_15 + (-0.77562737464904785) * gru_0_fwd_t1_h_16 + (-0.22821228206157684) * gru_0_fwd_t1_h_17 + (-0.29330494999885559) * gru_0_fwd_t1_h_18 + (0.020681081339716911) * gru_0_fwd_t1_h_19 + (0.32564654946327209) * gru_0_fwd_t1_h_20 + (-0.46010440587997437) * gru_0_fwd_t1_h_21 + (-0.81573671102523804) * gru_0_fwd_t1_h_22 + (0.92043167352676392) * gru_0_fwd_t1_h_23 + (-0.30672469735145569) * gru_0_fwd_t1_h_24 + (0.15629678964614868) * gru_0_fwd_t1_h_25 + (-0.88393104076385498) * gru_0_fwd_t1_h_26 + (-0.50379687547683716) * gru_0_fwd_t1_h_27 + (-0.19383423030376434) * gru_0_fwd_t1_h_28 + (0.20079107582569122) * gru_0_fwd_t1_h_29 + (0.83839195966720581) * gru_0_fwd_t1_h_30 + (0.36538109183311462) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.34568828344345093) + (0.039076611399650574) * emb_t2_0 + (-0.34323811531066895) * emb_t2_1 + (0.036192145198583603) * emb_t2_2 + (0.098099231719970703) * emb_t2_3 + (-0.64821422100067139) * emb_t2_4 + (0.033175818622112274) * emb_t2_5 + (-0.30631464719772339) * emb_t2_6 + (-0.020301338285207748) * emb_t2_7 + (0.087605379521846771) * emb_t2_8 + (-0.21309278905391693) * emb_t2_9 + (0.33025351166725159) * emb_t2_10 + (0.45017609000205994) * emb_t2_11 + (0.062943413853645325) * emb_t2_12 + (-0.12065744400024414) * emb_t2_13 + (-0.010905683971941471) * emb_t2_14 + (0.00064206327078863978) * emb_t2_15 + (0.0022179239895194769) * emb_t2_16 + (-0.83086913824081421) * emb_t2_17 + (0.043832376599311829) * emb_t2_18 + (0.27413231134414673) * emb_t2_19 + (-0.033662624657154083) * emb_t2_20 + (-0.021364977583289146) * emb_t2_21 + (0.28776085376739502) * emb_t2_22 + (-0.021695900708436966) * emb_t2_23 + (-0.099969953298568726) * emb_t2_24 + (-0.068793967366218567) * emb_t2_25 + (0.19015796482563019) * emb_t2_26 + (0.0076117902062833309) * emb_t2_27 + (0.047480151057243347) * emb_t2_28 + (-0.49421864748001099) * emb_t2_29 + (0.12573356926441193) * emb_t2_30 + (-0.15962667763233185) * emb_t2_31 + (0.16882030665874481) * gru_0_fwd_t1_h_0 + (0.092336326837539673) * gru_0_fwd_t1_h_1 + (0.76554650068283081) * gru_0_fwd_t1_h_2 + (1.1071410179138184) * gru_0_fwd_t1_h_3 + (0.12482080608606339) * gru_0_fwd_t1_h_4 + (0.36299654841423035) * gru_0_fwd_t1_h_5 + (-0.11517822742462158) * gru_0_fwd_t1_h_6 + (-0.47770243883132935) * gru_0_fwd_t1_h_7 + (1.4788484573364258) * gru_0_fwd_t1_h_8 + (0.27992838621139526) * gru_0_fwd_t1_h_9 + (-1.0805906057357788) * gru_0_fwd_t1_h_10 + (0.21662548184394836) * gru_0_fwd_t1_h_11 + (-0.005391064565628767) * gru_0_fwd_t1_h_12 + (-0.51090967655181885) * gru_0_fwd_t1_h_13 + (0.30192378163337708) * gru_0_fwd_t1_h_14 + (-0.014525953680276871) * gru_0_fwd_t1_h_15 + (-0.60952997207641602) * gru_0_fwd_t1_h_16 + (0.0054739476181566715) * gru_0_fwd_t1_h_17 + (0.66594505310058594) * gru_0_fwd_t1_h_18 + (-0.67218697071075439) * gru_0_fwd_t1_h_19 + (1.1015058755874634) * gru_0_fwd_t1_h_20 + (-0.49346360564231873) * gru_0_fwd_t1_h_21 + (0.38011345267295837) * gru_0_fwd_t1_h_22 + (-1.1572955846786499) * gru_0_fwd_t1_h_23 + (-0.025127673521637917) * gru_0_fwd_t1_h_24 + (-0.16782048344612122) * gru_0_fwd_t1_h_25 + (0.65971511602401733) * gru_0_fwd_t1_h_26 + (1.0656977891921997) * gru_0_fwd_t1_h_27 + (-1.7666223049163818) * gru_0_fwd_t1_h_28 + (-0.0043406952172517776) * gru_0_fwd_t1_h_29 + (0.42101752758026123) * gru_0_fwd_t1_h_30 + (0.28552570939064026) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.26719158887863159) + (0.073961347341537476) * emb_t2_0 + (-0.23871782422065735) * emb_t2_1 + (0.01909891702234745) * emb_t2_2 + (0.03399026021361351) * emb_t2_3 + (-0.61227846145629883) * emb_t2_4 + (-0.44694602489471436) * emb_t2_5 + (-0.13722310960292816) * emb_t2_6 + (-0.10464496165513992) * emb_t2_7 + (0.54586118459701538) * emb_t2_8 + (-0.059800054877996445) * emb_t2_9 + (-0.22064962983131409) * emb_t2_10 + (-0.39844140410423279) * emb_t2_11 + (0.082724079489707947) * emb_t2_12 + (0.020851833745837212) * emb_t2_13 + (-0.077367633581161499) * emb_t2_14 + (0.20684503018856049) * emb_t2_15 + (-0.022860409691929817) * emb_t2_16 + (-0.524647057056427) * emb_t2_17 + (0.10104715824127197) * emb_t2_18 + (0.14221270382404327) * emb_t2_19 + (0.30949804186820984) * emb_t2_20 + (0.29831352829933167) * emb_t2_21 + (-0.11125599592924118) * emb_t2_22 + (0.17298436164855957) * emb_t2_23 + (0.074098840355873108) * emb_t2_24 + (-0.014910106547176838) * emb_t2_25 + (0.45245653390884399) * emb_t2_26 + (0.15315267443656921) * emb_t2_27 + (0.259847491979599) * emb_t2_28 + (-0.11423767358064651) * emb_t2_29 + (-0.021640364080667496) * emb_t2_30 + (-0.10989490151405334) * emb_t2_31 + gate_r * ((0.26690664887428284) + (-0.022662045434117317) * gru_0_fwd_t1_h_0 + (-0.052836522459983826) * gru_0_fwd_t1_h_1 + (-0.033227104693651199) * gru_0_fwd_t1_h_2 + (-0.80096763372421265) * gru_0_fwd_t1_h_3 + (0.086029626429080963) * gru_0_fwd_t1_h_4 + (0.073501788079738617) * gru_0_fwd_t1_h_5 + (-0.77572256326675415) * gru_0_fwd_t1_h_6 + (0.17834819853305817) * gru_0_fwd_t1_h_7 + (0.92684692144393921) * gru_0_fwd_t1_h_8 + (1.8719316720962524) * gru_0_fwd_t1_h_9 + (0.2827606201171875) * gru_0_fwd_t1_h_10 + (-0.29582798480987549) * gru_0_fwd_t1_h_11 + (-0.40276676416397095) * gru_0_fwd_t1_h_12 + (-0.019562100991606712) * gru_0_fwd_t1_h_13 + (-0.28205779194831848) * gru_0_fwd_t1_h_14 + (-0.17583282291889191) * gru_0_fwd_t1_h_15 + (0.51120454072952271) * gru_0_fwd_t1_h_16 + (0.22647292912006378) * gru_0_fwd_t1_h_17 + (0.21033297479152679) * gru_0_fwd_t1_h_18 + (-0.076914645731449127) * gru_0_fwd_t1_h_19 + (0.8550066351890564) * gru_0_fwd_t1_h_20 + (0.26958692073822021) * gru_0_fwd_t1_h_21 + (-0.41717883944511414) * gru_0_fwd_t1_h_22 + (-1.0278539657592773) * gru_0_fwd_t1_h_23 + (0.40542715787887573) * gru_0_fwd_t1_h_24 + (-0.35031956434249878) * gru_0_fwd_t1_h_25 + (0.93681043386459351) * gru_0_fwd_t1_h_26 + (0.69629907608032227) * gru_0_fwd_t1_h_27 + (-0.58897274732589722) * gru_0_fwd_t1_h_28 + (0.75152206420898438) * gru_0_fwd_t1_h_29 + (-0.13744856417179108) * gru_0_fwd_t1_h_30 + (-0.93443822860717773) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_3 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_3;
    // h=4
    gate_r = sigmoid((-0.42540422081947327) + (-0.20194695889949799) * emb_t2_0 + (-0.95910543203353882) * emb_t2_1 + (0.14472165703773499) * emb_t2_2 + (-0.34521442651748657) * emb_t2_3 + (-0.48468440771102905) * emb_t2_4 + (0.11014232039451599) * emb_t2_5 + (-0.51376980543136597) * emb_t2_6 + (0.52164840698242188) * emb_t2_7 + (-1.1992356777191162) * emb_t2_8 + (1.9889419078826904) * emb_t2_9 + (1.8071471452713013) * emb_t2_10 + (-0.21530884504318237) * emb_t2_11 + (-0.89563268423080444) * emb_t2_12 + (-1.293562650680542) * emb_t2_13 + (-0.36114555597305298) * emb_t2_14 + (-0.29163080453872681) * emb_t2_15 + (0.22430737316608429) * emb_t2_16 + (0.22678232192993164) * emb_t2_17 + (1.9108097553253174) * emb_t2_18 + (-1.6922171115875244) * emb_t2_19 + (-0.031985752284526825) * emb_t2_20 + (-0.32923278212547302) * emb_t2_21 + (1.4173957109451294) * emb_t2_22 + (0.71515220403671265) * emb_t2_23 + (-0.19276925921440125) * emb_t2_24 + (0.76860618591308594) * emb_t2_25 + (0.33217763900756836) * emb_t2_26 + (-0.052287697792053223) * emb_t2_27 + (0.59960746765136719) * emb_t2_28 + (-0.80978822708129883) * emb_t2_29 + (0.14780299365520477) * emb_t2_30 + (0.89851784706115723) * emb_t2_31 + (-0.51567816734313965) * gru_0_fwd_t1_h_0 + (-0.56715703010559082) * gru_0_fwd_t1_h_1 + (-0.76100736856460571) * gru_0_fwd_t1_h_2 + (0.12674760818481445) * gru_0_fwd_t1_h_3 + (-0.77764767408370972) * gru_0_fwd_t1_h_4 + (-0.12644243240356445) * gru_0_fwd_t1_h_5 + (0.11164414137601852) * gru_0_fwd_t1_h_6 + (0.040539879351854324) * gru_0_fwd_t1_h_7 + (0.034693639725446701) * gru_0_fwd_t1_h_8 + (-0.25370112061500549) * gru_0_fwd_t1_h_9 + (0.63955771923065186) * gru_0_fwd_t1_h_10 + (0.12075168639421463) * gru_0_fwd_t1_h_11 + (0.25066637992858887) * gru_0_fwd_t1_h_12 + (0.46603596210479736) * gru_0_fwd_t1_h_13 + (-1.1255018711090088) * gru_0_fwd_t1_h_14 + (0.19626860320568085) * gru_0_fwd_t1_h_15 + (0.72975033521652222) * gru_0_fwd_t1_h_16 + (0.22281630337238312) * gru_0_fwd_t1_h_17 + (-0.2345568835735321) * gru_0_fwd_t1_h_18 + (0.042392414063215256) * gru_0_fwd_t1_h_19 + (-0.80893850326538086) * gru_0_fwd_t1_h_20 + (0.7035185694694519) * gru_0_fwd_t1_h_21 + (0.56572258472442627) * gru_0_fwd_t1_h_22 + (0.40611037611961365) * gru_0_fwd_t1_h_23 + (0.4424368143081665) * gru_0_fwd_t1_h_24 + (0.084960758686065674) * gru_0_fwd_t1_h_25 + (0.45271366834640503) * gru_0_fwd_t1_h_26 + (-0.50831377506256104) * gru_0_fwd_t1_h_27 + (0.73261266946792603) * gru_0_fwd_t1_h_28 + (-0.857352614402771) * gru_0_fwd_t1_h_29 + (-1.8184003829956055) * gru_0_fwd_t1_h_30 + (0.13682495057582855) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-0.12614654004573822) + (0.063160456717014313) * emb_t2_0 + (0.76167243719100952) * emb_t2_1 + (-0.13877630233764648) * emb_t2_2 + (-0.24188467860221863) * emb_t2_3 + (0.12049203366041183) * emb_t2_4 + (-0.17847223579883575) * emb_t2_5 + (0.30450329184532166) * emb_t2_6 + (-0.018857929855585098) * emb_t2_7 + (-0.244153693318367) * emb_t2_8 + (-0.68224793672561646) * emb_t2_9 + (-0.58444565534591675) * emb_t2_10 + (0.10306438058614731) * emb_t2_11 + (0.37857431173324585) * emb_t2_12 + (0.61797225475311279) * emb_t2_13 + (-0.022410331293940544) * emb_t2_14 + (0.089360855519771576) * emb_t2_15 + (0.059475280344486237) * emb_t2_16 + (0.11812642216682434) * emb_t2_17 + (-0.56128388643264771) * emb_t2_18 + (0.34508559107780457) * emb_t2_19 + (0.32594844698905945) * emb_t2_20 + (0.22418150305747986) * emb_t2_21 + (-0.06485816091299057) * emb_t2_22 + (-0.18808339536190033) * emb_t2_23 + (0.17854022979736328) * emb_t2_24 + (0.013190185651183128) * emb_t2_25 + (-0.1965005099773407) * emb_t2_26 + (-0.013800891116261482) * emb_t2_27 + (-0.66975629329681396) * emb_t2_28 + (1.1487005949020386) * emb_t2_29 + (0.038125619292259216) * emb_t2_30 + (-0.019804768264293671) * emb_t2_31 + (-0.22040164470672607) * gru_0_fwd_t1_h_0 + (-0.13487111032009125) * gru_0_fwd_t1_h_1 + (0.45504340529441833) * gru_0_fwd_t1_h_2 + (0.71854871511459351) * gru_0_fwd_t1_h_3 + (0.0041064741089940071) * gru_0_fwd_t1_h_4 + (-0.083416014909744263) * gru_0_fwd_t1_h_5 + (0.47878170013427734) * gru_0_fwd_t1_h_6 + (-0.20850211381912231) * gru_0_fwd_t1_h_7 + (0.30431303381919861) * gru_0_fwd_t1_h_8 + (0.25619006156921387) * gru_0_fwd_t1_h_9 + (-0.15055945515632629) * gru_0_fwd_t1_h_10 + (-0.41622769832611084) * gru_0_fwd_t1_h_11 + (0.17886780202388763) * gru_0_fwd_t1_h_12 + (0.097652234137058258) * gru_0_fwd_t1_h_13 + (-0.2066226601600647) * gru_0_fwd_t1_h_14 + (0.16189447045326233) * gru_0_fwd_t1_h_15 + (0.40761211514472961) * gru_0_fwd_t1_h_16 + (0.36098375916481018) * gru_0_fwd_t1_h_17 + (-0.1346014142036438) * gru_0_fwd_t1_h_18 + (1.0225104093551636) * gru_0_fwd_t1_h_19 + (0.52674251794815063) * gru_0_fwd_t1_h_20 + (0.921284019947052) * gru_0_fwd_t1_h_21 + (-0.074175886809825897) * gru_0_fwd_t1_h_22 + (-0.52639615535736084) * gru_0_fwd_t1_h_23 + (-0.38648593425750732) * gru_0_fwd_t1_h_24 + (-0.22507306933403015) * gru_0_fwd_t1_h_25 + (0.0013962397351861) * gru_0_fwd_t1_h_26 + (0.65791290998458862) * gru_0_fwd_t1_h_27 + (-1.5255998373031616) * gru_0_fwd_t1_h_28 + (0.65613555908203125) * gru_0_fwd_t1_h_29 + (-0.14266866445541382) * gru_0_fwd_t1_h_30 + (1.3813296556472778) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-1.76043701171875) + (-0.025369701907038689) * emb_t2_0 + (0.14386425912380219) * emb_t2_1 + (-0.012411795556545258) * emb_t2_2 + (-1.3306212425231934) * emb_t2_3 + (0.059490438550710678) * emb_t2_4 + (0.010017807595431805) * emb_t2_5 + (-0.38581046462059021) * emb_t2_6 + (0.026102280244231224) * emb_t2_7 + (-5.3316059112548828) * emb_t2_8 + (0.55693513154983521) * emb_t2_9 + (1.075499415397644) * emb_t2_10 + (-2.0826752185821533) * emb_t2_11 + (-3.896381139755249) * emb_t2_12 + (-0.012725798413157463) * emb_t2_13 + (0.012099700979888439) * emb_t2_14 + (-0.0090013118460774422) * emb_t2_15 + (-0.028221515938639641) * emb_t2_16 + (0.84943634271621704) * emb_t2_17 + (0.70072305202484131) * emb_t2_18 + (-0.91486865282058716) * emb_t2_19 + (-1.1964467763900757) * emb_t2_20 + (0.011377644725143909) * emb_t2_21 + (1.5379612445831299) * emb_t2_22 + (0.018764521926641464) * emb_t2_23 + (0.029102124273777008) * emb_t2_24 + (0.012979962863028049) * emb_t2_25 + (-0.72028487920761108) * emb_t2_26 + (0.0051553375087678432) * emb_t2_27 + (0.30544823408126831) * emb_t2_28 + (-0.11053411662578583) * emb_t2_29 + (-0.22952638566493988) * emb_t2_30 + (7.9563412666320801) * emb_t2_31 + gate_r * ((-1.7395802736282349) + (0.21468006074428558) * gru_0_fwd_t1_h_0 + (0.31632700562477112) * gru_0_fwd_t1_h_1 + (-1.3728216886520386) * gru_0_fwd_t1_h_2 + (-1.3128889799118042) * gru_0_fwd_t1_h_3 + (0.41887176036834717) * gru_0_fwd_t1_h_4 + (1.8807141780853271) * gru_0_fwd_t1_h_5 + (-0.32382175326347351) * gru_0_fwd_t1_h_6 + (0.61316955089569092) * gru_0_fwd_t1_h_7 + (0.58693748712539673) * gru_0_fwd_t1_h_8 + (0.82091033458709717) * gru_0_fwd_t1_h_9 + (0.95194673538208008) * gru_0_fwd_t1_h_10 + (0.18054668605327606) * gru_0_fwd_t1_h_11 + (-0.36203131079673767) * gru_0_fwd_t1_h_12 + (-0.33648210763931274) * gru_0_fwd_t1_h_13 + (0.10990398377180099) * gru_0_fwd_t1_h_14 + (-0.30996939539909363) * gru_0_fwd_t1_h_15 + (-0.03934512659907341) * gru_0_fwd_t1_h_16 + (0.043142590671777725) * gru_0_fwd_t1_h_17 + (0.2073424905538559) * gru_0_fwd_t1_h_18 + (0.45217365026473999) * gru_0_fwd_t1_h_19 + (0.46624067425727844) * gru_0_fwd_t1_h_20 + (0.70023840665817261) * gru_0_fwd_t1_h_21 + (-1.57627272605896) * gru_0_fwd_t1_h_22 + (-2.2531149387359619) * gru_0_fwd_t1_h_23 + (1.8536632061004639) * gru_0_fwd_t1_h_24 + (1.3966832160949707) * gru_0_fwd_t1_h_25 + (1.5252846479415894) * gru_0_fwd_t1_h_26 + (-1.3774404525756836) * gru_0_fwd_t1_h_27 + (1.5402415990829468) * gru_0_fwd_t1_h_28 + (0.60441911220550537) * gru_0_fwd_t1_h_29 + (0.22831811010837555) * gru_0_fwd_t1_h_30 + (-1.2709026336669922) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_4 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_4;
    // h=5
    gate_r = sigmoid((0.69085609912872314) + (0.31221577525138855) * emb_t2_0 + (-0.82488334178924561) * emb_t2_1 + (-0.48002389073371887) * emb_t2_2 + (0.15588852763175964) * emb_t2_3 + (-0.55411601066589355) * emb_t2_4 + (-0.87167394161224365) * emb_t2_5 + (-0.35193851590156555) * emb_t2_6 + (-0.92096197605133057) * emb_t2_7 + (0.27015870809555054) * emb_t2_8 + (0.029425617307424545) * emb_t2_9 + (-0.13232792913913727) * emb_t2_10 + (0.446541428565979) * emb_t2_11 + (0.17258265614509583) * emb_t2_12 + (-0.42043307423591614) * emb_t2_13 + (-0.22850875556468964) * emb_t2_14 + (-0.29999476671218872) * emb_t2_15 + (0.25832659006118774) * emb_t2_16 + (-0.86852681636810303) * emb_t2_17 + (0.12863753736019135) * emb_t2_18 + (0.020937630906701088) * emb_t2_19 + (-0.0073465197347104549) * emb_t2_20 + (-0.74482583999633789) * emb_t2_21 + (-0.092235080897808075) * emb_t2_22 + (-0.13648895919322968) * emb_t2_23 + (-0.64163213968276978) * emb_t2_24 + (-0.3159889280796051) * emb_t2_25 + (0.43557935953140259) * emb_t2_26 + (0.50488400459289551) * emb_t2_27 + (0.37466296553611755) * emb_t2_28 + (-0.42972543835639954) * emb_t2_29 + (0.2659851610660553) * emb_t2_30 + (0.14337827265262604) * emb_t2_31 + (0.61873674392700195) * gru_0_fwd_t1_h_0 + (-0.017917118966579437) * gru_0_fwd_t1_h_1 + (-1.8224114179611206) * gru_0_fwd_t1_h_2 + (-0.59753429889678955) * gru_0_fwd_t1_h_3 + (-0.57076460123062134) * gru_0_fwd_t1_h_4 + (-2.0504193305969238) * gru_0_fwd_t1_h_5 + (1.9493581056594849) * gru_0_fwd_t1_h_6 + (1.2902820110321045) * gru_0_fwd_t1_h_7 + (-1.5305608510971069) * gru_0_fwd_t1_h_8 + (-1.7380726337432861) * gru_0_fwd_t1_h_9 + (1.816393256187439) * gru_0_fwd_t1_h_10 + (2.3497500419616699) * gru_0_fwd_t1_h_11 + (-0.23452471196651459) * gru_0_fwd_t1_h_12 + (0.92605024576187134) * gru_0_fwd_t1_h_13 + (0.35671943426132202) * gru_0_fwd_t1_h_14 + (-1.2052809000015259) * gru_0_fwd_t1_h_15 + (-2.1646435260772705) * gru_0_fwd_t1_h_16 + (-2.3369350433349609) * gru_0_fwd_t1_h_17 + (-0.34785282611846924) * gru_0_fwd_t1_h_18 + (0.13206294178962708) * gru_0_fwd_t1_h_19 + (-3.3028016090393066) * gru_0_fwd_t1_h_20 + (-2.3300776481628418) * gru_0_fwd_t1_h_21 + (3.3226301670074463) * gru_0_fwd_t1_h_22 + (2.7316522598266602) * gru_0_fwd_t1_h_23 + (-0.023522058501839638) * gru_0_fwd_t1_h_24 + (-2.2624697685241699) * gru_0_fwd_t1_h_25 + (0.4919765293598175) * gru_0_fwd_t1_h_26 + (0.5446324348449707) * gru_0_fwd_t1_h_27 + (1.1471512317657471) * gru_0_fwd_t1_h_28 + (-1.5590293407440186) * gru_0_fwd_t1_h_29 + (-0.0038357814773917198) * gru_0_fwd_t1_h_30 + (2.4355244636535645) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-1.3584561347961426) + (-0.0028366802725940943) * emb_t2_0 + (0.10478486865758896) * emb_t2_1 + (-0.0043737040832638741) * emb_t2_2 + (-0.12542122602462769) * emb_t2_3 + (-0.074945889413356781) * emb_t2_4 + (-0.0013680461561307311) * emb_t2_5 + (-0.60080075263977051) * emb_t2_6 + (0.0014825690304860473) * emb_t2_7 + (-0.10453623533248901) * emb_t2_8 + (0.12971755862236023) * emb_t2_9 + (-0.054391741752624512) * emb_t2_10 + (-0.1130511686205864) * emb_t2_11 + (-0.0076990043744444847) * emb_t2_12 + (-0.29454752802848816) * emb_t2_13 + (0.0013349719811230898) * emb_t2_14 + (-0.0045643039047718048) * emb_t2_15 + (0.00097404565894976258) * emb_t2_16 + (0.49722012877464294) * emb_t2_17 + (0.14380873739719391) * emb_t2_18 + (-0.20514595508575439) * emb_t2_19 + (-0.0036781732924282551) * emb_t2_20 + (-0.0014908264856785536) * emb_t2_21 + (0.12914152443408966) * emb_t2_22 + (0.0026829149574041367) * emb_t2_23 + (0.00024567241780459881) * emb_t2_24 + (-0.0021099650766700506) * emb_t2_25 + (-0.10728149116039276) * emb_t2_26 + (0.00099281745497137308) * emb_t2_27 + (0.19901151955127716) * emb_t2_28 + (0.16660270094871521) * emb_t2_29 + (0.30264109373092651) * emb_t2_30 + (0.1391928642988205) * emb_t2_31 + (-0.78484249114990234) * gru_0_fwd_t1_h_0 + (-0.22690363228321075) * gru_0_fwd_t1_h_1 + (0.20833475887775421) * gru_0_fwd_t1_h_2 + (-0.97122448682785034) * gru_0_fwd_t1_h_3 + (-0.035477478057146072) * gru_0_fwd_t1_h_4 + (-0.14066416025161743) * gru_0_fwd_t1_h_5 + (0.17683656513690948) * gru_0_fwd_t1_h_6 + (-0.18406268954277039) * gru_0_fwd_t1_h_7 + (-0.13486909866333008) * gru_0_fwd_t1_h_8 + (1.0655478239059448) * gru_0_fwd_t1_h_9 + (-0.10352278500795364) * gru_0_fwd_t1_h_10 + (-1.0076307058334351) * gru_0_fwd_t1_h_11 + (1.1224737167358398) * gru_0_fwd_t1_h_12 + (0.97996717691421509) * gru_0_fwd_t1_h_13 + (-0.72492486238479614) * gru_0_fwd_t1_h_14 + (0.048568349331617355) * gru_0_fwd_t1_h_15 + (0.9234168529510498) * gru_0_fwd_t1_h_16 + (0.85181432962417603) * gru_0_fwd_t1_h_17 + (0.44085222482681274) * gru_0_fwd_t1_h_18 + (-0.40077000856399536) * gru_0_fwd_t1_h_19 + (1.9128485918045044) * gru_0_fwd_t1_h_20 + (-0.24256855249404907) * gru_0_fwd_t1_h_21 + (-0.3128688633441925) * gru_0_fwd_t1_h_22 + (0.097645081579685211) * gru_0_fwd_t1_h_23 + (0.20936150848865509) * gru_0_fwd_t1_h_24 + (0.26143145561218262) * gru_0_fwd_t1_h_25 + (0.025976488366723061) * gru_0_fwd_t1_h_26 + (-0.1152612715959549) * gru_0_fwd_t1_h_27 + (-1.7720012664794922) * gru_0_fwd_t1_h_28 + (0.83317804336547852) * gru_0_fwd_t1_h_29 + (-0.064557112753391266) * gru_0_fwd_t1_h_30 + (-0.16293874382972717) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.58344340324401855) + (-0.02623157761991024) * emb_t2_0 + (-0.55218946933746338) * emb_t2_1 + (-0.020457925274968147) * emb_t2_2 + (0.426810622215271) * emb_t2_3 + (-0.63272702693939209) * emb_t2_4 + (0.042069733142852783) * emb_t2_5 + (-0.55493944883346558) * emb_t2_6 + (0.020925011485815048) * emb_t2_7 + (0.41323971748352051) * emb_t2_8 + (-0.45961034297943115) * emb_t2_9 + (-0.58583390712738037) * emb_t2_10 + (0.86403512954711914) * emb_t2_11 + (0.46509718894958496) * emb_t2_12 + (-0.021772902458906174) * emb_t2_13 + (0.0052866223268210888) * emb_t2_14 + (-0.0038351269904524088) * emb_t2_15 + (0.035317875444889069) * emb_t2_16 + (-0.82278656959533691) * emb_t2_17 + (-0.38640621304512024) * emb_t2_18 + (0.38335981965065002) * emb_t2_19 + (0.0016717606922611594) * emb_t2_20 + (0.065966054797172546) * emb_t2_21 + (-0.77871835231781006) * emb_t2_22 + (-0.00248179049231112) * emb_t2_23 + (0.060930978506803513) * emb_t2_24 + (0.0041049802675843239) * emb_t2_25 + (0.40128898620605469) * emb_t2_26 + (-0.012996932491660118) * emb_t2_27 + (0.053499244153499603) * emb_t2_28 + (-0.60031735897064209) * emb_t2_29 + (0.23656852543354034) * emb_t2_30 + (-0.3339596688747406) * emb_t2_31 + gate_r * ((0.64305049180984497) + (-0.58677196502685547) * gru_0_fwd_t1_h_0 + (-0.12564921379089355) * gru_0_fwd_t1_h_1 + (0.75933915376663208) * gru_0_fwd_t1_h_2 + (0.32983219623565674) * gru_0_fwd_t1_h_3 + (-0.11433876305818558) * gru_0_fwd_t1_h_4 + (-0.0088129052892327309) * gru_0_fwd_t1_h_5 + (1.1392234563827515) * gru_0_fwd_t1_h_6 + (-0.82398366928100586) * gru_0_fwd_t1_h_7 + (0.2930293083190918) * gru_0_fwd_t1_h_8 + (-0.88711154460906982) * gru_0_fwd_t1_h_9 + (-0.49756619334220886) * gru_0_fwd_t1_h_10 + (-0.56768560409545898) * gru_0_fwd_t1_h_11 + (0.017192307859659195) * gru_0_fwd_t1_h_12 + (0.1989082545042038) * gru_0_fwd_t1_h_13 + (-0.22937609255313873) * gru_0_fwd_t1_h_14 + (0.22781237959861755) * gru_0_fwd_t1_h_15 + (0.34069955348968506) * gru_0_fwd_t1_h_16 + (0.72557371854782104) * gru_0_fwd_t1_h_17 + (-0.024579359218478203) * gru_0_fwd_t1_h_18 + (-0.38082993030548096) * gru_0_fwd_t1_h_19 + (-0.7922016978263855) * gru_0_fwd_t1_h_20 + (0.19465383887290955) * gru_0_fwd_t1_h_21 + (-0.31221199035644531) * gru_0_fwd_t1_h_22 + (-0.24073119461536407) * gru_0_fwd_t1_h_23 + (-1.2072917222976685) * gru_0_fwd_t1_h_24 + (0.13368858397006989) * gru_0_fwd_t1_h_25 + (-0.075423531234264374) * gru_0_fwd_t1_h_26 + (0.018354333937168121) * gru_0_fwd_t1_h_27 + (1.2350516319274902) * gru_0_fwd_t1_h_28 + (0.26653066277503967) * gru_0_fwd_t1_h_29 + (-0.34060528874397278) * gru_0_fwd_t1_h_30 + (1.2555168867111206) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_5 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_5;
    // h=6
    gate_r = sigmoid((0.64718681573867798) + (0.19801533222198486) * emb_t2_0 + (-0.0867265984416008) * emb_t2_1 + (0.39526337385177612) * emb_t2_2 + (0.59442460536956787) * emb_t2_3 + (-1.6713958978652954) * emb_t2_4 + (-0.48412996530532837) * emb_t2_5 + (-1.2345925569534302) * emb_t2_6 + (0.3731066882610321) * emb_t2_7 + (-0.059344939887523651) * emb_t2_8 + (-0.17235365509986877) * emb_t2_9 + (0.098720982670783997) * emb_t2_10 + (0.8037988543510437) * emb_t2_11 + (0.17604853212833405) * emb_t2_12 + (-0.50221645832061768) * emb_t2_13 + (-0.072246849536895752) * emb_t2_14 + (-0.47506251931190491) * emb_t2_15 + (0.72383040189743042) * emb_t2_16 + (-1.1351902484893799) * emb_t2_17 + (-0.29391643404960632) * emb_t2_18 + (0.049772348254919052) * emb_t2_19 + (0.27598553895950317) * emb_t2_20 + (-0.43667089939117432) * emb_t2_21 + (-0.17478509247303009) * emb_t2_22 + (0.84320688247680664) * emb_t2_23 + (0.014079547487199306) * emb_t2_24 + (0.11643157154321671) * emb_t2_25 + (0.7422022819519043) * emb_t2_26 + (0.43766725063323975) * emb_t2_27 + (0.66482996940612793) * emb_t2_28 + (-0.97944372892379761) * emb_t2_29 + (1.7599998712539673) * emb_t2_30 + (-0.43428409099578857) * emb_t2_31 + (0.41334882378578186) * gru_0_fwd_t1_h_0 + (-0.1925504207611084) * gru_0_fwd_t1_h_1 + (-2.6722970008850098) * gru_0_fwd_t1_h_2 + (-1.6650885343551636) * gru_0_fwd_t1_h_3 + (-0.3213023841381073) * gru_0_fwd_t1_h_4 + (0.2936214804649353) * gru_0_fwd_t1_h_5 + (-1.6638959646224976) * gru_0_fwd_t1_h_6 + (2.747128963470459) * gru_0_fwd_t1_h_7 + (1.5438847541809082) * gru_0_fwd_t1_h_8 + (0.28904175758361816) * gru_0_fwd_t1_h_9 + (2.7759256362915039) * gru_0_fwd_t1_h_10 + (0.92301291227340698) * gru_0_fwd_t1_h_11 + (-0.0057234112173318863) * gru_0_fwd_t1_h_12 + (-0.02192533016204834) * gru_0_fwd_t1_h_13 + (0.50918436050415039) * gru_0_fwd_t1_h_14 + (-0.18030187487602234) * gru_0_fwd_t1_h_15 + (-0.30933082103729248) * gru_0_fwd_t1_h_16 + (-0.19719628989696503) * gru_0_fwd_t1_h_17 + (0.93164551258087158) * gru_0_fwd_t1_h_18 + (-2.1038591861724854) * gru_0_fwd_t1_h_19 + (-1.1186971664428711) * gru_0_fwd_t1_h_20 + (-0.55217283964157104) * gru_0_fwd_t1_h_21 + (-0.39519959688186646) * gru_0_fwd_t1_h_22 + (-0.70560318231582642) * gru_0_fwd_t1_h_23 + (2.5476551055908203) * gru_0_fwd_t1_h_24 + (1.6238029003143311) * gru_0_fwd_t1_h_25 + (1.268197774887085) * gru_0_fwd_t1_h_26 + (1.61891770362854) * gru_0_fwd_t1_h_27 + (-1.3980979919433594) * gru_0_fwd_t1_h_28 + (-0.21743656694889069) * gru_0_fwd_t1_h_29 + (0.32857745885848999) * gru_0_fwd_t1_h_30 + (-0.021983066573739052) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.65747576951980591) + (0.067206531763076782) * emb_t2_0 + (-1.0778428316116333) * emb_t2_1 + (0.013203871436417103) * emb_t2_2 + (0.66260325908660889) * emb_t2_3 + (-1.418946385383606) * emb_t2_4 + (0.1124672070145607) * emb_t2_5 + (-1.385934591293335) * emb_t2_6 + (0.071301370859146118) * emb_t2_7 + (-0.0080569591373205185) * emb_t2_8 + (0.87950176000595093) * emb_t2_9 + (0.783558189868927) * emb_t2_10 + (0.40700605511665344) * emb_t2_11 + (-0.21359671652317047) * emb_t2_12 + (-1.9497834444046021) * emb_t2_13 + (0.013992402702569962) * emb_t2_14 + (0.012638125568628311) * emb_t2_15 + (0.070883192121982574) * emb_t2_16 + (-0.49914065003395081) * emb_t2_17 + (0.9817812442779541) * emb_t2_18 + (-0.30810070037841797) * emb_t2_19 + (0.9564129114151001) * emb_t2_20 + (0.087537698447704315) * emb_t2_21 + (0.55111497640609741) * emb_t2_22 + (-0.18253946304321289) * emb_t2_23 + (0.020325871184468269) * emb_t2_24 + (-0.19879433512687683) * emb_t2_25 + (0.61750954389572144) * emb_t2_26 + (0.14947935938835144) * emb_t2_27 + (1.2325707674026489) * emb_t2_28 + (-1.5029821395874023) * emb_t2_29 + (0.86577075719833374) * emb_t2_30 + (0.03104882687330246) * emb_t2_31 + (0.59958583116531372) * gru_0_fwd_t1_h_0 + (0.2975432276725769) * gru_0_fwd_t1_h_1 + (1.02239990234375) * gru_0_fwd_t1_h_2 + (0.060360003262758255) * gru_0_fwd_t1_h_3 + (0.18729795515537262) * gru_0_fwd_t1_h_4 + (-0.079461477696895599) * gru_0_fwd_t1_h_5 + (0.94696670770645142) * gru_0_fwd_t1_h_6 + (-1.0941493511199951) * gru_0_fwd_t1_h_7 + (0.54810881614685059) * gru_0_fwd_t1_h_8 + (-0.23597410321235657) * gru_0_fwd_t1_h_9 + (-1.13671875) * gru_0_fwd_t1_h_10 + (0.035320322960615158) * gru_0_fwd_t1_h_11 + (-0.085650622844696045) * gru_0_fwd_t1_h_12 + (-0.0066009238362312317) * gru_0_fwd_t1_h_13 + (0.26930779218673706) * gru_0_fwd_t1_h_14 + (-0.71623456478118896) * gru_0_fwd_t1_h_15 + (-0.35170376300811768) * gru_0_fwd_t1_h_16 + (-0.23666961491107941) * gru_0_fwd_t1_h_17 + (0.27765944600105286) * gru_0_fwd_t1_h_18 + (-1.3791419267654419) * gru_0_fwd_t1_h_19 + (0.475484699010849) * gru_0_fwd_t1_h_20 + (0.26780727505683899) * gru_0_fwd_t1_h_21 + (0.76974028348922729) * gru_0_fwd_t1_h_22 + (-0.096689775586128235) * gru_0_fwd_t1_h_23 + (0.41597720980644226) * gru_0_fwd_t1_h_24 + (0.15075415372848511) * gru_0_fwd_t1_h_25 + (-0.48091259598731995) * gru_0_fwd_t1_h_26 + (0.64957869052886963) * gru_0_fwd_t1_h_27 + (-0.8535277247428894) * gru_0_fwd_t1_h_28 + (0.23530571162700653) * gru_0_fwd_t1_h_29 + (0.39489635825157166) * gru_0_fwd_t1_h_30 + (0.52870970964431763) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.099463798105716705) + (0.062709107995033264) * emb_t2_0 + (-1.2834712266921997) * emb_t2_1 + (-0.20859083533287048) * emb_t2_2 + (-0.23270703852176666) * emb_t2_3 + (-1.7919075489044189) * emb_t2_4 + (-0.14767941832542419) * emb_t2_5 + (-1.0104644298553467) * emb_t2_6 + (0.058522380888462067) * emb_t2_7 + (-0.043983135372400284) * emb_t2_8 + (0.87878221273422241) * emb_t2_9 + (0.63444536924362183) * emb_t2_10 + (0.33520248532295227) * emb_t2_11 + (0.19363673031330109) * emb_t2_12 + (-1.7711124420166016) * emb_t2_13 + (-0.071262359619140625) * emb_t2_14 + (0.23429438471794128) * emb_t2_15 + (-0.20724251866340637) * emb_t2_16 + (-0.54762935638427734) * emb_t2_17 + (0.27906295657157898) * emb_t2_18 + (-0.34379884600639343) * emb_t2_19 + (0.3323701024055481) * emb_t2_20 + (-0.067786872386932373) * emb_t2_21 + (0.44148370623588562) * emb_t2_22 + (0.070823103189468384) * emb_t2_23 + (0.046068795025348663) * emb_t2_24 + (0.0074522043578326702) * emb_t2_25 + (0.075301051139831543) * emb_t2_26 + (-0.041412565857172012) * emb_t2_27 + (0.99621200561523438) * emb_t2_28 + (-1.3909389972686768) * emb_t2_29 + (1.8566527366638184) * emb_t2_30 + (-0.0053352117538452148) * emb_t2_31 + gate_r * ((0.30352130532264709) + (0.29498741030693054) * gru_0_fwd_t1_h_0 + (0.28553986549377441) * gru_0_fwd_t1_h_1 + (-1.4457919597625732) * gru_0_fwd_t1_h_2 + (-1.5347727537155151) * gru_0_fwd_t1_h_3 + (0.31883007287979126) * gru_0_fwd_t1_h_4 + (0.24447634816169739) * gru_0_fwd_t1_h_5 + (-1.5395359992980957) * gru_0_fwd_t1_h_6 + (1.5528138875961304) * gru_0_fwd_t1_h_7 + (0.83012276887893677) * gru_0_fwd_t1_h_8 + (3.3659200668334961) * gru_0_fwd_t1_h_9 + (1.1309764385223389) * gru_0_fwd_t1_h_10 + (0.30454486608505249) * gru_0_fwd_t1_h_11 + (-0.10719244182109833) * gru_0_fwd_t1_h_12 + (-0.11211328208446503) * gru_0_fwd_t1_h_13 + (0.45527991652488708) * gru_0_fwd_t1_h_14 + (-0.20179574191570282) * gru_0_fwd_t1_h_15 + (-0.26636531949043274) * gru_0_fwd_t1_h_16 + (-0.11448907852172852) * gru_0_fwd_t1_h_17 + (0.1768258810043335) * gru_0_fwd_t1_h_18 + (2.2013874053955078) * gru_0_fwd_t1_h_19 + (5.6519656181335449) * gru_0_fwd_t1_h_20 + (0.069680765271186829) * gru_0_fwd_t1_h_21 + (-0.43679985404014587) * gru_0_fwd_t1_h_22 + (-0.86616194248199463) * gru_0_fwd_t1_h_23 + (1.6500822305679321) * gru_0_fwd_t1_h_24 + (1.1663918495178223) * gru_0_fwd_t1_h_25 + (0.0060790488496422768) * gru_0_fwd_t1_h_26 + (-1.0129396915435791) * gru_0_fwd_t1_h_27 + (-3.5183789730072021) * gru_0_fwd_t1_h_28 + (1.3851574659347534) * gru_0_fwd_t1_h_29 + (0.49753525853157043) * gru_0_fwd_t1_h_30 + (-0.61034590005874634) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_6 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_6;
    // h=7
    gate_r = sigmoid((0.51928806304931641) + (-0.66626828908920288) * emb_t2_0 + (-0.69206690788269043) * emb_t2_1 + (-0.62170642614364624) * emb_t2_2 + (0.37097975611686707) * emb_t2_3 + (-0.52362000942230225) * emb_t2_4 + (-0.77756184339523315) * emb_t2_5 + (-0.57556211948394775) * emb_t2_6 + (-0.203417107462883) * emb_t2_7 + (0.23473478853702545) * emb_t2_8 + (0.14919237792491913) * emb_t2_9 + (0.25177469849586487) * emb_t2_10 + (0.54501938819885254) * emb_t2_11 + (0.085423931479454041) * emb_t2_12 + (-0.52105075120925903) * emb_t2_13 + (0.28557261824607849) * emb_t2_14 + (0.41559216380119324) * emb_t2_15 + (-1.020171046257019) * emb_t2_16 + (-0.38878875970840454) * emb_t2_17 + (-0.0029973615892231464) * emb_t2_18 + (-0.043685823678970337) * emb_t2_19 + (0.29491478204727173) * emb_t2_20 + (0.517647385597229) * emb_t2_21 + (-0.30049300193786621) * emb_t2_22 + (0.30185249447822571) * emb_t2_23 + (0.021078580990433693) * emb_t2_24 + (-1.4541704654693604) * emb_t2_25 + (0.23514877259731293) * emb_t2_26 + (0.32835391163825989) * emb_t2_27 + (0.68314176797866821) * emb_t2_28 + (-1.168696403503418) * emb_t2_29 + (0.36824145913124084) * emb_t2_30 + (-0.071854352951049805) * emb_t2_31 + (0.067609131336212158) * gru_0_fwd_t1_h_0 + (0.44890889525413513) * gru_0_fwd_t1_h_1 + (0.6773419976234436) * gru_0_fwd_t1_h_2 + (-1.1850106716156006) * gru_0_fwd_t1_h_3 + (0.46819853782653809) * gru_0_fwd_t1_h_4 + (-0.42627942562103271) * gru_0_fwd_t1_h_5 + (1.5049042701721191) * gru_0_fwd_t1_h_6 + (-0.007247112225741148) * gru_0_fwd_t1_h_7 + (0.63717913627624512) * gru_0_fwd_t1_h_8 + (1.2650812864303589) * gru_0_fwd_t1_h_9 + (-0.70689678192138672) * gru_0_fwd_t1_h_10 + (-0.91478770971298218) * gru_0_fwd_t1_h_11 + (0.49776679277420044) * gru_0_fwd_t1_h_12 + (0.47686061263084412) * gru_0_fwd_t1_h_13 + (-0.11209805309772491) * gru_0_fwd_t1_h_14 + (0.2208324521780014) * gru_0_fwd_t1_h_15 + (0.41881099343299866) * gru_0_fwd_t1_h_16 + (0.93815094232559204) * gru_0_fwd_t1_h_17 + (0.032492909580469131) * gru_0_fwd_t1_h_18 + (-1.3166286945343018) * gru_0_fwd_t1_h_19 + (2.5782415866851807) * gru_0_fwd_t1_h_20 + (0.40010526776313782) * gru_0_fwd_t1_h_21 + (0.40507233142852783) * gru_0_fwd_t1_h_22 + (-0.64354175329208374) * gru_0_fwd_t1_h_23 + (-3.2980225086212158) * gru_0_fwd_t1_h_24 + (1.5116459131240845) * gru_0_fwd_t1_h_25 + (4.3645520210266113) * gru_0_fwd_t1_h_26 + (1.5522013902664185) * gru_0_fwd_t1_h_27 + (-1.4030581712722778) * gru_0_fwd_t1_h_28 + (1.7865886688232422) * gru_0_fwd_t1_h_29 + (0.41302406787872314) * gru_0_fwd_t1_h_30 + (-0.19169566035270691) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.73438847064971924) + (-0.0064645968377590179) * emb_t2_0 + (-0.18605630099773407) * emb_t2_1 + (-0.16207568347454071) * emb_t2_2 + (0.45738211274147034) * emb_t2_3 + (-0.46812623739242554) * emb_t2_4 + (-0.18255303800106049) * emb_t2_5 + (0.11743010580539703) * emb_t2_6 + (-0.12166249752044678) * emb_t2_7 + (0.29705497622489929) * emb_t2_8 + (-0.1868426501750946) * emb_t2_9 + (0.22550836205482483) * emb_t2_10 + (1.0174425840377808) * emb_t2_11 + (0.090879075229167938) * emb_t2_12 + (-0.70268082618713379) * emb_t2_13 + (-0.0981459841132164) * emb_t2_14 + (-0.11535448580980301) * emb_t2_15 + (-0.10888410359621048) * emb_t2_16 + (-0.5201079249382019) * emb_t2_17 + (0.19124570488929749) * emb_t2_18 + (-0.046256080269813538) * emb_t2_19 + (0.047293435782194138) * emb_t2_20 + (0.067851394414901733) * emb_t2_21 + (-0.34270498156547546) * emb_t2_22 + (0.073853291571140289) * emb_t2_23 + (0.22339893877506256) * emb_t2_24 + (0.24973474442958832) * emb_t2_25 + (0.49641150236129761) * emb_t2_26 + (-0.17480954527854919) * emb_t2_27 + (-0.0069416211917996407) * emb_t2_28 + (-0.66635668277740479) * emb_t2_29 + (0.090449713170528412) * emb_t2_30 + (-0.68994534015655518) * emb_t2_31 + (0.64985942840576172) * gru_0_fwd_t1_h_0 + (0.19538487493991852) * gru_0_fwd_t1_h_1 + (1.3278148174285889) * gru_0_fwd_t1_h_2 + (0.81885486841201782) * gru_0_fwd_t1_h_3 + (0.29815822839736938) * gru_0_fwd_t1_h_4 + (-0.50817477703094482) * gru_0_fwd_t1_h_5 + (-1.4653851985931396) * gru_0_fwd_t1_h_6 + (-0.80211502313613892) * gru_0_fwd_t1_h_7 + (-0.44001898169517517) * gru_0_fwd_t1_h_8 + (0.9476819634437561) * gru_0_fwd_t1_h_9 + (-0.98095953464508057) * gru_0_fwd_t1_h_10 + (0.72107189893722534) * gru_0_fwd_t1_h_11 + (-0.27601596713066101) * gru_0_fwd_t1_h_12 + (-0.79996955394744873) * gru_0_fwd_t1_h_13 + (0.10184107720851898) * gru_0_fwd_t1_h_14 + (0.14149783551692963) * gru_0_fwd_t1_h_15 + (-0.014779034070670605) * gru_0_fwd_t1_h_16 + (-0.41685998439788818) * gru_0_fwd_t1_h_17 + (0.11937406659126282) * gru_0_fwd_t1_h_18 + (1.5282425880432129) * gru_0_fwd_t1_h_19 + (0.74435275793075562) * gru_0_fwd_t1_h_20 + (-0.033118549734354019) * gru_0_fwd_t1_h_21 + (-1.0111247301101685) * gru_0_fwd_t1_h_22 + (0.60414385795593262) * gru_0_fwd_t1_h_23 + (0.82993137836456299) * gru_0_fwd_t1_h_24 + (-0.13905845582485199) * gru_0_fwd_t1_h_25 + (-0.14072522521018982) * gru_0_fwd_t1_h_26 + (-0.22697837650775909) * gru_0_fwd_t1_h_27 + (0.26962760090827942) * gru_0_fwd_t1_h_28 + (-0.12845060229301453) * gru_0_fwd_t1_h_29 + (0.38843050599098206) * gru_0_fwd_t1_h_30 + (1.9815202951431274) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.10830821096897125) + (-0.0044161300174891949) * emb_t2_0 + (1.2483489513397217) * emb_t2_1 + (-0.20249013602733612) * emb_t2_2 + (-0.47926110029220581) * emb_t2_3 + (0.37111401557922363) * emb_t2_4 + (-0.28617849946022034) * emb_t2_5 + (0.62711554765701294) * emb_t2_6 + (-0.30587306618690491) * emb_t2_7 + (0.094337500631809235) * emb_t2_8 + (-0.37155324220657349) * emb_t2_9 + (-0.45645484328269958) * emb_t2_10 + (-0.012242344208061695) * emb_t2_11 + (0.22914335131645203) * emb_t2_12 + (0.80198967456817627) * emb_t2_13 + (-0.085915930569171906) * emb_t2_14 + (0.17644059658050537) * emb_t2_15 + (-0.10198923200368881) * emb_t2_16 + (-0.43352031707763672) * emb_t2_17 + (-0.72888320684432983) * emb_t2_18 + (0.12330874055624008) * emb_t2_19 + (-0.13199082016944885) * emb_t2_20 + (-0.080917231738567352) * emb_t2_21 + (-0.44285953044891357) * emb_t2_22 + (-0.0960673987865448) * emb_t2_23 + (0.28513142466545105) * emb_t2_24 + (4.5858068915549666e-05) * emb_t2_25 + (-0.029581915587186813) * emb_t2_26 + (-0.23752209544181824) * emb_t2_27 + (-1.454059362411499) * emb_t2_28 + (0.97153466939926147) * emb_t2_29 + (-0.49593016505241394) * emb_t2_30 + (-0.086260311305522919) * emb_t2_31 + gate_r * ((-0.10583814233541489) + (0.2016938179731369) * gru_0_fwd_t1_h_0 + (-0.00053945538820698857) * gru_0_fwd_t1_h_1 + (0.52430981397628784) * gru_0_fwd_t1_h_2 + (0.13030995428562164) * gru_0_fwd_t1_h_3 + (0.33396425843238831) * gru_0_fwd_t1_h_4 + (-1.5273259878158569) * gru_0_fwd_t1_h_5 + (-2.1187100410461426) * gru_0_fwd_t1_h_6 + (-1.2772527933120728) * gru_0_fwd_t1_h_7 + (-0.29961082339286804) * gru_0_fwd_t1_h_8 + (-0.34424695372581482) * gru_0_fwd_t1_h_9 + (-0.48198172450065613) * gru_0_fwd_t1_h_10 + (0.19718103110790253) * gru_0_fwd_t1_h_11 + (-0.33281877636909485) * gru_0_fwd_t1_h_12 + (-2.7101144790649414) * gru_0_fwd_t1_h_13 + (0.31475695967674255) * gru_0_fwd_t1_h_14 + (0.6801379919052124) * gru_0_fwd_t1_h_15 + (-0.53060495853424072) * gru_0_fwd_t1_h_16 + (-0.51198530197143555) * gru_0_fwd_t1_h_17 + (0.73494291305541992) * gru_0_fwd_t1_h_18 + (0.34764328598976135) * gru_0_fwd_t1_h_19 + (0.060747481882572174) * gru_0_fwd_t1_h_20 + (-0.22968952357769012) * gru_0_fwd_t1_h_21 + (0.098106242716312408) * gru_0_fwd_t1_h_22 + (0.61107033491134644) * gru_0_fwd_t1_h_23 + (-2.3478710651397705) * gru_0_fwd_t1_h_24 + (-0.69849437475204468) * gru_0_fwd_t1_h_25 + (-1.4497916698455811) * gru_0_fwd_t1_h_26 + (0.09782053530216217) * gru_0_fwd_t1_h_27 + (-0.4207339882850647) * gru_0_fwd_t1_h_28 + (-0.34333661198616028) * gru_0_fwd_t1_h_29 + (0.088049121201038361) * gru_0_fwd_t1_h_30 + (1.1988066434860229) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_7 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_7;
    // h=8
    gate_r = sigmoid((-2.1102445125579834) + (-0.64099812507629395) * emb_t2_0 + (0.18297652900218964) * emb_t2_1 + (-0.51232028007507324) * emb_t2_2 + (-1.0240108966827393) * emb_t2_3 + (0.42605817317962646) * emb_t2_4 + (0.98251241445541382) * emb_t2_5 + (0.69444173574447632) * emb_t2_6 + (0.85641461610794067) * emb_t2_7 + (-0.46913030743598938) * emb_t2_8 + (0.89420026540756226) * emb_t2_9 + (1.0797944068908691) * emb_t2_10 + (-1.0541499853134155) * emb_t2_11 + (-0.99826115369796753) * emb_t2_12 + (0.71844381093978882) * emb_t2_13 + (-0.16584454476833344) * emb_t2_14 + (0.79723727703094482) * emb_t2_15 + (-0.7281801700592041) * emb_t2_16 + (0.99311363697052002) * emb_t2_17 + (0.95930564403533936) * emb_t2_18 + (-0.67892605066299438) * emb_t2_19 + (-1.1966795921325684) * emb_t2_20 + (0.63275575637817383) * emb_t2_21 + (0.66495704650878906) * emb_t2_22 + (-0.72578388452529907) * emb_t2_23 + (0.84590631723403931) * emb_t2_24 + (-0.016845034435391426) * emb_t2_25 + (-0.73735642433166504) * emb_t2_26 + (-0.71553987264633179) * emb_t2_27 + (-0.30125522613525391) * emb_t2_28 + (0.38057148456573486) * emb_t2_29 + (-0.67262250185012817) * emb_t2_30 + (1.2060506343841553) * emb_t2_31 + (-0.84894436597824097) * gru_0_fwd_t1_h_0 + (-0.6338922381401062) * gru_0_fwd_t1_h_1 + (-0.040596727281808853) * gru_0_fwd_t1_h_2 + (1.1929042339324951) * gru_0_fwd_t1_h_3 + (-0.88270598649978638) * gru_0_fwd_t1_h_4 + (-1.2015831470489502) * gru_0_fwd_t1_h_5 + (0.53035688400268555) * gru_0_fwd_t1_h_6 + (-0.42501905560493469) * gru_0_fwd_t1_h_7 + (0.20497411489486694) * gru_0_fwd_t1_h_8 + (-0.13920921087265015) * gru_0_fwd_t1_h_9 + (-0.28797104954719543) * gru_0_fwd_t1_h_10 + (0.24502329528331757) * gru_0_fwd_t1_h_11 + (0.57306188344955444) * gru_0_fwd_t1_h_12 + (0.29016351699829102) * gru_0_fwd_t1_h_13 + (-0.64894348382949829) * gru_0_fwd_t1_h_14 + (1.4499149322509766) * gru_0_fwd_t1_h_15 + (0.87094360589981079) * gru_0_fwd_t1_h_16 + (-0.10382547229528427) * gru_0_fwd_t1_h_17 + (0.50576967000961304) * gru_0_fwd_t1_h_18 + (0.32818934321403503) * gru_0_fwd_t1_h_19 + (-0.1549752801656723) * gru_0_fwd_t1_h_20 + (0.13845831155776978) * gru_0_fwd_t1_h_21 + (-0.38481009006500244) * gru_0_fwd_t1_h_22 + (0.21326933801174164) * gru_0_fwd_t1_h_23 + (0.21375775337219238) * gru_0_fwd_t1_h_24 + (0.053267087787389755) * gru_0_fwd_t1_h_25 + (0.72237354516983032) * gru_0_fwd_t1_h_26 + (-0.52174323797225952) * gru_0_fwd_t1_h_27 + (0.18771404027938843) * gru_0_fwd_t1_h_28 + (-0.38091662526130676) * gru_0_fwd_t1_h_29 + (-0.92795312404632568) * gru_0_fwd_t1_h_30 + (0.66399639844894409) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.6772809624671936) + (-0.0032808671239763498) * emb_t2_0 + (-0.3112979531288147) * emb_t2_1 + (-0.010762996971607208) * emb_t2_2 + (0.079995937645435333) * emb_t2_3 + (0.059131823480129242) * emb_t2_4 + (0.0050346935167908669) * emb_t2_5 + (-0.10491648316383362) * emb_t2_6 + (-0.0042254058644175529) * emb_t2_7 + (0.50806194543838501) * emb_t2_8 + (-0.049719773232936859) * emb_t2_9 + (-0.048791203647851944) * emb_t2_10 + (0.52275699377059937) * emb_t2_11 + (-0.1125863790512085) * emb_t2_12 + (-0.22505795955657959) * emb_t2_13 + (-0.00020142269204370677) * emb_t2_14 + (0.00065615866333246231) * emb_t2_15 + (-0.0057878624647855759) * emb_t2_16 + (-0.42166346311569214) * emb_t2_17 + (0.04228254035115242) * emb_t2_18 + (0.085595965385437012) * emb_t2_19 + (0.22659857571125031) * emb_t2_20 + (-0.002691956702619791) * emb_t2_21 + (0.33013865351676941) * emb_t2_22 + (-0.0034022859763354063) * emb_t2_23 + (-0.0040348111651837826) * emb_t2_24 + (-0.0038222384173423052) * emb_t2_25 + (-0.013078427873551846) * emb_t2_26 + (-0.0054868278093636036) * emb_t2_27 + (0.048570383340120316) * emb_t2_28 + (-0.018936770036816597) * emb_t2_29 + (0.53899973630905151) * emb_t2_30 + (0.12751126289367676) * emb_t2_31 + (-0.82060790061950684) * gru_0_fwd_t1_h_0 + (-0.77872204780578613) * gru_0_fwd_t1_h_1 + (-0.34278988838195801) * gru_0_fwd_t1_h_2 + (0.99013000726699829) * gru_0_fwd_t1_h_3 + (-0.83292549848556519) * gru_0_fwd_t1_h_4 + (0.02025747112929821) * gru_0_fwd_t1_h_5 + (1.9733446836471558) * gru_0_fwd_t1_h_6 + (0.54976308345794678) * gru_0_fwd_t1_h_7 + (-0.73911535739898682) * gru_0_fwd_t1_h_8 + (-1.1636242866516113) * gru_0_fwd_t1_h_9 + (0.26721858978271484) * gru_0_fwd_t1_h_10 + (-0.69625484943389893) * gru_0_fwd_t1_h_11 + (1.1293892860412598) * gru_0_fwd_t1_h_12 + (0.64323961734771729) * gru_0_fwd_t1_h_13 + (-0.46308672428131104) * gru_0_fwd_t1_h_14 + (1.0495226383209229) * gru_0_fwd_t1_h_15 + (0.55621910095214844) * gru_0_fwd_t1_h_16 + (0.32059207558631897) * gru_0_fwd_t1_h_17 + (-1.0575906038284302) * gru_0_fwd_t1_h_18 + (1.0924899578094482) * gru_0_fwd_t1_h_19 + (-0.94153982400894165) * gru_0_fwd_t1_h_20 + (-1.0066181421279907) * gru_0_fwd_t1_h_21 + (0.15435196459293365) * gru_0_fwd_t1_h_22 + (-0.24547705054283142) * gru_0_fwd_t1_h_23 + (0.34429788589477539) * gru_0_fwd_t1_h_24 + (0.18252860009670258) * gru_0_fwd_t1_h_25 + (-0.00036616771831177175) * gru_0_fwd_t1_h_26 + (-0.44742515683174133) * gru_0_fwd_t1_h_27 + (-0.19489307701587677) * gru_0_fwd_t1_h_28 + (-0.13575111329555511) * gru_0_fwd_t1_h_29 + (-0.74507838487625122) * gru_0_fwd_t1_h_30 + (0.77776861190795898) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.14400477707386017) + (0.017657605931162834) * emb_t2_0 + (0.52903920412063599) * emb_t2_1 + (0.19074809551239014) * emb_t2_2 + (-0.13002277910709381) * emb_t2_3 + (0.81449234485626221) * emb_t2_4 + (-0.046540670096874237) * emb_t2_5 + (-0.16178229451179504) * emb_t2_6 + (-0.070509575307369232) * emb_t2_7 + (-0.28544071316719055) * emb_t2_8 + (-0.28470435738563538) * emb_t2_9 + (-0.017579587176442146) * emb_t2_10 + (-0.28403806686401367) * emb_t2_11 + (0.19652369618415833) * emb_t2_12 + (0.63823056221008301) * emb_t2_13 + (0.049733228981494904) * emb_t2_14 + (-0.056254390627145767) * emb_t2_15 + (0.081860765814781189) * emb_t2_16 + (0.50213766098022461) * emb_t2_17 + (-0.15268562734127045) * emb_t2_18 + (-0.28229197859764099) * emb_t2_19 + (-0.2869446873664856) * emb_t2_20 + (-0.10242445766925812) * emb_t2_21 + (-0.15779213607311249) * emb_t2_22 + (0.037097692489624023) * emb_t2_23 + (-0.029618021100759506) * emb_t2_24 + (-0.086710184812545776) * emb_t2_25 + (-0.55746769905090332) * emb_t2_26 + (0.026910783722996712) * emb_t2_27 + (-0.58989018201828003) * emb_t2_28 + (0.23668175935745239) * emb_t2_29 + (-0.71780180931091309) * emb_t2_30 + (-0.043909285217523575) * emb_t2_31 + gate_r * ((0.087005168199539185) + (0.063888326287269592) * gru_0_fwd_t1_h_0 + (-0.35430386662483215) * gru_0_fwd_t1_h_1 + (0.41224220395088196) * gru_0_fwd_t1_h_2 + (0.58040314912796021) * gru_0_fwd_t1_h_3 + (-0.4396074116230011) * gru_0_fwd_t1_h_4 + (-0.77431201934814453) * gru_0_fwd_t1_h_5 + (0.37736198306083679) * gru_0_fwd_t1_h_6 + (-0.040429241955280304) * gru_0_fwd_t1_h_7 + (-0.34044015407562256) * gru_0_fwd_t1_h_8 + (-0.095932386815547943) * gru_0_fwd_t1_h_9 + (0.013764162547886372) * gru_0_fwd_t1_h_10 + (0.14016297459602356) * gru_0_fwd_t1_h_11 + (0.25288084149360657) * gru_0_fwd_t1_h_12 + (0.16335810720920563) * gru_0_fwd_t1_h_13 + (0.37526193261146545) * gru_0_fwd_t1_h_14 + (0.35459306836128235) * gru_0_fwd_t1_h_15 + (-0.1204790398478508) * gru_0_fwd_t1_h_16 + (-0.23970738053321838) * gru_0_fwd_t1_h_17 + (0.23090445995330811) * gru_0_fwd_t1_h_18 + (-0.047148708254098892) * gru_0_fwd_t1_h_19 + (-0.54039394855499268) * gru_0_fwd_t1_h_20 + (-0.088330924510955811) * gru_0_fwd_t1_h_21 + (0.0024632676504552364) * gru_0_fwd_t1_h_22 + (0.18685212731361389) * gru_0_fwd_t1_h_23 + (-0.11592207849025726) * gru_0_fwd_t1_h_24 + (-0.64342427253723145) * gru_0_fwd_t1_h_25 + (0.43200528621673584) * gru_0_fwd_t1_h_26 + (-0.14468787610530853) * gru_0_fwd_t1_h_27 + (-0.099868424236774445) * gru_0_fwd_t1_h_28 + (-0.085422948002815247) * gru_0_fwd_t1_h_29 + (0.20468093454837799) * gru_0_fwd_t1_h_30 + (0.60648691654205322) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_8 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_8;
    // h=9
    gate_r = sigmoid((-1.0291666984558105) + (-0.21775640547275543) * emb_t2_0 + (-1.8440258502960205) * emb_t2_1 + (-0.93004554510116577) * emb_t2_2 + (-0.30066102743148804) * emb_t2_3 + (0.34967991709709167) * emb_t2_4 + (0.14449562132358551) * emb_t2_5 + (0.64237546920776367) * emb_t2_6 + (0.92417067289352417) * emb_t2_7 + (-0.57878071069717407) * emb_t2_8 + (1.0784271955490112) * emb_t2_9 + (0.81259322166442871) * emb_t2_10 + (0.2183707058429718) * emb_t2_11 + (-0.060155056416988373) * emb_t2_12 + (-0.47093659639358521) * emb_t2_13 + (0.36868727207183838) * emb_t2_14 + (0.037063281983137131) * emb_t2_15 + (-1.0734480619430542) * emb_t2_16 + (0.10764206945896149) * emb_t2_17 + (0.4209350049495697) * emb_t2_18 + (-0.3842143714427948) * emb_t2_19 + (-0.65933746099472046) * emb_t2_20 + (0.68210357427597046) * emb_t2_21 + (0.55667674541473389) * emb_t2_22 + (-0.87310385704040527) * emb_t2_23 + (0.14842422306537628) * emb_t2_24 + (0.10924425721168518) * emb_t2_25 + (-0.72992944717407227) * emb_t2_26 + (-0.93228572607040405) * emb_t2_27 + (1.7560552358627319) * emb_t2_28 + (-0.79292899370193481) * emb_t2_29 + (-0.46273943781852722) * emb_t2_30 + (0.59081840515136719) * emb_t2_31 + (-1.3595693111419678) * gru_0_fwd_t1_h_0 + (0.3105807900428772) * gru_0_fwd_t1_h_1 + (0.03615405410528183) * gru_0_fwd_t1_h_2 + (0.42669129371643066) * gru_0_fwd_t1_h_3 + (-0.11484607309103012) * gru_0_fwd_t1_h_4 + (0.39541345834732056) * gru_0_fwd_t1_h_5 + (-0.9882960319519043) * gru_0_fwd_t1_h_6 + (-0.31572169065475464) * gru_0_fwd_t1_h_7 + (0.65913540124893188) * gru_0_fwd_t1_h_8 + (-0.94910144805908203) * gru_0_fwd_t1_h_9 + (0.34012278914451599) * gru_0_fwd_t1_h_10 + (-0.47219425439834595) * gru_0_fwd_t1_h_11 + (0.26353141665458679) * gru_0_fwd_t1_h_12 + (0.067969560623168945) * gru_0_fwd_t1_h_13 + (-0.92074286937713623) * gru_0_fwd_t1_h_14 + (1.4525289535522461) * gru_0_fwd_t1_h_15 + (0.60223031044006348) * gru_0_fwd_t1_h_16 + (0.7999541163444519) * gru_0_fwd_t1_h_17 + (1.0592775344848633) * gru_0_fwd_t1_h_18 + (-1.8160401582717896) * gru_0_fwd_t1_h_19 + (-1.5269317626953125) * gru_0_fwd_t1_h_20 + (0.30956953763961792) * gru_0_fwd_t1_h_21 + (-1.4395476579666138) * gru_0_fwd_t1_h_22 + (-0.3491356372833252) * gru_0_fwd_t1_h_23 + (1.3573189973831177) * gru_0_fwd_t1_h_24 + (0.62004417181015015) * gru_0_fwd_t1_h_25 + (-0.61518222093582153) * gru_0_fwd_t1_h_26 + (1.9287381172180176) * gru_0_fwd_t1_h_27 + (2.0179994106292725) * gru_0_fwd_t1_h_28 + (0.50569581985473633) * gru_0_fwd_t1_h_29 + (-0.36348322033882141) * gru_0_fwd_t1_h_30 + (-1.7054089307785034) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.85079783201217651) + (0.027700528502464294) * emb_t2_0 + (-1.6402249336242676) * emb_t2_1 + (0.003532967995852232) * emb_t2_2 + (0.77251291275024414) * emb_t2_3 + (-1.3702539205551147) * emb_t2_4 + (-0.063031569123268127) * emb_t2_5 + (-1.3805216550827026) * emb_t2_6 + (0.028332382440567017) * emb_t2_7 + (0.25258532166481018) * emb_t2_8 + (0.87281262874603271) * emb_t2_9 + (0.63106030225753784) * emb_t2_10 + (0.51318782567977905) * emb_t2_11 + (0.20813657343387604) * emb_t2_12 + (-1.4596974849700928) * emb_t2_13 + (-0.11888401210308075) * emb_t2_14 + (-0.087026022374629974) * emb_t2_15 + (0.14262071251869202) * emb_t2_16 + (-0.98146480321884155) * emb_t2_17 + (0.26782575249671936) * emb_t2_18 + (-0.46255949139595032) * emb_t2_19 + (0.74560445547103882) * emb_t2_20 + (-0.2749481201171875) * emb_t2_21 + (-0.33875569701194763) * emb_t2_22 + (0.39340636134147644) * emb_t2_23 + (-0.22331483662128448) * emb_t2_24 + (0.14061516523361206) * emb_t2_25 + (0.79723787307739258) * emb_t2_26 + (0.13435083627700806) * emb_t2_27 + (1.3481860160827637) * emb_t2_28 + (-1.299435019493103) * emb_t2_29 + (1.7842432260513306) * emb_t2_30 + (-0.33600029349327087) * emb_t2_31 + (0.04364752396941185) * gru_0_fwd_t1_h_0 + (0.76857584714889526) * gru_0_fwd_t1_h_1 + (-0.064171619713306427) * gru_0_fwd_t1_h_2 + (-1.4456877708435059) * gru_0_fwd_t1_h_3 + (0.73483419418334961) * gru_0_fwd_t1_h_4 + (0.50353491306304932) * gru_0_fwd_t1_h_5 + (1.2429378032684326) * gru_0_fwd_t1_h_6 + (0.24548597633838654) * gru_0_fwd_t1_h_7 + (-0.044744715094566345) * gru_0_fwd_t1_h_8 + (-2.2741949558258057) * gru_0_fwd_t1_h_9 + (-0.16652980446815491) * gru_0_fwd_t1_h_10 + (-0.40498128533363342) * gru_0_fwd_t1_h_11 + (-0.78659147024154663) * gru_0_fwd_t1_h_12 + (0.32747757434844971) * gru_0_fwd_t1_h_13 + (0.46970006823539734) * gru_0_fwd_t1_h_14 + (-0.75661355257034302) * gru_0_fwd_t1_h_15 + (-0.50469964742660522) * gru_0_fwd_t1_h_16 + (-0.19922125339508057) * gru_0_fwd_t1_h_17 + (0.19081026315689087) * gru_0_fwd_t1_h_18 + (-1.5592091083526611) * gru_0_fwd_t1_h_19 + (-2.318049430847168) * gru_0_fwd_t1_h_20 + (-0.096753008663654327) * gru_0_fwd_t1_h_21 + (-0.88264548778533936) * gru_0_fwd_t1_h_22 + (-0.24940571188926697) * gru_0_fwd_t1_h_23 + (0.22806352376937866) * gru_0_fwd_t1_h_24 + (0.51703208684921265) * gru_0_fwd_t1_h_25 + (-0.2743927538394928) * gru_0_fwd_t1_h_26 + (0.2976660430431366) * gru_0_fwd_t1_h_27 + (0.42707479000091553) * gru_0_fwd_t1_h_28 + (2.4570937156677246) * gru_0_fwd_t1_h_29 + (0.28030979633331299) * gru_0_fwd_t1_h_30 + (-1.1908520460128784) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.055959109216928482) + (-0.051719106733798981) * emb_t2_0 + (2.6439423561096191) * emb_t2_1 + (-0.03181258961558342) * emb_t2_2 + (-0.39270472526550293) * emb_t2_3 + (0.44733655452728271) * emb_t2_4 + (-0.019772948697209358) * emb_t2_5 + (0.25335595011711121) * emb_t2_6 + (-0.011402004398405552) * emb_t2_7 + (-0.11188554763793945) * emb_t2_8 + (-1.1831616163253784) * emb_t2_9 + (-0.53981113433837891) * emb_t2_10 + (0.11820565164089203) * emb_t2_11 + (-0.049987800419330597) * emb_t2_12 + (2.0571584701538086) * emb_t2_13 + (0.011857649311423302) * emb_t2_14 + (0.0038197364192456007) * emb_t2_15 + (-0.027544032782316208) * emb_t2_16 + (0.67758220434188843) * emb_t2_17 + (-0.68091249465942383) * emb_t2_18 + (-0.011754167266190052) * emb_t2_19 + (0.14636367559432983) * emb_t2_20 + (0.051333952695131302) * emb_t2_21 + (-0.057307995855808258) * emb_t2_22 + (-0.003894260386005044) * emb_t2_23 + (0.0083711054176092148) * emb_t2_24 + (-0.022006513550877571) * emb_t2_25 + (0.40414318442344666) * emb_t2_26 + (0.028273157775402069) * emb_t2_27 + (-1.8429552316665649) * emb_t2_28 + (1.1191720962524414) * emb_t2_29 + (-0.14868780970573425) * emb_t2_30 + (0.076381869614124298) * emb_t2_31 + gate_r * ((-0.27155947685241699) + (0.50994867086410522) * gru_0_fwd_t1_h_0 + (0.064687661826610565) * gru_0_fwd_t1_h_1 + (-0.26204624772071838) * gru_0_fwd_t1_h_2 + (-0.76411658525466919) * gru_0_fwd_t1_h_3 + (0.03781445324420929) * gru_0_fwd_t1_h_4 + (0.020905639976263046) * gru_0_fwd_t1_h_5 + (2.6629087924957275) * gru_0_fwd_t1_h_6 + (0.27694472670555115) * gru_0_fwd_t1_h_7 + (0.12950915098190308) * gru_0_fwd_t1_h_8 + (0.3509196937084198) * gru_0_fwd_t1_h_9 + (0.18956245481967926) * gru_0_fwd_t1_h_10 + (0.37658938765525818) * gru_0_fwd_t1_h_11 + (-0.13181357085704803) * gru_0_fwd_t1_h_12 + (-0.13751678168773651) * gru_0_fwd_t1_h_13 + (0.024980755522847176) * gru_0_fwd_t1_h_14 + (-0.033619947731494904) * gru_0_fwd_t1_h_15 + (0.26171833276748657) * gru_0_fwd_t1_h_16 + (0.091965459287166595) * gru_0_fwd_t1_h_17 + (-1.1338552236557007) * gru_0_fwd_t1_h_18 + (1.4432523250579834) * gru_0_fwd_t1_h_19 + (0.84344375133514404) * gru_0_fwd_t1_h_20 + (0.038401640951633453) * gru_0_fwd_t1_h_21 + (1.7251847982406616) * gru_0_fwd_t1_h_22 + (0.079124584794044495) * gru_0_fwd_t1_h_23 + (-1.2314834594726562) * gru_0_fwd_t1_h_24 + (-0.26243951916694641) * gru_0_fwd_t1_h_25 + (0.90659612417221069) * gru_0_fwd_t1_h_26 + (-0.66635364294052124) * gru_0_fwd_t1_h_27 + (-0.90394556522369385) * gru_0_fwd_t1_h_28 + (-0.043215785175561905) * gru_0_fwd_t1_h_29 + (-0.42130252718925476) * gru_0_fwd_t1_h_30 + (1.0876805782318115) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_9 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_9;
    // h=10
    gate_r = sigmoid((-0.2903326153755188) + (0.37272307276725769) * emb_t2_0 + (2.1254901885986328) * emb_t2_1 + (0.51294076442718506) * emb_t2_2 + (-0.28422167897224426) * emb_t2_3 + (1.0091205835342407) * emb_t2_4 + (0.28378525376319885) * emb_t2_5 + (0.4720015823841095) * emb_t2_6 + (0.54543757438659668) * emb_t2_7 + (-0.060786671936511993) * emb_t2_8 + (-1.2298010587692261) * emb_t2_9 + (-0.42318448424339294) * emb_t2_10 + (-0.058135654777288437) * emb_t2_11 + (-0.13925759494304657) * emb_t2_12 + (2.0293993949890137) * emb_t2_13 + (0.045136716216802597) * emb_t2_14 + (-0.010812145657837391) * emb_t2_15 + (0.14596937596797943) * emb_t2_16 + (0.77113783359527588) * emb_t2_17 + (-0.4976145327091217) * emb_t2_18 + (0.28042915463447571) * emb_t2_19 + (-0.2694212794303894) * emb_t2_20 + (0.71386456489562988) * emb_t2_21 + (-0.38260719180107117) * emb_t2_22 + (-0.42595985531806946) * emb_t2_23 + (0.58858376741409302) * emb_t2_24 + (-1.0039747953414917) * emb_t2_25 + (-0.71076148748397827) * emb_t2_26 + (-0.3871326744556427) * emb_t2_27 + (-1.5637490749359131) * emb_t2_28 + (1.9813101291656494) * emb_t2_29 + (-0.6420896053314209) * emb_t2_30 + (-0.4590383768081665) * emb_t2_31 + (0.24292473495006561) * gru_0_fwd_t1_h_0 + (1.1668368577957153) * gru_0_fwd_t1_h_1 + (-1.4260040521621704) * gru_0_fwd_t1_h_2 + (0.081427648663520813) * gru_0_fwd_t1_h_3 + (-0.27907374501228333) * gru_0_fwd_t1_h_4 + (-0.62538629770278931) * gru_0_fwd_t1_h_5 + (1.6038655042648315) * gru_0_fwd_t1_h_6 + (1.5079123973846436) * gru_0_fwd_t1_h_7 + (0.62992048263549805) * gru_0_fwd_t1_h_8 + (-0.7392544150352478) * gru_0_fwd_t1_h_9 + (1.1289826631546021) * gru_0_fwd_t1_h_10 + (-0.20437446236610413) * gru_0_fwd_t1_h_11 + (0.60902053117752075) * gru_0_fwd_t1_h_12 + (0.76403748989105225) * gru_0_fwd_t1_h_13 + (0.13490474224090576) * gru_0_fwd_t1_h_14 + (0.86240559816360474) * gru_0_fwd_t1_h_15 + (0.43386802077293396) * gru_0_fwd_t1_h_16 + (0.21007892489433289) * gru_0_fwd_t1_h_17 + (0.59327840805053711) * gru_0_fwd_t1_h_18 + (0.673908531665802) * gru_0_fwd_t1_h_19 + (-0.1562994122505188) * gru_0_fwd_t1_h_20 + (0.3929002583026886) * gru_0_fwd_t1_h_21 + (0.78684711456298828) * gru_0_fwd_t1_h_22 + (-0.47935879230499268) * gru_0_fwd_t1_h_23 + (-0.86181312799453735) * gru_0_fwd_t1_h_24 + (-0.17392794787883759) * gru_0_fwd_t1_h_25 + (0.49387761950492859) * gru_0_fwd_t1_h_26 + (1.1017006635665894) * gru_0_fwd_t1_h_27 + (0.44429120421409607) * gru_0_fwd_t1_h_28 + (0.047304622828960419) * gru_0_fwd_t1_h_29 + (-0.21966002881526947) * gru_0_fwd_t1_h_30 + (1.1421937942504883) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.57233887910842896) + (0.090228058397769928) * emb_t2_0 + (-0.36436763405799866) * emb_t2_1 + (-0.0051405825652182102) * emb_t2_2 + (0.95805394649505615) * emb_t2_3 + (-0.1199549064040184) * emb_t2_4 + (-0.30429720878601074) * emb_t2_5 + (-0.12012226134538651) * emb_t2_6 + (-0.042424552142620087) * emb_t2_7 + (0.26405581831932068) * emb_t2_8 + (0.43321284651756287) * emb_t2_9 + (0.60185432434082031) * emb_t2_10 + (0.17534030973911285) * emb_t2_11 + (-0.36868458986282349) * emb_t2_12 + (-0.13284038007259369) * emb_t2_13 + (0.053552355617284775) * emb_t2_14 + (0.010950467549264431) * emb_t2_15 + (0.22625735402107239) * emb_t2_16 + (-0.54855036735534668) * emb_t2_17 + (0.1969267725944519) * emb_t2_18 + (-0.12199658155441284) * emb_t2_19 + (0.11403308063745499) * emb_t2_20 + (-0.22981852293014526) * emb_t2_21 + (0.57611727714538574) * emb_t2_22 + (-0.094779215753078461) * emb_t2_23 + (-0.20558524131774902) * emb_t2_24 + (0.16236050426959991) * emb_t2_25 + (0.33887395262718201) * emb_t2_26 + (0.13582667708396912) * emb_t2_27 + (0.32426339387893677) * emb_t2_28 + (0.023488067090511322) * emb_t2_29 + (0.90272992849349976) * emb_t2_30 + (-0.12089567631483078) * emb_t2_31 + (-0.30256864428520203) * gru_0_fwd_t1_h_0 + (0.36382913589477539) * gru_0_fwd_t1_h_1 + (0.69661259651184082) * gru_0_fwd_t1_h_2 + (-2.5443358421325684) * gru_0_fwd_t1_h_3 + (0.70908015966415405) * gru_0_fwd_t1_h_4 + (-0.39497953653335571) * gru_0_fwd_t1_h_5 + (-1.2060931921005249) * gru_0_fwd_t1_h_6 + (-0.99475961923599243) * gru_0_fwd_t1_h_7 + (-0.26585802435874939) * gru_0_fwd_t1_h_8 + (1.1499350070953369) * gru_0_fwd_t1_h_9 + (-0.86988794803619385) * gru_0_fwd_t1_h_10 + (-0.86657655239105225) * gru_0_fwd_t1_h_11 + (-0.56321561336517334) * gru_0_fwd_t1_h_12 + (-0.66391599178314209) * gru_0_fwd_t1_h_13 + (0.96256345510482788) * gru_0_fwd_t1_h_14 + (-1.9237656593322754) * gru_0_fwd_t1_h_15 + (-0.69726389646530151) * gru_0_fwd_t1_h_16 + (-0.45243427157402039) * gru_0_fwd_t1_h_17 + (-0.82856094837188721) * gru_0_fwd_t1_h_18 + (-0.26724031567573547) * gru_0_fwd_t1_h_19 + (0.98476874828338623) * gru_0_fwd_t1_h_20 + (-0.40161135792732239) * gru_0_fwd_t1_h_21 + (-1.4788168668746948) * gru_0_fwd_t1_h_22 + (0.13274243474006653) * gru_0_fwd_t1_h_23 + (1.873927116394043) * gru_0_fwd_t1_h_24 + (0.047955486923456192) * gru_0_fwd_t1_h_25 + (-0.65096127986907959) * gru_0_fwd_t1_h_26 + (-0.27890083193778992) * gru_0_fwd_t1_h_27 + (-0.86823314428329468) * gru_0_fwd_t1_h_28 + (0.60682368278503418) * gru_0_fwd_t1_h_29 + (0.90974825620651245) * gru_0_fwd_t1_h_30 + (-0.83886760473251343) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.40624549984931946) + (0.19553357362747192) * emb_t2_0 + (0.61454755067825317) * emb_t2_1 + (0.22711406648159027) * emb_t2_2 + (-0.47619748115539551) * emb_t2_3 + (0.5250057578086853) * emb_t2_4 + (-0.30787089467048645) * emb_t2_5 + (0.58269178867340088) * emb_t2_6 + (0.2436896413564682) * emb_t2_7 + (-0.56383085250854492) * emb_t2_8 + (-0.066878989338874817) * emb_t2_9 + (0.07875882089138031) * emb_t2_10 + (-0.02602069079875946) * emb_t2_11 + (-0.54256433248519897) * emb_t2_12 + (0.59359228610992432) * emb_t2_13 + (-0.64823770523071289) * emb_t2_14 + (0.84101134538650513) * emb_t2_15 + (-0.66109991073608398) * emb_t2_16 + (0.95889270305633545) * emb_t2_17 + (0.31039738655090332) * emb_t2_18 + (-0.25118133425712585) * emb_t2_19 + (-0.53400975465774536) * emb_t2_20 + (0.42753329873085022) * emb_t2_21 + (0.42158985137939453) * emb_t2_22 + (-0.27095669507980347) * emb_t2_23 + (-0.020703541114926338) * emb_t2_24 + (-0.51858866214752197) * emb_t2_25 + (-0.3015424907207489) * emb_t2_26 + (-0.28902149200439453) * emb_t2_27 + (-0.44251716136932373) * emb_t2_28 + (1.1271430253982544) * emb_t2_29 + (-0.9146265983581543) * emb_t2_30 + (0.71135240793228149) * emb_t2_31 + gate_r * ((0.168348029255867) + (-0.38537079095840454) * gru_0_fwd_t1_h_0 + (0.41060531139373779) * gru_0_fwd_t1_h_1 + (-0.70355117321014404) * gru_0_fwd_t1_h_2 + (0.99690449237823486) * gru_0_fwd_t1_h_3 + (0.22493129968643188) * gru_0_fwd_t1_h_4 + (0.0051134857349097729) * gru_0_fwd_t1_h_5 + (-0.0041355774737894535) * gru_0_fwd_t1_h_6 + (0.57902765274047852) * gru_0_fwd_t1_h_7 + (-0.094685196876525879) * gru_0_fwd_t1_h_8 + (0.20434698462486267) * gru_0_fwd_t1_h_9 + (0.88527071475982666) * gru_0_fwd_t1_h_10 + (-0.67636287212371826) * gru_0_fwd_t1_h_11 + (0.63379651308059692) * gru_0_fwd_t1_h_12 + (-0.48752933740615845) * gru_0_fwd_t1_h_13 + (-0.6990436315536499) * gru_0_fwd_t1_h_14 + (0.75626653432846069) * gru_0_fwd_t1_h_15 + (0.041450876742601395) * gru_0_fwd_t1_h_16 + (0.33057296276092529) * gru_0_fwd_t1_h_17 + (0.11691021919250488) * gru_0_fwd_t1_h_18 + (0.10554688423871994) * gru_0_fwd_t1_h_19 + (0.35515418648719788) * gru_0_fwd_t1_h_20 + (-0.37428972125053406) * gru_0_fwd_t1_h_21 + (-0.43946847319602966) * gru_0_fwd_t1_h_22 + (0.14420497417449951) * gru_0_fwd_t1_h_23 + (0.97654640674591064) * gru_0_fwd_t1_h_24 + (0.51884651184082031) * gru_0_fwd_t1_h_25 + (-0.031644299626350403) * gru_0_fwd_t1_h_26 + (-0.081154756247997284) * gru_0_fwd_t1_h_27 + (0.3023676872253418) * gru_0_fwd_t1_h_28 + (0.20551168918609619) * gru_0_fwd_t1_h_29 + (0.12971283495426178) * gru_0_fwd_t1_h_30 + (-4.1572079658508301) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_10 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_10;
    // h=11
    gate_r = sigmoid((0.1956886500120163) + (0.0029698507860302925) * emb_t2_0 + (0.65398687124252319) * emb_t2_1 + (0.059658382087945938) * emb_t2_2 + (-0.18636082112789154) * emb_t2_3 + (-0.13120843470096588) * emb_t2_4 + (-0.3475576639175415) * emb_t2_5 + (0.11475776880979538) * emb_t2_6 + (-0.12411230802536011) * emb_t2_7 + (-0.065247401595115662) * emb_t2_8 + (-1.1529113054275513) * emb_t2_9 + (-1.7391422986984253) * emb_t2_10 + (0.48048648238182068) * emb_t2_11 + (0.5705493688583374) * emb_t2_12 + (0.15491962432861328) * emb_t2_13 + (-0.17362949252128601) * emb_t2_14 + (0.12102485448122025) * emb_t2_15 + (0.046184800565242767) * emb_t2_16 + (0.36707079410552979) * emb_t2_17 + (-1.5311754941940308) * emb_t2_18 + (1.3056511878967285) * emb_t2_19 + (0.22978360950946808) * emb_t2_20 + (-0.15438579022884369) * emb_t2_21 + (-0.71544802188873291) * emb_t2_22 + (0.0093332389369606972) * emb_t2_23 + (-0.12306014448404312) * emb_t2_24 + (0.37900832295417786) * emb_t2_25 + (0.056395094841718674) * emb_t2_26 + (-0.037252459675073624) * emb_t2_27 + (-0.79381108283996582) * emb_t2_28 + (0.078465789556503296) * emb_t2_29 + (0.41637760400772095) * emb_t2_30 + (-0.2509402334690094) * emb_t2_31 + (0.24902075529098511) * gru_0_fwd_t1_h_0 + (0.18872329592704773) * gru_0_fwd_t1_h_1 + (-1.156943678855896) * gru_0_fwd_t1_h_2 + (-0.26141980290412903) * gru_0_fwd_t1_h_3 + (0.12621775269508362) * gru_0_fwd_t1_h_4 + (-0.14882530272006989) * gru_0_fwd_t1_h_5 + (-0.92031693458557129) * gru_0_fwd_t1_h_6 + (0.21755166351795197) * gru_0_fwd_t1_h_7 + (-0.14906533062458038) * gru_0_fwd_t1_h_8 + (0.26624387502670288) * gru_0_fwd_t1_h_9 + (1.4410631656646729) * gru_0_fwd_t1_h_10 + (0.30767664313316345) * gru_0_fwd_t1_h_11 + (-0.11122284084558487) * gru_0_fwd_t1_h_12 + (-0.42663794755935669) * gru_0_fwd_t1_h_13 + (0.25622057914733887) * gru_0_fwd_t1_h_14 + (-0.26118564605712891) * gru_0_fwd_t1_h_15 + (-0.03057689405977726) * gru_0_fwd_t1_h_16 + (-0.13202273845672607) * gru_0_fwd_t1_h_17 + (-0.020579682663083076) * gru_0_fwd_t1_h_18 + (-1.667967677116394) * gru_0_fwd_t1_h_19 + (-0.16229031980037689) * gru_0_fwd_t1_h_20 + (0.12047503143548965) * gru_0_fwd_t1_h_21 + (-0.55972546339035034) * gru_0_fwd_t1_h_22 + (0.41362357139587402) * gru_0_fwd_t1_h_23 + (0.57131630182266235) * gru_0_fwd_t1_h_24 + (0.14650556445121765) * gru_0_fwd_t1_h_25 + (-0.034010078758001328) * gru_0_fwd_t1_h_26 + (-0.53238606452941895) * gru_0_fwd_t1_h_27 + (-0.41153216361999512) * gru_0_fwd_t1_h_28 + (-0.5209735631942749) * gru_0_fwd_t1_h_29 + (0.22027134895324707) * gru_0_fwd_t1_h_30 + (-0.49471953511238098) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-1.1835981607437134) + (-0.38325873017311096) * emb_t2_0 + (1.2180261611938477) * emb_t2_1 + (-0.50477433204650879) * emb_t2_2 + (-0.71793818473815918) * emb_t2_3 + (1.185329794883728) * emb_t2_4 + (-0.47439354658126831) * emb_t2_5 + (0.69456666707992554) * emb_t2_6 + (0.42801237106323242) * emb_t2_7 + (-0.74283206462860107) * emb_t2_8 + (0.050644747912883759) * emb_t2_9 + (-0.0024067610502243042) * emb_t2_10 + (-0.50373858213424683) * emb_t2_11 + (-0.28058198094367981) * emb_t2_12 + (1.210016131401062) * emb_t2_13 + (0.11959413439035416) * emb_t2_14 + (0.5850263237953186) * emb_t2_15 + (-0.6549835205078125) * emb_t2_16 + (0.81251460313796997) * emb_t2_17 + (-0.36874586343765259) * emb_t2_18 + (-0.54592388868331909) * emb_t2_19 + (-0.9350135326385498) * emb_t2_20 + (0.37382754683494568) * emb_t2_21 + (0.38894951343536377) * emb_t2_22 + (-0.30774560570716858) * emb_t2_23 + (0.45080414414405823) * emb_t2_24 + (-0.3780987560749054) * emb_t2_25 + (-1.2254502773284912) * emb_t2_26 + (0.13949069380760193) * emb_t2_27 + (-1.1461809873580933) * emb_t2_28 + (1.0603877305984497) * emb_t2_29 + (-1.4554656744003296) * emb_t2_30 + (0.30579391121864319) * emb_t2_31 + (-0.10615801066160202) * gru_0_fwd_t1_h_0 + (0.062277205288410187) * gru_0_fwd_t1_h_1 + (-2.9809088706970215) * gru_0_fwd_t1_h_2 + (-1.3029937744140625) * gru_0_fwd_t1_h_3 + (0.080119766294956207) * gru_0_fwd_t1_h_4 + (-0.57045543193817139) * gru_0_fwd_t1_h_5 + (0.17521990835666656) * gru_0_fwd_t1_h_6 + (2.1046972274780273) * gru_0_fwd_t1_h_7 + (-0.55869829654693604) * gru_0_fwd_t1_h_8 + (-0.57184040546417236) * gru_0_fwd_t1_h_9 + (2.8678064346313477) * gru_0_fwd_t1_h_10 + (0.31140592694282532) * gru_0_fwd_t1_h_11 + (-0.04938780888915062) * gru_0_fwd_t1_h_12 + (-0.052740257233381271) * gru_0_fwd_t1_h_13 + (-0.48869532346725464) * gru_0_fwd_t1_h_14 + (-0.039912566542625427) * gru_0_fwd_t1_h_15 + (0.38393378257751465) * gru_0_fwd_t1_h_16 + (0.09867868572473526) * gru_0_fwd_t1_h_17 + (0.16850613057613373) * gru_0_fwd_t1_h_18 + (2.2231631278991699) * gru_0_fwd_t1_h_19 + (-1.355987548828125) * gru_0_fwd_t1_h_20 + (1.3890461921691895) * gru_0_fwd_t1_h_21 + (-0.45556288957595825) * gru_0_fwd_t1_h_22 + (0.55173391103744507) * gru_0_fwd_t1_h_23 + (2.1711466312408447) * gru_0_fwd_t1_h_24 + (1.5733431577682495) * gru_0_fwd_t1_h_25 + (-0.31027799844741821) * gru_0_fwd_t1_h_26 + (-0.71380138397216797) * gru_0_fwd_t1_h_27 + (0.53722262382507324) * gru_0_fwd_t1_h_28 + (-0.24148008227348328) * gru_0_fwd_t1_h_29 + (-0.59723645448684692) * gru_0_fwd_t1_h_30 + (-1.0308324098587036) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.093171462416648865) + (-0.0026334382127970457) * emb_t2_0 + (-0.18988069891929626) * emb_t2_1 + (-0.0021763790864497423) * emb_t2_2 + (0.41077297925949097) * emb_t2_3 + (-0.22049932181835175) * emb_t2_4 + (-0.011800613254308701) * emb_t2_5 + (-0.66309380531311035) * emb_t2_6 + (-0.013310860842466354) * emb_t2_7 + (-0.4265671968460083) * emb_t2_8 + (0.26797905564308167) * emb_t2_9 + (0.61712539196014404) * emb_t2_10 + (0.16253611445426941) * emb_t2_11 + (-0.14216451346874237) * emb_t2_12 + (-0.63450866937637329) * emb_t2_13 + (-0.024728493764996529) * emb_t2_14 + (0.018113439902663231) * emb_t2_15 + (-0.0097484393045306206) * emb_t2_16 + (-0.81316870450973511) * emb_t2_17 + (0.166947141289711) * emb_t2_18 + (-0.38231483101844788) * emb_t2_19 + (0.33632215857505798) * emb_t2_20 + (0.014915128238499165) * emb_t2_21 + (0.53567588329315186) * emb_t2_22 + (-0.016212737187743187) * emb_t2_23 + (0.010487335734069347) * emb_t2_24 + (0.022374428808689117) * emb_t2_25 + (0.14556528627872467) * emb_t2_26 + (-0.0049680685624480247) * emb_t2_27 + (0.008115917444229126) * emb_t2_28 + (-0.62235081195831299) * emb_t2_29 + (0.3570418655872345) * emb_t2_30 + (0.11953973025083542) * emb_t2_31 + gate_r * ((0.23773778975009918) + (-0.2487059086561203) * gru_0_fwd_t1_h_0 + (0.028771974146366119) * gru_0_fwd_t1_h_1 + (0.46639904379844666) * gru_0_fwd_t1_h_2 + (-0.032455295324325562) * gru_0_fwd_t1_h_3 + (-0.082337528467178345) * gru_0_fwd_t1_h_4 + (0.020752320066094398) * gru_0_fwd_t1_h_5 + (0.60596978664398193) * gru_0_fwd_t1_h_6 + (0.91006499528884888) * gru_0_fwd_t1_h_7 + (0.2911192774772644) * gru_0_fwd_t1_h_8 + (-0.058060787618160248) * gru_0_fwd_t1_h_9 + (-0.17348109185695648) * gru_0_fwd_t1_h_10 + (-0.53574538230895996) * gru_0_fwd_t1_h_11 + (0.13039921224117279) * gru_0_fwd_t1_h_12 + (0.14083090424537659) * gru_0_fwd_t1_h_13 + (-0.35861220955848694) * gru_0_fwd_t1_h_14 + (0.021743543446063995) * gru_0_fwd_t1_h_15 + (0.34549611806869507) * gru_0_fwd_t1_h_16 + (0.0046041081659495831) * gru_0_fwd_t1_h_17 + (0.020699158310890198) * gru_0_fwd_t1_h_18 + (0.31412455439567566) * gru_0_fwd_t1_h_19 + (0.11900006234645844) * gru_0_fwd_t1_h_20 + (-0.23512519896030426) * gru_0_fwd_t1_h_21 + (-0.021319052204489708) * gru_0_fwd_t1_h_22 + (-0.088279232382774353) * gru_0_fwd_t1_h_23 + (-0.36241886019706726) * gru_0_fwd_t1_h_24 + (-0.13654504716396332) * gru_0_fwd_t1_h_25 + (0.042143896222114563) * gru_0_fwd_t1_h_26 + (0.17744766175746918) * gru_0_fwd_t1_h_27 + (-0.042073432356119156) * gru_0_fwd_t1_h_28 + (0.70212197303771973) * gru_0_fwd_t1_h_29 + (0.18689286708831787) * gru_0_fwd_t1_h_30 + (-0.064656473696231842) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_11 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_11;
    // h=12
    gate_r = sigmoid((-0.13819116353988647) + (0.71213573217391968) * emb_t2_0 + (1.8283154964447021) * emb_t2_1 + (-0.43105298280715942) * emb_t2_2 + (-0.5775381326675415) * emb_t2_3 + (0.79101389646530151) * emb_t2_4 + (0.10034384578466415) * emb_t2_5 + (0.38175764679908752) * emb_t2_6 + (0.048554982990026474) * emb_t2_7 + (0.033263951539993286) * emb_t2_8 + (-2.5481750965118408) * emb_t2_9 + (-2.3444526195526123) * emb_t2_10 + (0.13829174637794495) * emb_t2_11 + (0.36406019330024719) * emb_t2_12 + (0.91075325012207031) * emb_t2_13 + (-0.47730499505996704) * emb_t2_14 + (-0.10274036228656769) * emb_t2_15 + (-0.75440347194671631) * emb_t2_16 + (0.43904596567153931) * emb_t2_17 + (-1.9574978351593018) * emb_t2_18 + (1.7656664848327637) * emb_t2_19 + (-0.29784631729125977) * emb_t2_20 + (-0.56409049034118652) * emb_t2_21 + (-0.33933252096176147) * emb_t2_22 + (0.14233733713626862) * emb_t2_23 + (-0.83454227447509766) * emb_t2_24 + (-0.54138535261154175) * emb_t2_25 + (-0.12354942411184311) * emb_t2_26 + (0.2123880535364151) * emb_t2_27 + (-1.4417906999588013) * emb_t2_28 + (1.2856999635696411) * emb_t2_29 + (-0.95881056785583496) * emb_t2_30 + (-0.10788094997406006) * emb_t2_31 + (0.0090473564341664314) * gru_0_fwd_t1_h_0 + (0.8950456976890564) * gru_0_fwd_t1_h_1 + (2.4839749336242676) * gru_0_fwd_t1_h_2 + (-0.37794238328933716) * gru_0_fwd_t1_h_3 + (1.0362467765808105) * gru_0_fwd_t1_h_4 + (-0.74827289581298828) * gru_0_fwd_t1_h_5 + (-1.6676448583602905) * gru_0_fwd_t1_h_6 + (-1.2527164220809937) * gru_0_fwd_t1_h_7 + (0.091055743396282196) * gru_0_fwd_t1_h_8 + (0.89740616083145142) * gru_0_fwd_t1_h_9 + (-2.1588451862335205) * gru_0_fwd_t1_h_10 + (0.049445953220129013) * gru_0_fwd_t1_h_11 + (-0.81097656488418579) * gru_0_fwd_t1_h_12 + (-2.4401075839996338) * gru_0_fwd_t1_h_13 + (1.3959482908248901) * gru_0_fwd_t1_h_14 + (-0.030937181785702705) * gru_0_fwd_t1_h_15 + (-0.50152140855789185) * gru_0_fwd_t1_h_16 + (0.047568630427122116) * gru_0_fwd_t1_h_17 + (-0.92836695909500122) * gru_0_fwd_t1_h_18 + (-0.056089095771312714) * gru_0_fwd_t1_h_19 + (0.85286045074462891) * gru_0_fwd_t1_h_20 + (0.014015817083418369) * gru_0_fwd_t1_h_21 + (-1.0862104892730713) * gru_0_fwd_t1_h_22 + (-0.38725745677947998) * gru_0_fwd_t1_h_23 + (1.593845009803772) * gru_0_fwd_t1_h_24 + (-0.23849309980869293) * gru_0_fwd_t1_h_25 + (-0.40643125772476196) * gru_0_fwd_t1_h_26 + (0.51577633619308472) * gru_0_fwd_t1_h_27 + (-0.59974658489227295) * gru_0_fwd_t1_h_28 + (0.18683210015296936) * gru_0_fwd_t1_h_29 + (0.80650776624679565) * gru_0_fwd_t1_h_30 + (-0.46420764923095703) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-0.27623444795608521) + (-0.089181937277317047) * emb_t2_0 + (0.76283031702041626) * emb_t2_1 + (0.11799173802137375) * emb_t2_2 + (-0.15994881093502045) * emb_t2_3 + (0.53601408004760742) * emb_t2_4 + (-0.032277382910251617) * emb_t2_5 + (0.40841758251190186) * emb_t2_6 + (0.085295476019382477) * emb_t2_7 + (0.034288864582777023) * emb_t2_8 + (-0.35551208257675171) * emb_t2_9 + (-0.23638394474983215) * emb_t2_10 + (-0.13408811390399933) * emb_t2_11 + (-0.28604474663734436) * emb_t2_12 + (0.93144750595092773) * emb_t2_13 + (0.12393957376480103) * emb_t2_14 + (-0.037020359188318253) * emb_t2_15 + (0.014558936469256878) * emb_t2_16 + (-0.042967621237039566) * emb_t2_17 + (-0.43295100331306458) * emb_t2_18 + (0.043752454221248627) * emb_t2_19 + (0.036420885473489761) * emb_t2_20 + (0.07897331565618515) * emb_t2_21 + (0.21949999034404755) * emb_t2_22 + (0.052591770887374878) * emb_t2_23 + (-0.0051065650768578053) * emb_t2_24 + (-0.099439755082130432) * emb_t2_25 + (-0.56317055225372314) * emb_t2_26 + (0.087972633540630341) * emb_t2_27 + (-0.79017859697341919) * emb_t2_28 + (0.45507970452308655) * emb_t2_29 + (-0.91383707523345947) * emb_t2_30 + (-0.088416539132595062) * emb_t2_31 + (-0.021238697692751884) * gru_0_fwd_t1_h_0 + (-0.24551065266132355) * gru_0_fwd_t1_h_1 + (0.59170997142791748) * gru_0_fwd_t1_h_2 + (-0.13845841586589813) * gru_0_fwd_t1_h_3 + (-0.2295953631401062) * gru_0_fwd_t1_h_4 + (-0.20016495883464813) * gru_0_fwd_t1_h_5 + (-2.2545435428619385) * gru_0_fwd_t1_h_6 + (-0.087938807904720306) * gru_0_fwd_t1_h_7 + (-1.0665727853775024) * gru_0_fwd_t1_h_8 + (0.77216607332229614) * gru_0_fwd_t1_h_9 + (-0.26303356885910034) * gru_0_fwd_t1_h_10 + (-0.28161472082138062) * gru_0_fwd_t1_h_11 + (0.36923268437385559) * gru_0_fwd_t1_h_12 + (0.23734328150749207) * gru_0_fwd_t1_h_13 + (-0.16878208518028259) * gru_0_fwd_t1_h_14 + (0.19129160046577454) * gru_0_fwd_t1_h_15 + (0.08678784966468811) * gru_0_fwd_t1_h_16 + (0.12244928628206253) * gru_0_fwd_t1_h_17 + (-0.075215756893157959) * gru_0_fwd_t1_h_18 + (0.54215341806411743) * gru_0_fwd_t1_h_19 + (0.56646305322647095) * gru_0_fwd_t1_h_20 + (-0.97092926502227783) * gru_0_fwd_t1_h_21 + (0.023204375058412552) * gru_0_fwd_t1_h_22 + (0.90324562788009644) * gru_0_fwd_t1_h_23 + (-0.60343492031097412) * gru_0_fwd_t1_h_24 + (-0.57573312520980835) * gru_0_fwd_t1_h_25 + (-0.22784486413002014) * gru_0_fwd_t1_h_26 + (-0.36288154125213623) * gru_0_fwd_t1_h_27 + (-0.4593643844127655) * gru_0_fwd_t1_h_28 + (0.46129304170608521) * gru_0_fwd_t1_h_29 + (-0.044744506478309631) * gru_0_fwd_t1_h_30 + (0.94160538911819458) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.13113819062709808) + (0.22662451863288879) * emb_t2_0 + (1.5104523897171021) * emb_t2_1 + (0.092487126588821411) * emb_t2_2 + (-0.19270691275596619) * emb_t2_3 + (0.61304205656051636) * emb_t2_4 + (0.14026537537574768) * emb_t2_5 + (0.84852981567382812) * emb_t2_6 + (-0.22449961304664612) * emb_t2_7 + (0.77730453014373779) * emb_t2_8 + (-1.432608962059021) * emb_t2_9 + (-1.0286837816238403) * emb_t2_10 + (0.40930461883544922) * emb_t2_11 + (0.44087821245193481) * emb_t2_12 + (0.78888535499572754) * emb_t2_13 + (-0.026853414252400398) * emb_t2_14 + (0.0083698723465204239) * emb_t2_15 + (-0.094677470624446869) * emb_t2_16 + (-0.12160506099462509) * emb_t2_17 + (-0.64910811185836792) * emb_t2_18 + (0.8080596923828125) * emb_t2_19 + (-0.045504763722419739) * emb_t2_20 + (0.07694593071937561) * emb_t2_21 + (-0.26050093770027161) * emb_t2_22 + (-0.2208828330039978) * emb_t2_23 + (0.042329814285039902) * emb_t2_24 + (-0.3294677734375) * emb_t2_25 + (-0.19749502837657928) * emb_t2_26 + (-0.023264419287443161) * emb_t2_27 + (-1.450143575668335) * emb_t2_28 + (0.89601916074752808) * emb_t2_29 + (-0.1187267005443573) * emb_t2_30 + (0.10795458406209946) * emb_t2_31 + gate_r * ((0.37629064917564392) + (0.69379758834838867) * gru_0_fwd_t1_h_0 + (0.12566670775413513) * gru_0_fwd_t1_h_1 + (-0.83343267440795898) * gru_0_fwd_t1_h_2 + (0.022798594087362289) * gru_0_fwd_t1_h_3 + (0.4766353964805603) * gru_0_fwd_t1_h_4 + (-0.17307616770267487) * gru_0_fwd_t1_h_5 + (0.0065453494898974895) * gru_0_fwd_t1_h_6 + (1.3504506349563599) * gru_0_fwd_t1_h_7 + (-0.2527967095375061) * gru_0_fwd_t1_h_8 + (-0.13116355240345001) * gru_0_fwd_t1_h_9 + (0.75132447481155396) * gru_0_fwd_t1_h_10 + (0.0869012251496315) * gru_0_fwd_t1_h_11 + (0.31392928957939148) * gru_0_fwd_t1_h_12 + (0.47258263826370239) * gru_0_fwd_t1_h_13 + (0.20868019759654999) * gru_0_fwd_t1_h_14 + (-0.42683520913124084) * gru_0_fwd_t1_h_15 + (-1.7988011837005615) * gru_0_fwd_t1_h_16 + (-0.55691534280776978) * gru_0_fwd_t1_h_17 + (0.13598142564296722) * gru_0_fwd_t1_h_18 + (0.60253244638442993) * gru_0_fwd_t1_h_19 + (-0.033223610371351242) * gru_0_fwd_t1_h_20 + (-2.9145157337188721) * gru_0_fwd_t1_h_21 + (0.16910871863365173) * gru_0_fwd_t1_h_22 + (0.56474870443344116) * gru_0_fwd_t1_h_23 + (-1.2080322504043579) * gru_0_fwd_t1_h_24 + (-0.049844924360513687) * gru_0_fwd_t1_h_25 + (0.51085406541824341) * gru_0_fwd_t1_h_26 + (0.34663772583007812) * gru_0_fwd_t1_h_27 + (0.22599013149738312) * gru_0_fwd_t1_h_28 + (0.13649067282676697) * gru_0_fwd_t1_h_29 + (0.71261942386627197) * gru_0_fwd_t1_h_30 + (0.55585193634033203) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_12 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_12;
    // h=13
    gate_r = sigmoid((-0.24493922293186188) + (0.086082376539707184) * emb_t2_0 + (0.38436013460159302) * emb_t2_1 + (0.0080774137750267982) * emb_t2_2 + (0.22742687165737152) * emb_t2_3 + (0.23284217715263367) * emb_t2_4 + (0.23968285322189331) * emb_t2_5 + (0.10541507601737976) * emb_t2_6 + (-0.1000438779592514) * emb_t2_7 + (-0.28793677687644958) * emb_t2_8 + (-0.81730258464813232) * emb_t2_9 + (0.12368114292621613) * emb_t2_10 + (0.018839264288544655) * emb_t2_11 + (-0.47766834497451782) * emb_t2_12 + (0.92572909593582153) * emb_t2_13 + (-0.13857302069664001) * emb_t2_14 + (0.037022668868303299) * emb_t2_15 + (0.12148556858301163) * emb_t2_16 + (0.44007572531700134) * emb_t2_17 + (-0.22023935616016388) * emb_t2_18 + (0.29928433895111084) * emb_t2_19 + (0.014743290841579437) * emb_t2_20 + (0.10428926348686218) * emb_t2_21 + (-0.011639767326414585) * emb_t2_22 + (-0.092648565769195557) * emb_t2_23 + (-0.26083177328109741) * emb_t2_24 + (-0.041358672082424164) * emb_t2_25 + (-0.38760218024253845) * emb_t2_26 + (0.09958377480506897) * emb_t2_27 + (-0.72730666399002075) * emb_t2_28 + (0.49651417136192322) * emb_t2_29 + (-0.78872323036193848) * emb_t2_30 + (0.14876808226108551) * emb_t2_31 + (-0.031369868665933609) * gru_0_fwd_t1_h_0 + (0.01079487893730402) * gru_0_fwd_t1_h_1 + (-0.45101001858711243) * gru_0_fwd_t1_h_2 + (-0.1594884991645813) * gru_0_fwd_t1_h_3 + (-0.015288441441953182) * gru_0_fwd_t1_h_4 + (-0.54123544692993164) * gru_0_fwd_t1_h_5 + (-0.6456267237663269) * gru_0_fwd_t1_h_6 + (0.6101868748664856) * gru_0_fwd_t1_h_7 + (-0.22409060597419739) * gru_0_fwd_t1_h_8 + (2.0768654346466064) * gru_0_fwd_t1_h_9 + (0.77579575777053833) * gru_0_fwd_t1_h_10 + (-0.12615425884723663) * gru_0_fwd_t1_h_11 + (-0.092989988625049591) * gru_0_fwd_t1_h_12 + (0.077129408717155457) * gru_0_fwd_t1_h_13 + (0.23493316769599915) * gru_0_fwd_t1_h_14 + (0.13873523473739624) * gru_0_fwd_t1_h_15 + (0.19349849224090576) * gru_0_fwd_t1_h_16 + (0.24411840736865997) * gru_0_fwd_t1_h_17 + (-0.48364555835723877) * gru_0_fwd_t1_h_18 + (0.98478013277053833) * gru_0_fwd_t1_h_19 + (1.8207108974456787) * gru_0_fwd_t1_h_20 + (0.33441993594169617) * gru_0_fwd_t1_h_21 + (-0.90809851884841919) * gru_0_fwd_t1_h_22 + (0.21336637437343597) * gru_0_fwd_t1_h_23 + (0.76319783926010132) * gru_0_fwd_t1_h_24 + (0.88129830360412598) * gru_0_fwd_t1_h_25 + (-0.36887520551681519) * gru_0_fwd_t1_h_26 + (-0.74829745292663574) * gru_0_fwd_t1_h_27 + (-0.7790876030921936) * gru_0_fwd_t1_h_28 + (1.9297181367874146) * gru_0_fwd_t1_h_29 + (-0.092375501990318298) * gru_0_fwd_t1_h_30 + (-0.44336175918579102) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-0.20209278166294098) + (0.12011343985795975) * emb_t2_0 + (0.43581271171569824) * emb_t2_1 + (-0.085991226136684418) * emb_t2_2 + (-0.10847796499729156) * emb_t2_3 + (0.08875449001789093) * emb_t2_4 + (0.04469192773103714) * emb_t2_5 + (0.077407456934452057) * emb_t2_6 + (-0.056165929883718491) * emb_t2_7 + (0.52228039503097534) * emb_t2_8 + (0.12703190743923187) * emb_t2_9 + (-0.83562815189361572) * emb_t2_10 + (-0.27128544449806213) * emb_t2_11 + (-0.062053818255662918) * emb_t2_12 + (0.78520691394805908) * emb_t2_13 + (-0.0057147601619362831) * emb_t2_14 + (0.058222625404596329) * emb_t2_15 + (-0.0096234641969203949) * emb_t2_16 + (0.51676738262176514) * emb_t2_17 + (-0.39960962533950806) * emb_t2_18 + (0.17886106669902802) * emb_t2_19 + (0.076249495148658752) * emb_t2_20 + (-0.11904884874820709) * emb_t2_21 + (0.087140798568725586) * emb_t2_22 + (-0.16650499403476715) * emb_t2_23 + (0.014134772121906281) * emb_t2_24 + (0.09465017169713974) * emb_t2_25 + (0.032041411846876144) * emb_t2_26 + (-0.053211189806461334) * emb_t2_27 + (-0.37721812725067139) * emb_t2_28 + (1.0725784301757812) * emb_t2_29 + (-0.39212498068809509) * emb_t2_30 + (0.0097467908635735512) * emb_t2_31 + (-0.16063301265239716) * gru_0_fwd_t1_h_0 + (-0.19093786180019379) * gru_0_fwd_t1_h_1 + (0.9770311713218689) * gru_0_fwd_t1_h_2 + (1.3272440433502197) * gru_0_fwd_t1_h_3 + (-0.3668459951877594) * gru_0_fwd_t1_h_4 + (0.050397083163261414) * gru_0_fwd_t1_h_5 + (-0.43690767884254456) * gru_0_fwd_t1_h_6 + (-0.6259617805480957) * gru_0_fwd_t1_h_7 + (0.17461547255516052) * gru_0_fwd_t1_h_8 + (-0.84528946876525879) * gru_0_fwd_t1_h_9 + (-0.84525787830352783) * gru_0_fwd_t1_h_10 + (-0.025077451020479202) * gru_0_fwd_t1_h_11 + (0.067844130098819733) * gru_0_fwd_t1_h_12 + (0.25158962607383728) * gru_0_fwd_t1_h_13 + (-0.11787939816713333) * gru_0_fwd_t1_h_14 + (0.29186570644378662) * gru_0_fwd_t1_h_15 + (0.23569834232330322) * gru_0_fwd_t1_h_16 + (0.21120734512805939) * gru_0_fwd_t1_h_17 + (-0.0070596304722130299) * gru_0_fwd_t1_h_18 + (0.62990552186965942) * gru_0_fwd_t1_h_19 + (-0.043732855468988419) * gru_0_fwd_t1_h_20 + (-0.24200022220611572) * gru_0_fwd_t1_h_21 + (1.1273998022079468) * gru_0_fwd_t1_h_22 + (-0.20935983955860138) * gru_0_fwd_t1_h_23 + (-1.3802403211593628) * gru_0_fwd_t1_h_24 + (-1.1846910715103149) * gru_0_fwd_t1_h_25 + (-0.043649103492498398) * gru_0_fwd_t1_h_26 + (0.12872309982776642) * gru_0_fwd_t1_h_27 + (0.065025448799133301) * gru_0_fwd_t1_h_28 + (-1.6417814493179321) * gru_0_fwd_t1_h_29 + (0.076392970979213715) * gru_0_fwd_t1_h_30 + (0.93184041976928711) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.11905974894762039) + (-0.016840549185872078) * emb_t2_0 + (0.041920192539691925) * emb_t2_1 + (0.00884269829839468) * emb_t2_2 + (0.069766901433467865) * emb_t2_3 + (0.21086820960044861) * emb_t2_4 + (-0.075556255877017975) * emb_t2_5 + (-0.03695233166217804) * emb_t2_6 + (-0.0045304498635232449) * emb_t2_7 + (0.23122778534889221) * emb_t2_8 + (-2.2711155414581299) * emb_t2_9 + (-1.0234404802322388) * emb_t2_10 + (0.17471009492874146) * emb_t2_11 + (0.860251784324646) * emb_t2_12 + (0.65159422159194946) * emb_t2_13 + (0.021172599866986275) * emb_t2_14 + (-0.0033173365518450737) * emb_t2_15 + (-0.027907770127058029) * emb_t2_16 + (0.26877656579017639) * emb_t2_17 + (-0.55647808313369751) * emb_t2_18 + (1.0068657398223877) * emb_t2_19 + (-0.16727805137634277) * emb_t2_20 + (-0.041272759437561035) * emb_t2_21 + (-0.4111783504486084) * emb_t2_22 + (0.033408738672733307) * emb_t2_23 + (0.010147839784622192) * emb_t2_24 + (-0.020526517182588577) * emb_t2_25 + (-0.15061844885349274) * emb_t2_26 + (0.012502701953053474) * emb_t2_27 + (-0.49056321382522583) * emb_t2_28 + (0.2233232855796814) * emb_t2_29 + (-0.26701906323432922) * emb_t2_30 + (-0.27094089984893799) * emb_t2_31 + gate_r * ((0.024951677769422531) + (0.1846538633108139) * gru_0_fwd_t1_h_0 + (0.30879944562911987) * gru_0_fwd_t1_h_1 + (-0.052811075001955032) * gru_0_fwd_t1_h_2 + (0.068536072969436646) * gru_0_fwd_t1_h_3 + (0.04347427561879158) * gru_0_fwd_t1_h_4 + (-0.040291834622621536) * gru_0_fwd_t1_h_5 + (-0.52785974740982056) * gru_0_fwd_t1_h_6 + (0.67994570732116699) * gru_0_fwd_t1_h_7 + (-0.079058468341827393) * gru_0_fwd_t1_h_8 + (1.1558336019515991) * gru_0_fwd_t1_h_9 + (-0.065450683236122131) * gru_0_fwd_t1_h_10 + (0.094174079596996307) * gru_0_fwd_t1_h_11 + (-0.14515061676502228) * gru_0_fwd_t1_h_12 + (-0.15944577753543854) * gru_0_fwd_t1_h_13 + (0.013243325985968113) * gru_0_fwd_t1_h_14 + (-0.10206355154514313) * gru_0_fwd_t1_h_15 + (-0.16590829193592072) * gru_0_fwd_t1_h_16 + (0.050888065248727798) * gru_0_fwd_t1_h_17 + (-0.10996798425912857) * gru_0_fwd_t1_h_18 + (0.14285895228385925) * gru_0_fwd_t1_h_19 + (1.0072370767593384) * gru_0_fwd_t1_h_20 + (0.10481662303209305) * gru_0_fwd_t1_h_21 + (0.18209335207939148) * gru_0_fwd_t1_h_22 + (-0.00083213509060442448) * gru_0_fwd_t1_h_23 + (0.32121744751930237) * gru_0_fwd_t1_h_24 + (0.44419571757316589) * gru_0_fwd_t1_h_25 + (-0.1261940598487854) * gru_0_fwd_t1_h_26 + (-0.69567960500717163) * gru_0_fwd_t1_h_27 + (-0.48560014367103577) * gru_0_fwd_t1_h_28 + (1.1801481246948242) * gru_0_fwd_t1_h_29 + (0.21133951842784882) * gru_0_fwd_t1_h_30 + (-0.48859679698944092) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_13 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_13;
    // h=14
    gate_r = sigmoid((-0.45397192239761353) + (-0.033411845564842224) * emb_t2_0 + (0.77575004100799561) * emb_t2_1 + (-0.15062379837036133) * emb_t2_2 + (-0.38417389988899231) * emb_t2_3 + (0.54749584197998047) * emb_t2_4 + (-0.017853233963251114) * emb_t2_5 + (0.62360298633575439) * emb_t2_6 + (0.20147290825843811) * emb_t2_7 + (0.0037806939799338579) * emb_t2_8 + (-2.002647876739502) * emb_t2_9 + (-1.9313151836395264) * emb_t2_10 + (0.20988962054252625) * emb_t2_11 + (0.024559801444411278) * emb_t2_12 + (1.0112464427947998) * emb_t2_13 + (0.086578674614429474) * emb_t2_14 + (0.17845530807971954) * emb_t2_15 + (-0.12912113964557648) * emb_t2_16 + (0.583179771900177) * emb_t2_17 + (-1.4173449277877808) * emb_t2_18 + (0.67875206470489502) * emb_t2_19 + (-0.23821991682052612) * emb_t2_20 + (0.2199874073266983) * emb_t2_21 + (-0.13230594992637634) * emb_t2_22 + (-0.11907476186752319) * emb_t2_23 + (0.18906261026859283) * emb_t2_24 + (-0.18793632090091705) * emb_t2_25 + (-0.78451645374298096) * emb_t2_26 + (0.14537540078163147) * emb_t2_27 + (-0.65835261344909668) * emb_t2_28 + (1.2940597534179688) * emb_t2_29 + (-0.73795926570892334) * emb_t2_30 + (-0.10836069285869598) * emb_t2_31 + (-0.18968197703361511) * gru_0_fwd_t1_h_0 + (0.11785489320755005) * gru_0_fwd_t1_h_1 + (0.89207345247268677) * gru_0_fwd_t1_h_2 + (1.0348373651504517) * gru_0_fwd_t1_h_3 + (0.20847609639167786) * gru_0_fwd_t1_h_4 + (-0.06429697573184967) * gru_0_fwd_t1_h_5 + (-0.5135541558265686) * gru_0_fwd_t1_h_6 + (-0.44656145572662354) * gru_0_fwd_t1_h_7 + (0.32979092001914978) * gru_0_fwd_t1_h_8 + (0.13249126076698303) * gru_0_fwd_t1_h_9 + (-0.64700412750244141) * gru_0_fwd_t1_h_10 + (-0.22079920768737793) * gru_0_fwd_t1_h_11 + (0.095960550010204315) * gru_0_fwd_t1_h_12 + (-0.46071651577949524) * gru_0_fwd_t1_h_13 + (-0.49897831678390503) * gru_0_fwd_t1_h_14 + (0.23245227336883545) * gru_0_fwd_t1_h_15 + (0.79710197448730469) * gru_0_fwd_t1_h_16 + (0.38094121217727661) * gru_0_fwd_t1_h_17 + (0.12681452929973602) * gru_0_fwd_t1_h_18 + (0.09750007838010788) * gru_0_fwd_t1_h_19 + (0.22199058532714844) * gru_0_fwd_t1_h_20 + (1.1034625768661499) * gru_0_fwd_t1_h_21 + (-0.15211495757102966) * gru_0_fwd_t1_h_22 + (-0.41669708490371704) * gru_0_fwd_t1_h_23 + (0.29847469925880432) * gru_0_fwd_t1_h_24 + (0.17946365475654602) * gru_0_fwd_t1_h_25 + (0.090495258569717407) * gru_0_fwd_t1_h_26 + (-0.22310546040534973) * gru_0_fwd_t1_h_27 + (-0.256451815366745) * gru_0_fwd_t1_h_28 + (0.2812512218952179) * gru_0_fwd_t1_h_29 + (-0.32578763365745544) * gru_0_fwd_t1_h_30 + (0.14687429368495941) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-1.8232038021087646) + (-0.15023361146450043) * emb_t2_0 + (0.96385926008224487) * emb_t2_1 + (-1.3140143156051636) * emb_t2_2 + (-1.0027141571044922) * emb_t2_3 + (1.2459331750869751) * emb_t2_4 + (0.77761995792388916) * emb_t2_5 + (1.7574244737625122) * emb_t2_6 + (0.058845601975917816) * emb_t2_7 + (-1.009594202041626) * emb_t2_8 + (-0.23899698257446289) * emb_t2_9 + (0.98808836936950684) * emb_t2_10 + (-1.1500662565231323) * emb_t2_11 + (-0.38337048888206482) * emb_t2_12 + (0.9971422553062439) * emb_t2_13 + (0.38504603505134583) * emb_t2_14 + (2.160029411315918) * emb_t2_15 + (-1.5431840419769287) * emb_t2_16 + (1.4221694469451904) * emb_t2_17 + (-0.0063379169441759586) * emb_t2_18 + (-0.39146113395690918) * emb_t2_19 + (-1.0994603633880615) * emb_t2_20 + (0.065883010625839233) * emb_t2_21 + (0.32091152667999268) * emb_t2_22 + (-1.3230479955673218) * emb_t2_23 + (-0.023029988631606102) * emb_t2_24 + (0.41010692715644836) * emb_t2_25 + (-1.5492093563079834) * emb_t2_26 + (-1.405240535736084) * emb_t2_27 + (-0.87734037637710571) * emb_t2_28 + (1.3899809122085571) * emb_t2_29 + (-1.4813506603240967) * emb_t2_30 + (1.0255727767944336) * emb_t2_31 + (-0.50430756807327271) * gru_0_fwd_t1_h_0 + (0.16521644592285156) * gru_0_fwd_t1_h_1 + (0.17965446412563324) * gru_0_fwd_t1_h_2 + (0.29590305685997009) * gru_0_fwd_t1_h_3 + (0.15497098863124847) * gru_0_fwd_t1_h_4 + (0.61226785182952881) * gru_0_fwd_t1_h_5 + (0.32421654462814331) * gru_0_fwd_t1_h_6 + (-0.66990190744400024) * gru_0_fwd_t1_h_7 + (0.43279746174812317) * gru_0_fwd_t1_h_8 + (-0.53012102842330933) * gru_0_fwd_t1_h_9 + (-0.46658101677894592) * gru_0_fwd_t1_h_10 + (0.087285324931144714) * gru_0_fwd_t1_h_11 + (0.26987358927726746) * gru_0_fwd_t1_h_12 + (-0.3242114782333374) * gru_0_fwd_t1_h_13 + (-0.29275771975517273) * gru_0_fwd_t1_h_14 + (0.42743027210235596) * gru_0_fwd_t1_h_15 + (0.33621290326118469) * gru_0_fwd_t1_h_16 + (0.34911978244781494) * gru_0_fwd_t1_h_17 + (0.29506510496139526) * gru_0_fwd_t1_h_18 + (-0.074105307459831238) * gru_0_fwd_t1_h_19 + (-0.20606906712055206) * gru_0_fwd_t1_h_20 + (0.42721608281135559) * gru_0_fwd_t1_h_21 + (-0.18179690837860107) * gru_0_fwd_t1_h_22 + (-0.40997448563575745) * gru_0_fwd_t1_h_23 + (-0.15746484696865082) * gru_0_fwd_t1_h_24 + (0.65432345867156982) * gru_0_fwd_t1_h_25 + (-0.87175244092941284) * gru_0_fwd_t1_h_26 + (0.14778010547161102) * gru_0_fwd_t1_h_27 + (0.37648963928222656) * gru_0_fwd_t1_h_28 + (-0.1515754908323288) * gru_0_fwd_t1_h_29 + (-0.41502752900123596) * gru_0_fwd_t1_h_30 + (-0.6245003342628479) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.14886282384395599) + (-0.047864139080047607) * emb_t2_0 + (-1.1459468603134155) * emb_t2_1 + (-0.065569460391998291) * emb_t2_2 + (-0.15098020434379578) * emb_t2_3 + (-0.22753581404685974) * emb_t2_4 + (0.023284910246729851) * emb_t2_5 + (0.051384422928094864) * emb_t2_6 + (-0.012710169889032841) * emb_t2_7 + (-0.23814584314823151) * emb_t2_8 + (0.26451963186264038) * emb_t2_9 + (-0.037323541939258575) * emb_t2_10 + (-0.067752987146377563) * emb_t2_11 + (-0.246310755610466) * emb_t2_12 + (-1.4979100227355957) * emb_t2_13 + (-0.017943916842341423) * emb_t2_14 + (0.048866741359233856) * emb_t2_15 + (0.0038056995254009962) * emb_t2_16 + (-0.58103436231613159) * emb_t2_17 + (0.5919191837310791) * emb_t2_18 + (-0.35030663013458252) * emb_t2_19 + (-0.32851973176002502) * emb_t2_20 + (0.041404847055673599) * emb_t2_21 + (0.19779631495475769) * emb_t2_22 + (0.0076771387830376625) * emb_t2_23 + (-0.015984067693352699) * emb_t2_24 + (0.031097317114472389) * emb_t2_25 + (0.14534047245979309) * emb_t2_26 + (0.0060985912568867207) * emb_t2_27 + (0.52801203727722168) * emb_t2_28 + (-1.4571421146392822) * emb_t2_29 + (0.22780649363994598) * emb_t2_30 + (0.26633980870246887) * emb_t2_31 + gate_r * ((-0.16346175968647003) + (-0.09786040335893631) * gru_0_fwd_t1_h_0 + (0.23419897258281708) * gru_0_fwd_t1_h_1 + (-0.21457135677337646) * gru_0_fwd_t1_h_2 + (-0.2570309042930603) * gru_0_fwd_t1_h_3 + (0.48327177762985229) * gru_0_fwd_t1_h_4 + (0.28896036744117737) * gru_0_fwd_t1_h_5 + (1.0622642040252686) * gru_0_fwd_t1_h_6 + (0.013798998668789864) * gru_0_fwd_t1_h_7 + (-0.41571080684661865) * gru_0_fwd_t1_h_8 + (-0.58850526809692383) * gru_0_fwd_t1_h_9 + (0.2131301611661911) * gru_0_fwd_t1_h_10 + (0.6998564600944519) * gru_0_fwd_t1_h_11 + (-0.28208157420158386) * gru_0_fwd_t1_h_12 + (2.29621055041207e-05) * gru_0_fwd_t1_h_13 + (0.22485107183456421) * gru_0_fwd_t1_h_14 + (-0.25836142897605896) * gru_0_fwd_t1_h_15 + (-0.52887260913848877) * gru_0_fwd_t1_h_16 + (-0.53442943096160889) * gru_0_fwd_t1_h_17 + (-0.31122002005577087) * gru_0_fwd_t1_h_18 + (0.35197198390960693) * gru_0_fwd_t1_h_19 + (-0.49808287620544434) * gru_0_fwd_t1_h_20 + (-0.0582708939909935) * gru_0_fwd_t1_h_21 + (-0.052767980843782425) * gru_0_fwd_t1_h_22 + (0.043715298175811768) * gru_0_fwd_t1_h_23 + (0.070448495447635651) * gru_0_fwd_t1_h_24 + (0.054185613989830017) * gru_0_fwd_t1_h_25 + (0.049206249415874481) * gru_0_fwd_t1_h_26 + (0.031890500336885452) * gru_0_fwd_t1_h_27 + (0.4271150529384613) * gru_0_fwd_t1_h_28 + (-0.585274338722229) * gru_0_fwd_t1_h_29 + (-0.15266133844852448) * gru_0_fwd_t1_h_30 + (-0.3196665346622467) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_14 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_14;
    // h=15
    gate_r = sigmoid((0.22253870964050293) + (0.016360677778720856) * emb_t2_0 + (-1.5026537179946899) * emb_t2_1 + (-0.28024399280548096) * emb_t2_2 + (0.050498653203248978) * emb_t2_3 + (-0.351624995470047) * emb_t2_4 + (-0.40350571274757385) * emb_t2_5 + (-0.031484890729188919) * emb_t2_6 + (0.67858278751373291) * emb_t2_7 + (-0.013686429709196091) * emb_t2_8 + (1.7512952089309692) * emb_t2_9 + (0.69301760196685791) * emb_t2_10 + (0.14288672804832458) * emb_t2_11 + (0.36211758852005005) * emb_t2_12 + (-1.0030416250228882) * emb_t2_13 + (0.34899410605430603) * emb_t2_14 + (-0.21793220937252045) * emb_t2_15 + (-0.51826560497283936) * emb_t2_16 + (-0.27691742777824402) * emb_t2_17 + (0.78273630142211914) * emb_t2_18 + (-0.92822736501693726) * emb_t2_19 + (0.61438661813735962) * emb_t2_20 + (0.068580500781536102) * emb_t2_21 + (-0.15008574724197388) * emb_t2_22 + (0.9668419361114502) * emb_t2_23 + (0.62467503547668457) * emb_t2_24 + (0.81891769170761108) * emb_t2_25 + (0.49519169330596924) * emb_t2_26 + (0.43116772174835205) * emb_t2_27 + (0.9864344596862793) * emb_t2_28 + (-0.91429358720779419) * emb_t2_29 + (0.56097209453582764) * emb_t2_30 + (-0.2036910206079483) * emb_t2_31 + (-0.32502686977386475) * gru_0_fwd_t1_h_0 + (0.78232389688491821) * gru_0_fwd_t1_h_1 + (2.7676272392272949) * gru_0_fwd_t1_h_2 + (1.0437133312225342) * gru_0_fwd_t1_h_3 + (0.66671812534332275) * gru_0_fwd_t1_h_4 + (-0.33811968564987183) * gru_0_fwd_t1_h_5 + (-1.4537038803100586) * gru_0_fwd_t1_h_6 + (-2.1731481552124023) * gru_0_fwd_t1_h_7 + (0.30157884955406189) * gru_0_fwd_t1_h_8 + (0.71992242336273193) * gru_0_fwd_t1_h_9 + (-2.8815383911132812) * gru_0_fwd_t1_h_10 + (-0.63359981775283813) * gru_0_fwd_t1_h_11 + (-0.85792505741119385) * gru_0_fwd_t1_h_12 + (-1.2990736961364746) * gru_0_fwd_t1_h_13 + (-0.11267029494047165) * gru_0_fwd_t1_h_14 + (0.38575854897499084) * gru_0_fwd_t1_h_15 + (2.1269447803497314) * gru_0_fwd_t1_h_16 + (0.87227088212966919) * gru_0_fwd_t1_h_17 + (-0.50431704521179199) * gru_0_fwd_t1_h_18 + (-0.49995335936546326) * gru_0_fwd_t1_h_19 + (0.48225829005241394) * gru_0_fwd_t1_h_20 + (1.9649089574813843) * gru_0_fwd_t1_h_21 + (1.7164056301116943) * gru_0_fwd_t1_h_22 + (-0.24436867237091064) * gru_0_fwd_t1_h_23 + (-0.37714755535125732) * gru_0_fwd_t1_h_24 + (0.41893485188484192) * gru_0_fwd_t1_h_25 + (-2.9731860160827637) * gru_0_fwd_t1_h_26 + (1.8013137578964233) * gru_0_fwd_t1_h_27 + (-0.83482253551483154) * gru_0_fwd_t1_h_28 + (-0.49966242909431458) * gru_0_fwd_t1_h_29 + (0.16722197830677032) * gru_0_fwd_t1_h_30 + (0.56645631790161133) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.30070364475250244) + (-0.05635673925280571) * emb_t2_0 + (-0.067112065851688385) * emb_t2_1 + (-0.06425350159406662) * emb_t2_2 + (0.077421307563781738) * emb_t2_3 + (-0.1746942400932312) * emb_t2_4 + (-0.039307020604610443) * emb_t2_5 + (-0.28659650683403015) * emb_t2_6 + (-0.017274713143706322) * emb_t2_7 + (0.19208724796772003) * emb_t2_8 + (0.0077798711135983467) * emb_t2_9 + (0.2279905378818512) * emb_t2_10 + (-0.10878977924585342) * emb_t2_11 + (0.25834912061691284) * emb_t2_12 + (-0.1210922971367836) * emb_t2_13 + (-0.035897888243198395) * emb_t2_14 + (0.0085645783692598343) * emb_t2_15 + (-0.034590538591146469) * emb_t2_16 + (0.16058775782585144) * emb_t2_17 + (-0.35205802321434021) * emb_t2_18 + (-0.065378278493881226) * emb_t2_19 + (-0.38194951415061951) * emb_t2_20 + (0.013348866254091263) * emb_t2_21 + (-0.39324495196342468) * emb_t2_22 + (0.10962370038032532) * emb_t2_23 + (0.10738728195428848) * emb_t2_24 + (-0.0048113111406564713) * emb_t2_25 + (-0.35867854952812195) * emb_t2_26 + (-0.072245530784130096) * emb_t2_27 + (0.42355561256408691) * emb_t2_28 + (0.10928520560264587) * emb_t2_29 + (-0.15295638144016266) * emb_t2_30 + (-0.029373915866017342) * emb_t2_31 + (-0.067728616297245026) * gru_0_fwd_t1_h_0 + (-0.20345865190029144) * gru_0_fwd_t1_h_1 + (-1.0847338438034058) * gru_0_fwd_t1_h_2 + (-1.1996949911117554) * gru_0_fwd_t1_h_3 + (-0.22191739082336426) * gru_0_fwd_t1_h_4 + (-0.20452636480331421) * gru_0_fwd_t1_h_5 + (-0.048956055194139481) * gru_0_fwd_t1_h_6 + (1.2858961820602417) * gru_0_fwd_t1_h_7 + (-0.74420595169067383) * gru_0_fwd_t1_h_8 + (0.28957799077033997) * gru_0_fwd_t1_h_9 + (0.85666459798812866) * gru_0_fwd_t1_h_10 + (-0.077054582536220551) * gru_0_fwd_t1_h_11 + (0.19617670774459839) * gru_0_fwd_t1_h_12 + (0.3047325611114502) * gru_0_fwd_t1_h_13 + (0.10374833643436432) * gru_0_fwd_t1_h_14 + (0.096282213926315308) * gru_0_fwd_t1_h_15 + (-0.27681022882461548) * gru_0_fwd_t1_h_16 + (-0.13420893251895905) * gru_0_fwd_t1_h_17 + (0.25321295857429504) * gru_0_fwd_t1_h_18 + (-0.82909852266311646) * gru_0_fwd_t1_h_19 + (1.1336630582809448) * gru_0_fwd_t1_h_20 + (-0.80600464344024658) * gru_0_fwd_t1_h_21 + (-0.094633661210536957) * gru_0_fwd_t1_h_22 + (0.90198403596878052) * gru_0_fwd_t1_h_23 + (0.077765151858329773) * gru_0_fwd_t1_h_24 + (0.81448769569396973) * gru_0_fwd_t1_h_25 + (-0.081442184746265411) * gru_0_fwd_t1_h_26 + (-0.74932938814163208) * gru_0_fwd_t1_h_27 + (-1.1786587238311768) * gru_0_fwd_t1_h_28 + (-0.19917643070220947) * gru_0_fwd_t1_h_29 + (-0.05151926726102829) * gru_0_fwd_t1_h_30 + (-0.57075226306915283) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.3616282045841217) + (-0.052971519529819489) * emb_t2_0 + (0.34601053595542908) * emb_t2_1 + (-0.041287470608949661) * emb_t2_2 + (-0.089550361037254333) * emb_t2_3 + (-0.19137284159660339) * emb_t2_4 + (0.099235080182552338) * emb_t2_5 + (-0.20383144915103912) * emb_t2_6 + (0.10927039384841919) * emb_t2_7 + (0.73237818479537964) * emb_t2_8 + (-0.20619137585163116) * emb_t2_9 + (-0.38912254571914673) * emb_t2_10 + (0.46198239922523499) * emb_t2_11 + (0.71200597286224365) * emb_t2_12 + (0.62918221950531006) * emb_t2_13 + (-0.073357544839382172) * emb_t2_14 + (-0.066233411431312561) * emb_t2_15 + (0.038170069456100464) * emb_t2_16 + (-0.21940472722053528) * emb_t2_17 + (-0.31465387344360352) * emb_t2_18 + (0.19183281064033508) * emb_t2_19 + (0.58151531219482422) * emb_t2_20 + (-0.045800652354955673) * emb_t2_21 + (-0.97698229551315308) * emb_t2_22 + (-0.079118646681308746) * emb_t2_23 + (-0.11023763567209244) * emb_t2_24 + (0.10056966543197632) * emb_t2_25 + (0.15606807172298431) * emb_t2_26 + (-0.01731976680457592) * emb_t2_27 + (-0.097230903804302216) * emb_t2_28 + (-0.18679577112197876) * emb_t2_29 + (0.24642644822597504) * emb_t2_30 + (-0.30758565664291382) * emb_t2_31 + gate_r * ((0.31660577654838562) + (-0.034243829548358917) * gru_0_fwd_t1_h_0 + (-0.55281025171279907) * gru_0_fwd_t1_h_1 + (-0.60067349672317505) * gru_0_fwd_t1_h_2 + (-0.63544893264770508) * gru_0_fwd_t1_h_3 + (-0.40026074647903442) * gru_0_fwd_t1_h_4 + (0.1882937103509903) * gru_0_fwd_t1_h_5 + (0.069357238709926605) * gru_0_fwd_t1_h_6 + (1.0766537189483643) * gru_0_fwd_t1_h_7 + (0.095588341355323792) * gru_0_fwd_t1_h_8 + (0.21260377764701843) * gru_0_fwd_t1_h_9 + (0.47428795695304871) * gru_0_fwd_t1_h_10 + (0.12378742545843124) * gru_0_fwd_t1_h_11 + (0.77961325645446777) * gru_0_fwd_t1_h_12 + (0.96212154626846313) * gru_0_fwd_t1_h_13 + (-0.17048311233520508) * gru_0_fwd_t1_h_14 + (0.0021893491502851248) * gru_0_fwd_t1_h_15 + (-1.8534501791000366) * gru_0_fwd_t1_h_16 + (-0.31350404024124146) * gru_0_fwd_t1_h_17 + (-0.21819962561130524) * gru_0_fwd_t1_h_18 + (0.65013450384140015) * gru_0_fwd_t1_h_19 + (0.065584197640419006) * gru_0_fwd_t1_h_20 + (-1.3217240571975708) * gru_0_fwd_t1_h_21 + (0.035432245582342148) * gru_0_fwd_t1_h_22 + (1.0178897380828857) * gru_0_fwd_t1_h_23 + (-0.84909510612487793) * gru_0_fwd_t1_h_24 + (-0.081171117722988129) * gru_0_fwd_t1_h_25 + (0.11481735110282898) * gru_0_fwd_t1_h_26 + (0.2735942006111145) * gru_0_fwd_t1_h_27 + (0.36477044224739075) * gru_0_fwd_t1_h_28 + (-0.30473536252975464) * gru_0_fwd_t1_h_29 + (0.016806839033961296) * gru_0_fwd_t1_h_30 + (0.55331087112426758) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_15 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_15;
    // h=16
    gate_r = sigmoid((-0.73997431993484497) + (-1.0838247537612915) * emb_t2_0 + (1.6113995313644409) * emb_t2_1 + (0.09555208683013916) * emb_t2_2 + (-0.12945468723773956) * emb_t2_3 + (1.206310510635376) * emb_t2_4 + (1.3071699142456055) * emb_t2_5 + (1.2296496629714966) * emb_t2_6 + (0.70433187484741211) * emb_t2_7 + (-0.23897583782672882) * emb_t2_8 + (-0.59379929304122925) * emb_t2_9 + (0.13181863725185394) * emb_t2_10 + (-0.78146284818649292) * emb_t2_11 + (-0.48472240567207336) * emb_t2_12 + (3.5554032325744629) * emb_t2_13 + (0.80827802419662476) * emb_t2_14 + (-0.050797589123249054) * emb_t2_15 + (-0.29431825876235962) * emb_t2_16 + (0.76010715961456299) * emb_t2_17 + (-0.68920987844467163) * emb_t2_18 + (0.27093410491943359) * emb_t2_19 + (-0.98353135585784912) * emb_t2_20 + (0.13234071433544159) * emb_t2_21 + (-0.028872635215520859) * emb_t2_22 + (0.25065895915031433) * emb_t2_23 + (-0.074389934539794922) * emb_t2_24 + (-0.74144589900970459) * emb_t2_25 + (-0.66827142238616943) * emb_t2_26 + (0.13513536751270294) * emb_t2_27 + (-2.4185609817504883) * emb_t2_28 + (2.9619016647338867) * emb_t2_29 + (-1.3314070701599121) * emb_t2_30 + (0.48485049605369568) * emb_t2_31 + (-0.60848426818847656) * gru_0_fwd_t1_h_0 + (-0.17199832201004028) * gru_0_fwd_t1_h_1 + (0.39312633872032166) * gru_0_fwd_t1_h_2 + (1.1678085327148438) * gru_0_fwd_t1_h_3 + (-0.31434905529022217) * gru_0_fwd_t1_h_4 + (-0.68196260929107666) * gru_0_fwd_t1_h_5 + (0.31036126613616943) * gru_0_fwd_t1_h_6 + (0.18033614754676819) * gru_0_fwd_t1_h_7 + (1.0017088651657104) * gru_0_fwd_t1_h_8 + (2.0560801029205322) * gru_0_fwd_t1_h_9 + (-0.4431794285774231) * gru_0_fwd_t1_h_10 + (-0.97738891839981079) * gru_0_fwd_t1_h_11 + (0.56611824035644531) * gru_0_fwd_t1_h_12 + (-0.27449139952659607) * gru_0_fwd_t1_h_13 + (-1.0815316438674927) * gru_0_fwd_t1_h_14 + (1.4929941892623901) * gru_0_fwd_t1_h_15 + (1.1836279630661011) * gru_0_fwd_t1_h_16 + (1.2436140775680542) * gru_0_fwd_t1_h_17 + (0.027332702651619911) * gru_0_fwd_t1_h_18 + (1.1978269815444946) * gru_0_fwd_t1_h_19 + (2.5207579135894775) * gru_0_fwd_t1_h_20 + (0.37166756391525269) * gru_0_fwd_t1_h_21 + (-1.2014214992523193) * gru_0_fwd_t1_h_22 + (-1.2131277322769165) * gru_0_fwd_t1_h_23 + (0.43751922249794006) * gru_0_fwd_t1_h_24 + (1.7389219999313354) * gru_0_fwd_t1_h_25 + (0.3110823929309845) * gru_0_fwd_t1_h_26 + (0.15468284487724304) * gru_0_fwd_t1_h_27 + (0.43365064263343811) * gru_0_fwd_t1_h_28 + (0.67030280828475952) * gru_0_fwd_t1_h_29 + (-0.32367131114006042) * gru_0_fwd_t1_h_30 + (1.5189623832702637) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-1.0357828140258789) + (0.27539888024330139) * emb_t2_0 + (0.59584897756576538) * emb_t2_1 + (0.10291215032339096) * emb_t2_2 + (-0.64288908243179321) * emb_t2_3 + (0.8546634316444397) * emb_t2_4 + (0.22404970228672028) * emb_t2_5 + (0.45606052875518799) * emb_t2_6 + (0.027393341064453125) * emb_t2_7 + (-0.3333868682384491) * emb_t2_8 + (-0.51985597610473633) * emb_t2_9 + (-0.32270315289497375) * emb_t2_10 + (-0.72846126556396484) * emb_t2_11 + (-0.0087089985609054565) * emb_t2_12 + (0.34818348288536072) * emb_t2_13 + (-0.090691708028316498) * emb_t2_14 + (0.06084224209189415) * emb_t2_15 + (0.081887513399124146) * emb_t2_16 + (0.67644339799880981) * emb_t2_17 + (-0.71408045291900635) * emb_t2_18 + (0.50977230072021484) * emb_t2_19 + (-0.4526250958442688) * emb_t2_20 + (-0.072483427822589874) * emb_t2_21 + (-0.21886618435382843) * emb_t2_22 + (-0.49965697526931763) * emb_t2_23 + (-0.55434966087341309) * emb_t2_24 + (-0.15808673202991486) * emb_t2_25 + (-0.90712028741836548) * emb_t2_26 + (0.11859484016895294) * emb_t2_27 + (-0.072024427354335785) * emb_t2_28 + (0.37507486343383789) * emb_t2_29 + (-0.61730808019638062) * emb_t2_30 + (0.12027415633201599) * emb_t2_31 + (-0.58968281745910645) * gru_0_fwd_t1_h_0 + (-0.25251510739326477) * gru_0_fwd_t1_h_1 + (0.33586642146110535) * gru_0_fwd_t1_h_2 + (-0.30003276467323303) * gru_0_fwd_t1_h_3 + (-0.081556104123592377) * gru_0_fwd_t1_h_4 + (-0.064192347228527069) * gru_0_fwd_t1_h_5 + (-0.56159782409667969) * gru_0_fwd_t1_h_6 + (0.51345431804656982) * gru_0_fwd_t1_h_7 + (1.0489184856414795) * gru_0_fwd_t1_h_8 + (1.3790045976638794) * gru_0_fwd_t1_h_9 + (-0.26369619369506836) * gru_0_fwd_t1_h_10 + (-0.96238869428634644) * gru_0_fwd_t1_h_11 + (0.54039424657821655) * gru_0_fwd_t1_h_12 + (-0.17825877666473389) * gru_0_fwd_t1_h_13 + (0.50966209173202515) * gru_0_fwd_t1_h_14 + (0.33082431554794312) * gru_0_fwd_t1_h_15 + (0.7379152774810791) * gru_0_fwd_t1_h_16 + (0.90720963478088379) * gru_0_fwd_t1_h_17 + (-0.075094543397426605) * gru_0_fwd_t1_h_18 + (-0.62965631484985352) * gru_0_fwd_t1_h_19 + (1.2285047769546509) * gru_0_fwd_t1_h_20 + (-0.47901156544685364) * gru_0_fwd_t1_h_21 + (-1.1846243143081665) * gru_0_fwd_t1_h_22 + (-1.1536780595779419) * gru_0_fwd_t1_h_23 + (-0.42495104670524597) * gru_0_fwd_t1_h_24 + (1.923803448677063) * gru_0_fwd_t1_h_25 + (-0.39528197050094604) * gru_0_fwd_t1_h_26 + (-0.30994394421577454) * gru_0_fwd_t1_h_27 + (-0.63625937700271606) * gru_0_fwd_t1_h_28 + (1.6195392608642578) * gru_0_fwd_t1_h_29 + (0.98101377487182617) * gru_0_fwd_t1_h_30 + (1.1056489944458008) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.22604900598526001) + (-0.006568356417119503) * emb_t2_0 + (0.73290365934371948) * emb_t2_1 + (-0.034640386700630188) * emb_t2_2 + (-0.48012259602546692) * emb_t2_3 + (1.0691393613815308) * emb_t2_4 + (0.069804370403289795) * emb_t2_5 + (0.48285406827926636) * emb_t2_6 + (0.033279825001955032) * emb_t2_7 + (-0.047217335551977158) * emb_t2_8 + (-0.39067170023918152) * emb_t2_9 + (-0.36527392268180847) * emb_t2_10 + (-0.44020587205886841) * emb_t2_11 + (-0.11152506619691849) * emb_t2_12 + (0.89139139652252197) * emb_t2_13 + (-0.017423044890165329) * emb_t2_14 + (-0.022252680733799934) * emb_t2_15 + (0.0013354213442653418) * emb_t2_16 + (0.7033536434173584) * emb_t2_17 + (-0.58364081382751465) * emb_t2_18 + (0.56353777647018433) * emb_t2_19 + (-0.34482285380363464) * emb_t2_20 + (-0.063773065805435181) * emb_t2_21 + (0.043443888425827026) * emb_t2_22 + (-0.007825109176337719) * emb_t2_23 + (-0.00087158574024215341) * emb_t2_24 + (-0.027193684130907059) * emb_t2_25 + (-0.073232665657997131) * emb_t2_26 + (0.0092520695179700851) * emb_t2_27 + (-1.0322616100311279) * emb_t2_28 + (1.1936490535736084) * emb_t2_29 + (-1.7239460945129395) * emb_t2_30 + (0.36147743463516235) * emb_t2_31 + gate_r * ((-0.015922574326395988) + (0.71038424968719482) * gru_0_fwd_t1_h_0 + (-0.82354414463043213) * gru_0_fwd_t1_h_1 + (0.71342611312866211) * gru_0_fwd_t1_h_2 + (2.1833083629608154) * gru_0_fwd_t1_h_3 + (-0.86910384893417358) * gru_0_fwd_t1_h_4 + (-1.1434696912765503) * gru_0_fwd_t1_h_5 + (-0.053345590829849243) * gru_0_fwd_t1_h_6 + (-0.65996527671813965) * gru_0_fwd_t1_h_7 + (-0.68012493848800659) * gru_0_fwd_t1_h_8 + (-0.23802518844604492) * gru_0_fwd_t1_h_9 + (-1.2880663871765137) * gru_0_fwd_t1_h_10 + (-0.090565159916877747) * gru_0_fwd_t1_h_11 + (0.69197744131088257) * gru_0_fwd_t1_h_12 + (0.55457842350006104) * gru_0_fwd_t1_h_13 + (-0.31055340170860291) * gru_0_fwd_t1_h_14 + (1.28516685962677) * gru_0_fwd_t1_h_15 + (-0.013504244387149811) * gru_0_fwd_t1_h_16 + (-0.49443179368972778) * gru_0_fwd_t1_h_17 + (0.16000360250473022) * gru_0_fwd_t1_h_18 + (0.13232322037220001) * gru_0_fwd_t1_h_19 + (-0.7382352352142334) * gru_0_fwd_t1_h_20 + (-0.44987884163856506) * gru_0_fwd_t1_h_21 + (1.4714065790176392) * gru_0_fwd_t1_h_22 + (1.1448880434036255) * gru_0_fwd_t1_h_23 + (2.5568864345550537) * gru_0_fwd_t1_h_24 + (-1.1003286838531494) * gru_0_fwd_t1_h_25 + (0.26475486159324646) * gru_0_fwd_t1_h_26 + (-0.1294424831867218) * gru_0_fwd_t1_h_27 + (0.96459364891052246) * gru_0_fwd_t1_h_28 + (-0.033777289092540741) * gru_0_fwd_t1_h_29 + (-0.042816810309886932) * gru_0_fwd_t1_h_30 + (3.0048985481262207) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_16 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_16;
    // h=17
    gate_r = sigmoid((0.10671024769544601) + (-0.23648755252361298) * emb_t2_0 + (0.43049430847167969) * emb_t2_1 + (-0.3498130738735199) * emb_t2_2 + (0.15949311852455139) * emb_t2_3 + (-0.46395626664161682) * emb_t2_4 + (0.29232200980186462) * emb_t2_5 + (-0.1528313010931015) * emb_t2_6 + (0.42776691913604736) * emb_t2_7 + (-0.032471984624862671) * emb_t2_8 + (-0.9297674298286438) * emb_t2_9 + (-0.22700458765029907) * emb_t2_10 + (-0.22688305377960205) * emb_t2_11 + (0.17295850813388824) * emb_t2_12 + (-0.11975060403347015) * emb_t2_13 + (0.70245897769927979) * emb_t2_14 + (-0.11701890081167221) * emb_t2_15 + (-0.20448246598243713) * emb_t2_16 + (-0.22946646809577942) * emb_t2_17 + (-0.51368790864944458) * emb_t2_18 + (0.37154388427734375) * emb_t2_19 + (0.020844604820013046) * emb_t2_20 + (0.42527708411216736) * emb_t2_21 + (-0.21234305202960968) * emb_t2_22 + (-1.0256682634353638) * emb_t2_23 + (1.0685691833496094) * emb_t2_24 + (-0.31615725159645081) * emb_t2_25 + (0.015889819711446762) * emb_t2_26 + (-0.1097104474902153) * emb_t2_27 + (-0.10378453135490417) * emb_t2_28 + (0.03240981325507164) * emb_t2_29 + (0.15514448285102844) * emb_t2_30 + (0.10904211550951004) * emb_t2_31 + (-0.20885476469993591) * gru_0_fwd_t1_h_0 + (-0.5939335823059082) * gru_0_fwd_t1_h_1 + (-0.84695279598236084) * gru_0_fwd_t1_h_2 + (-0.16071151196956635) * gru_0_fwd_t1_h_3 + (-0.17109014093875885) * gru_0_fwd_t1_h_4 + (-0.59088057279586792) * gru_0_fwd_t1_h_5 + (-0.58758258819580078) * gru_0_fwd_t1_h_6 + (1.7108736038208008) * gru_0_fwd_t1_h_7 + (0.71550261974334717) * gru_0_fwd_t1_h_8 + (0.73931771516799927) * gru_0_fwd_t1_h_9 + (0.80718463659286499) * gru_0_fwd_t1_h_10 + (-0.80158305168151855) * gru_0_fwd_t1_h_11 + (0.65658044815063477) * gru_0_fwd_t1_h_12 + (0.69120669364929199) * gru_0_fwd_t1_h_13 + (-0.25397372245788574) * gru_0_fwd_t1_h_14 + (0.42931491136550903) * gru_0_fwd_t1_h_15 + (1.3923923969268799) * gru_0_fwd_t1_h_16 + (1.1407744884490967) * gru_0_fwd_t1_h_17 + (-0.79056680202484131) * gru_0_fwd_t1_h_18 + (1.9352906942367554) * gru_0_fwd_t1_h_19 + (0.2213260680437088) * gru_0_fwd_t1_h_20 + (0.36506339907646179) * gru_0_fwd_t1_h_21 + (1.1636108160018921) * gru_0_fwd_t1_h_22 + (-1.126855731010437) * gru_0_fwd_t1_h_23 + (1.5854309797286987) * gru_0_fwd_t1_h_24 + (1.7039406299591064) * gru_0_fwd_t1_h_25 + (-0.08300492912530899) * gru_0_fwd_t1_h_26 + (0.73399502038955688) * gru_0_fwd_t1_h_27 + (-0.18402589857578278) * gru_0_fwd_t1_h_28 + (1.0647958517074585) * gru_0_fwd_t1_h_29 + (0.17502686381340027) * gru_0_fwd_t1_h_30 + (1.5966989994049072) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-1.2117055654525757) + (0.016612272709608078) * emb_t2_0 + (-0.56738293170928955) * emb_t2_1 + (0.062147699296474457) * emb_t2_2 + (-0.82648879289627075) * emb_t2_3 + (0.0026352535933256149) * emb_t2_4 + (-0.15189161896705627) * emb_t2_5 + (0.10423162579536438) * emb_t2_6 + (-0.1574280709028244) * emb_t2_7 + (-0.37564891576766968) * emb_t2_8 + (0.016060840338468552) * emb_t2_9 + (-0.39851653575897217) * emb_t2_10 + (-0.44850707054138184) * emb_t2_11 + (-0.97382181882858276) * emb_t2_12 + (-0.050746697932481766) * emb_t2_13 + (-0.071229681372642517) * emb_t2_14 + (0.035132970660924911) * emb_t2_15 + (-0.044965546578168869) * emb_t2_16 + (0.37717399001121521) * emb_t2_17 + (-0.07468501478433609) * emb_t2_18 + (0.18675146996974945) * emb_t2_19 + (-0.35855942964553833) * emb_t2_20 + (0.034738294780254364) * emb_t2_21 + (0.48146829009056091) * emb_t2_22 + (-0.23794594407081604) * emb_t2_23 + (-0.020208531990647316) * emb_t2_24 + (-0.024742672219872475) * emb_t2_25 + (-0.58671784400939941) * emb_t2_26 + (-0.084546305239200592) * emb_t2_27 + (0.050398003309965134) * emb_t2_28 + (0.11159729212522507) * emb_t2_29 + (-0.1683114618062973) * emb_t2_30 + (0.59767723083496094) * emb_t2_31 + (-0.66424638032913208) * gru_0_fwd_t1_h_0 + (-1.7605105638504028) * gru_0_fwd_t1_h_1 + (-0.061611965298652649) * gru_0_fwd_t1_h_2 + (-0.36829972267150879) * gru_0_fwd_t1_h_3 + (-0.11340346187353134) * gru_0_fwd_t1_h_4 + (-1.5295470952987671) * gru_0_fwd_t1_h_5 + (-1.4087090492248535) * gru_0_fwd_t1_h_6 + (0.85979932546615601) * gru_0_fwd_t1_h_7 + (0.046740297228097916) * gru_0_fwd_t1_h_8 + (2.1486403942108154) * gru_0_fwd_t1_h_9 + (0.25788146257400513) * gru_0_fwd_t1_h_10 + (-2.4474005699157715) * gru_0_fwd_t1_h_11 + (1.8636674880981445) * gru_0_fwd_t1_h_12 + (1.7786251306533813) * gru_0_fwd_t1_h_13 + (-1.0125643014907837) * gru_0_fwd_t1_h_14 + (1.40236496925354) * gru_0_fwd_t1_h_15 + (0.86920839548110962) * gru_0_fwd_t1_h_16 + (0.99941128492355347) * gru_0_fwd_t1_h_17 + (-0.77754104137420654) * gru_0_fwd_t1_h_18 + (0.64665108919143677) * gru_0_fwd_t1_h_19 + (2.827669620513916) * gru_0_fwd_t1_h_20 + (-0.96254074573516846) * gru_0_fwd_t1_h_21 + (-0.76606088876724243) * gru_0_fwd_t1_h_22 + (-0.54202193021774292) * gru_0_fwd_t1_h_23 + (4.0713658332824707) * gru_0_fwd_t1_h_24 + (1.5718939304351807) * gru_0_fwd_t1_h_25 + (-0.63543123006820679) * gru_0_fwd_t1_h_26 + (0.19542558491230011) * gru_0_fwd_t1_h_27 + (-1.0633385181427002) * gru_0_fwd_t1_h_28 + (2.7317180633544922) * gru_0_fwd_t1_h_29 + (0.050327729433774948) * gru_0_fwd_t1_h_30 + (2.8962955474853516) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.221898153424263) + (-0.019147153943777084) * emb_t2_0 + (0.57370299100875854) * emb_t2_1 + (-0.047257333993911743) * emb_t2_2 + (-0.58628159761428833) * emb_t2_3 + (0.50026649236679077) * emb_t2_4 + (-0.13116469979286194) * emb_t2_5 + (0.83004248142242432) * emb_t2_6 + (0.051303304731845856) * emb_t2_7 + (0.037409216165542603) * emb_t2_8 + (0.02389940619468689) * emb_t2_9 + (-0.045890837907791138) * emb_t2_10 + (0.16196003556251526) * emb_t2_11 + (-0.038877710700035095) * emb_t2_12 + (1.0539206266403198) * emb_t2_13 + (0.04584098607301712) * emb_t2_14 + (-0.0076764603145420551) * emb_t2_15 + (0.027467524632811546) * emb_t2_16 + (0.33011424541473389) * emb_t2_17 + (-0.25294643640518188) * emb_t2_18 + (0.2804621160030365) * emb_t2_19 + (-0.10838799178600311) * emb_t2_20 + (0.085922889411449432) * emb_t2_21 + (0.089250512421131134) * emb_t2_22 + (0.017442543059587479) * emb_t2_23 + (0.12681078910827637) * emb_t2_24 + (0.055263526737689972) * emb_t2_25 + (-0.31791079044342041) * emb_t2_26 + (0.021327197551727295) * emb_t2_27 + (0.018859518691897392) * emb_t2_28 + (1.0924072265625) * emb_t2_29 + (-0.28373891115188599) * emb_t2_30 + (0.10267849266529083) * emb_t2_31 + gate_r * ((0.082600101828575134) + (0.13910973072052002) * gru_0_fwd_t1_h_0 + (-0.044356118887662888) * gru_0_fwd_t1_h_1 + (0.49587962031364441) * gru_0_fwd_t1_h_2 + (-0.81794220209121704) * gru_0_fwd_t1_h_3 + (0.027326216921210289) * gru_0_fwd_t1_h_4 + (0.34553560614585876) * gru_0_fwd_t1_h_5 + (-0.55109268426895142) * gru_0_fwd_t1_h_6 + (0.070090353488922119) * gru_0_fwd_t1_h_7 + (0.5720595121383667) * gru_0_fwd_t1_h_8 + (-0.28998285531997681) * gru_0_fwd_t1_h_9 + (-0.2824021577835083) * gru_0_fwd_t1_h_10 + (-0.53865683078765869) * gru_0_fwd_t1_h_11 + (-0.13653825223445892) * gru_0_fwd_t1_h_12 + (-0.074214465916156769) * gru_0_fwd_t1_h_13 + (0.62393003702163696) * gru_0_fwd_t1_h_14 + (-0.61766749620437622) * gru_0_fwd_t1_h_15 + (0.58145958185195923) * gru_0_fwd_t1_h_16 + (0.54063016176223755) * gru_0_fwd_t1_h_17 + (-0.089276522397994995) * gru_0_fwd_t1_h_18 + (-0.23601256310939789) * gru_0_fwd_t1_h_19 + (0.33422911167144775) * gru_0_fwd_t1_h_20 + (-0.054138053208589554) * gru_0_fwd_t1_h_21 + (-0.81494510173797607) * gru_0_fwd_t1_h_22 + (-0.84211784601211548) * gru_0_fwd_t1_h_23 + (0.057144619524478912) * gru_0_fwd_t1_h_24 + (0.083349727094173431) * gru_0_fwd_t1_h_25 + (-0.40048390626907349) * gru_0_fwd_t1_h_26 + (0.16642892360687256) * gru_0_fwd_t1_h_27 + (-0.49617204070091248) * gru_0_fwd_t1_h_28 + (0.37616777420043945) * gru_0_fwd_t1_h_29 + (0.19343669712543488) * gru_0_fwd_t1_h_30 + (-0.94743365049362183) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_17 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_17;
    // h=18
    gate_r = sigmoid((-0.080384597182273865) + (-0.53457856178283691) * emb_t2_0 + (-1.9672771692276001) * emb_t2_1 + (-0.52992790937423706) * emb_t2_2 + (-0.056390851736068726) * emb_t2_3 + (-0.63948482275009155) * emb_t2_4 + (0.62443774938583374) * emb_t2_5 + (-0.78366184234619141) * emb_t2_6 + (-0.01881898008286953) * emb_t2_7 + (-0.28969237208366394) * emb_t2_8 + (5.459223747253418) * emb_t2_9 + (2.5146589279174805) * emb_t2_10 + (-0.0088729793205857277) * emb_t2_11 + (-0.23458743095397949) * emb_t2_12 + (-2.1902823448181152) * emb_t2_13 + (-0.59745347499847412) * emb_t2_14 + (-0.22062887251377106) * emb_t2_15 + (0.42509707808494568) * emb_t2_16 + (-0.44736215472221375) * emb_t2_17 + (1.9501816034317017) * emb_t2_18 + (-1.4777431488037109) * emb_t2_19 + (-0.16341967880725861) * emb_t2_20 + (-0.73815649747848511) * emb_t2_21 + (0.59230250120162964) * emb_t2_22 + (1.9121017456054688) * emb_t2_23 + (0.13281752169132233) * emb_t2_24 + (2.828221321105957) * emb_t2_25 + (0.11647900193929672) * emb_t2_26 + (0.76455706357955933) * emb_t2_27 + (1.8853341341018677) * emb_t2_28 + (-2.0072565078735352) * emb_t2_29 + (0.31579062342643738) * emb_t2_30 + (0.44909194111824036) * emb_t2_31 + (-1.0544208288192749) * gru_0_fwd_t1_h_0 + (-0.043615773320198059) * gru_0_fwd_t1_h_1 + (-1.6775637865066528) * gru_0_fwd_t1_h_2 + (-1.6872161626815796) * gru_0_fwd_t1_h_3 + (-0.071235030889511108) * gru_0_fwd_t1_h_4 + (2.5193819999694824) * gru_0_fwd_t1_h_5 + (-0.026698639616370201) * gru_0_fwd_t1_h_6 + (0.45818287134170532) * gru_0_fwd_t1_h_7 + (0.54886561632156372) * gru_0_fwd_t1_h_8 + (-0.43824577331542969) * gru_0_fwd_t1_h_9 + (1.4022860527038574) * gru_0_fwd_t1_h_10 + (0.63794064521789551) * gru_0_fwd_t1_h_11 + (-1.258359432220459) * gru_0_fwd_t1_h_12 + (0.98059135675430298) * gru_0_fwd_t1_h_13 + (-0.75651293992996216) * gru_0_fwd_t1_h_14 + (-0.58807969093322754) * gru_0_fwd_t1_h_15 + (0.12245570868253708) * gru_0_fwd_t1_h_16 + (0.052455324679613113) * gru_0_fwd_t1_h_17 + (-0.54277968406677246) * gru_0_fwd_t1_h_18 + (-0.97650367021560669) * gru_0_fwd_t1_h_19 + (-1.5222657918930054) * gru_0_fwd_t1_h_20 + (0.45175480842590332) * gru_0_fwd_t1_h_21 + (-0.069768629968166351) * gru_0_fwd_t1_h_22 + (-0.21819955110549927) * gru_0_fwd_t1_h_23 + (2.3023533821105957) * gru_0_fwd_t1_h_24 + (0.77952349185943604) * gru_0_fwd_t1_h_25 + (1.1918904781341553) * gru_0_fwd_t1_h_26 + (-0.20099546015262604) * gru_0_fwd_t1_h_27 + (1.4409035444259644) * gru_0_fwd_t1_h_28 + (-0.038982309401035309) * gru_0_fwd_t1_h_29 + (-0.35645768046379089) * gru_0_fwd_t1_h_30 + (-0.12278830260038376) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-0.036812819540500641) + (-0.043464448302984238) * emb_t2_0 + (-0.19282066822052002) * emb_t2_1 + (-0.00018582388292998075) * emb_t2_2 + (-0.15364494919776917) * emb_t2_3 + (-0.16343356668949127) * emb_t2_4 + (-0.094423063099384308) * emb_t2_5 + (0.42070397734642029) * emb_t2_6 + (0.037465885281562805) * emb_t2_7 + (-0.0077730361372232437) * emb_t2_8 + (-0.11454466730356216) * emb_t2_9 + (-0.21702392399311066) * emb_t2_10 + (-0.21569274365901947) * emb_t2_11 + (-0.095556393265724182) * emb_t2_12 + (0.39995089173316956) * emb_t2_13 + (0.075654298067092896) * emb_t2_14 + (-0.092791028320789337) * emb_t2_15 + (-0.077034182846546173) * emb_t2_16 + (0.12179234623908997) * emb_t2_17 + (-0.2004254013299942) * emb_t2_18 + (-0.055181924253702164) * emb_t2_19 + (-0.0083613507449626923) * emb_t2_20 + (-0.16232788562774658) * emb_t2_21 + (0.17317308485507965) * emb_t2_22 + (0.11220531165599823) * emb_t2_23 + (-0.12206471711397171) * emb_t2_24 + (-0.064161069691181183) * emb_t2_25 + (-0.17174755036830902) * emb_t2_26 + (0.048049692064523697) * emb_t2_27 + (0.16295656561851501) * emb_t2_28 + (0.21343213319778442) * emb_t2_29 + (-0.82913541793823242) * emb_t2_30 + (-0.44215726852416992) * emb_t2_31 + (0.32374817132949829) * gru_0_fwd_t1_h_0 + (-0.035181246697902679) * gru_0_fwd_t1_h_1 + (0.83833110332489014) * gru_0_fwd_t1_h_2 + (0.28980547189712524) * gru_0_fwd_t1_h_3 + (-0.26283451914787292) * gru_0_fwd_t1_h_4 + (0.017004899680614471) * gru_0_fwd_t1_h_5 + (-0.25298106670379639) * gru_0_fwd_t1_h_6 + (-0.22384192049503326) * gru_0_fwd_t1_h_7 + (1.1933842897415161) * gru_0_fwd_t1_h_8 + (0.27356076240539551) * gru_0_fwd_t1_h_9 + (-0.60849910974502563) * gru_0_fwd_t1_h_10 + (0.041127443313598633) * gru_0_fwd_t1_h_11 + (-0.03553028404712677) * gru_0_fwd_t1_h_12 + (-0.16684837639331818) * gru_0_fwd_t1_h_13 + (0.2131020575761795) * gru_0_fwd_t1_h_14 + (-0.019674293696880341) * gru_0_fwd_t1_h_15 + (-0.16409741342067719) * gru_0_fwd_t1_h_16 + (0.054505225270986557) * gru_0_fwd_t1_h_17 + (-0.18662057816982269) * gru_0_fwd_t1_h_18 + (0.92045480012893677) * gru_0_fwd_t1_h_19 + (0.46676093339920044) * gru_0_fwd_t1_h_20 + (-0.17047835886478424) * gru_0_fwd_t1_h_21 + (0.85916578769683838) * gru_0_fwd_t1_h_22 + (-1.4981727600097656) * gru_0_fwd_t1_h_23 + (-1.0504188537597656) * gru_0_fwd_t1_h_24 + (-0.40342941880226135) * gru_0_fwd_t1_h_25 + (0.14724715054035187) * gru_0_fwd_t1_h_26 + (0.094913125038146973) * gru_0_fwd_t1_h_27 + (-1.3825669288635254) * gru_0_fwd_t1_h_28 + (0.072561778128147125) * gru_0_fwd_t1_h_29 + (0.5774383544921875) * gru_0_fwd_t1_h_30 + (1.4931644201278687) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-1.1240848302841187) + (-0.0032565377186983824) * emb_t2_0 + (0.29058277606964111) * emb_t2_1 + (-0.0089740334078669548) * emb_t2_2 + (-0.036575175821781158) * emb_t2_3 + (-0.25129532814025879) * emb_t2_4 + (-0.0070654852315783501) * emb_t2_5 + (0.05891655758023262) * emb_t2_6 + (0.023560198023915291) * emb_t2_7 + (-0.35265010595321655) * emb_t2_8 + (0.018033051863312721) * emb_t2_9 + (0.39441010355949402) * emb_t2_10 + (-0.62951600551605225) * emb_t2_11 + (-0.49614825844764709) * emb_t2_12 + (0.037315733730792999) * emb_t2_13 + (0.00012678073835559189) * emb_t2_14 + (0.011788002215325832) * emb_t2_15 + (-0.018984138965606689) * emb_t2_16 + (0.50741171836853027) * emb_t2_17 + (0.4170382022857666) * emb_t2_18 + (-0.40696176886558533) * emb_t2_19 + (-0.4595235288143158) * emb_t2_20 + (0.0033596991561353207) * emb_t2_21 + (-0.26304739713668823) * emb_t2_22 + (0.013037304393947124) * emb_t2_23 + (0.00097623461624607444) * emb_t2_24 + (0.015604049898684025) * emb_t2_25 + (-0.81264543533325195) * emb_t2_26 + (-0.00052027194760739803) * emb_t2_27 + (0.66501837968826294) * emb_t2_28 + (0.032645765691995621) * emb_t2_29 + (-0.20347568392753601) * emb_t2_30 + (0.36088526248931885) * emb_t2_31 + gate_r * ((-1.2115147113800049) + (-0.15821366012096405) * gru_0_fwd_t1_h_0 + (0.1776328831911087) * gru_0_fwd_t1_h_1 + (-0.47565549612045288) * gru_0_fwd_t1_h_2 + (-0.40383961796760559) * gru_0_fwd_t1_h_3 + (-0.10716640204191208) * gru_0_fwd_t1_h_4 + (0.057474859058856964) * gru_0_fwd_t1_h_5 + (0.18227092921733856) * gru_0_fwd_t1_h_6 + (0.31493225693702698) * gru_0_fwd_t1_h_7 + (-0.25516930222511292) * gru_0_fwd_t1_h_8 + (-0.81112360954284668) * gru_0_fwd_t1_h_9 + (0.41633594036102295) * gru_0_fwd_t1_h_10 + (-0.27039119601249695) * gru_0_fwd_t1_h_11 + (0.36123308539390564) * gru_0_fwd_t1_h_12 + (0.015203099697828293) * gru_0_fwd_t1_h_13 + (-0.22701126337051392) * gru_0_fwd_t1_h_14 + (-0.046218235045671463) * gru_0_fwd_t1_h_15 + (0.14197537302970886) * gru_0_fwd_t1_h_16 + (-0.081643015146255493) * gru_0_fwd_t1_h_17 + (-0.022593345493078232) * gru_0_fwd_t1_h_18 + (-0.32155174016952515) * gru_0_fwd_t1_h_19 + (-0.65488499402999878) * gru_0_fwd_t1_h_20 + (-0.25856485962867737) * gru_0_fwd_t1_h_21 + (0.46391794085502625) * gru_0_fwd_t1_h_22 + (0.037140145897865295) * gru_0_fwd_t1_h_23 + (0.097739994525909424) * gru_0_fwd_t1_h_24 + (0.39088773727416992) * gru_0_fwd_t1_h_25 + (0.0045818914659321308) * gru_0_fwd_t1_h_26 + (-0.77833598852157593) * gru_0_fwd_t1_h_27 + (1.0865935087203979) * gru_0_fwd_t1_h_28 + (-0.48962011933326721) * gru_0_fwd_t1_h_29 + (-0.021357877179980278) * gru_0_fwd_t1_h_30 + (-0.68388760089874268) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_18 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_18;
    // h=19
    gate_r = sigmoid((0.13702301681041718) + (-0.77147626876831055) * emb_t2_0 + (-0.81997603178024292) * emb_t2_1 + (-0.51858359575271606) * emb_t2_2 + (0.215241938829422) * emb_t2_3 + (-0.10814429074525833) * emb_t2_4 + (-0.7251744270324707) * emb_t2_5 + (0.22982233762741089) * emb_t2_6 + (1.1049644947052002) * emb_t2_7 + (0.041693773120641708) * emb_t2_8 + (0.31527870893478394) * emb_t2_9 + (0.073341958224773407) * emb_t2_10 + (-0.090279273688793182) * emb_t2_11 + (0.47558885812759399) * emb_t2_12 + (-0.67739063501358032) * emb_t2_13 + (-0.69604277610778809) * emb_t2_14 + (0.41969269514083862) * emb_t2_15 + (0.34479019045829773) * emb_t2_16 + (-0.30273699760437012) * emb_t2_17 + (0.20772376656532288) * emb_t2_18 + (-0.16666583716869354) * emb_t2_19 + (-0.21695272624492645) * emb_t2_20 + (-0.07149689644575119) * emb_t2_21 + (-0.22304373979568481) * emb_t2_22 + (-0.30659812688827515) * emb_t2_23 + (-0.50573498010635376) * emb_t2_24 + (-1.402186393737793) * emb_t2_25 + (-0.11665292829275131) * emb_t2_26 + (0.76719427108764648) * emb_t2_27 + (1.2840746641159058) * emb_t2_28 + (-0.55129820108413696) * emb_t2_29 + (0.54777896404266357) * emb_t2_30 + (0.074715390801429749) * emb_t2_31 + (-2.8526573181152344) * gru_0_fwd_t1_h_0 + (1.7887822389602661) * gru_0_fwd_t1_h_1 + (3.0391373634338379) * gru_0_fwd_t1_h_2 + (-0.20921067893505096) * gru_0_fwd_t1_h_3 + (0.0072909616865217686) * gru_0_fwd_t1_h_4 + (-2.4760928153991699) * gru_0_fwd_t1_h_5 + (-2.7908399105072021) * gru_0_fwd_t1_h_6 + (-2.7641496658325195) * gru_0_fwd_t1_h_7 + (-0.22666700184345245) * gru_0_fwd_t1_h_8 + (0.0045752758160233498) * gru_0_fwd_t1_h_9 + (-3.2631030082702637) * gru_0_fwd_t1_h_10 + (0.046420663595199585) * gru_0_fwd_t1_h_11 + (-0.56187623739242554) * gru_0_fwd_t1_h_12 + (-1.5471879243850708) * gru_0_fwd_t1_h_13 + (1.3221325874328613) * gru_0_fwd_t1_h_14 + (0.80259990692138672) * gru_0_fwd_t1_h_15 + (0.0087368553504347801) * gru_0_fwd_t1_h_16 + (-0.32477712631225586) * gru_0_fwd_t1_h_17 + (1.0905032157897949) * gru_0_fwd_t1_h_18 + (-1.984528660774231) * gru_0_fwd_t1_h_19 + (0.52044022083282471) * gru_0_fwd_t1_h_20 + (-1.2629274129867554) * gru_0_fwd_t1_h_21 + (-5.4095230102539062) * gru_0_fwd_t1_h_22 + (-0.013624479062855244) * gru_0_fwd_t1_h_23 + (-1.6504526138305664) * gru_0_fwd_t1_h_24 + (-0.36562290787696838) * gru_0_fwd_t1_h_25 + (-0.54857754707336426) * gru_0_fwd_t1_h_26 + (0.68696314096450806) * gru_0_fwd_t1_h_27 + (1.205736517906189) * gru_0_fwd_t1_h_28 + (0.22609786689281464) * gru_0_fwd_t1_h_29 + (-0.0090778917074203491) * gru_0_fwd_t1_h_30 + (4.6916089057922363) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.85480773448944092) + (-0.21520616114139557) * emb_t2_0 + (-2.2161507606506348) * emb_t2_1 + (0.23663683235645294) * emb_t2_2 + (0.48636487126350403) * emb_t2_3 + (-0.85795557498931885) * emb_t2_4 + (-0.022270169109106064) * emb_t2_5 + (-0.58062177896499634) * emb_t2_6 + (0.082631804049015045) * emb_t2_7 + (0.38727238774299622) * emb_t2_8 + (0.15240995585918427) * emb_t2_9 + (0.80955964326858521) * emb_t2_10 + (0.090886808931827545) * emb_t2_11 + (-0.0036922660656273365) * emb_t2_12 + (-1.9164177179336548) * emb_t2_13 + (0.1397346556186676) * emb_t2_14 + (-0.20619784295558929) * emb_t2_15 + (-0.067076936364173889) * emb_t2_16 + (-0.85549318790435791) * emb_t2_17 + (0.51533985137939453) * emb_t2_18 + (-0.1094854548573494) * emb_t2_19 + (0.44327619671821594) * emb_t2_20 + (-0.14836879074573517) * emb_t2_21 + (-0.50238251686096191) * emb_t2_22 + (0.089014597237110138) * emb_t2_23 + (0.030395112931728363) * emb_t2_24 + (-0.13065908849239349) * emb_t2_25 + (0.84965229034423828) * emb_t2_26 + (0.0078766858205199242) * emb_t2_27 + (1.561223030090332) * emb_t2_28 + (-2.3291647434234619) * emb_t2_29 + (0.78856474161148071) * emb_t2_30 + (-0.16484884917736053) * emb_t2_31 + (0.16172224283218384) * gru_0_fwd_t1_h_0 + (-0.13099808990955353) * gru_0_fwd_t1_h_1 + (0.5365479588508606) * gru_0_fwd_t1_h_2 + (0.56869065761566162) * gru_0_fwd_t1_h_3 + (0.41316038370132446) * gru_0_fwd_t1_h_4 + (-0.78851574659347534) * gru_0_fwd_t1_h_5 + (0.28300455212593079) * gru_0_fwd_t1_h_6 + (-0.043467126786708832) * gru_0_fwd_t1_h_7 + (-0.37293469905853271) * gru_0_fwd_t1_h_8 + (-0.078414715826511383) * gru_0_fwd_t1_h_9 + (-0.54853296279907227) * gru_0_fwd_t1_h_10 + (-0.094554536044597626) * gru_0_fwd_t1_h_11 + (0.22240327298641205) * gru_0_fwd_t1_h_12 + (0.42632156610488892) * gru_0_fwd_t1_h_13 + (-0.019151108339428902) * gru_0_fwd_t1_h_14 + (-0.16051851212978363) * gru_0_fwd_t1_h_15 + (-1.1754809617996216) * gru_0_fwd_t1_h_16 + (-0.21626882255077362) * gru_0_fwd_t1_h_17 + (0.093382380902767181) * gru_0_fwd_t1_h_18 + (-0.36010116338729858) * gru_0_fwd_t1_h_19 + (-0.41321304440498352) * gru_0_fwd_t1_h_20 + (-1.0202927589416504) * gru_0_fwd_t1_h_21 + (0.54137027263641357) * gru_0_fwd_t1_h_22 + (0.86165499687194824) * gru_0_fwd_t1_h_23 + (0.64933735132217407) * gru_0_fwd_t1_h_24 + (-0.82840794324874878) * gru_0_fwd_t1_h_25 + (0.1550883948802948) * gru_0_fwd_t1_h_26 + (0.5506514310836792) * gru_0_fwd_t1_h_27 + (-0.072553403675556183) * gru_0_fwd_t1_h_28 + (-0.11321496218442917) * gru_0_fwd_t1_h_29 + (0.32333263754844666) * gru_0_fwd_t1_h_30 + (0.9308742880821228) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.29461702704429626) + (0.098695814609527588) * emb_t2_0 + (-0.050111845135688782) * emb_t2_1 + (-0.79249697923660278) * emb_t2_2 + (-0.57037860155105591) * emb_t2_3 + (0.98440682888031006) * emb_t2_4 + (1.3170485496520996) * emb_t2_5 + (0.88842856884002686) * emb_t2_6 + (-0.27849915623664856) * emb_t2_7 + (-0.10486403852701187) * emb_t2_8 + (-0.090551190078258514) * emb_t2_9 + (0.32440716028213501) * emb_t2_10 + (-0.22776670753955841) * emb_t2_11 + (-0.19591304659843445) * emb_t2_12 + (0.38721725344657898) * emb_t2_13 + (-0.5123976469039917) * emb_t2_14 + (-0.08726780116558075) * emb_t2_15 + (-0.65979176759719849) * emb_t2_16 + (0.21374836564064026) * emb_t2_17 + (0.39032477140426636) * emb_t2_18 + (0.15093979239463806) * emb_t2_19 + (-0.36676704883575439) * emb_t2_20 + (-0.28320741653442383) * emb_t2_21 + (0.3018161952495575) * emb_t2_22 + (0.33088979125022888) * emb_t2_23 + (0.069458380341529846) * emb_t2_24 + (1.3295258283615112) * emb_t2_25 + (-0.29155522584915161) * emb_t2_26 + (-0.37340447306632996) * emb_t2_27 + (-0.1591511070728302) * emb_t2_28 + (0.61140620708465576) * emb_t2_29 + (-0.96917432546615601) * emb_t2_30 + (0.37255612015724182) * emb_t2_31 + gate_r * ((0.038723930716514587) + (0.71871602535247803) * gru_0_fwd_t1_h_0 + (0.35461735725402832) * gru_0_fwd_t1_h_1 + (-1.8082106113433838) * gru_0_fwd_t1_h_2 + (-1.0910797119140625) * gru_0_fwd_t1_h_3 + (0.59715878963470459) * gru_0_fwd_t1_h_4 + (-0.38347211480140686) * gru_0_fwd_t1_h_5 + (-1.7521129846572876) * gru_0_fwd_t1_h_6 + (1.1610547304153442) * gru_0_fwd_t1_h_7 + (0.81346917152404785) * gru_0_fwd_t1_h_8 + (-1.3757381439208984) * gru_0_fwd_t1_h_9 + (1.7969933748245239) * gru_0_fwd_t1_h_10 + (1.0978133678436279) * gru_0_fwd_t1_h_11 + (-0.60260176658630371) * gru_0_fwd_t1_h_12 + (-0.31954067945480347) * gru_0_fwd_t1_h_13 + (0.47215557098388672) * gru_0_fwd_t1_h_14 + (-0.62301129102706909) * gru_0_fwd_t1_h_15 + (-1.1450519561767578) * gru_0_fwd_t1_h_16 + (-1.0311846733093262) * gru_0_fwd_t1_h_17 + (3.0510616302490234) * gru_0_fwd_t1_h_18 + (-1.0563687086105347) * gru_0_fwd_t1_h_19 + (-2.082733154296875) * gru_0_fwd_t1_h_20 + (-0.55186563730239868) * gru_0_fwd_t1_h_21 + (-0.34734997153282166) * gru_0_fwd_t1_h_22 + (0.45276942849159241) * gru_0_fwd_t1_h_23 + (4.8646140098571777) * gru_0_fwd_t1_h_24 + (0.10721302777528763) * gru_0_fwd_t1_h_25 + (0.15253573656082153) * gru_0_fwd_t1_h_26 + (3.4689960479736328) * gru_0_fwd_t1_h_27 + (-0.42484703660011292) * gru_0_fwd_t1_h_28 + (-1.6124985218048096) * gru_0_fwd_t1_h_29 + (0.065662793815135956) * gru_0_fwd_t1_h_30 + (-3.5532767772674561) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_19 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_19;
    // h=20
    gate_r = sigmoid((-1.4264136552810669) + (-0.61451834440231323) * emb_t2_0 + (0.9676063060760498) * emb_t2_1 + (-0.94664418697357178) * emb_t2_2 + (-0.27056741714477539) * emb_t2_3 + (0.60138159990310669) * emb_t2_4 + (-0.070817932486534119) * emb_t2_5 + (0.52880221605300903) * emb_t2_6 + (0.73380756378173828) * emb_t2_7 + (-0.41712021827697754) * emb_t2_8 + (-0.33273202180862427) * emb_t2_9 + (0.36960679292678833) * emb_t2_10 + (-0.52336287498474121) * emb_t2_11 + (-1.0750094652175903) * emb_t2_12 + (0.21908813714981079) * emb_t2_13 + (0.27061182260513306) * emb_t2_14 + (0.81519228219985962) * emb_t2_15 + (-0.9285845160484314) * emb_t2_16 + (0.80743718147277832) * emb_t2_17 + (0.44628602266311646) * emb_t2_18 + (-0.40048074722290039) * emb_t2_19 + (-1.0603158473968506) * emb_t2_20 + (1.1480264663696289) * emb_t2_21 + (0.064746752381324768) * emb_t2_22 + (-0.19120794534683228) * emb_t2_23 + (0.37202847003936768) * emb_t2_24 + (-0.53232592344284058) * emb_t2_25 + (-0.58353972434997559) * emb_t2_26 + (-0.38865470886230469) * emb_t2_27 + (-1.3387019634246826) * emb_t2_28 + (0.2499217689037323) * emb_t2_29 + (-0.81861937046051025) * emb_t2_30 + (0.93983441591262817) * emb_t2_31 + (-0.51043975353240967) * gru_0_fwd_t1_h_0 + (-0.12270515412092209) * gru_0_fwd_t1_h_1 + (0.38579663634300232) * gru_0_fwd_t1_h_2 + (1.1638079881668091) * gru_0_fwd_t1_h_3 + (-0.66700035333633423) * gru_0_fwd_t1_h_4 + (-0.038244079798460007) * gru_0_fwd_t1_h_5 + (-0.077993050217628479) * gru_0_fwd_t1_h_6 + (-0.7780725359916687) * gru_0_fwd_t1_h_7 + (0.041865695267915726) * gru_0_fwd_t1_h_8 + (-0.75539052486419678) * gru_0_fwd_t1_h_9 + (-0.380867600440979) * gru_0_fwd_t1_h_10 + (-0.00079149095108732581) * gru_0_fwd_t1_h_11 + (0.47831350564956665) * gru_0_fwd_t1_h_12 + (0.022403061389923096) * gru_0_fwd_t1_h_13 + (-0.23141846060752869) * gru_0_fwd_t1_h_14 + (1.2462131977081299) * gru_0_fwd_t1_h_15 + (0.2914695143699646) * gru_0_fwd_t1_h_16 + (-0.0077635240741074085) * gru_0_fwd_t1_h_17 + (0.00024050111824180931) * gru_0_fwd_t1_h_18 + (-0.12924732267856598) * gru_0_fwd_t1_h_19 + (-0.35402598977088928) * gru_0_fwd_t1_h_20 + (0.31677544116973877) * gru_0_fwd_t1_h_21 + (-0.12117447704076767) * gru_0_fwd_t1_h_22 + (0.12163569778203964) * gru_0_fwd_t1_h_23 + (-0.29210895299911499) * gru_0_fwd_t1_h_24 + (-0.12133040279150009) * gru_0_fwd_t1_h_25 + (0.74352371692657471) * gru_0_fwd_t1_h_26 + (-0.35036200284957886) * gru_0_fwd_t1_h_27 + (0.69085007905960083) * gru_0_fwd_t1_h_28 + (-0.64645785093307495) * gru_0_fwd_t1_h_29 + (-0.77016842365264893) * gru_0_fwd_t1_h_30 + (0.29687145352363586) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.78340870141983032) + (0.0093115903437137604) * emb_t2_0 + (-1.3106697797775269) * emb_t2_1 + (0.070482634007930756) * emb_t2_2 + (0.74399459362030029) * emb_t2_3 + (-1.7504346370697021) * emb_t2_4 + (-0.17938202619552612) * emb_t2_5 + (-1.5448827743530273) * emb_t2_6 + (0.45566824078559875) * emb_t2_7 + (0.16360156238079071) * emb_t2_8 + (0.64405936002731323) * emb_t2_9 + (0.63596910238265991) * emb_t2_10 + (0.3477228581905365) * emb_t2_11 + (0.14837765693664551) * emb_t2_12 + (-1.6296197175979614) * emb_t2_13 + (-0.027351710945367813) * emb_t2_14 + (0.2887057363986969) * emb_t2_15 + (-0.43357890844345093) * emb_t2_16 + (-1.1509120464324951) * emb_t2_17 + (0.45720386505126953) * emb_t2_18 + (-0.089075967669487) * emb_t2_19 + (-0.11648203432559967) * emb_t2_20 + (0.23850665986537933) * emb_t2_21 + (-0.11085425317287445) * emb_t2_22 + (-0.11032970249652863) * emb_t2_23 + (0.13056460022926331) * emb_t2_24 + (0.13636663556098938) * emb_t2_25 + (0.53029882907867432) * emb_t2_26 + (-0.15261341631412506) * emb_t2_27 + (1.3694639205932617) * emb_t2_28 + (-1.3386867046356201) * emb_t2_29 + (1.4924653768539429) * emb_t2_30 + (-0.13950049877166748) * emb_t2_31 + (0.48628047108650208) * gru_0_fwd_t1_h_0 + (0.21051883697509766) * gru_0_fwd_t1_h_1 + (-1.0688115358352661) * gru_0_fwd_t1_h_2 + (-1.0911155939102173) * gru_0_fwd_t1_h_3 + (0.31970366835594177) * gru_0_fwd_t1_h_4 + (-0.11139605194330215) * gru_0_fwd_t1_h_5 + (-0.39456751942634583) * gru_0_fwd_t1_h_6 + (1.7038534879684448) * gru_0_fwd_t1_h_7 + (-0.4214419424533844) * gru_0_fwd_t1_h_8 + (1.4970355033874512) * gru_0_fwd_t1_h_9 + (0.99378371238708496) * gru_0_fwd_t1_h_10 + (0.025125883519649506) * gru_0_fwd_t1_h_11 + (-0.25553834438323975) * gru_0_fwd_t1_h_12 + (-0.23067842423915863) * gru_0_fwd_t1_h_13 + (0.40070882439613342) * gru_0_fwd_t1_h_14 + (-0.17735753953456879) * gru_0_fwd_t1_h_15 + (-0.21756827831268311) * gru_0_fwd_t1_h_16 + (-0.15500575304031372) * gru_0_fwd_t1_h_17 + (0.034841418266296387) * gru_0_fwd_t1_h_18 + (-1.4620842933654785) * gru_0_fwd_t1_h_19 + (1.2685364484786987) * gru_0_fwd_t1_h_20 + (-0.51054549217224121) * gru_0_fwd_t1_h_21 + (-1.4877482652664185) * gru_0_fwd_t1_h_22 + (0.2790437638759613) * gru_0_fwd_t1_h_23 + (-0.37473547458648682) * gru_0_fwd_t1_h_24 + (0.84603983163833618) * gru_0_fwd_t1_h_25 + (-0.22208477556705475) * gru_0_fwd_t1_h_26 + (-1.0723576545715332) * gru_0_fwd_t1_h_27 + (-1.0190043449401855) * gru_0_fwd_t1_h_28 + (2.0106806755065918) * gru_0_fwd_t1_h_29 + (0.30822852253913879) * gru_0_fwd_t1_h_30 + (0.53976470232009888) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.03097127191722393) + (-0.10320930927991867) * emb_t2_0 + (0.82765489816665649) * emb_t2_1 + (0.141297847032547) * emb_t2_2 + (0.12704472243785858) * emb_t2_3 + (0.012132569216191769) * emb_t2_4 + (-0.021528003737330437) * emb_t2_5 + (0.36666831374168396) * emb_t2_6 + (0.099240675568580627) * emb_t2_7 + (-0.13016323745250702) * emb_t2_8 + (-0.26259425282478333) * emb_t2_9 + (-0.52248859405517578) * emb_t2_10 + (-0.22280031442642212) * emb_t2_11 + (-0.33534818887710571) * emb_t2_12 + (1.1036478281021118) * emb_t2_13 + (0.07683108001947403) * emb_t2_14 + (-0.20535741746425629) * emb_t2_15 + (-0.41591957211494446) * emb_t2_16 + (-0.1484646201133728) * emb_t2_17 + (-0.28565922379493713) * emb_t2_18 + (0.24257487058639526) * emb_t2_19 + (0.12129694223403931) * emb_t2_20 + (0.070638753473758698) * emb_t2_21 + (-0.6485905647277832) * emb_t2_22 + (0.10159780830144882) * emb_t2_23 + (0.11358051747083664) * emb_t2_24 + (-0.22537481784820557) * emb_t2_25 + (0.0052508106455206871) * emb_t2_26 + (-0.15447917580604553) * emb_t2_27 + (-0.5520210862159729) * emb_t2_28 + (0.55410987138748169) * emb_t2_29 + (-0.10804798454046249) * emb_t2_30 + (-0.43829053640365601) * emb_t2_31 + gate_r * ((-0.35891956090927124) + (0.223118856549263) * gru_0_fwd_t1_h_0 + (-0.094040468335151672) * gru_0_fwd_t1_h_1 + (0.1416572779417038) * gru_0_fwd_t1_h_2 + (0.35163509845733643) * gru_0_fwd_t1_h_3 + (-0.019120942801237106) * gru_0_fwd_t1_h_4 + (-0.25521457195281982) * gru_0_fwd_t1_h_5 + (0.42509672045707703) * gru_0_fwd_t1_h_6 + (-0.29731228947639465) * gru_0_fwd_t1_h_7 + (-0.028367247432470322) * gru_0_fwd_t1_h_8 + (0.12945768237113953) * gru_0_fwd_t1_h_9 + (-0.055589742958545685) * gru_0_fwd_t1_h_10 + (0.71071815490722656) * gru_0_fwd_t1_h_11 + (-0.16418313980102539) * gru_0_fwd_t1_h_12 + (-0.4120762050151825) * gru_0_fwd_t1_h_13 + (-0.11395704001188278) * gru_0_fwd_t1_h_14 + (0.13627280294895172) * gru_0_fwd_t1_h_15 + (-0.10628999024629593) * gru_0_fwd_t1_h_16 + (-0.012025352567434311) * gru_0_fwd_t1_h_17 + (0.081316210329532623) * gru_0_fwd_t1_h_18 + (-0.15269237756729126) * gru_0_fwd_t1_h_19 + (-0.39982026815414429) * gru_0_fwd_t1_h_20 + (0.070969395339488983) * gru_0_fwd_t1_h_21 + (0.12789562344551086) * gru_0_fwd_t1_h_22 + (0.042518820613622665) * gru_0_fwd_t1_h_23 + (-0.0056482981890439987) * gru_0_fwd_t1_h_24 + (-0.56775158643722534) * gru_0_fwd_t1_h_25 + (0.10113644599914551) * gru_0_fwd_t1_h_26 + (-0.68507564067840576) * gru_0_fwd_t1_h_27 + (-0.23388475179672241) * gru_0_fwd_t1_h_28 + (-0.43714827299118042) * gru_0_fwd_t1_h_29 + (-0.26752457022666931) * gru_0_fwd_t1_h_30 + (-0.44777467846870422) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_20 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_20;
    // h=21
    gate_r = sigmoid((-0.75448429584503174) + (-0.60397064685821533) * emb_t2_0 + (1.3377755880355835) * emb_t2_1 + (-0.44530278444290161) * emb_t2_2 + (-0.61841064691543579) * emb_t2_3 + (2.1105039119720459) * emb_t2_4 + (0.033293161541223526) * emb_t2_5 + (1.4935053586959839) * emb_t2_6 + (0.45641455054283142) * emb_t2_7 + (-0.94164890050888062) * emb_t2_8 + (-0.40494272112846375) * emb_t2_9 + (-0.28412389755249023) * emb_t2_10 + (-1.0010306835174561) * emb_t2_11 + (-0.20056094229221344) * emb_t2_12 + (3.0117461681365967) * emb_t2_13 + (0.29082617163658142) * emb_t2_14 + (-0.10617721080780029) * emb_t2_15 + (-0.87306720018386841) * emb_t2_16 + (1.2671747207641602) * emb_t2_17 + (0.1245114877820015) * emb_t2_18 + (-0.20348267257213593) * emb_t2_19 + (-0.43186381459236145) * emb_t2_20 + (-0.0091402828693389893) * emb_t2_21 + (0.10847589373588562) * emb_t2_22 + (-0.18693244457244873) * emb_t2_23 + (0.38213422894477844) * emb_t2_24 + (0.079246267676353455) * emb_t2_25 + (-1.0802562236785889) * emb_t2_26 + (0.693134605884552) * emb_t2_27 + (-1.6949421167373657) * emb_t2_28 + (3.1226041316986084) * emb_t2_29 + (-1.8109089136123657) * emb_t2_30 + (0.3125346302986145) * emb_t2_31 + (-0.85069328546524048) * gru_0_fwd_t1_h_0 + (-0.32397401332855225) * gru_0_fwd_t1_h_1 + (0.56070405244827271) * gru_0_fwd_t1_h_2 + (0.10745317488908768) * gru_0_fwd_t1_h_3 + (-0.39001005887985229) * gru_0_fwd_t1_h_4 + (-0.10489377379417419) * gru_0_fwd_t1_h_5 + (-0.66585135459899902) * gru_0_fwd_t1_h_6 + (0.0047519099898636341) * gru_0_fwd_t1_h_7 + (0.49933555722236633) * gru_0_fwd_t1_h_8 + (-0.49055632948875427) * gru_0_fwd_t1_h_9 + (-0.77148646116256714) * gru_0_fwd_t1_h_10 + (-1.3971984386444092) * gru_0_fwd_t1_h_11 + (0.32975786924362183) * gru_0_fwd_t1_h_12 + (0.51354753971099854) * gru_0_fwd_t1_h_13 + (-1.0794321298599243) * gru_0_fwd_t1_h_14 + (0.25098642706871033) * gru_0_fwd_t1_h_15 + (0.73258328437805176) * gru_0_fwd_t1_h_16 + (0.77561652660369873) * gru_0_fwd_t1_h_17 + (-0.35138970613479614) * gru_0_fwd_t1_h_18 + (-0.6915593147277832) * gru_0_fwd_t1_h_19 + (0.41405618190765381) * gru_0_fwd_t1_h_20 + (-0.95336252450942993) * gru_0_fwd_t1_h_21 + (-0.1472303718328476) * gru_0_fwd_t1_h_22 + (-0.72671568393707275) * gru_0_fwd_t1_h_23 + (-2.7335584163665771) * gru_0_fwd_t1_h_24 + (0.42180526256561279) * gru_0_fwd_t1_h_25 + (0.54061704874038696) * gru_0_fwd_t1_h_26 + (0.07454054057598114) * gru_0_fwd_t1_h_27 + (-0.56692910194396973) * gru_0_fwd_t1_h_28 + (0.28828316926956177) * gru_0_fwd_t1_h_29 + (-0.46947076916694641) * gru_0_fwd_t1_h_30 + (-2.2877655029296875) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.1659313291311264) + (-0.059404477477073669) * emb_t2_0 + (-1.5426498651504517) * emb_t2_1 + (-0.12076904624700546) * emb_t2_2 + (-0.15307776629924774) * emb_t2_3 + (-0.78816777467727661) * emb_t2_4 + (-0.12634673714637756) * emb_t2_5 + (-0.38280525803565979) * emb_t2_6 + (-0.13048599660396576) * emb_t2_7 + (-0.33374744653701782) * emb_t2_8 + (2.2566838264465332) * emb_t2_9 + (1.3857483863830566) * emb_t2_10 + (0.27771812677383423) * emb_t2_11 + (0.12092950195074081) * emb_t2_12 + (-1.1749651432037354) * emb_t2_13 + (0.042060606181621552) * emb_t2_14 + (0.17812110483646393) * emb_t2_15 + (0.13741962611675262) * emb_t2_16 + (-0.70766586065292358) * emb_t2_17 + (1.0735412836074829) * emb_t2_18 + (-0.75406134128570557) * emb_t2_19 + (0.49758979678153992) * emb_t2_20 + (-0.14628584682941437) * emb_t2_21 + (0.31552261114120483) * emb_t2_22 + (0.095008321106433868) * emb_t2_23 + (0.031381096690893173) * emb_t2_24 + (0.051027026027441025) * emb_t2_25 + (0.15242032706737518) * emb_t2_26 + (-0.073639869689941406) * emb_t2_27 + (1.6127007007598877) * emb_t2_28 + (-0.89815688133239746) * emb_t2_29 + (0.1326320469379425) * emb_t2_30 + (0.065456710755825043) * emb_t2_31 + (-0.21921448409557343) * gru_0_fwd_t1_h_0 + (-0.1384766697883606) * gru_0_fwd_t1_h_1 + (1.596102237701416) * gru_0_fwd_t1_h_2 + (-0.14150257408618927) * gru_0_fwd_t1_h_3 + (-0.141457200050354) * gru_0_fwd_t1_h_4 + (0.44412463903427124) * gru_0_fwd_t1_h_5 + (0.0061343135312199593) * gru_0_fwd_t1_h_6 + (-0.70102918148040771) * gru_0_fwd_t1_h_7 + (0.59358978271484375) * gru_0_fwd_t1_h_8 + (-0.19482012093067169) * gru_0_fwd_t1_h_9 + (-1.5857459306716919) * gru_0_fwd_t1_h_10 + (-0.5879523754119873) * gru_0_fwd_t1_h_11 + (0.17175436019897461) * gru_0_fwd_t1_h_12 + (-0.043679013848304749) * gru_0_fwd_t1_h_13 + (0.010474169626832008) * gru_0_fwd_t1_h_14 + (0.10585435479879379) * gru_0_fwd_t1_h_15 + (0.70362997055053711) * gru_0_fwd_t1_h_16 + (0.46827393770217896) * gru_0_fwd_t1_h_17 + (-0.20001392066478729) * gru_0_fwd_t1_h_18 + (-1.4314056634902954) * gru_0_fwd_t1_h_19 + (-0.35849666595458984) * gru_0_fwd_t1_h_20 + (0.31747311353683472) * gru_0_fwd_t1_h_21 + (0.15795955061912537) * gru_0_fwd_t1_h_22 + (-1.1763895750045776) * gru_0_fwd_t1_h_23 + (0.14186584949493408) * gru_0_fwd_t1_h_24 + (0.31498688459396362) * gru_0_fwd_t1_h_25 + (-0.10055151581764221) * gru_0_fwd_t1_h_26 + (0.18007659912109375) * gru_0_fwd_t1_h_27 + (-0.036663834005594254) * gru_0_fwd_t1_h_28 + (0.01569698378443718) * gru_0_fwd_t1_h_29 + (-0.10717400908470154) * gru_0_fwd_t1_h_30 + (-0.21439552307128906) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.16009370982646942) + (0.0072921901009976864) * emb_t2_0 + (0.74330586194992065) * emb_t2_1 + (0.050713468343019485) * emb_t2_2 + (-0.11244460940361023) * emb_t2_3 + (1.6828031539916992) * emb_t2_4 + (-0.014534174464643002) * emb_t2_5 + (0.94250988960266113) * emb_t2_6 + (-0.032487243413925171) * emb_t2_7 + (-0.26775258779525757) * emb_t2_8 + (-0.56313753128051758) * emb_t2_9 + (-0.1127462238073349) * emb_t2_10 + (-0.29746371507644653) * emb_t2_11 + (-0.47493234276771545) * emb_t2_12 + (1.5236636400222778) * emb_t2_13 + (-0.011699901893734932) * emb_t2_14 + (0.030248831957578659) * emb_t2_15 + (-0.01076570525765419) * emb_t2_16 + (0.80592316389083862) * emb_t2_17 + (-0.2362731397151947) * emb_t2_18 + (0.29742428660392761) * emb_t2_19 + (-0.42108970880508423) * emb_t2_20 + (-0.0057761971838772297) * emb_t2_21 + (0.0049860086292028427) * emb_t2_22 + (0.0066011436283588409) * emb_t2_23 + (-0.029815567657351494) * emb_t2_24 + (0.020044909790158272) * emb_t2_25 + (-0.91018575429916382) * emb_t2_26 + (-0.015423117205500603) * emb_t2_27 + (-0.83507370948791504) * emb_t2_28 + (1.3157124519348145) * emb_t2_29 + (-1.9486069679260254) * emb_t2_30 + (-0.46395385265350342) * emb_t2_31 + gate_r * ((-0.59306299686431885) + (-0.79797446727752686) * gru_0_fwd_t1_h_0 + (-0.063619017601013184) * gru_0_fwd_t1_h_1 + (0.61186695098876953) * gru_0_fwd_t1_h_2 + (-0.7286260724067688) * gru_0_fwd_t1_h_3 + (-0.19665729999542236) * gru_0_fwd_t1_h_4 + (-0.90855199098587036) * gru_0_fwd_t1_h_5 + (-1.1772280931472778) * gru_0_fwd_t1_h_6 + (-1.1512963771820068) * gru_0_fwd_t1_h_7 + (-0.11262544989585876) * gru_0_fwd_t1_h_8 + (-0.32425978779792786) * gru_0_fwd_t1_h_9 + (-0.34354487061500549) * gru_0_fwd_t1_h_10 + (0.11692102998495102) * gru_0_fwd_t1_h_11 + (-0.07977304607629776) * gru_0_fwd_t1_h_12 + (-0.077659793198108673) * gru_0_fwd_t1_h_13 + (0.23622740805149078) * gru_0_fwd_t1_h_14 + (0.41564139723777771) * gru_0_fwd_t1_h_15 + (0.45393610000610352) * gru_0_fwd_t1_h_16 + (-0.42782124876976013) * gru_0_fwd_t1_h_17 + (-0.49360615015029907) * gru_0_fwd_t1_h_18 + (-1.7283173799514771) * gru_0_fwd_t1_h_19 + (-2.0538356304168701) * gru_0_fwd_t1_h_20 + (-0.52976137399673462) * gru_0_fwd_t1_h_21 + (-0.62666851282119751) * gru_0_fwd_t1_h_22 + (0.70413291454315186) * gru_0_fwd_t1_h_23 + (-0.45116016268730164) * gru_0_fwd_t1_h_24 + (-1.2912591695785522) * gru_0_fwd_t1_h_25 + (0.77810639142990112) * gru_0_fwd_t1_h_26 + (-1.0218957662582397) * gru_0_fwd_t1_h_27 + (1.7101496458053589) * gru_0_fwd_t1_h_28 + (-1.6388822793960571) * gru_0_fwd_t1_h_29 + (-0.51859986782073975) * gru_0_fwd_t1_h_30 + (-5.2676653861999512) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_21 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_21;
    // h=22
    gate_r = sigmoid((0.22232441604137421) + (0.14432895183563232) * emb_t2_0 + (0.63392680883407593) * emb_t2_1 + (-0.24514274299144745) * emb_t2_2 + (0.13581065833568573) * emb_t2_3 + (0.10619806498289108) * emb_t2_4 + (0.46599224209785461) * emb_t2_5 + (0.083665944635868073) * emb_t2_6 + (-0.014844410121440887) * emb_t2_7 + (0.29981794953346252) * emb_t2_8 + (-0.4095737636089325) * emb_t2_9 + (-0.48311740159988403) * emb_t2_10 + (0.27599778771400452) * emb_t2_11 + (0.6456371545791626) * emb_t2_12 + (0.55034679174423218) * emb_t2_13 + (0.044860605150461197) * emb_t2_14 + (0.47197750210762024) * emb_t2_15 + (0.27355846762657166) * emb_t2_16 + (-0.094060458242893219) * emb_t2_17 + (-0.87734121084213257) * emb_t2_18 + (1.0346982479095459) * emb_t2_19 + (0.07719731330871582) * emb_t2_20 + (0.54850244522094727) * emb_t2_21 + (-0.55708694458007812) * emb_t2_22 + (-0.25350877642631531) * emb_t2_23 + (0.051934774965047836) * emb_t2_24 + (0.34791865944862366) * emb_t2_25 + (-0.033115178346633911) * emb_t2_26 + (-0.12398674339056015) * emb_t2_27 + (-0.7691807746887207) * emb_t2_28 + (0.53856956958770752) * emb_t2_29 + (-0.26347059011459351) * emb_t2_30 + (-0.26297396421432495) * emb_t2_31 + (0.50346875190734863) * gru_0_fwd_t1_h_0 + (0.033009402453899384) * gru_0_fwd_t1_h_1 + (-0.44727873802185059) * gru_0_fwd_t1_h_2 + (0.65297764539718628) * gru_0_fwd_t1_h_3 + (0.068770073354244232) * gru_0_fwd_t1_h_4 + (0.22616927325725555) * gru_0_fwd_t1_h_5 + (-0.78909832239151001) * gru_0_fwd_t1_h_6 + (0.377083420753479) * gru_0_fwd_t1_h_7 + (-0.3367563784122467) * gru_0_fwd_t1_h_8 + (1.1276493072509766) * gru_0_fwd_t1_h_9 + (0.48034343123435974) * gru_0_fwd_t1_h_10 + (0.023056183010339737) * gru_0_fwd_t1_h_11 + (-0.031834043562412262) * gru_0_fwd_t1_h_12 + (-0.28589686751365662) * gru_0_fwd_t1_h_13 + (0.20956309139728546) * gru_0_fwd_t1_h_14 + (0.095395870506763458) * gru_0_fwd_t1_h_15 + (0.12358914315700531) * gru_0_fwd_t1_h_16 + (0.12608131766319275) * gru_0_fwd_t1_h_17 + (-0.45664343237876892) * gru_0_fwd_t1_h_18 + (0.40054979920387268) * gru_0_fwd_t1_h_19 + (1.2761877775192261) * gru_0_fwd_t1_h_20 + (-0.11252130568027496) * gru_0_fwd_t1_h_21 + (-0.14598965644836426) * gru_0_fwd_t1_h_22 + (0.38299411535263062) * gru_0_fwd_t1_h_23 + (-0.65788412094116211) * gru_0_fwd_t1_h_24 + (0.39183104038238525) * gru_0_fwd_t1_h_25 + (-0.10770905017852783) * gru_0_fwd_t1_h_26 + (-0.42507964372634888) * gru_0_fwd_t1_h_27 + (-0.56168591976165771) * gru_0_fwd_t1_h_28 + (-0.37817615270614624) * gru_0_fwd_t1_h_29 + (0.2039531022310257) * gru_0_fwd_t1_h_30 + (0.67430120706558228) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-0.93942070007324219) + (0.11115106195211411) * emb_t2_0 + (-0.63090580701828003) * emb_t2_1 + (-0.071883440017700195) * emb_t2_2 + (-0.28505125641822815) * emb_t2_3 + (0.7965739369392395) * emb_t2_4 + (-0.16488155722618103) * emb_t2_5 + (0.3491804301738739) * emb_t2_6 + (-0.12354090809822083) * emb_t2_7 + (-0.61144405603408813) * emb_t2_8 + (0.83174175024032593) * emb_t2_9 + (1.2928620576858521) * emb_t2_10 + (-0.10546582937240601) * emb_t2_11 + (-0.83152902126312256) * emb_t2_12 + (-0.31091767549514771) * emb_t2_13 + (-0.0085102338343858719) * emb_t2_14 + (0.16558945178985596) * emb_t2_15 + (0.28977552056312561) * emb_t2_16 + (-0.082078844308853149) * emb_t2_17 + (0.81430768966674805) * emb_t2_18 + (-0.97559165954589844) * emb_t2_19 + (-0.31335684657096863) * emb_t2_20 + (0.02463197335600853) * emb_t2_21 + (0.7066650390625) * emb_t2_22 + (-0.020347137004137039) * emb_t2_23 + (-0.0015776599757373333) * emb_t2_24 + (0.13019591569900513) * emb_t2_25 + (-0.037300162017345428) * emb_t2_26 + (0.035494159907102585) * emb_t2_27 + (0.30291920900344849) * emb_t2_28 + (-0.25515484809875488) * emb_t2_29 + (0.34898930788040161) * emb_t2_30 + (0.72254091501235962) * emb_t2_31 + (-0.46165996789932251) * gru_0_fwd_t1_h_0 + (-0.20620779693126678) * gru_0_fwd_t1_h_1 + (0.40251854062080383) * gru_0_fwd_t1_h_2 + (-0.6452297568321228) * gru_0_fwd_t1_h_3 + (-0.74615192413330078) * gru_0_fwd_t1_h_4 + (0.43793082237243652) * gru_0_fwd_t1_h_5 + (0.60696560144424438) * gru_0_fwd_t1_h_6 + (-1.2510863542556763) * gru_0_fwd_t1_h_7 + (0.21089045703411102) * gru_0_fwd_t1_h_8 + (0.64291352033615112) * gru_0_fwd_t1_h_9 + (-0.59695684909820557) * gru_0_fwd_t1_h_10 + (-0.55037325620651245) * gru_0_fwd_t1_h_11 + (-0.10626621544361115) * gru_0_fwd_t1_h_12 + (-0.0754365473985672) * gru_0_fwd_t1_h_13 + (-0.65126419067382812) * gru_0_fwd_t1_h_14 + (0.35631448030471802) * gru_0_fwd_t1_h_15 + (1.3788570165634155) * gru_0_fwd_t1_h_16 + (0.89240419864654541) * gru_0_fwd_t1_h_17 + (-0.1338297575712204) * gru_0_fwd_t1_h_18 + (0.22875770926475525) * gru_0_fwd_t1_h_19 + (0.30579310655593872) * gru_0_fwd_t1_h_20 + (1.1471136808395386) * gru_0_fwd_t1_h_21 + (-0.25104662775993347) * gru_0_fwd_t1_h_22 + (-0.95108801126480103) * gru_0_fwd_t1_h_23 + (-0.39531269669532776) * gru_0_fwd_t1_h_24 + (0.80319070816040039) * gru_0_fwd_t1_h_25 + (-0.65852648019790649) * gru_0_fwd_t1_h_26 + (-0.16704751551151276) * gru_0_fwd_t1_h_27 + (-0.62891978025436401) * gru_0_fwd_t1_h_28 + (0.37359809875488281) * gru_0_fwd_t1_h_29 + (-0.029219662770628929) * gru_0_fwd_t1_h_30 + (0.94995653629302979) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.12542098760604858) + (0.02847139909863472) * emb_t2_0 + (0.45614024996757507) * emb_t2_1 + (0.032807901501655579) * emb_t2_2 + (0.12147294729948044) * emb_t2_3 + (-0.031896248459815979) * emb_t2_4 + (-0.032112009823322296) * emb_t2_5 + (0.13905428349971771) * emb_t2_6 + (-0.025810571387410164) * emb_t2_7 + (0.412300705909729) * emb_t2_8 + (0.25688058137893677) * emb_t2_9 + (-0.32088249921798706) * emb_t2_10 + (0.45053127408027649) * emb_t2_11 + (0.21068808436393738) * emb_t2_12 + (0.045599725097417831) * emb_t2_13 + (0.028648883104324341) * emb_t2_14 + (-0.0070934589020907879) * emb_t2_15 + (0.088209502398967743) * emb_t2_16 + (-0.20205187797546387) * emb_t2_17 + (0.14459925889968872) * emb_t2_18 + (-0.32664421200752258) * emb_t2_19 + (-0.11298113316297531) * emb_t2_20 + (-0.0076954751275479794) * emb_t2_21 + (-0.10125642269849777) * emb_t2_22 + (0.0028009216766804457) * emb_t2_23 + (-0.01182953454554081) * emb_t2_24 + (0.0075764358043670654) * emb_t2_25 + (0.27925705909729004) * emb_t2_26 + (0.030963465571403503) * emb_t2_27 + (-0.15762284398078918) * emb_t2_28 + (-0.027296982705593109) * emb_t2_29 + (-0.10209710150957108) * emb_t2_30 + (-0.26654323935508728) * emb_t2_31 + gate_r * ((0.14417892694473267) + (-0.032270863652229309) * gru_0_fwd_t1_h_0 + (0.017763817682862282) * gru_0_fwd_t1_h_1 + (-0.34458154439926147) * gru_0_fwd_t1_h_2 + (-1.5024503469467163) * gru_0_fwd_t1_h_3 + (0.034417986869812012) * gru_0_fwd_t1_h_4 + (0.022317977622151375) * gru_0_fwd_t1_h_5 + (0.45194205641746521) * gru_0_fwd_t1_h_6 + (1.2048952579498291) * gru_0_fwd_t1_h_7 + (0.06879095733165741) * gru_0_fwd_t1_h_8 + (0.1791805773973465) * gru_0_fwd_t1_h_9 + (-0.0097812023013830185) * gru_0_fwd_t1_h_10 + (-0.29928514361381531) * gru_0_fwd_t1_h_11 + (-0.00049575854791328311) * gru_0_fwd_t1_h_12 + (-0.079048663377761841) * gru_0_fwd_t1_h_13 + (-0.081144839525222778) * gru_0_fwd_t1_h_14 + (-0.17304474115371704) * gru_0_fwd_t1_h_15 + (0.24865236878395081) * gru_0_fwd_t1_h_16 + (0.22042044997215271) * gru_0_fwd_t1_h_17 + (-0.085619233548641205) * gru_0_fwd_t1_h_18 + (0.20166356861591339) * gru_0_fwd_t1_h_19 + (0.58380502462387085) * gru_0_fwd_t1_h_20 + (-0.10176272690296173) * gru_0_fwd_t1_h_21 + (-0.24396076798439026) * gru_0_fwd_t1_h_22 + (-0.19851920008659363) * gru_0_fwd_t1_h_23 + (0.85868173837661743) * gru_0_fwd_t1_h_24 + (0.51087868213653564) * gru_0_fwd_t1_h_25 + (-0.031795091927051544) * gru_0_fwd_t1_h_26 + (0.0041944412514567375) * gru_0_fwd_t1_h_27 + (-1.2211177349090576) * gru_0_fwd_t1_h_28 + (0.78436762094497681) * gru_0_fwd_t1_h_29 + (0.32634839415550232) * gru_0_fwd_t1_h_30 + (-0.76815015077590942) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_22 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_22;
    // h=23
    gate_r = sigmoid((-1.4372566938400269) + (-0.39234703779220581) * emb_t2_0 + (-0.65967637300491333) * emb_t2_1 + (-0.071052439510822296) * emb_t2_2 + (-0.92880433797836304) * emb_t2_3 + (0.8391646146774292) * emb_t2_4 + (0.68460333347320557) * emb_t2_5 + (-0.1301560252904892) * emb_t2_6 + (0.85143405199050903) * emb_t2_7 + (-0.6508057713508606) * emb_t2_8 + (0.66896092891693115) * emb_t2_9 + (0.60199868679046631) * emb_t2_10 + (-1.0075886249542236) * emb_t2_11 + (-0.84444040060043335) * emb_t2_12 + (0.0475890152156353) * emb_t2_13 + (0.33527296781539917) * emb_t2_14 + (0.36624777317047119) * emb_t2_15 + (-0.55104702711105347) * emb_t2_16 + (0.64168679714202881) * emb_t2_17 + (1.3143234252929688) * emb_t2_18 + (-1.257668137550354) * emb_t2_19 + (0.055039774626493454) * emb_t2_20 + (-0.050016801804304123) * emb_t2_21 + (0.2848517894744873) * emb_t2_22 + (-0.46394193172454834) * emb_t2_23 + (0.32708796858787537) * emb_t2_24 + (0.36200582981109619) * emb_t2_25 + (-0.54281848669052124) * emb_t2_26 + (-0.63623672723770142) * emb_t2_27 + (0.47470811009407043) * emb_t2_28 + (-0.41771861910820007) * emb_t2_29 + (-0.1495717465877533) * emb_t2_30 + (1.0250616073608398) * emb_t2_31 + (0.091299697756767273) * gru_0_fwd_t1_h_0 + (-0.18915928900241852) * gru_0_fwd_t1_h_1 + (-0.16752433776855469) * gru_0_fwd_t1_h_2 + (1.1779680252075195) * gru_0_fwd_t1_h_3 + (-0.43839457631111145) * gru_0_fwd_t1_h_4 + (-0.84412527084350586) * gru_0_fwd_t1_h_5 + (0.93176573514938354) * gru_0_fwd_t1_h_6 + (-0.10491558909416199) * gru_0_fwd_t1_h_7 + (0.27141395211219788) * gru_0_fwd_t1_h_8 + (-0.25275003910064697) * gru_0_fwd_t1_h_9 + (0.14956510066986084) * gru_0_fwd_t1_h_10 + (0.34307989478111267) * gru_0_fwd_t1_h_11 + (0.17246076464653015) * gru_0_fwd_t1_h_12 + (-0.074065588414669037) * gru_0_fwd_t1_h_13 + (-0.77376890182495117) * gru_0_fwd_t1_h_14 + (0.38478374481201172) * gru_0_fwd_t1_h_15 + (0.73501062393188477) * gru_0_fwd_t1_h_16 + (0.19134847819805145) * gru_0_fwd_t1_h_17 + (-0.019460849463939667) * gru_0_fwd_t1_h_18 + (-0.067709639668464661) * gru_0_fwd_t1_h_19 + (-0.3755965530872345) * gru_0_fwd_t1_h_20 + (0.65912789106369019) * gru_0_fwd_t1_h_21 + (0.3467136025428772) * gru_0_fwd_t1_h_22 + (-0.64116579294204712) * gru_0_fwd_t1_h_23 + (0.23202022910118103) * gru_0_fwd_t1_h_24 + (0.0019396636635065079) * gru_0_fwd_t1_h_25 + (1.5180647373199463) * gru_0_fwd_t1_h_26 + (0.23301690816879272) * gru_0_fwd_t1_h_27 + (-0.005673212930560112) * gru_0_fwd_t1_h_28 + (0.042451970279216766) * gru_0_fwd_t1_h_29 + (-1.0244024991989136) * gru_0_fwd_t1_h_30 + (0.36804443597793579) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.61976110935211182) + (0.0017395347822457552) * emb_t2_0 + (0.49588724970817566) * emb_t2_1 + (0.0013732225634157658) * emb_t2_2 + (0.1210077777504921) * emb_t2_3 + (-0.083217605948448181) * emb_t2_4 + (0.010000631213188171) * emb_t2_5 + (0.19645869731903076) * emb_t2_6 + (0.0020481990650296211) * emb_t2_7 + (0.17209510505199432) * emb_t2_8 + (0.40283161401748657) * emb_t2_9 + (0.14623387157917023) * emb_t2_10 + (0.51970767974853516) * emb_t2_11 + (0.23716218769550323) * emb_t2_12 + (-0.29412993788719177) * emb_t2_13 + (-0.0052056112326681614) * emb_t2_14 + (0.00064429978374391794) * emb_t2_15 + (-0.00080575479660183191) * emb_t2_16 + (-0.22381328046321869) * emb_t2_17 + (0.060716450214385986) * emb_t2_18 + (0.14090333878993988) * emb_t2_19 + (0.45113977789878845) * emb_t2_20 + (-0.00464985566213727) * emb_t2_21 + (-0.0023604398593306541) * emb_t2_22 + (-0.0094850435853004456) * emb_t2_23 + (-0.0089275417849421501) * emb_t2_24 + (0.0041711162775754929) * emb_t2_25 + (0.20036607980728149) * emb_t2_26 + (-0.0033157493453472853) * emb_t2_27 + (0.45266419649124146) * emb_t2_28 + (-0.030859475955367088) * emb_t2_29 + (0.15223509073257446) * emb_t2_30 + (-0.10438157618045807) * emb_t2_31 + (-0.50631844997406006) * gru_0_fwd_t1_h_0 + (-1.2671583890914917) * gru_0_fwd_t1_h_1 + (0.36770382523536682) * gru_0_fwd_t1_h_2 + (0.50714772939682007) * gru_0_fwd_t1_h_3 + (-0.17476978898048401) * gru_0_fwd_t1_h_4 + (0.17848873138427734) * gru_0_fwd_t1_h_5 + (0.59532862901687622) * gru_0_fwd_t1_h_6 + (0.10343361645936966) * gru_0_fwd_t1_h_7 + (-0.19488680362701416) * gru_0_fwd_t1_h_8 + (-0.0027685835957527161) * gru_0_fwd_t1_h_9 + (-0.34478315711021423) * gru_0_fwd_t1_h_10 + (-1.1179394721984863) * gru_0_fwd_t1_h_11 + (1.2495048046112061) * gru_0_fwd_t1_h_12 + (1.0837697982788086) * gru_0_fwd_t1_h_13 + (-0.59405750036239624) * gru_0_fwd_t1_h_14 + (0.85695922374725342) * gru_0_fwd_t1_h_15 + (0.64243221282958984) * gru_0_fwd_t1_h_16 + (0.46623179316520691) * gru_0_fwd_t1_h_17 + (-0.80266320705413818) * gru_0_fwd_t1_h_18 + (0.7561718225479126) * gru_0_fwd_t1_h_19 + (0.1847129762172699) * gru_0_fwd_t1_h_20 + (-0.49190515279769897) * gru_0_fwd_t1_h_21 + (-0.10383030027151108) * gru_0_fwd_t1_h_22 + (0.64979374408721924) * gru_0_fwd_t1_h_23 + (0.092567823827266693) * gru_0_fwd_t1_h_24 + (0.44425475597381592) * gru_0_fwd_t1_h_25 + (-0.027806838974356651) * gru_0_fwd_t1_h_26 + (-0.26620802283287048) * gru_0_fwd_t1_h_27 + (-1.4643025398254395) * gru_0_fwd_t1_h_28 + (0.51402580738067627) * gru_0_fwd_t1_h_29 + (-0.34282532334327698) * gru_0_fwd_t1_h_30 + (-0.39811566472053528) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.14805704355239868) + (0.030165025964379311) * emb_t2_0 + (-0.4771411120891571) * emb_t2_1 + (0.081697553396224976) * emb_t2_2 + (0.22992120683193207) * emb_t2_3 + (-0.66089200973510742) * emb_t2_4 + (-0.10074235498905182) * emb_t2_5 + (-0.27499783039093018) * emb_t2_6 + (-0.027905428782105446) * emb_t2_7 + (-0.26984643936157227) * emb_t2_8 + (0.1298011839389801) * emb_t2_9 + (0.15038271248340607) * emb_t2_10 + (0.27356818318367004) * emb_t2_11 + (-0.050830315798521042) * emb_t2_12 + (-0.91521328687667847) * emb_t2_13 + (0.026960011571645737) * emb_t2_14 + (-0.036410592496395111) * emb_t2_15 + (0.083435095846652985) * emb_t2_16 + (-0.39623141288757324) * emb_t2_17 + (0.17122599482536316) * emb_t2_18 + (-0.031495299190282822) * emb_t2_19 + (0.1618841141462326) * emb_t2_20 + (-0.048973001539707184) * emb_t2_21 + (0.26459577679634094) * emb_t2_22 + (0.047094825655221939) * emb_t2_23 + (0.015456338413059711) * emb_t2_24 + (-0.018500324338674545) * emb_t2_25 + (-0.032394051551818848) * emb_t2_26 + (0.044937077909708023) * emb_t2_27 + (-0.31905952095985413) * emb_t2_28 + (-0.77755343914031982) * emb_t2_29 + (0.55898034572601318) * emb_t2_30 + (-0.073935866355895996) * emb_t2_31 + gate_r * ((-0.59993588924407959) + (-0.11364419758319855) * gru_0_fwd_t1_h_0 + (-0.088236890733242035) * gru_0_fwd_t1_h_1 + (-0.42801657319068909) * gru_0_fwd_t1_h_2 + (-0.44055536389350891) * gru_0_fwd_t1_h_3 + (0.024369917809963226) * gru_0_fwd_t1_h_4 + (0.93204969167709351) * gru_0_fwd_t1_h_5 + (-0.18504449725151062) * gru_0_fwd_t1_h_6 + (0.012040631845593452) * gru_0_fwd_t1_h_7 + (-0.10954278707504272) * gru_0_fwd_t1_h_8 + (-0.013763665221631527) * gru_0_fwd_t1_h_9 + (0.29762038588523865) * gru_0_fwd_t1_h_10 + (0.090684182941913605) * gru_0_fwd_t1_h_11 + (0.16061416268348694) * gru_0_fwd_t1_h_12 + (0.0086331050843000412) * gru_0_fwd_t1_h_13 + (-0.26285949349403381) * gru_0_fwd_t1_h_14 + (0.22399052977561951) * gru_0_fwd_t1_h_15 + (-0.052464358508586884) * gru_0_fwd_t1_h_16 + (-0.10801418125629425) * gru_0_fwd_t1_h_17 + (-0.42459577322006226) * gru_0_fwd_t1_h_18 + (-0.036628421396017075) * gru_0_fwd_t1_h_19 + (0.16649600863456726) * gru_0_fwd_t1_h_20 + (0.092572234570980072) * gru_0_fwd_t1_h_21 + (0.17800259590148926) * gru_0_fwd_t1_h_22 + (0.75597155094146729) * gru_0_fwd_t1_h_23 + (-0.35074532032012939) * gru_0_fwd_t1_h_24 + (0.51727187633514404) * gru_0_fwd_t1_h_25 + (-0.44666662812232971) * gru_0_fwd_t1_h_26 + (0.27042338252067566) * gru_0_fwd_t1_h_27 + (0.14888226985931396) * gru_0_fwd_t1_h_28 + (-0.48049443960189819) * gru_0_fwd_t1_h_29 + (-0.13683727383613586) * gru_0_fwd_t1_h_30 + (-0.26658672094345093) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_23 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_23;
    // h=24
    gate_r = sigmoid((0.15203022956848145) + (-0.41437360644340515) * emb_t2_0 + (-0.50429695844650269) * emb_t2_1 + (-0.84589999914169312) * emb_t2_2 + (0.12389332801103592) * emb_t2_3 + (-0.17265568673610687) * emb_t2_4 + (0.21862593293190002) * emb_t2_5 + (-0.12251073867082596) * emb_t2_6 + (0.17872543632984161) * emb_t2_7 + (-0.33167076110839844) * emb_t2_8 + (1.0968760251998901) * emb_t2_9 + (0.59272187948226929) * emb_t2_10 + (0.13609956204891205) * emb_t2_11 + (-0.28593286871910095) * emb_t2_12 + (0.035031147301197052) * emb_t2_13 + (-0.1208752766251564) * emb_t2_14 + (0.59117799997329712) * emb_t2_15 + (-0.82235527038574219) * emb_t2_16 + (0.025749290362000465) * emb_t2_17 + (0.53562521934509277) * emb_t2_18 + (-0.62151885032653809) * emb_t2_19 + (0.068764694035053253) * emb_t2_20 + (0.24319063127040863) * emb_t2_21 + (0.075040839612483978) * emb_t2_22 + (0.27558189630508423) * emb_t2_23 + (-0.11961220949888229) * emb_t2_24 + (0.66673910617828369) * emb_t2_25 + (0.50751489400863647) * emb_t2_26 + (-0.011195056140422821) * emb_t2_27 + (0.54052072763442993) * emb_t2_28 + (-0.88304990530014038) * emb_t2_29 + (0.13426861166954041) * emb_t2_30 + (0.35878992080688477) * emb_t2_31 + (0.25862419605255127) * gru_0_fwd_t1_h_0 + (-0.1295611560344696) * gru_0_fwd_t1_h_1 + (1.1757415533065796) * gru_0_fwd_t1_h_2 + (1.5983432531356812) * gru_0_fwd_t1_h_3 + (-0.050313025712966919) * gru_0_fwd_t1_h_4 + (0.55876356363296509) * gru_0_fwd_t1_h_5 + (-0.63593393564224243) * gru_0_fwd_t1_h_6 + (-1.048126220703125) * gru_0_fwd_t1_h_7 + (-1.2541776895523071) * gru_0_fwd_t1_h_8 + (-0.43078586459159851) * gru_0_fwd_t1_h_9 + (-1.2106524705886841) * gru_0_fwd_t1_h_10 + (0.088430516421794891) * gru_0_fwd_t1_h_11 + (-0.0074482429772615433) * gru_0_fwd_t1_h_12 + (-0.20261076092720032) * gru_0_fwd_t1_h_13 + (0.14268635213375092) * gru_0_fwd_t1_h_14 + (0.16308289766311646) * gru_0_fwd_t1_h_15 + (-0.25486171245574951) * gru_0_fwd_t1_h_16 + (0.16803278028964996) * gru_0_fwd_t1_h_17 + (-0.28903147578239441) * gru_0_fwd_t1_h_18 + (-0.083545781672000885) * gru_0_fwd_t1_h_19 + (0.068354852497577667) * gru_0_fwd_t1_h_20 + (-0.40377002954483032) * gru_0_fwd_t1_h_21 + (0.53017431497573853) * gru_0_fwd_t1_h_22 + (1.1052025556564331) * gru_0_fwd_t1_h_23 + (-2.4652099609375) * gru_0_fwd_t1_h_24 + (-0.98065602779388428) * gru_0_fwd_t1_h_25 + (-2.3398432731628418) * gru_0_fwd_t1_h_26 + (-0.179029181599617) * gru_0_fwd_t1_h_27 + (0.26972070336341858) * gru_0_fwd_t1_h_28 + (-0.72971314191818237) * gru_0_fwd_t1_h_29 + (0.12141218781471252) * gru_0_fwd_t1_h_30 + (4.2799897193908691) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.82881957292556763) + (-0.032669905573129654) * emb_t2_0 + (-0.71753436326980591) * emb_t2_1 + (0.054842587560415268) * emb_t2_2 + (0.34206923842430115) * emb_t2_3 + (-0.53493368625640869) * emb_t2_4 + (0.079079441726207733) * emb_t2_5 + (-0.69489783048629761) * emb_t2_6 + (-0.0077556241303682327) * emb_t2_7 + (0.22698178887367249) * emb_t2_8 + (0.64480888843536377) * emb_t2_9 + (0.38151192665100098) * emb_t2_10 + (0.71875602006912231) * emb_t2_11 + (0.03274829313158989) * emb_t2_12 + (-0.20307245850563049) * emb_t2_13 + (-0.10653422772884369) * emb_t2_14 + (-0.37308338284492493) * emb_t2_15 + (0.048809364438056946) * emb_t2_16 + (-0.7546231746673584) * emb_t2_17 + (0.41141235828399658) * emb_t2_18 + (-0.26685541868209839) * emb_t2_19 + (0.35539630055427551) * emb_t2_20 + (-0.011230818927288055) * emb_t2_21 + (0.10237331688404083) * emb_t2_22 + (0.14811430871486664) * emb_t2_23 + (-0.18485890328884125) * emb_t2_24 + (-0.0076148174703121185) * emb_t2_25 + (0.3941701352596283) * emb_t2_26 + (0.25375643372535706) * emb_t2_27 + (0.79693359136581421) * emb_t2_28 + (-0.35914981365203857) * emb_t2_29 + (0.49608811736106873) * emb_t2_30 + (-0.37685561180114746) * emb_t2_31 + (0.046108301728963852) * gru_0_fwd_t1_h_0 + (0.12449415028095245) * gru_0_fwd_t1_h_1 + (0.9165111780166626) * gru_0_fwd_t1_h_2 + (-1.2439364194869995) * gru_0_fwd_t1_h_3 + (0.36703664064407349) * gru_0_fwd_t1_h_4 + (1.4912416934967041) * gru_0_fwd_t1_h_5 + (0.34523659944534302) * gru_0_fwd_t1_h_6 + (-1.3588192462921143) * gru_0_fwd_t1_h_7 + (-0.26727569103240967) * gru_0_fwd_t1_h_8 + (0.24977287650108337) * gru_0_fwd_t1_h_9 + (-0.70369464159011841) * gru_0_fwd_t1_h_10 + (0.060918852686882019) * gru_0_fwd_t1_h_11 + (-0.018755810335278511) * gru_0_fwd_t1_h_12 + (-0.49130865931510925) * gru_0_fwd_t1_h_13 + (0.7971351146697998) * gru_0_fwd_t1_h_14 + (-0.35094118118286133) * gru_0_fwd_t1_h_15 + (-0.55020886659622192) * gru_0_fwd_t1_h_16 + (-0.19487893581390381) * gru_0_fwd_t1_h_17 + (-0.24890242516994476) * gru_0_fwd_t1_h_18 + (-0.1453777402639389) * gru_0_fwd_t1_h_19 + (0.86798065900802612) * gru_0_fwd_t1_h_20 + (-0.31785133481025696) * gru_0_fwd_t1_h_21 + (-0.10452240705490112) * gru_0_fwd_t1_h_22 + (-1.0413234233856201) * gru_0_fwd_t1_h_23 + (-0.56942588090896606) * gru_0_fwd_t1_h_24 + (-1.3681586980819702) * gru_0_fwd_t1_h_25 + (-1.6157556772232056) * gru_0_fwd_t1_h_26 + (1.3190709352493286) * gru_0_fwd_t1_h_27 + (-0.63206452131271362) * gru_0_fwd_t1_h_28 + (-0.082171514630317688) * gru_0_fwd_t1_h_29 + (0.60932940244674683) * gru_0_fwd_t1_h_30 + (-1.6343598365783691) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.4714750349521637) + (-0.57756763696670532) * emb_t2_0 + (0.56365013122558594) * emb_t2_1 + (-1.3471122980117798) * emb_t2_2 + (-0.42250025272369385) * emb_t2_3 + (0.12985128164291382) * emb_t2_4 + (0.38154962658882141) * emb_t2_5 + (0.54560041427612305) * emb_t2_6 + (0.63811838626861572) * emb_t2_7 + (-0.76133978366851807) * emb_t2_8 + (-0.1686820387840271) * emb_t2_9 + (-0.041589364409446716) * emb_t2_10 + (-0.23406855762004852) * emb_t2_11 + (-0.53229618072509766) * emb_t2_12 + (0.069438368082046509) * emb_t2_13 + (-0.38813266158103943) * emb_t2_14 + (1.2326817512512207) * emb_t2_15 + (-1.4377819299697876) * emb_t2_16 + (0.27771225571632385) * emb_t2_17 + (0.67373669147491455) * emb_t2_18 + (-0.56840986013412476) * emb_t2_19 + (-0.23943985998630524) * emb_t2_20 + (0.75957351922988892) * emb_t2_21 + (0.60640108585357666) * emb_t2_22 + (0.12128475308418274) * emb_t2_23 + (0.036494050174951553) * emb_t2_24 + (0.27568504214286804) * emb_t2_25 + (-0.50869345664978027) * emb_t2_26 + (-0.53578948974609375) * emb_t2_27 + (-0.36341932415962219) * emb_t2_28 + (0.36780670285224915) * emb_t2_29 + (-0.45210695266723633) * emb_t2_30 + (0.51651155948638916) * emb_t2_31 + gate_r * ((-0.26023483276367188) + (0.41521504521369934) * gru_0_fwd_t1_h_0 + (0.15590476989746094) * gru_0_fwd_t1_h_1 + (2.0625624656677246) * gru_0_fwd_t1_h_2 + (2.3858773708343506) * gru_0_fwd_t1_h_3 + (0.3065454363822937) * gru_0_fwd_t1_h_4 + (0.34035190939903259) * gru_0_fwd_t1_h_5 + (1.4717333316802979) * gru_0_fwd_t1_h_6 + (-2.3134212493896484) * gru_0_fwd_t1_h_7 + (-0.20983682572841644) * gru_0_fwd_t1_h_8 + (-0.50119471549987793) * gru_0_fwd_t1_h_9 + (-1.9693751335144043) * gru_0_fwd_t1_h_10 + (0.71617686748504639) * gru_0_fwd_t1_h_11 + (-0.30667406320571899) * gru_0_fwd_t1_h_12 + (-0.63607001304626465) * gru_0_fwd_t1_h_13 + (0.31413298845291138) * gru_0_fwd_t1_h_14 + (-0.00063408416463062167) * gru_0_fwd_t1_h_15 + (-0.35067310929298401) * gru_0_fwd_t1_h_16 + (-0.28556546568870544) * gru_0_fwd_t1_h_17 + (0.50362700223922729) * gru_0_fwd_t1_h_18 + (-0.0065443175844848156) * gru_0_fwd_t1_h_19 + (0.22482088208198547) * gru_0_fwd_t1_h_20 + (0.21317368745803833) * gru_0_fwd_t1_h_21 + (-0.86699873208999634) * gru_0_fwd_t1_h_22 + (-0.21839945018291473) * gru_0_fwd_t1_h_23 + (-1.8996685743331909) * gru_0_fwd_t1_h_24 + (-0.35395076870918274) * gru_0_fwd_t1_h_25 + (-1.9395508766174316) * gru_0_fwd_t1_h_26 + (-0.27604249119758606) * gru_0_fwd_t1_h_27 + (-0.31488481163978577) * gru_0_fwd_t1_h_28 + (-0.54667782783508301) * gru_0_fwd_t1_h_29 + (0.26295483112335205) * gru_0_fwd_t1_h_30 + (2.8812198638916016) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_24 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_24;
    // h=25
    gate_r = sigmoid((-1.207040548324585) + (-0.53727519512176514) * emb_t2_0 + (1.1072384119033813) * emb_t2_1 + (0.40012621879577637) * emb_t2_2 + (-0.46095481514930725) * emb_t2_3 + (0.6963038444519043) * emb_t2_4 + (0.19891306757926941) * emb_t2_5 + (0.7521166205406189) * emb_t2_6 + (0.42679575085639954) * emb_t2_7 + (-0.40599632263183594) * emb_t2_8 + (0.2415887713432312) * emb_t2_9 + (0.036852065473794937) * emb_t2_10 + (-0.31197518110275269) * emb_t2_11 + (-0.35900202393531799) * emb_t2_12 + (1.3596224784851074) * emb_t2_13 + (-0.11130786687135696) * emb_t2_14 + (0.083800904452800751) * emb_t2_15 + (0.45915275812149048) * emb_t2_16 + (0.7408861517906189) * emb_t2_17 + (-0.15519112348556519) * emb_t2_18 + (-0.58635705709457397) * emb_t2_19 + (-0.89865314960479736) * emb_t2_20 + (-0.093932032585144043) * emb_t2_21 + (0.52295839786529541) * emb_t2_22 + (0.73061728477478027) * emb_t2_23 + (0.10966010391712189) * emb_t2_24 + (1.2037180662155151) * emb_t2_25 + (-1.1282285451889038) * emb_t2_26 + (0.45238432288169861) * emb_t2_27 + (-0.80081349611282349) * emb_t2_28 + (1.3268431425094604) * emb_t2_29 + (-1.000893235206604) * emb_t2_30 + (0.58030581474304199) * emb_t2_31 + (-0.45215898752212524) * gru_0_fwd_t1_h_0 + (-0.13307294249534607) * gru_0_fwd_t1_h_1 + (-0.21898284554481506) * gru_0_fwd_t1_h_2 + (1.0612844228744507) * gru_0_fwd_t1_h_3 + (-0.32119348645210266) * gru_0_fwd_t1_h_4 + (-0.86211276054382324) * gru_0_fwd_t1_h_5 + (0.547782301902771) * gru_0_fwd_t1_h_6 + (-0.093592330813407898) * gru_0_fwd_t1_h_7 + (0.055243801325559616) * gru_0_fwd_t1_h_8 + (-0.91423493623733521) * gru_0_fwd_t1_h_9 + (0.53878659009933472) * gru_0_fwd_t1_h_10 + (0.15865139663219452) * gru_0_fwd_t1_h_11 + (0.37276193499565125) * gru_0_fwd_t1_h_12 + (-0.29169294238090515) * gru_0_fwd_t1_h_13 + (-0.30360648036003113) * gru_0_fwd_t1_h_14 + (0.73583757877349854) * gru_0_fwd_t1_h_15 + (0.47895017266273499) * gru_0_fwd_t1_h_16 + (0.3505704402923584) * gru_0_fwd_t1_h_17 + (-0.098445117473602295) * gru_0_fwd_t1_h_18 + (0.57940876483917236) * gru_0_fwd_t1_h_19 + (-1.2554378509521484) * gru_0_fwd_t1_h_20 + (0.46390146017074585) * gru_0_fwd_t1_h_21 + (-0.35657134652137756) * gru_0_fwd_t1_h_22 + (0.074698597192764282) * gru_0_fwd_t1_h_23 + (1.801325798034668) * gru_0_fwd_t1_h_24 + (0.32495126128196716) * gru_0_fwd_t1_h_25 + (0.54336130619049072) * gru_0_fwd_t1_h_26 + (-1.212252140045166) * gru_0_fwd_t1_h_27 + (0.55194634199142456) * gru_0_fwd_t1_h_28 + (-0.48049992322921753) * gru_0_fwd_t1_h_29 + (-0.56101453304290771) * gru_0_fwd_t1_h_30 + (1.4934470653533936) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-0.99985933303833008) + (0.012666893191635609) * emb_t2_0 + (-0.36976549029350281) * emb_t2_1 + (0.00081338832387700677) * emb_t2_2 + (-0.4098648726940155) * emb_t2_3 + (-0.060852337628602982) * emb_t2_4 + (-0.0071054697036743164) * emb_t2_5 + (0.5041191577911377) * emb_t2_6 + (0.0041021513752639294) * emb_t2_7 + (-1.1778392791748047) * emb_t2_8 + (0.27574408054351807) * emb_t2_9 + (0.21442620456218719) * emb_t2_10 + (-0.25847554206848145) * emb_t2_11 + (-1.3537337779998779) * emb_t2_12 + (0.24077826738357544) * emb_t2_13 + (0.004743561614304781) * emb_t2_14 + (-0.012401350773870945) * emb_t2_15 + (0.0018615471199154854) * emb_t2_16 + (0.10535589605569839) * emb_t2_17 + (0.74999076128005981) * emb_t2_18 + (-0.26380902528762817) * emb_t2_19 + (-0.3003496527671814) * emb_t2_20 + (0.0062813307158648968) * emb_t2_21 + (0.37778767943382263) * emb_t2_22 + (0.015250887721776962) * emb_t2_23 + (-0.026627309620380402) * emb_t2_24 + (0.0019454022403806448) * emb_t2_25 + (-0.23446691036224365) * emb_t2_26 + (0.014307253062725067) * emb_t2_27 + (-0.12069432437419891) * emb_t2_28 + (0.18225772678852081) * emb_t2_29 + (-0.048142679035663605) * emb_t2_30 + (1.2029211521148682) * emb_t2_31 + (0.17526847124099731) * gru_0_fwd_t1_h_0 + (0.29039204120635986) * gru_0_fwd_t1_h_1 + (0.11212082207202911) * gru_0_fwd_t1_h_2 + (-0.048150893300771713) * gru_0_fwd_t1_h_3 + (0.19449453055858612) * gru_0_fwd_t1_h_4 + (-0.20177531242370605) * gru_0_fwd_t1_h_5 + (1.4033830165863037) * gru_0_fwd_t1_h_6 + (0.59134262800216675) * gru_0_fwd_t1_h_7 + (-0.4713418185710907) * gru_0_fwd_t1_h_8 + (0.32442927360534668) * gru_0_fwd_t1_h_9 + (-0.22370561957359314) * gru_0_fwd_t1_h_10 + (-0.11116007715463638) * gru_0_fwd_t1_h_11 + (0.18665459752082825) * gru_0_fwd_t1_h_12 + (-0.34142369031906128) * gru_0_fwd_t1_h_13 + (0.20437553524971008) * gru_0_fwd_t1_h_14 + (-0.16410362720489502) * gru_0_fwd_t1_h_15 + (-0.21899665892124176) * gru_0_fwd_t1_h_16 + (-0.0068166921846568584) * gru_0_fwd_t1_h_17 + (0.1391448974609375) * gru_0_fwd_t1_h_18 + (1.44562828540802) * gru_0_fwd_t1_h_19 + (0.40861636400222778) * gru_0_fwd_t1_h_20 + (-1.0526155233383179) * gru_0_fwd_t1_h_21 + (-0.50122278928756714) * gru_0_fwd_t1_h_22 + (-0.26286423206329346) * gru_0_fwd_t1_h_23 + (1.0404269695281982) * gru_0_fwd_t1_h_24 + (0.5514523983001709) * gru_0_fwd_t1_h_25 + (-0.03918822854757309) * gru_0_fwd_t1_h_26 + (-1.0946950912475586) * gru_0_fwd_t1_h_27 + (-0.78440093994140625) * gru_0_fwd_t1_h_28 + (0.28671541810035706) * gru_0_fwd_t1_h_29 + (0.35990628600120544) * gru_0_fwd_t1_h_30 + (-0.053561616688966751) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.057761009782552719) + (-0.01312168687582016) * emb_t2_0 + (0.47595793008804321) * emb_t2_1 + (0.0092984763905405998) * emb_t2_2 + (-0.4075809121131897) * emb_t2_3 + (-0.36018025875091553) * emb_t2_4 + (0.010031003504991531) * emb_t2_5 + (0.21895751357078552) * emb_t2_6 + (0.021545520052313805) * emb_t2_7 + (0.11336663365364075) * emb_t2_8 + (-0.19972579181194305) * emb_t2_9 + (-0.30430427193641663) * emb_t2_10 + (-0.16214349865913391) * emb_t2_11 + (0.075866244733333588) * emb_t2_12 + (0.12699282169342041) * emb_t2_13 + (-0.0094527620822191238) * emb_t2_14 + (0.0077823619358241558) * emb_t2_15 + (-0.0064509240910410881) * emb_t2_16 + (0.28971478343009949) * emb_t2_17 + (-0.18353718519210815) * emb_t2_18 + (0.22298148274421692) * emb_t2_19 + (0.12622544169425964) * emb_t2_20 + (0.032157350331544876) * emb_t2_21 + (-0.32767745852470398) * emb_t2_22 + (-0.019268279895186424) * emb_t2_23 + (0.037682931870222092) * emb_t2_24 + (0.010643746703863144) * emb_t2_25 + (-0.51101380586624146) * emb_t2_26 + (-0.022530023008584976) * emb_t2_27 + (-0.13611628115177155) * emb_t2_28 + (0.099264971911907196) * emb_t2_29 + (-0.1492578536272049) * emb_t2_30 + (0.24172401428222656) * emb_t2_31 + gate_r * ((-0.14063067734241486) + (-0.72258692979812622) * gru_0_fwd_t1_h_0 + (0.34815940260887146) * gru_0_fwd_t1_h_1 + (0.019773149862885475) * gru_0_fwd_t1_h_2 + (0.072194881737232208) * gru_0_fwd_t1_h_3 + (0.21713615953922272) * gru_0_fwd_t1_h_4 + (-0.35022461414337158) * gru_0_fwd_t1_h_5 + (0.66270744800567627) * gru_0_fwd_t1_h_6 + (-0.19786584377288818) * gru_0_fwd_t1_h_7 + (0.0037957692984491587) * gru_0_fwd_t1_h_8 + (-0.62089145183563232) * gru_0_fwd_t1_h_9 + (-0.21985287964344025) * gru_0_fwd_t1_h_10 + (-0.51880043745040894) * gru_0_fwd_t1_h_11 + (-0.043916121125221252) * gru_0_fwd_t1_h_12 + (-0.017323354259133339) * gru_0_fwd_t1_h_13 + (0.1272447407245636) * gru_0_fwd_t1_h_14 + (-0.060213353484869003) * gru_0_fwd_t1_h_15 + (0.14859829843044281) * gru_0_fwd_t1_h_16 + (0.28968065977096558) * gru_0_fwd_t1_h_17 + (0.0064339698292315006) * gru_0_fwd_t1_h_18 + (0.41365617513656616) * gru_0_fwd_t1_h_19 + (-0.76514774560928345) * gru_0_fwd_t1_h_20 + (0.29725161194801331) * gru_0_fwd_t1_h_21 + (-0.29023060202598572) * gru_0_fwd_t1_h_22 + (-0.046404916793107986) * gru_0_fwd_t1_h_23 + (0.04404718428850174) * gru_0_fwd_t1_h_24 + (0.17632803320884705) * gru_0_fwd_t1_h_25 + (0.15760982036590576) * gru_0_fwd_t1_h_26 + (-0.67023319005966187) * gru_0_fwd_t1_h_27 + (0.128376305103302) * gru_0_fwd_t1_h_28 + (1.1769653558731079) * gru_0_fwd_t1_h_29 + (0.070794560015201569) * gru_0_fwd_t1_h_30 + (-0.097687073051929474) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_25 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_25;
    // h=26
    gate_r = sigmoid((-0.67598038911819458) + (0.0558026023209095) * emb_t2_0 + (-0.032692935317754745) * emb_t2_1 + (-0.32052004337310791) * emb_t2_2 + (-0.044908050447702408) * emb_t2_3 + (0.059886354953050613) * emb_t2_4 + (-0.18540339171886444) * emb_t2_5 + (-0.044968158006668091) * emb_t2_6 + (-0.078618504106998444) * emb_t2_7 + (-0.88261473178863525) * emb_t2_8 + (0.78627192974090576) * emb_t2_9 + (0.76120537519454956) * emb_t2_10 + (-0.43989229202270508) * emb_t2_11 + (-2.231489896774292) * emb_t2_12 + (0.53752708435058594) * emb_t2_13 + (0.070067539811134338) * emb_t2_14 + (0.11337725818157196) * emb_t2_15 + (-0.10081614553928375) * emb_t2_16 + (0.27088576555252075) * emb_t2_17 + (0.59885233640670776) * emb_t2_18 + (-0.50101006031036377) * emb_t2_19 + (0.017447620630264282) * emb_t2_20 + (-0.020487589761614799) * emb_t2_21 + (0.68872314691543579) * emb_t2_22 + (0.0055485651828348637) * emb_t2_23 + (-0.17244178056716919) * emb_t2_24 + (-0.072804965078830719) * emb_t2_25 + (-0.028020752593874931) * emb_t2_26 + (-0.043609999120235443) * emb_t2_27 + (0.042965706437826157) * emb_t2_28 + (-0.11476427316665649) * emb_t2_29 + (-0.10693560540676117) * emb_t2_30 + (1.3514949083328247) * emb_t2_31 + (-0.41277074813842773) * gru_0_fwd_t1_h_0 + (-0.48156276345252991) * gru_0_fwd_t1_h_1 + (-0.091673322021961212) * gru_0_fwd_t1_h_2 + (0.54766333103179932) * gru_0_fwd_t1_h_3 + (-0.50859808921813965) * gru_0_fwd_t1_h_4 + (1.0555626153945923) * gru_0_fwd_t1_h_5 + (-0.41380441188812256) * gru_0_fwd_t1_h_6 + (0.17298330366611481) * gru_0_fwd_t1_h_7 + (-0.16196425259113312) * gru_0_fwd_t1_h_8 + (0.19671882688999176) * gru_0_fwd_t1_h_9 + (0.20455469191074371) * gru_0_fwd_t1_h_10 + (-0.24578157067298889) * gru_0_fwd_t1_h_11 + (0.35916396975517273) * gru_0_fwd_t1_h_12 + (0.66282665729522705) * gru_0_fwd_t1_h_13 + (-0.39608979225158691) * gru_0_fwd_t1_h_14 + (0.13951408863067627) * gru_0_fwd_t1_h_15 + (0.010326295159757137) * gru_0_fwd_t1_h_16 + (0.14644314348697662) * gru_0_fwd_t1_h_17 + (-0.12216160446405411) * gru_0_fwd_t1_h_18 + (-0.36179104447364807) * gru_0_fwd_t1_h_19 + (-0.55214738845825195) * gru_0_fwd_t1_h_20 + (-0.53031104803085327) * gru_0_fwd_t1_h_21 + (0.45541763305664062) * gru_0_fwd_t1_h_22 + (-0.10570087283849716) * gru_0_fwd_t1_h_23 + (-0.8588065505027771) * gru_0_fwd_t1_h_24 + (0.24876505136489868) * gru_0_fwd_t1_h_25 + (-0.015186787582933903) * gru_0_fwd_t1_h_26 + (-0.62532055377960205) * gru_0_fwd_t1_h_27 + (-0.75504863262176514) * gru_0_fwd_t1_h_28 + (-0.49642285704612732) * gru_0_fwd_t1_h_29 + (-0.64390230178833008) * gru_0_fwd_t1_h_30 + (-2.1742944717407227) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.18419407308101654) + (0.12636376917362213) * emb_t2_0 + (0.35873430967330933) * emb_t2_1 + (-0.13167670369148254) * emb_t2_2 + (0.12444440275430679) * emb_t2_3 + (-0.085923030972480774) * emb_t2_4 + (-0.18459318578243256) * emb_t2_5 + (-0.068045005202293396) * emb_t2_6 + (-0.095175199210643768) * emb_t2_7 + (0.13584671914577484) * emb_t2_8 + (-0.054698679596185684) * emb_t2_9 + (-0.17042535543441772) * emb_t2_10 + (-0.042757421731948853) * emb_t2_11 + (0.27541375160217285) * emb_t2_12 + (0.043980639427900314) * emb_t2_13 + (-0.10892507433891296) * emb_t2_14 + (0.10816606134176254) * emb_t2_15 + (0.0012410585768520832) * emb_t2_16 + (0.22231405973434448) * emb_t2_17 + (-0.32718575000762939) * emb_t2_18 + (0.080248810350894928) * emb_t2_19 + (-0.39937981963157654) * emb_t2_20 + (-0.002908983500674367) * emb_t2_21 + (-0.15612867474555969) * emb_t2_22 + (-0.026376662775874138) * emb_t2_23 + (-0.1197054460644722) * emb_t2_24 + (-0.11736680567264557) * emb_t2_25 + (0.2113531082868576) * emb_t2_26 + (-0.0025766040198504925) * emb_t2_27 + (-0.42322325706481934) * emb_t2_28 + (0.51667916774749756) * emb_t2_29 + (-0.1519358903169632) * emb_t2_30 + (0.24732120335102081) * emb_t2_31 + (-0.067249543964862823) * gru_0_fwd_t1_h_0 + (-0.31226459145545959) * gru_0_fwd_t1_h_1 + (-0.51877528429031372) * gru_0_fwd_t1_h_2 + (-2.6487679481506348) * gru_0_fwd_t1_h_3 + (-0.22110287845134735) * gru_0_fwd_t1_h_4 + (0.059728037565946579) * gru_0_fwd_t1_h_5 + (0.31080162525177002) * gru_0_fwd_t1_h_6 + (1.2482510805130005) * gru_0_fwd_t1_h_7 + (-1.6078381538391113) * gru_0_fwd_t1_h_8 + (0.61239218711853027) * gru_0_fwd_t1_h_9 + (0.46207064390182495) * gru_0_fwd_t1_h_10 + (-0.49545717239379883) * gru_0_fwd_t1_h_11 + (0.33834400773048401) * gru_0_fwd_t1_h_12 + (0.41088160872459412) * gru_0_fwd_t1_h_13 + (-0.1262013167142868) * gru_0_fwd_t1_h_14 + (0.38419285416603088) * gru_0_fwd_t1_h_15 + (0.2053573876619339) * gru_0_fwd_t1_h_16 + (0.24931047856807709) * gru_0_fwd_t1_h_17 + (-0.66092485189437866) * gru_0_fwd_t1_h_18 + (-0.48832961916923523) * gru_0_fwd_t1_h_19 + (0.97472214698791504) * gru_0_fwd_t1_h_20 + (-0.50731301307678223) * gru_0_fwd_t1_h_21 + (-1.9935340881347656) * gru_0_fwd_t1_h_22 + (0.98487734794616699) * gru_0_fwd_t1_h_23 + (-0.85541796684265137) * gru_0_fwd_t1_h_24 + (0.91506683826446533) * gru_0_fwd_t1_h_25 + (0.4220888614654541) * gru_0_fwd_t1_h_26 + (-1.2311486005783081) * gru_0_fwd_t1_h_27 + (0.89576292037963867) * gru_0_fwd_t1_h_28 + (2.0731654167175293) * gru_0_fwd_t1_h_29 + (0.22377066314220428) * gru_0_fwd_t1_h_30 + (4.7580680847167969) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.68298327922821045) + (-0.0045996089465916157) * emb_t2_0 + (-0.26857757568359375) * emb_t2_1 + (0.0060096019878983498) * emb_t2_2 + (0.19714565575122833) * emb_t2_3 + (-0.070438794791698456) * emb_t2_4 + (0.0003719716623891145) * emb_t2_5 + (-0.24212051928043365) * emb_t2_6 + (-0.0039247330278158188) * emb_t2_7 + (0.1604858934879303) * emb_t2_8 + (0.19536077976226807) * emb_t2_9 + (0.0010357029968872666) * emb_t2_10 + (0.337159663438797) * emb_t2_11 + (0.31912016868591309) * emb_t2_12 + (-0.29516184329986572) * emb_t2_13 + (0.0060392273589968681) * emb_t2_14 + (-0.0038403165526688099) * emb_t2_15 + (0.0091936858370900154) * emb_t2_16 + (-0.10049980878829956) * emb_t2_17 + (0.14445026218891144) * emb_t2_18 + (0.24470673501491547) * emb_t2_19 + (0.10333190113306046) * emb_t2_20 + (-0.0037639811635017395) * emb_t2_21 + (0.044285371899604797) * emb_t2_22 + (-0.0030138194561004639) * emb_t2_23 + (-0.0010317657142877579) * emb_t2_24 + (-0.0053920131176710129) * emb_t2_25 + (-0.023041162639856339) * emb_t2_26 + (0.008960566483438015) * emb_t2_27 + (0.0030284069944173098) * emb_t2_28 + (-0.14610596001148224) * emb_t2_29 + (-0.38512983918190002) * emb_t2_30 + (-0.33107215166091919) * emb_t2_31 + gate_r * ((-1.6079645156860352) + (-1.6780352592468262) * gru_0_fwd_t1_h_0 + (-0.13621599972248077) * gru_0_fwd_t1_h_1 + (-0.72709625959396362) * gru_0_fwd_t1_h_2 + (-0.79967761039733887) * gru_0_fwd_t1_h_3 + (0.032421570271253586) * gru_0_fwd_t1_h_4 + (-0.046066980808973312) * gru_0_fwd_t1_h_5 + (-0.92822104692459106) * gru_0_fwd_t1_h_6 + (0.2892645001411438) * gru_0_fwd_t1_h_7 + (0.083832323551177979) * gru_0_fwd_t1_h_8 + (0.96019530296325684) * gru_0_fwd_t1_h_9 + (0.63194537162780762) * gru_0_fwd_t1_h_10 + (-1.7499481439590454) * gru_0_fwd_t1_h_11 + (1.7524468898773193) * gru_0_fwd_t1_h_12 + (1.1961889266967773) * gru_0_fwd_t1_h_13 + (-1.8419791460037231) * gru_0_fwd_t1_h_14 + (-0.12721528112888336) * gru_0_fwd_t1_h_15 + (1.7608006000518799) * gru_0_fwd_t1_h_16 + (1.1260322332382202) * gru_0_fwd_t1_h_17 + (1.9182668924331665) * gru_0_fwd_t1_h_18 + (0.71170955896377563) * gru_0_fwd_t1_h_19 + (0.60601592063903809) * gru_0_fwd_t1_h_20 + (0.52277868986129761) * gru_0_fwd_t1_h_21 + (-0.61187374591827393) * gru_0_fwd_t1_h_22 + (1.3637593984603882) * gru_0_fwd_t1_h_23 + (0.47312158346176147) * gru_0_fwd_t1_h_24 + (0.26127108931541443) * gru_0_fwd_t1_h_25 + (-0.039028014987707138) * gru_0_fwd_t1_h_26 + (0.38539132475852966) * gru_0_fwd_t1_h_27 + (-0.98905032873153687) * gru_0_fwd_t1_h_28 + (0.52149510383605957) * gru_0_fwd_t1_h_29 + (0.002440096577629447) * gru_0_fwd_t1_h_30 + (-0.081774525344371796) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_26 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_26;
    // h=27
    gate_r = sigmoid((1.3634942770004272) + (-0.056222405284643173) * emb_t2_0 + (-0.90043377876281738) * emb_t2_1 + (0.14871729910373688) * emb_t2_2 + (0.81509596109390259) * emb_t2_3 + (-1.0132437944412231) * emb_t2_4 + (-1.3146908283233643) * emb_t2_5 + (-1.1923024654388428) * emb_t2_6 + (-1.0540844202041626) * emb_t2_7 + (0.28570744395256042) * emb_t2_8 + (0.64994561672210693) * emb_t2_9 + (0.32622694969177246) * emb_t2_10 + (0.41002455353736877) * emb_t2_11 + (0.39588391780853271) * emb_t2_12 + (-0.82721132040023804) * emb_t2_13 + (0.34960439801216125) * emb_t2_14 + (-0.65033972263336182) * emb_t2_15 + (0.80080020427703857) * emb_t2_16 + (-0.41169336438179016) * emb_t2_17 + (0.29242280125617981) * emb_t2_18 + (-0.74909293651580811) * emb_t2_19 + (0.35264158248901367) * emb_t2_20 + (-0.36563953757286072) * emb_t2_21 + (0.12845835089683533) * emb_t2_22 + (-0.0042146192863583565) * emb_t2_23 + (0.056114397943019867) * emb_t2_24 + (0.55274033546447754) * emb_t2_25 + (0.99801844358444214) * emb_t2_26 + (0.73413902521133423) * emb_t2_27 + (1.0847474336624146) * emb_t2_28 + (-0.87734442949295044) * emb_t2_29 + (1.007982611656189) * emb_t2_30 + (-0.5187227725982666) * emb_t2_31 + (-0.6661791205406189) * gru_0_fwd_t1_h_0 + (-0.25041276216506958) * gru_0_fwd_t1_h_1 + (-0.12346621602773666) * gru_0_fwd_t1_h_2 + (-0.79780864715576172) * gru_0_fwd_t1_h_3 + (-0.73847734928131104) * gru_0_fwd_t1_h_4 + (-0.44822749495506287) * gru_0_fwd_t1_h_5 + (0.45567899942398071) * gru_0_fwd_t1_h_6 + (-0.37372899055480957) * gru_0_fwd_t1_h_7 + (-3.5865321159362793) * gru_0_fwd_t1_h_8 + (-2.8938295841217041) * gru_0_fwd_t1_h_9 + (0.62683761119842529) * gru_0_fwd_t1_h_10 + (1.5945019721984863) * gru_0_fwd_t1_h_11 + (-0.66199398040771484) * gru_0_fwd_t1_h_12 + (-0.020994732156395912) * gru_0_fwd_t1_h_13 + (2.1936030387878418) * gru_0_fwd_t1_h_14 + (-0.13972392678260803) * gru_0_fwd_t1_h_15 + (-3.8492581844329834) * gru_0_fwd_t1_h_16 + (-5.7116146087646484) * gru_0_fwd_t1_h_17 + (-0.27653229236602783) * gru_0_fwd_t1_h_18 + (-1.1225560903549194) * gru_0_fwd_t1_h_19 + (-4.0217747688293457) * gru_0_fwd_t1_h_20 + (-1.6410280466079712) * gru_0_fwd_t1_h_21 + (-0.2692897617816925) * gru_0_fwd_t1_h_22 + (5.0880932807922363) * gru_0_fwd_t1_h_23 + (2.1827061176300049) * gru_0_fwd_t1_h_24 + (-3.0956466197967529) * gru_0_fwd_t1_h_25 + (1.6472270488739014) * gru_0_fwd_t1_h_26 + (-2.9991559982299805) * gru_0_fwd_t1_h_27 + (0.50273555517196655) * gru_0_fwd_t1_h_28 + (-1.400140643119812) * gru_0_fwd_t1_h_29 + (-0.16161012649536133) * gru_0_fwd_t1_h_30 + (2.6617364883422852) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-0.033420410007238388) + (0.0064380182884633541) * emb_t2_0 + (-0.36172717809677124) * emb_t2_1 + (-0.0055471537634730339) * emb_t2_2 + (-0.20949901640415192) * emb_t2_3 + (-0.14390110969543457) * emb_t2_4 + (0.0017085226718336344) * emb_t2_5 + (0.19041195511817932) * emb_t2_6 + (-0.0082351481541991234) * emb_t2_7 + (0.038002565503120422) * emb_t2_8 + (0.37232178449630737) * emb_t2_9 + (0.64640152454376221) * emb_t2_10 + (0.082609288394451141) * emb_t2_11 + (0.1782267689704895) * emb_t2_12 + (-0.18052464723587036) * emb_t2_13 + (-0.017151672393083572) * emb_t2_14 + (-0.014069987460970879) * emb_t2_15 + (-0.0068942955695092678) * emb_t2_16 + (-0.031040454283356667) * emb_t2_17 + (0.25211223959922791) * emb_t2_18 + (-0.21565334498882294) * emb_t2_19 + (0.025725236162543297) * emb_t2_20 + (-0.00059418560704216361) * emb_t2_21 + (0.29571840167045593) * emb_t2_22 + (-0.0073421113193035126) * emb_t2_23 + (0.0049376604147255421) * emb_t2_24 + (-0.022504758089780807) * emb_t2_25 + (0.13833615183830261) * emb_t2_26 + (-0.0049349567852914333) * emb_t2_27 + (0.08759000152349472) * emb_t2_28 + (0.12952020764350891) * emb_t2_29 + (-0.11354436725378036) * emb_t2_30 + (0.35968726873397827) * emb_t2_31 + (-0.5234827995300293) * gru_0_fwd_t1_h_0 + (-0.75930380821228027) * gru_0_fwd_t1_h_1 + (0.23536282777786255) * gru_0_fwd_t1_h_2 + (-0.20003423094749451) * gru_0_fwd_t1_h_3 + (-0.89727324247360229) * gru_0_fwd_t1_h_4 + (0.19947317242622375) * gru_0_fwd_t1_h_5 + (-0.55144459009170532) * gru_0_fwd_t1_h_6 + (-0.19658015668392181) * gru_0_fwd_t1_h_7 + (-0.11698223650455475) * gru_0_fwd_t1_h_8 + (-0.082482509315013885) * gru_0_fwd_t1_h_9 + (-0.3781915009021759) * gru_0_fwd_t1_h_10 + (-0.81994861364364624) * gru_0_fwd_t1_h_11 + (0.97556012868881226) * gru_0_fwd_t1_h_12 + (0.86488986015319824) * gru_0_fwd_t1_h_13 + (0.070089027285575867) * gru_0_fwd_t1_h_14 + (0.99436193704605103) * gru_0_fwd_t1_h_15 + (0.3084876537322998) * gru_0_fwd_t1_h_16 + (0.20581619441509247) * gru_0_fwd_t1_h_17 + (-0.86727488040924072) * gru_0_fwd_t1_h_18 + (-0.10319950431585312) * gru_0_fwd_t1_h_19 + (0.32673987746238708) * gru_0_fwd_t1_h_20 + (-0.25143009424209595) * gru_0_fwd_t1_h_21 + (0.5033947229385376) * gru_0_fwd_t1_h_22 + (-0.22281058132648468) * gru_0_fwd_t1_h_23 + (0.56214594841003418) * gru_0_fwd_t1_h_24 + (0.12110262364149094) * gru_0_fwd_t1_h_25 + (-0.01768973283469677) * gru_0_fwd_t1_h_26 + (1.0673447847366333) * gru_0_fwd_t1_h_27 + (-1.3145279884338379) * gru_0_fwd_t1_h_28 + (-0.048735242336988449) * gru_0_fwd_t1_h_29 + (-0.034720852971076965) * gru_0_fwd_t1_h_30 + (-0.99321061372756958) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.40442636609077454) + (0.059626400470733643) * emb_t2_0 + (-0.097424276173114777) * emb_t2_1 + (0.0076822992414236069) * emb_t2_2 + (0.086698137223720551) * emb_t2_3 + (-0.47075149416923523) * emb_t2_4 + (-0.033074695616960526) * emb_t2_5 + (-0.16545090079307556) * emb_t2_6 + (-0.021484445780515671) * emb_t2_7 + (0.3537864089012146) * emb_t2_8 + (-0.082181729376316071) * emb_t2_9 + (-0.10835350304841995) * emb_t2_10 + (0.2522473931312561) * emb_t2_11 + (0.4435955286026001) * emb_t2_12 + (-0.22137553989887238) * emb_t2_13 + (-0.021348340436816216) * emb_t2_14 + (0.051935482770204544) * emb_t2_15 + (0.022021180018782616) * emb_t2_16 + (-0.23186801373958588) * emb_t2_17 + (-0.6292957067489624) * emb_t2_18 + (-0.1941601037979126) * emb_t2_19 + (0.23594163358211517) * emb_t2_20 + (-0.008351876400411129) * emb_t2_21 + (-0.42310482263565063) * emb_t2_22 + (-0.0052936812862753868) * emb_t2_23 + (-0.0021497618872672319) * emb_t2_24 + (-0.021310068666934967) * emb_t2_25 + (0.14420174062252045) * emb_t2_26 + (0.024472739547491074) * emb_t2_27 + (-0.20820614695549011) * emb_t2_28 + (0.0054779555648565292) * emb_t2_29 + (-0.019656142219901085) * emb_t2_30 + (-0.60367149114608765) * emb_t2_31 + gate_r * ((0.66925060749053955) + (-0.27853310108184814) * gru_0_fwd_t1_h_0 + (-0.10380613058805466) * gru_0_fwd_t1_h_1 + (-0.0054271132685244083) * gru_0_fwd_t1_h_2 + (0.27972781658172607) * gru_0_fwd_t1_h_3 + (-0.060516022145748138) * gru_0_fwd_t1_h_4 + (0.063562795519828796) * gru_0_fwd_t1_h_5 + (0.61955720186233521) * gru_0_fwd_t1_h_6 + (0.016443360596895218) * gru_0_fwd_t1_h_7 + (0.097532466053962708) * gru_0_fwd_t1_h_8 + (-0.25765687227249146) * gru_0_fwd_t1_h_9 + (0.39379838109016418) * gru_0_fwd_t1_h_10 + (-0.36339232325553894) * gru_0_fwd_t1_h_11 + (0.18765503168106079) * gru_0_fwd_t1_h_12 + (0.21706663072109222) * gru_0_fwd_t1_h_13 + (-0.27371245622634888) * gru_0_fwd_t1_h_14 + (0.096289582550525665) * gru_0_fwd_t1_h_15 + (0.14562420547008514) * gru_0_fwd_t1_h_16 + (0.29114526510238647) * gru_0_fwd_t1_h_17 + (-0.1404486745595932) * gru_0_fwd_t1_h_18 + (2.7993574142456055) * gru_0_fwd_t1_h_19 + (-1.0938600301742554) * gru_0_fwd_t1_h_20 + (0.015156141482293606) * gru_0_fwd_t1_h_21 + (-0.4472515881061554) * gru_0_fwd_t1_h_22 + (0.071304410696029663) * gru_0_fwd_t1_h_23 + (-0.23107630014419556) * gru_0_fwd_t1_h_24 + (0.023721644654870033) * gru_0_fwd_t1_h_25 + (0.026057315990328789) * gru_0_fwd_t1_h_26 + (-0.0056411502882838249) * gru_0_fwd_t1_h_27 + (-0.30286586284637451) * gru_0_fwd_t1_h_28 + (0.17545744776725769) * gru_0_fwd_t1_h_29 + (-0.18913552165031433) * gru_0_fwd_t1_h_30 + (1.0454243421554565) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_27 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_27;
    // h=28
    gate_r = sigmoid((-1.292569637298584) + (0.053969614207744598) * emb_t2_0 + (0.84029549360275269) * emb_t2_1 + (-1.751328706741333) * emb_t2_2 + (-0.44191840291023254) * emb_t2_3 + (0.54275029897689819) * emb_t2_4 + (0.28760188817977905) * emb_t2_5 + (0.65396994352340698) * emb_t2_6 + (0.88202369213104248) * emb_t2_7 + (-0.63079744577407837) * emb_t2_8 + (-0.62787461280822754) * emb_t2_9 + (-0.019234701991081238) * emb_t2_10 + (-0.53413426876068115) * emb_t2_11 + (-0.34742468595504761) * emb_t2_12 + (0.73544913530349731) * emb_t2_13 + (-0.50395351648330688) * emb_t2_14 + (1.5419316291809082) * emb_t2_15 + (-0.53303635120391846) * emb_t2_16 + (0.90656989812850952) * emb_t2_17 + (-0.47902229428291321) * emb_t2_18 + (-0.19090864062309265) * emb_t2_19 + (-0.17996221780776978) * emb_t2_20 + (0.40649709105491638) * emb_t2_21 + (0.60855847597122192) * emb_t2_22 + (0.67197114229202271) * emb_t2_23 + (-0.062262497842311859) * emb_t2_24 + (0.05978093296289444) * emb_t2_25 + (-0.56690949201583862) * emb_t2_26 + (-0.24178600311279297) * emb_t2_27 + (-0.81900542974472046) * emb_t2_28 + (0.97798550128936768) * emb_t2_29 + (-0.14322385191917419) * emb_t2_30 + (0.608226478099823) * emb_t2_31 + (0.025221085175871849) * gru_0_fwd_t1_h_0 + (0.049941185861825943) * gru_0_fwd_t1_h_1 + (0.088683575391769409) * gru_0_fwd_t1_h_2 + (-0.38951092958450317) * gru_0_fwd_t1_h_3 + (0.53304773569107056) * gru_0_fwd_t1_h_4 + (1.048098087310791) * gru_0_fwd_t1_h_5 + (-1.0918179750442505) * gru_0_fwd_t1_h_6 + (-0.5610041618347168) * gru_0_fwd_t1_h_7 + (0.68512958288192749) * gru_0_fwd_t1_h_8 + (0.18700028955936432) * gru_0_fwd_t1_h_9 + (0.092129983007907867) * gru_0_fwd_t1_h_10 + (0.065248891711235046) * gru_0_fwd_t1_h_11 + (-0.0082201473414897919) * gru_0_fwd_t1_h_12 + (-0.27918216586112976) * gru_0_fwd_t1_h_13 + (-1.161197304725647) * gru_0_fwd_t1_h_14 + (0.23061954975128174) * gru_0_fwd_t1_h_15 + (0.88139182329177856) * gru_0_fwd_t1_h_16 + (0.13258109986782074) * gru_0_fwd_t1_h_17 + (-0.15281245112419128) * gru_0_fwd_t1_h_18 + (-0.55834925174713135) * gru_0_fwd_t1_h_19 + (-0.20168487727642059) * gru_0_fwd_t1_h_20 + (0.84790438413619995) * gru_0_fwd_t1_h_21 + (0.30727106332778931) * gru_0_fwd_t1_h_22 + (-0.20956370234489441) * gru_0_fwd_t1_h_23 + (-0.33019140362739563) * gru_0_fwd_t1_h_24 + (0.035808708518743515) * gru_0_fwd_t1_h_25 + (-0.012295838445425034) * gru_0_fwd_t1_h_26 + (-0.10886805504560471) * gru_0_fwd_t1_h_27 + (0.43562328815460205) * gru_0_fwd_t1_h_28 + (-0.12479058653116226) * gru_0_fwd_t1_h_29 + (-0.44247058033943176) * gru_0_fwd_t1_h_30 + (1.023451566696167) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.80183142423629761) + (0.037749048322439194) * emb_t2_0 + (-1.3777821063995361) * emb_t2_1 + (-0.3930060863494873) * emb_t2_2 + (0.38262185454368591) * emb_t2_3 + (-1.0268763303756714) * emb_t2_4 + (-0.44091349840164185) * emb_t2_5 + (-1.0418828725814819) * emb_t2_6 + (0.2112157940864563) * emb_t2_7 + (0.13275355100631714) * emb_t2_8 + (0.42874050140380859) * emb_t2_9 + (0.42819133400917053) * emb_t2_10 + (0.4522298276424408) * emb_t2_11 + (0.3910057544708252) * emb_t2_12 + (-1.7797743082046509) * emb_t2_13 + (0.062521956861019135) * emb_t2_14 + (-0.2064393013715744) * emb_t2_15 + (0.32217961549758911) * emb_t2_16 + (-0.88105738162994385) * emb_t2_17 + (0.073882870376110077) * emb_t2_18 + (-0.11560744792222977) * emb_t2_19 + (0.94725418090820312) * emb_t2_20 + (-0.16107381880283356) * emb_t2_21 + (-0.093473196029663086) * emb_t2_22 + (1.3574447631835938) * emb_t2_23 + (0.48626694083213806) * emb_t2_24 + (0.70945572853088379) * emb_t2_25 + (1.0981122255325317) * emb_t2_26 + (0.72538602352142334) * emb_t2_27 + (1.787631630897522) * emb_t2_28 + (-2.3084738254547119) * emb_t2_29 + (1.2363383769989014) * emb_t2_30 + (0.22205078601837158) * emb_t2_31 + (0.36775466799736023) * gru_0_fwd_t1_h_0 + (0.22176246345043182) * gru_0_fwd_t1_h_1 + (-0.44520357251167297) * gru_0_fwd_t1_h_2 + (0.044741537421941757) * gru_0_fwd_t1_h_3 + (0.58238863945007324) * gru_0_fwd_t1_h_4 + (-0.94655632972717285) * gru_0_fwd_t1_h_5 + (0.74089521169662476) * gru_0_fwd_t1_h_6 + (1.0737566947937012) * gru_0_fwd_t1_h_7 + (-0.71389651298522949) * gru_0_fwd_t1_h_8 + (0.37089678645133972) * gru_0_fwd_t1_h_9 + (0.44034215807914734) * gru_0_fwd_t1_h_10 + (0.48689711093902588) * gru_0_fwd_t1_h_11 + (0.35777571797370911) * gru_0_fwd_t1_h_12 + (0.40952318906784058) * gru_0_fwd_t1_h_13 + (0.32340788841247559) * gru_0_fwd_t1_h_14 + (-0.26525449752807617) * gru_0_fwd_t1_h_15 + (-1.1085613965988159) * gru_0_fwd_t1_h_16 + (-0.73834836483001709) * gru_0_fwd_t1_h_17 + (-0.26148673892021179) * gru_0_fwd_t1_h_18 + (-1.0798720121383667) * gru_0_fwd_t1_h_19 + (0.044556822627782822) * gru_0_fwd_t1_h_20 + (-1.1963039636611938) * gru_0_fwd_t1_h_21 + (-0.8264126181602478) * gru_0_fwd_t1_h_22 + (0.77406275272369385) * gru_0_fwd_t1_h_23 + (0.012892594560980797) * gru_0_fwd_t1_h_24 + (0.50934898853302002) * gru_0_fwd_t1_h_25 + (0.36857566237449646) * gru_0_fwd_t1_h_26 + (-0.47647750377655029) * gru_0_fwd_t1_h_27 + (-0.34616562724113464) * gru_0_fwd_t1_h_28 + (0.038031734526157379) * gru_0_fwd_t1_h_29 + (0.50173258781433105) * gru_0_fwd_t1_h_30 + (-1.8020660877227783) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.057754348963499069) + (0.23920117318630219) * emb_t2_0 + (-2.5100808143615723) * emb_t2_1 + (0.46204259991645813) * emb_t2_2 + (-0.029308877885341644) * emb_t2_3 + (-0.43936541676521301) * emb_t2_4 + (0.99328601360321045) * emb_t2_5 + (-0.76978802680969238) * emb_t2_6 + (0.52340561151504517) * emb_t2_7 + (-0.17568124830722809) * emb_t2_8 + (1.6829434633255005) * emb_t2_9 + (0.97307509183883667) * emb_t2_10 + (-0.12742845714092255) * emb_t2_11 + (-0.22464659810066223) * emb_t2_12 + (-1.2527275085449219) * emb_t2_13 + (-0.4431215226650238) * emb_t2_14 + (-0.88653063774108887) * emb_t2_15 + (0.11366888135671616) * emb_t2_16 + (0.15872882306575775) * emb_t2_17 + (0.67116409540176392) * emb_t2_18 + (-1.0426526069641113) * emb_t2_19 + (-0.076840460300445557) * emb_t2_20 + (0.33484953641891479) * emb_t2_21 + (0.25041815638542175) * emb_t2_22 + (-0.84799081087112427) * emb_t2_23 + (-0.011975551024079323) * emb_t2_24 + (-0.47233113646507263) * emb_t2_25 + (-0.2212168425321579) * emb_t2_26 + (0.047423329204320908) * emb_t2_27 + (2.3713116645812988) * emb_t2_28 + (-1.3745518922805786) * emb_t2_29 + (0.42232599854469299) * emb_t2_30 + (0.56859183311462402) * emb_t2_31 + gate_r * ((-0.098516441881656647) + (-0.23088675737380981) * gru_0_fwd_t1_h_0 + (-0.68228960037231445) * gru_0_fwd_t1_h_1 + (0.37348487973213196) * gru_0_fwd_t1_h_2 + (-1.6243604421615601) * gru_0_fwd_t1_h_3 + (-1.1399021148681641) * gru_0_fwd_t1_h_4 + (-0.8140413761138916) * gru_0_fwd_t1_h_5 + (0.43853938579559326) * gru_0_fwd_t1_h_6 + (-0.11266043782234192) * gru_0_fwd_t1_h_7 + (-0.41289544105529785) * gru_0_fwd_t1_h_8 + (0.14110228419303894) * gru_0_fwd_t1_h_9 + (-0.43223839998245239) * gru_0_fwd_t1_h_10 + (0.055673964321613312) * gru_0_fwd_t1_h_11 + (-0.72240167856216431) * gru_0_fwd_t1_h_12 + (0.63826394081115723) * gru_0_fwd_t1_h_13 + (1.0867960453033447) * gru_0_fwd_t1_h_14 + (-0.92242056131362915) * gru_0_fwd_t1_h_15 + (-0.3301178514957428) * gru_0_fwd_t1_h_16 + (-0.27486145496368408) * gru_0_fwd_t1_h_17 + (-1.1910151243209839) * gru_0_fwd_t1_h_18 + (0.32932460308074951) * gru_0_fwd_t1_h_19 + (-0.14576353132724762) * gru_0_fwd_t1_h_20 + (-0.34404507279396057) * gru_0_fwd_t1_h_21 + (0.13158722221851349) * gru_0_fwd_t1_h_22 + (0.23220203816890717) * gru_0_fwd_t1_h_23 + (0.045593172311782837) * gru_0_fwd_t1_h_24 + (-0.058448214083909988) * gru_0_fwd_t1_h_25 + (-0.43583637475967407) * gru_0_fwd_t1_h_26 + (-0.3931058943271637) * gru_0_fwd_t1_h_27 + (-0.068734019994735718) * gru_0_fwd_t1_h_28 + (-0.30712255835533142) * gru_0_fwd_t1_h_29 + (-0.17921477556228638) * gru_0_fwd_t1_h_30 + (-0.75506126880645752) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_28 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_28;
    // h=29
    gate_r = sigmoid((-2.7073235511779785) + (-0.94925135374069214) * emb_t2_0 + (0.47642731666564941) * emb_t2_1 + (-0.89598292112350464) * emb_t2_2 + (-1.2521011829376221) * emb_t2_3 + (0.97779101133346558) * emb_t2_4 + (0.94753819704055786) * emb_t2_5 + (1.122064471244812) * emb_t2_6 + (1.3330873250961304) * emb_t2_7 + (-1.1404660940170288) * emb_t2_8 + (0.90771013498306274) * emb_t2_9 + (1.3533643484115601) * emb_t2_10 + (-0.93836623430252075) * emb_t2_11 + (-1.4471783638000488) * emb_t2_12 + (0.81418299674987793) * emb_t2_13 + (0.43665635585784912) * emb_t2_14 + (0.64093393087387085) * emb_t2_15 + (-1.0563971996307373) * emb_t2_16 + (1.2846221923828125) * emb_t2_17 + (1.2511874437332153) * emb_t2_18 + (-1.3642784357070923) * emb_t2_19 + (-1.1827380657196045) * emb_t2_20 + (0.91577178239822388) * emb_t2_21 + (1.0097044706344604) * emb_t2_22 + (-0.61382186412811279) * emb_t2_23 + (0.41742041707038879) * emb_t2_24 + (0.55784028768539429) * emb_t2_25 + (-1.0337615013122559) * emb_t2_26 + (-0.84527939558029175) * emb_t2_27 + (-0.32469251751899719) * emb_t2_28 + (0.66467571258544922) * emb_t2_29 + (-1.0546854734420776) * emb_t2_30 + (1.537489652633667) * emb_t2_31 + (-0.80361813306808472) * gru_0_fwd_t1_h_0 + (-0.57504624128341675) * gru_0_fwd_t1_h_1 + (-2.2439088821411133) * gru_0_fwd_t1_h_2 + (-0.28392288088798523) * gru_0_fwd_t1_h_3 + (-1.0859048366546631) * gru_0_fwd_t1_h_4 + (-0.41850793361663818) * gru_0_fwd_t1_h_5 + (0.48004212975502014) * gru_0_fwd_t1_h_6 + (0.17141380906105042) * gru_0_fwd_t1_h_7 + (0.12205420434474945) * gru_0_fwd_t1_h_8 + (-0.79070055484771729) * gru_0_fwd_t1_h_9 + (1.8991626501083374) * gru_0_fwd_t1_h_10 + (0.24836893379688263) * gru_0_fwd_t1_h_11 + (0.46768170595169067) * gru_0_fwd_t1_h_12 + (0.91601681709289551) * gru_0_fwd_t1_h_13 + (-1.7057197093963623) * gru_0_fwd_t1_h_14 + (-0.062965147197246552) * gru_0_fwd_t1_h_15 + (0.52966642379760742) * gru_0_fwd_t1_h_16 + (0.049649883061647415) * gru_0_fwd_t1_h_17 + (-0.25261175632476807) * gru_0_fwd_t1_h_18 + (-0.76427584886550903) * gru_0_fwd_t1_h_19 + (-1.0443379878997803) * gru_0_fwd_t1_h_20 + (1.242803692817688) * gru_0_fwd_t1_h_21 + (0.17352627217769623) * gru_0_fwd_t1_h_22 + (0.19701914489269257) * gru_0_fwd_t1_h_23 + (1.2348150014877319) * gru_0_fwd_t1_h_24 + (0.35278141498565674) * gru_0_fwd_t1_h_25 + (-0.08996235579252243) * gru_0_fwd_t1_h_26 + (-0.44341492652893066) * gru_0_fwd_t1_h_27 + (0.65234887599945068) * gru_0_fwd_t1_h_28 + (-0.8684159517288208) * gru_0_fwd_t1_h_29 + (-1.4730590581893921) * gru_0_fwd_t1_h_30 + (-0.046284548938274384) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((-0.056443262845277786) + (-0.03196324035525322) * emb_t2_0 + (-0.0229691993445158) * emb_t2_1 + (-0.18045066297054291) * emb_t2_2 + (0.27553969621658325) * emb_t2_3 + (-0.10216351598501205) * emb_t2_4 + (-0.25471451878547668) * emb_t2_5 + (-0.84951281547546387) * emb_t2_6 + (-0.032789483666419983) * emb_t2_7 + (-0.27887484431266785) * emb_t2_8 + (0.41600000858306885) * emb_t2_9 + (0.89267796277999878) * emb_t2_10 + (0.23763236403465271) * emb_t2_11 + (-0.062552072107791901) * emb_t2_12 + (-0.70800107717514038) * emb_t2_13 + (-0.067132025957107544) * emb_t2_14 + (0.14265495538711548) * emb_t2_15 + (0.067372404038906097) * emb_t2_16 + (-0.25397962331771851) * emb_t2_17 + (0.62374836206436157) * emb_t2_18 + (-0.6575474739074707) * emb_t2_19 + (-0.10580789297819138) * emb_t2_20 + (0.065436460077762604) * emb_t2_21 + (0.32486039400100708) * emb_t2_22 + (-0.075660750269889832) * emb_t2_23 + (0.1511588841676712) * emb_t2_24 + (0.074822284281253815) * emb_t2_25 + (-0.10156043618917465) * emb_t2_26 + (-0.12224345654249191) * emb_t2_27 + (0.39430534839630127) * emb_t2_28 + (-0.47580116987228394) * emb_t2_29 + (0.27572977542877197) * emb_t2_30 + (0.33399310708045959) * emb_t2_31 + (-0.36428603529930115) * gru_0_fwd_t1_h_0 + (-0.97782361507415771) * gru_0_fwd_t1_h_1 + (-0.57410454750061035) * gru_0_fwd_t1_h_2 + (0.6566736102104187) * gru_0_fwd_t1_h_3 + (-1.2112106084823608) * gru_0_fwd_t1_h_4 + (0.41262859106063843) * gru_0_fwd_t1_h_5 + (1.0171276330947876) * gru_0_fwd_t1_h_6 + (0.68784201145172119) * gru_0_fwd_t1_h_7 + (-0.81705474853515625) * gru_0_fwd_t1_h_8 + (-0.89226329326629639) * gru_0_fwd_t1_h_9 + (0.55755019187927246) * gru_0_fwd_t1_h_10 + (-0.44155105948448181) * gru_0_fwd_t1_h_11 + (1.1925638914108276) * gru_0_fwd_t1_h_12 + (1.0589302778244019) * gru_0_fwd_t1_h_13 + (0.049674276262521744) * gru_0_fwd_t1_h_14 + (1.0742425918579102) * gru_0_fwd_t1_h_15 + (-0.2486003190279007) * gru_0_fwd_t1_h_16 + (-0.19188736379146576) * gru_0_fwd_t1_h_17 + (-0.25937572121620178) * gru_0_fwd_t1_h_18 + (-0.50415164232254028) * gru_0_fwd_t1_h_19 + (-1.4578251838684082) * gru_0_fwd_t1_h_20 + (-1.1739803552627563) * gru_0_fwd_t1_h_21 + (-0.016172729432582855) * gru_0_fwd_t1_h_22 + (0.93428677320480347) * gru_0_fwd_t1_h_23 + (-1.0509359836578369) * gru_0_fwd_t1_h_24 + (0.62188982963562012) * gru_0_fwd_t1_h_25 + (-0.52237957715988159) * gru_0_fwd_t1_h_26 + (-0.53212374448776245) * gru_0_fwd_t1_h_27 + (1.122877836227417) * gru_0_fwd_t1_h_28 + (-0.63721579313278198) * gru_0_fwd_t1_h_29 + (-0.45199927687644958) * gru_0_fwd_t1_h_30 + (0.63762730360031128) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.0026651120278984308) + (-0.0007670973427593708) * emb_t2_0 + (0.30098393559455872) * emb_t2_1 + (-0.0033250201959162951) * emb_t2_2 + (-0.071036316454410553) * emb_t2_3 + (-0.26820725202560425) * emb_t2_4 + (0.019483672454953194) * emb_t2_5 + (0.12064753472805023) * emb_t2_6 + (-0.0051138438284397125) * emb_t2_7 + (0.17796516418457031) * emb_t2_8 + (-1.4751404523849487) * emb_t2_9 + (-0.99466776847839355) * emb_t2_10 + (-0.017730532214045525) * emb_t2_11 + (0.12764541804790497) * emb_t2_12 + (0.42036482691764832) * emb_t2_13 + (0.0020732586272060871) * emb_t2_14 + (0.011034803465008736) * emb_t2_15 + (0.0069487877190113068) * emb_t2_16 + (0.24754548072814941) * emb_t2_17 + (-0.69944238662719727) * emb_t2_18 + (0.25500887632369995) * emb_t2_19 + (-0.18170234560966492) * emb_t2_20 + (0.004214264452457428) * emb_t2_21 + (-0.22800268232822418) * emb_t2_22 + (-0.017809022217988968) * emb_t2_23 + (0.0039610196836292744) * emb_t2_24 + (0.00044058103230781853) * emb_t2_25 + (0.0024200116749852896) * emb_t2_26 + (-0.003990312572568655) * emb_t2_27 + (0.075013726949691772) * emb_t2_28 + (0.53727042675018311) * emb_t2_29 + (-0.13611550629138947) * emb_t2_30 + (0.19305303692817688) * emb_t2_31 + gate_r * ((0.25899869203567505) + (0.16288661956787109) * gru_0_fwd_t1_h_0 + (-0.35113167762756348) * gru_0_fwd_t1_h_1 + (-0.18958817422389984) * gru_0_fwd_t1_h_2 + (0.94292402267456055) * gru_0_fwd_t1_h_3 + (0.23965242505073547) * gru_0_fwd_t1_h_4 + (0.45363539457321167) * gru_0_fwd_t1_h_5 + (1.3372179269790649) * gru_0_fwd_t1_h_6 + (-0.12373480945825577) * gru_0_fwd_t1_h_7 + (-0.97690945863723755) * gru_0_fwd_t1_h_8 + (-0.55289578437805176) * gru_0_fwd_t1_h_9 + (0.34432458877563477) * gru_0_fwd_t1_h_10 + (-0.23434913158416748) * gru_0_fwd_t1_h_11 + (0.48187974095344543) * gru_0_fwd_t1_h_12 + (-0.27376341819763184) * gru_0_fwd_t1_h_13 + (-0.0036491365171968937) * gru_0_fwd_t1_h_14 + (0.022629210725426674) * gru_0_fwd_t1_h_15 + (-0.056529335677623749) * gru_0_fwd_t1_h_16 + (-0.22381070256233215) * gru_0_fwd_t1_h_17 + (0.40684634447097778) * gru_0_fwd_t1_h_18 + (0.50929147005081177) * gru_0_fwd_t1_h_19 + (-0.63804280757904053) * gru_0_fwd_t1_h_20 + (-0.69697868824005127) * gru_0_fwd_t1_h_21 + (0.19814963638782501) * gru_0_fwd_t1_h_22 + (0.24296677112579346) * gru_0_fwd_t1_h_23 + (-0.19607749581336975) * gru_0_fwd_t1_h_24 + (0.084557957947254181) * gru_0_fwd_t1_h_25 + (0.034659907221794128) * gru_0_fwd_t1_h_26 + (0.25299382209777832) * gru_0_fwd_t1_h_27 + (0.20477312803268433) * gru_0_fwd_t1_h_28 + (0.53523534536361694) * gru_0_fwd_t1_h_29 + (0.44081112742424011) * gru_0_fwd_t1_h_30 + (0.21616044640541077) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_29 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_29;
    // h=30
    gate_r = sigmoid((-0.60926437377929688) + (-0.1737588495016098) * emb_t2_0 + (0.38025620579719543) * emb_t2_1 + (-0.23901283740997314) * emb_t2_2 + (0.14169171452522278) * emb_t2_3 + (0.3176858127117157) * emb_t2_4 + (0.54151701927185059) * emb_t2_5 + (0.0081971064209938049) * emb_t2_6 + (0.46974891424179077) * emb_t2_7 + (-0.13857337832450867) * emb_t2_8 + (0.36790543794631958) * emb_t2_9 + (-0.24031583964824677) * emb_t2_10 + (-0.1045849546790123) * emb_t2_11 + (-0.2426922470331192) * emb_t2_12 + (0.53255182504653931) * emb_t2_13 + (0.32064676284790039) * emb_t2_14 + (0.14229309558868408) * emb_t2_15 + (-0.67697983980178833) * emb_t2_16 + (0.34046971797943115) * emb_t2_17 + (0.57716649770736694) * emb_t2_18 + (-0.62413954734802246) * emb_t2_19 + (-0.75847715139389038) * emb_t2_20 + (0.26862534880638123) * emb_t2_21 + (0.46359333395957947) * emb_t2_22 + (-0.16749709844589233) * emb_t2_23 + (0.085932508111000061) * emb_t2_24 + (-0.041258085519075394) * emb_t2_25 + (-0.85725200176239014) * emb_t2_26 + (-0.67194253206253052) * emb_t2_27 + (-0.34857276082038879) * emb_t2_28 + (0.48101553320884705) * emb_t2_29 + (-0.35512596368789673) * emb_t2_30 + (0.039552904665470123) * emb_t2_31 + (-0.00027722973027266562) * gru_0_fwd_t1_h_0 + (0.13967601954936981) * gru_0_fwd_t1_h_1 + (-0.076582960784435272) * gru_0_fwd_t1_h_2 + (-0.031882289797067642) * gru_0_fwd_t1_h_3 + (-0.22067312896251678) * gru_0_fwd_t1_h_4 + (-0.15091697871685028) * gru_0_fwd_t1_h_5 + (-0.21777372062206268) * gru_0_fwd_t1_h_6 + (0.22374427318572998) * gru_0_fwd_t1_h_7 + (0.24008607864379883) * gru_0_fwd_t1_h_8 + (0.11101856082677841) * gru_0_fwd_t1_h_9 + (0.38299888372421265) * gru_0_fwd_t1_h_10 + (-0.074292056262493134) * gru_0_fwd_t1_h_11 + (-0.14499440789222717) * gru_0_fwd_t1_h_12 + (-0.28087863326072693) * gru_0_fwd_t1_h_13 + (-0.29889938235282898) * gru_0_fwd_t1_h_14 + (-0.049163069576025009) * gru_0_fwd_t1_h_15 + (0.60885560512542725) * gru_0_fwd_t1_h_16 + (-0.017051950097084045) * gru_0_fwd_t1_h_17 + (-0.29631364345550537) * gru_0_fwd_t1_h_18 + (-0.15292312204837799) * gru_0_fwd_t1_h_19 + (0.16586235165596008) * gru_0_fwd_t1_h_20 + (0.73832559585571289) * gru_0_fwd_t1_h_21 + (0.10271792113780975) * gru_0_fwd_t1_h_22 + (-0.25901055335998535) * gru_0_fwd_t1_h_23 + (-0.15158264338970184) * gru_0_fwd_t1_h_24 + (0.010116232559084892) * gru_0_fwd_t1_h_25 + (-0.15553593635559082) * gru_0_fwd_t1_h_26 + (0.14589026570320129) * gru_0_fwd_t1_h_27 + (0.015231951139867306) * gru_0_fwd_t1_h_28 + (0.11976413428783417) * gru_0_fwd_t1_h_29 + (-0.171246737241745) * gru_0_fwd_t1_h_30 + (-0.16328799724578857) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((3.5595059394836426) + (-0.11819758266210556) * emb_t2_0 + (0.46444812417030334) * emb_t2_1 + (0.099807538092136383) * emb_t2_2 + (1.3323699235916138) * emb_t2_3 + (0.063966400921344757) * emb_t2_4 + (-0.04518963024020195) * emb_t2_5 + (0.0052352412603795528) * emb_t2_6 + (-0.71445292234420776) * emb_t2_7 + (13.063044548034668) * emb_t2_8 + (-1.0494433641433716) * emb_t2_9 + (-1.3069334030151367) * emb_t2_10 + (2.086686372756958) * emb_t2_11 + (15.495023727416992) * emb_t2_12 + (0.13620203733444214) * emb_t2_13 + (0.10010219365358353) * emb_t2_14 + (0.039625681936740875) * emb_t2_15 + (0.29575812816619873) * emb_t2_16 + (-0.21675293147563934) * emb_t2_17 + (-1.9148987531661987) * emb_t2_18 + (1.6983498334884644) * emb_t2_19 + (0.72538363933563232) * emb_t2_20 + (-0.058488767594099045) * emb_t2_21 + (-3.0187828540802002) * emb_t2_22 + (-0.043490733951330185) * emb_t2_23 + (0.18401242792606354) * emb_t2_24 + (0.0079329926520586014) * emb_t2_25 + (0.3969980776309967) * emb_t2_26 + (0.10597033798694611) * emb_t2_27 + (-0.39887553453445435) * emb_t2_28 + (0.24764560163021088) * emb_t2_29 + (0.010339950211346149) * emb_t2_30 + (-26.064796447753906) * emb_t2_31 + (-0.03930971771478653) * gru_0_fwd_t1_h_0 + (-0.063254229724407196) * gru_0_fwd_t1_h_1 + (-0.17143750190734863) * gru_0_fwd_t1_h_2 + (-0.22121824324131012) * gru_0_fwd_t1_h_3 + (0.081121601164340973) * gru_0_fwd_t1_h_4 + (-0.17711508274078369) * gru_0_fwd_t1_h_5 + (0.053732555359601974) * gru_0_fwd_t1_h_6 + (-0.013868593610823154) * gru_0_fwd_t1_h_7 + (-0.21183019876480103) * gru_0_fwd_t1_h_8 + (-0.079803653061389923) * gru_0_fwd_t1_h_9 + (0.13144606351852417) * gru_0_fwd_t1_h_10 + (0.27198252081871033) * gru_0_fwd_t1_h_11 + (-0.26403969526290894) * gru_0_fwd_t1_h_12 + (0.09865175187587738) * gru_0_fwd_t1_h_13 + (-0.16335944831371307) * gru_0_fwd_t1_h_14 + (0.13145570456981659) * gru_0_fwd_t1_h_15 + (0.0071426434442400932) * gru_0_fwd_t1_h_16 + (-0.073695704340934753) * gru_0_fwd_t1_h_17 + (-0.04787876084446907) * gru_0_fwd_t1_h_18 + (-0.12485899031162262) * gru_0_fwd_t1_h_19 + (-0.0693960040807724) * gru_0_fwd_t1_h_20 + (-0.10138034075498581) * gru_0_fwd_t1_h_21 + (0.38854435086250305) * gru_0_fwd_t1_h_22 + (-0.085076592862606049) * gru_0_fwd_t1_h_23 + (-0.20835670828819275) * gru_0_fwd_t1_h_24 + (0.11841475963592529) * gru_0_fwd_t1_h_25 + (-0.21061988174915314) * gru_0_fwd_t1_h_26 + (-0.40929943323135376) * gru_0_fwd_t1_h_27 + (0.25362920761108398) * gru_0_fwd_t1_h_28 + (-0.31492403149604797) * gru_0_fwd_t1_h_29 + (-0.18786926567554474) * gru_0_fwd_t1_h_30 + (-0.36842077970504761) * gru_0_fwd_t1_h_31);
    gate_n = tanh((-0.08687765896320343) + (0.16526171565055847) * emb_t2_0 + (-0.32881477475166321) * emb_t2_1 + (0.27678346633911133) * emb_t2_2 + (0.027460221201181412) * emb_t2_3 + (-0.44662627577781677) * emb_t2_4 + (0.064712986350059509) * emb_t2_5 + (-0.75604557991027832) * emb_t2_6 + (0.64118564128875732) * emb_t2_7 + (-1.3876652717590332) * emb_t2_8 + (0.39513736963272095) * emb_t2_9 + (0.78433924913406372) * emb_t2_10 + (-0.50290870666503906) * emb_t2_11 + (-1.2582765817642212) * emb_t2_12 + (-0.48526936769485474) * emb_t2_13 + (-0.14105387032032013) * emb_t2_14 + (0.23871798813343048) * emb_t2_15 + (0.16358593106269836) * emb_t2_16 + (-0.46926319599151611) * emb_t2_17 + (0.3503749668598175) * emb_t2_18 + (-0.60224151611328125) * emb_t2_19 + (-0.038888074457645416) * emb_t2_20 + (-0.0082476558163762093) * emb_t2_21 + (0.71288597583770752) * emb_t2_22 + (0.18342132866382599) * emb_t2_23 + (0.063889488577842712) * emb_t2_24 + (-0.18233002722263336) * emb_t2_25 + (0.31547543406486511) * emb_t2_26 + (0.31835886836051941) * emb_t2_27 + (0.63821768760681152) * emb_t2_28 + (-0.47004371881484985) * emb_t2_29 + (0.2905077338218689) * emb_t2_30 + (1.4950629472732544) * emb_t2_31 + gate_r * ((-0.12416427582502365) + (0.14524014294147491) * gru_0_fwd_t1_h_0 + (-0.048091653734445572) * gru_0_fwd_t1_h_1 + (-0.20196244120597839) * gru_0_fwd_t1_h_2 + (-0.034997005015611649) * gru_0_fwd_t1_h_3 + (0.11581975966691971) * gru_0_fwd_t1_h_4 + (0.043937698006629944) * gru_0_fwd_t1_h_5 + (-0.24249815940856934) * gru_0_fwd_t1_h_6 + (0.072261504828929901) * gru_0_fwd_t1_h_7 + (0.28045105934143066) * gru_0_fwd_t1_h_8 + (0.10529207438230515) * gru_0_fwd_t1_h_9 + (0.084984160959720612) * gru_0_fwd_t1_h_10 + (0.074663154780864716) * gru_0_fwd_t1_h_11 + (0.012277777306735516) * gru_0_fwd_t1_h_12 + (-0.20052669942378998) * gru_0_fwd_t1_h_13 + (0.038231607526540756) * gru_0_fwd_t1_h_14 + (-0.14791277050971985) * gru_0_fwd_t1_h_15 + (0.33751910924911499) * gru_0_fwd_t1_h_16 + (0.037267103791236877) * gru_0_fwd_t1_h_17 + (-0.14503590762615204) * gru_0_fwd_t1_h_18 + (-0.30621060729026794) * gru_0_fwd_t1_h_19 + (0.16484667360782623) * gru_0_fwd_t1_h_20 + (0.40561693906784058) * gru_0_fwd_t1_h_21 + (0.11365178227424622) * gru_0_fwd_t1_h_22 + (-0.10142455995082855) * gru_0_fwd_t1_h_23 + (-0.070976734161376953) * gru_0_fwd_t1_h_24 + (0.11741837859153748) * gru_0_fwd_t1_h_25 + (0.21560783684253693) * gru_0_fwd_t1_h_26 + (-0.36539861559867859) * gru_0_fwd_t1_h_27 + (-0.032710321247577667) * gru_0_fwd_t1_h_28 + (0.00060825917171314359) * gru_0_fwd_t1_h_29 + (-0.14171038568019867) * gru_0_fwd_t1_h_30 + (-0.29205510020256042) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_30 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_30;
    // h=31
    gate_r = sigmoid((1.1197860240936279) + (0.82189655303955078) * emb_t2_0 + (0.84979915618896484) * emb_t2_1 + (0.63162010908126831) * emb_t2_2 + (0.59661942720413208) * emb_t2_3 + (-0.26328656077384949) * emb_t2_4 + (-0.74788320064544678) * emb_t2_5 + (0.042410414665937424) * emb_t2_6 + (-0.86037814617156982) * emb_t2_7 + (0.69385504722595215) * emb_t2_8 + (-1.1680564880371094) * emb_t2_9 + (-0.36268532276153564) * emb_t2_10 + (0.5741237998008728) * emb_t2_11 + (0.80066180229187012) * emb_t2_12 + (0.3629651665687561) * emb_t2_13 + (-0.48242610692977905) * emb_t2_14 + (0.36558768153190613) * emb_t2_15 + (1.2318867444992065) * emb_t2_16 + (-0.26140722632408142) * emb_t2_17 + (-1.0478253364562988) * emb_t2_18 + (1.1572840213775635) * emb_t2_19 + (0.58639121055603027) * emb_t2_20 + (-0.42898482084274292) * emb_t2_21 + (-0.49490630626678467) * emb_t2_22 + (-0.025686496868729591) * emb_t2_23 + (-0.032259661704301834) * emb_t2_24 + (-0.58412003517150879) * emb_t2_25 + (0.042390689253807068) * emb_t2_26 + (-0.014617961831390858) * emb_t2_27 + (-0.45873472094535828) * emb_t2_28 + (0.76545733213424683) * emb_t2_29 + (-0.11830274760723114) * emb_t2_30 + (-0.82707095146179199) * emb_t2_31 + (-0.11377521604299545) * gru_0_fwd_t1_h_0 + (0.49484780430793762) * gru_0_fwd_t1_h_1 + (0.14865636825561523) * gru_0_fwd_t1_h_2 + (1.0188875198364258) * gru_0_fwd_t1_h_3 + (0.79360133409500122) * gru_0_fwd_t1_h_4 + (0.88067495822906494) * gru_0_fwd_t1_h_5 + (-3.5741405487060547) * gru_0_fwd_t1_h_6 + (-0.080673180520534515) * gru_0_fwd_t1_h_7 + (0.3026549220085144) * gru_0_fwd_t1_h_8 + (1.10136878490448) * gru_0_fwd_t1_h_9 + (0.030721839517354965) * gru_0_fwd_t1_h_10 + (0.24231904745101929) * gru_0_fwd_t1_h_11 + (-0.25698202848434448) * gru_0_fwd_t1_h_12 + (-0.79313129186630249) * gru_0_fwd_t1_h_13 + (0.38349774479866028) * gru_0_fwd_t1_h_14 + (0.88436049222946167) * gru_0_fwd_t1_h_15 + (0.047915004193782806) * gru_0_fwd_t1_h_16 + (0.10697253048419952) * gru_0_fwd_t1_h_17 + (1.5925276279449463) * gru_0_fwd_t1_h_18 + (0.94665277004241943) * gru_0_fwd_t1_h_19 + (2.1543376445770264) * gru_0_fwd_t1_h_20 + (0.22832992672920227) * gru_0_fwd_t1_h_21 + (0.074176594614982605) * gru_0_fwd_t1_h_22 + (-0.4923250675201416) * gru_0_fwd_t1_h_23 + (1.8622615337371826) * gru_0_fwd_t1_h_24 + (0.26764729619026184) * gru_0_fwd_t1_h_25 + (1.0227169990539551) * gru_0_fwd_t1_h_26 + (0.71264427900314331) * gru_0_fwd_t1_h_27 + (-0.56702607870101929) * gru_0_fwd_t1_h_28 + (1.5039618015289307) * gru_0_fwd_t1_h_29 + (0.42466428875923157) * gru_0_fwd_t1_h_30 + (-2.046318531036377) * gru_0_fwd_t1_h_31);
    gate_z = sigmoid((0.93570268154144287) + (0.027945071458816528) * emb_t2_0 + (-0.29999658465385437) * emb_t2_1 + (0.37092065811157227) * emb_t2_2 + (0.11785808950662613) * emb_t2_3 + (-0.42889499664306641) * emb_t2_4 + (0.025375081226229668) * emb_t2_5 + (-0.013721304945647717) * emb_t2_6 + (-0.28716537356376648) * emb_t2_7 + (0.52241778373718262) * emb_t2_8 + (0.20057013630867004) * emb_t2_9 + (0.043395094573497772) * emb_t2_10 + (0.33710560202598572) * emb_t2_11 + (0.53270399570465088) * emb_t2_12 + (-0.6542210578918457) * emb_t2_13 + (0.28734761476516724) * emb_t2_14 + (0.11672159284353256) * emb_t2_15 + (0.20078630745410919) * emb_t2_16 + (-0.63615882396697998) * emb_t2_17 + (0.022169522941112518) * emb_t2_18 + (0.61556482315063477) * emb_t2_19 + (0.56159460544586182) * emb_t2_20 + (0.2355131208896637) * emb_t2_21 + (-0.58501154184341431) * emb_t2_22 + (-0.23210981488227844) * emb_t2_23 + (0.043808095157146454) * emb_t2_24 + (-0.00083580572390928864) * emb_t2_25 + (0.48075786232948303) * emb_t2_26 + (0.1017712876200676) * emb_t2_27 + (0.35832160711288452) * emb_t2_28 + (-0.19724997878074646) * emb_t2_29 + (1.0564422607421875) * emb_t2_30 + (-0.51558518409729004) * emb_t2_31 + (-0.052631378173828125) * gru_0_fwd_t1_h_0 + (0.12540276348590851) * gru_0_fwd_t1_h_1 + (-0.40728402137756348) * gru_0_fwd_t1_h_2 + (0.45038846135139465) * gru_0_fwd_t1_h_3 + (0.0069151311181485653) * gru_0_fwd_t1_h_4 + (0.043897204101085663) * gru_0_fwd_t1_h_5 + (-0.51441150903701782) * gru_0_fwd_t1_h_6 + (0.54450982809066772) * gru_0_fwd_t1_h_7 + (0.93323218822479248) * gru_0_fwd_t1_h_8 + (-0.20096880197525024) * gru_0_fwd_t1_h_9 + (0.41260793805122375) * gru_0_fwd_t1_h_10 + (0.21722094714641571) * gru_0_fwd_t1_h_11 + (-0.21869494020938873) * gru_0_fwd_t1_h_12 + (-0.59330326318740845) * gru_0_fwd_t1_h_13 + (0.28238683938980103) * gru_0_fwd_t1_h_14 + (0.31732171773910522) * gru_0_fwd_t1_h_15 + (0.0050415699370205402) * gru_0_fwd_t1_h_16 + (-0.53080970048904419) * gru_0_fwd_t1_h_17 + (0.40165555477142334) * gru_0_fwd_t1_h_18 + (0.37447160482406616) * gru_0_fwd_t1_h_19 + (-0.41426545381546021) * gru_0_fwd_t1_h_20 + (-0.95179545879364014) * gru_0_fwd_t1_h_21 + (0.78936189413070679) * gru_0_fwd_t1_h_22 + (-1.1169302463531494) * gru_0_fwd_t1_h_23 + (-1.5654652118682861) * gru_0_fwd_t1_h_24 + (-0.13280864059925079) * gru_0_fwd_t1_h_25 + (-3.115680456161499) * gru_0_fwd_t1_h_26 + (0.34119254350662231) * gru_0_fwd_t1_h_27 + (-0.64078515768051147) * gru_0_fwd_t1_h_28 + (-0.21707659959793091) * gru_0_fwd_t1_h_29 + (0.17915607988834381) * gru_0_fwd_t1_h_30 + (0.49229168891906738) * gru_0_fwd_t1_h_31);
    gate_n = tanh((0.059556685388088226) + (0.0093570752069354057) * emb_t2_0 + (-0.14118006825447083) * emb_t2_1 + (0.27748677134513855) * emb_t2_2 + (0.13478186726570129) * emb_t2_3 + (-0.096241101622581482) * emb_t2_4 + (0.028125690296292305) * emb_t2_5 + (-0.21943745017051697) * emb_t2_6 + (-0.040820885449647903) * emb_t2_7 + (0.015611233189702034) * emb_t2_8 + (-0.026535511016845703) * emb_t2_9 + (0.11295320093631744) * emb_t2_10 + (0.1657504141330719) * emb_t2_11 + (0.30802986025810242) * emb_t2_12 + (-0.19599159061908722) * emb_t2_13 + (0.051283437758684158) * emb_t2_14 + (0.01581161841750145) * emb_t2_15 + (0.16965529322624207) * emb_t2_16 + (0.17486566305160522) * emb_t2_17 + (-0.3228529691696167) * emb_t2_18 + (0.04059198871254921) * emb_t2_19 + (0.10199558734893799) * emb_t2_20 + (0.044503945857286453) * emb_t2_21 + (-0.3532220721244812) * emb_t2_22 + (0.072760716080665588) * emb_t2_23 + (-0.031821347773075104) * emb_t2_24 + (-0.00347660924308002) * emb_t2_25 + (-0.068912975490093231) * emb_t2_26 + (0.12479005008935928) * emb_t2_27 + (0.0084166890010237694) * emb_t2_28 + (-0.074207529425621033) * emb_t2_29 + (-0.19051642715930939) * emb_t2_30 + (-0.29854661226272583) * emb_t2_31 + gate_r * ((0.093639783561229706) + (-0.26055413484573364) * gru_0_fwd_t1_h_0 + (-0.095837920904159546) * gru_0_fwd_t1_h_1 + (0.038966912776231766) * gru_0_fwd_t1_h_2 + (0.014310726895928383) * gru_0_fwd_t1_h_3 + (-0.049272693693637848) * gru_0_fwd_t1_h_4 + (0.22457613050937653) * gru_0_fwd_t1_h_5 + (1.4724425077438354) * gru_0_fwd_t1_h_6 + (-0.077588565647602081) * gru_0_fwd_t1_h_7 + (0.097471266984939575) * gru_0_fwd_t1_h_8 + (-0.55311673879623413) * gru_0_fwd_t1_h_9 + (-0.13370458781719208) * gru_0_fwd_t1_h_10 + (-0.25395268201828003) * gru_0_fwd_t1_h_11 + (0.4308381974697113) * gru_0_fwd_t1_h_12 + (0.25299379229545593) * gru_0_fwd_t1_h_13 + (-0.29430118203163147) * gru_0_fwd_t1_h_14 + (-0.014947656542062759) * gru_0_fwd_t1_h_15 + (0.022595809772610664) * gru_0_fwd_t1_h_16 + (0.54277259111404419) * gru_0_fwd_t1_h_17 + (-0.35988220572471619) * gru_0_fwd_t1_h_18 + (1.1189311742782593) * gru_0_fwd_t1_h_19 + (0.42105749249458313) * gru_0_fwd_t1_h_20 + (0.31713798642158508) * gru_0_fwd_t1_h_21 + (-0.59697574377059937) * gru_0_fwd_t1_h_22 + (0.041749343276023865) * gru_0_fwd_t1_h_23 + (-0.99520927667617798) * gru_0_fwd_t1_h_24 + (0.28341895341873169) * gru_0_fwd_t1_h_25 + (2.939974308013916) * gru_0_fwd_t1_h_26 + (0.26471617817878723) * gru_0_fwd_t1_h_27 + (-0.81368362903594971) * gru_0_fwd_t1_h_28 + (-0.32824662327766418) * gru_0_fwd_t1_h_29 + (-0.31704512238502502) * gru_0_fwd_t1_h_30 + (1.2399663925170898) * gru_0_fwd_t1_h_31));
    gru_0_fwd_t2_h_31 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t1_h_31;

    // FW step t=3
    // h=0
    gate_r = sigmoid((-0.63586723804473877) + (0.25612789392471313) * emb_t3_0 + (0.20511561632156372) * emb_t3_1 + (-0.059482339769601822) * emb_t3_2 + (-0.3379744291305542) * emb_t3_3 + (0.070997722446918488) * emb_t3_4 + (0.24011668562889099) * emb_t3_5 + (0.54058331251144409) * emb_t3_6 + (0.050093494355678558) * emb_t3_7 + (-0.20927594602108002) * emb_t3_8 + (0.62939280271530151) * emb_t3_9 + (0.040228515863418579) * emb_t3_10 + (0.049732539802789688) * emb_t3_11 + (-0.37557637691497803) * emb_t3_12 + (0.37011173367500305) * emb_t3_13 + (-0.30297467112541199) * emb_t3_14 + (0.062840230762958527) * emb_t3_15 + (-0.077686019241809845) * emb_t3_16 + (0.00018224099767394364) * emb_t3_17 + (0.64129030704498291) * emb_t3_18 + (-0.25011655688285828) * emb_t3_19 + (-0.35314306616783142) * emb_t3_20 + (-0.65542095899581909) * emb_t3_21 + (-0.026311812922358513) * emb_t3_22 + (0.22445248067378998) * emb_t3_23 + (-0.46241691708564758) * emb_t3_24 + (0.47750246524810791) * emb_t3_25 + (-0.23792253434658051) * emb_t3_26 + (-0.09793505072593689) * emb_t3_27 + (-0.60475265979766846) * emb_t3_28 + (0.27672046422958374) * emb_t3_29 + (-0.28143492341041565) * emb_t3_30 + (0.26639610528945923) * emb_t3_31 + (0.39939281344413757) * gru_0_fwd_t2_h_0 + (-0.45239430665969849) * gru_0_fwd_t2_h_1 + (0.51542329788208008) * gru_0_fwd_t2_h_2 + (1.1852349042892456) * gru_0_fwd_t2_h_3 + (-0.57260710000991821) * gru_0_fwd_t2_h_4 + (0.4299236536026001) * gru_0_fwd_t2_h_5 + (1.5196936130523682) * gru_0_fwd_t2_h_6 + (-0.62232279777526855) * gru_0_fwd_t2_h_7 + (-0.0047591947950422764) * gru_0_fwd_t2_h_8 + (-1.1724215745925903) * gru_0_fwd_t2_h_9 + (-0.089997418224811554) * gru_0_fwd_t2_h_10 + (0.98156434297561646) * gru_0_fwd_t2_h_11 + (0.43952465057373047) * gru_0_fwd_t2_h_12 + (-0.30990126729011536) * gru_0_fwd_t2_h_13 + (-0.19336289167404175) * gru_0_fwd_t2_h_14 + (1.0875648260116577) * gru_0_fwd_t2_h_15 + (0.31760719418525696) * gru_0_fwd_t2_h_16 + (0.037163529545068741) * gru_0_fwd_t2_h_17 + (-0.33116120100021362) * gru_0_fwd_t2_h_18 + (-0.68276423215866089) * gru_0_fwd_t2_h_19 + (-0.38833123445510864) * gru_0_fwd_t2_h_20 + (-0.2306981086730957) * gru_0_fwd_t2_h_21 + (-0.068562164902687073) * gru_0_fwd_t2_h_22 + (0.14103168249130249) * gru_0_fwd_t2_h_23 + (-0.29763594269752502) * gru_0_fwd_t2_h_24 + (-0.24194538593292236) * gru_0_fwd_t2_h_25 + (0.5872117280960083) * gru_0_fwd_t2_h_26 + (0.31708100438117981) * gru_0_fwd_t2_h_27 + (-0.027148989960551262) * gru_0_fwd_t2_h_28 + (-1.2354743480682373) * gru_0_fwd_t2_h_29 + (-0.48650023341178894) * gru_0_fwd_t2_h_30 + (2.7708353996276855) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((-0.1805730015039444) + (-0.1730819046497345) * emb_t3_0 + (0.99021154642105103) * emb_t3_1 + (-0.19890351593494415) * emb_t3_2 + (-0.59255599975585938) * emb_t3_3 + (1.2440937757492065) * emb_t3_4 + (0.30739772319793701) * emb_t3_5 + (0.70177561044692993) * emb_t3_6 + (0.019682634621858597) * emb_t3_7 + (-0.077413111925125122) * emb_t3_8 + (-0.50500905513763428) * emb_t3_9 + (-0.67638945579528809) * emb_t3_10 + (-0.026483789086341858) * emb_t3_11 + (0.23927073180675507) * emb_t3_12 + (0.54627126455307007) * emb_t3_13 + (0.1137111634016037) * emb_t3_14 + (-0.038617175072431564) * emb_t3_15 + (-0.12933528423309326) * emb_t3_16 + (0.11861786246299744) * emb_t3_17 + (-0.36897361278533936) * emb_t3_18 + (0.26175644993782043) * emb_t3_19 + (-0.27793017029762268) * emb_t3_20 + (-0.24079181253910065) * emb_t3_21 + (0.38042914867401123) * emb_t3_22 + (0.0097168097272515297) * emb_t3_23 + (-0.063354566693305969) * emb_t3_24 + (0.13164801895618439) * emb_t3_25 + (-0.70986056327819824) * emb_t3_26 + (-0.030485551804304123) * emb_t3_27 + (-0.99285542964935303) * emb_t3_28 + (1.2676990032196045) * emb_t3_29 + (-1.3924852609634399) * emb_t3_30 + (-0.066610008478164673) * emb_t3_31 + (0.048599831759929657) * gru_0_fwd_t2_h_0 + (0.24509155750274658) * gru_0_fwd_t2_h_1 + (-1.980970025062561) * gru_0_fwd_t2_h_2 + (-1.600147008895874) * gru_0_fwd_t2_h_3 + (-0.054658118635416031) * gru_0_fwd_t2_h_4 + (-0.072297543287277222) * gru_0_fwd_t2_h_5 + (1.8688979148864746) * gru_0_fwd_t2_h_6 + (2.1074397563934326) * gru_0_fwd_t2_h_7 + (0.19694878160953522) * gru_0_fwd_t2_h_8 + (-1.5771154165267944) * gru_0_fwd_t2_h_9 + (1.4935240745544434) * gru_0_fwd_t2_h_10 + (0.013767411932349205) * gru_0_fwd_t2_h_11 + (0.17914442718029022) * gru_0_fwd_t2_h_12 + (0.033899158239364624) * gru_0_fwd_t2_h_13 + (0.050818316638469696) * gru_0_fwd_t2_h_14 + (-0.17568990588188171) * gru_0_fwd_t2_h_15 + (-0.38448107242584229) * gru_0_fwd_t2_h_16 + (-0.20525273680686951) * gru_0_fwd_t2_h_17 + (0.048907119780778885) * gru_0_fwd_t2_h_18 + (-0.4544963538646698) * gru_0_fwd_t2_h_19 + (-1.2446156740188599) * gru_0_fwd_t2_h_20 + (-0.46960261464118958) * gru_0_fwd_t2_h_21 + (0.057055030018091202) * gru_0_fwd_t2_h_22 + (-0.11502393335103989) * gru_0_fwd_t2_h_23 + (0.93711066246032715) * gru_0_fwd_t2_h_24 + (1.0189545154571533) * gru_0_fwd_t2_h_25 + (0.25243127346038818) * gru_0_fwd_t2_h_26 + (0.21382462978363037) * gru_0_fwd_t2_h_27 + (0.13708734512329102) * gru_0_fwd_t2_h_28 + (0.56444734334945679) * gru_0_fwd_t2_h_29 + (-0.042037498205900192) * gru_0_fwd_t2_h_30 + (-1.8988234996795654) * gru_0_fwd_t2_h_31);
    gate_n = tanh((-0.098105855286121368) + (-0.006110471673309803) * emb_t3_0 + (-0.16757895052433014) * emb_t3_1 + (-0.0028194685000926256) * emb_t3_2 + (0.067232899367809296) * emb_t3_3 + (0.074285827577114105) * emb_t3_4 + (-0.060071688145399094) * emb_t3_5 + (-0.098569884896278381) * emb_t3_6 + (-0.044600673019886017) * emb_t3_7 + (0.14502266049385071) * emb_t3_8 + (0.61696690320968628) * emb_t3_9 + (0.60714042186737061) * emb_t3_10 + (-0.15376155078411102) * emb_t3_11 + (-0.14660400152206421) * emb_t3_12 + (-0.59865099191665649) * emb_t3_13 + (0.021863484755158424) * emb_t3_14 + (0.019111357629299164) * emb_t3_15 + (0.061020586639642715) * emb_t3_16 + (-0.17076332867145538) * emb_t3_17 + (0.45876485109329224) * emb_t3_18 + (-0.16259600222110748) * emb_t3_19 + (-0.09534762054681778) * emb_t3_20 + (0.063709385693073273) * emb_t3_21 + (0.45876595377922058) * emb_t3_22 + (-0.014692286029458046) * emb_t3_23 + (0.037582259625196457) * emb_t3_24 + (-0.029277998954057693) * emb_t3_25 + (-0.42821526527404785) * emb_t3_26 + (-0.00062267959583550692) * emb_t3_27 + (0.28537830710411072) * emb_t3_28 + (-0.16059227287769318) * emb_t3_29 + (0.58637130260467529) * emb_t3_30 + (-0.053730327636003494) * emb_t3_31 + gate_r * ((0.27915149927139282) + (-0.38889393210411072) * gru_0_fwd_t2_h_0 + (-0.092167168855667114) * gru_0_fwd_t2_h_1 + (-0.58291137218475342) * gru_0_fwd_t2_h_2 + (-1.1983227729797363) * gru_0_fwd_t2_h_3 + (0.088861025869846344) * gru_0_fwd_t2_h_4 + (-0.40719360113143921) * gru_0_fwd_t2_h_5 + (1.7541582584381104) * gru_0_fwd_t2_h_6 + (0.96002089977264404) * gru_0_fwd_t2_h_7 + (-0.020488433539867401) * gru_0_fwd_t2_h_8 + (-0.62128281593322754) * gru_0_fwd_t2_h_9 + (0.27136930823326111) * gru_0_fwd_t2_h_10 + (-1.2635856866836548) * gru_0_fwd_t2_h_11 + (0.10848518460988998) * gru_0_fwd_t2_h_12 + (0.5185091495513916) * gru_0_fwd_t2_h_13 + (0.29575502872467041) * gru_0_fwd_t2_h_14 + (0.21881890296936035) * gru_0_fwd_t2_h_15 + (-0.26780650019645691) * gru_0_fwd_t2_h_16 + (-0.17633502185344696) * gru_0_fwd_t2_h_17 + (-0.046199630945920944) * gru_0_fwd_t2_h_18 + (0.30445775389671326) * gru_0_fwd_t2_h_19 + (-0.46879208087921143) * gru_0_fwd_t2_h_20 + (-0.23298667371273041) * gru_0_fwd_t2_h_21 + (-0.38246411085128784) * gru_0_fwd_t2_h_22 + (0.017062928527593613) * gru_0_fwd_t2_h_23 + (1.7557300329208374) * gru_0_fwd_t2_h_24 + (0.053831141442060471) * gru_0_fwd_t2_h_25 + (-0.25340673327445984) * gru_0_fwd_t2_h_26 + (0.08145345002412796) * gru_0_fwd_t2_h_27 + (-0.56892961263656616) * gru_0_fwd_t2_h_28 + (1.0762699842453003) * gru_0_fwd_t2_h_29 + (0.33208164572715759) * gru_0_fwd_t2_h_30 + (-1.4441461563110352) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_0 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_0;
    // h=1
    gate_r = sigmoid((-0.47315943241119385) + (-0.20197930932044983) * emb_t3_0 + (0.3900463879108429) * emb_t3_1 + (-0.91626137495040894) * emb_t3_2 + (-0.80037456750869751) * emb_t3_3 + (0.54234069585800171) * emb_t3_4 + (0.56150758266448975) * emb_t3_5 + (0.086490333080291748) * emb_t3_6 + (0.11938868463039398) * emb_t3_7 + (-0.35315313935279846) * emb_t3_8 + (0.22998486459255219) * emb_t3_9 + (-0.21408471465110779) * emb_t3_10 + (-0.39615523815155029) * emb_t3_11 + (-0.06396804004907608) * emb_t3_12 + (0.24132311344146729) * emb_t3_13 + (0.40227016806602478) * emb_t3_14 + (0.26782363653182983) * emb_t3_15 + (-0.51870536804199219) * emb_t3_16 + (-0.1805369108915329) * emb_t3_17 + (-0.31617352366447449) * emb_t3_18 + (0.0055455435067415237) * emb_t3_19 + (-0.2888895571231842) * emb_t3_20 + (-0.50013643503189087) * emb_t3_21 + (0.32653516530990601) * emb_t3_22 + (-0.0013026917586103082) * emb_t3_23 + (0.13138106465339661) * emb_t3_24 + (-0.63240700960159302) * emb_t3_25 + (-0.5113060474395752) * emb_t3_26 + (-0.18826660513877869) * emb_t3_27 + (-0.18575501441955566) * emb_t3_28 + (0.38022315502166748) * emb_t3_29 + (-0.14143200218677521) * emb_t3_30 + (0.28079184889793396) * emb_t3_31 + (0.25332635641098022) * gru_0_fwd_t2_h_0 + (0.62572824954986572) * gru_0_fwd_t2_h_1 + (0.38907268643379211) * gru_0_fwd_t2_h_2 + (2.1785023212432861) * gru_0_fwd_t2_h_3 + (0.35492026805877686) * gru_0_fwd_t2_h_4 + (-0.55905872583389282) * gru_0_fwd_t2_h_5 + (-0.15405474603176117) * gru_0_fwd_t2_h_6 + (-0.60063296556472778) * gru_0_fwd_t2_h_7 + (-0.2269970029592514) * gru_0_fwd_t2_h_8 + (-0.66512209177017212) * gru_0_fwd_t2_h_9 + (-0.52616441249847412) * gru_0_fwd_t2_h_10 + (0.3572535514831543) * gru_0_fwd_t2_h_11 + (-0.51676905155181885) * gru_0_fwd_t2_h_12 + (-0.4776788055896759) * gru_0_fwd_t2_h_13 + (-0.049878422170877457) * gru_0_fwd_t2_h_14 + (-0.16086640954017639) * gru_0_fwd_t2_h_15 + (-0.23704136908054352) * gru_0_fwd_t2_h_16 + (-0.36966648697853088) * gru_0_fwd_t2_h_17 + (0.54794615507125854) * gru_0_fwd_t2_h_18 + (-0.4142346978187561) * gru_0_fwd_t2_h_19 + (-0.49277323484420776) * gru_0_fwd_t2_h_20 + (-0.045853972434997559) * gru_0_fwd_t2_h_21 + (0.55593365430831909) * gru_0_fwd_t2_h_22 + (0.3110499382019043) * gru_0_fwd_t2_h_23 + (0.86221796274185181) * gru_0_fwd_t2_h_24 + (-0.20161892473697662) * gru_0_fwd_t2_h_25 + (2.4296295642852783) * gru_0_fwd_t2_h_26 + (-0.08931434154510498) * gru_0_fwd_t2_h_27 + (0.23503243923187256) * gru_0_fwd_t2_h_28 + (-0.063249334692955017) * gru_0_fwd_t2_h_29 + (0.23077639937400818) * gru_0_fwd_t2_h_30 + (1.1132805347442627) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((-0.081969015300273895) + (-0.040738023817539215) * emb_t3_0 + (1.3161453008651733) * emb_t3_1 + (0.094650112092494965) * emb_t3_2 + (-0.25734174251556396) * emb_t3_3 + (0.1212867945432663) * emb_t3_4 + (0.0084351236000657082) * emb_t3_5 + (1.317499041557312) * emb_t3_6 + (0.097850881516933441) * emb_t3_7 + (0.093310289084911346) * emb_t3_8 + (-0.55444943904876709) * emb_t3_9 + (-0.083038963377475739) * emb_t3_10 + (-0.079097941517829895) * emb_t3_11 + (0.19021616876125336) * emb_t3_12 + (1.1669929027557373) * emb_t3_13 + (-0.09754655510187149) * emb_t3_14 + (-0.20385529100894928) * emb_t3_15 + (0.099251508712768555) * emb_t3_16 + (0.18394295871257782) * emb_t3_17 + (-0.30976629257202148) * emb_t3_18 + (-0.094525299966335297) * emb_t3_19 + (0.0028359678108245134) * emb_t3_20 + (-0.24470433592796326) * emb_t3_21 + (0.055819042026996613) * emb_t3_22 + (0.4079681932926178) * emb_t3_23 + (-0.19975447654724121) * emb_t3_24 + (0.24829433858394623) * emb_t3_25 + (-0.37130647897720337) * emb_t3_26 + (0.1413697749376297) * emb_t3_27 + (-0.77388912439346313) * emb_t3_28 + (0.80072581768035889) * emb_t3_29 + (-0.39179623126983643) * emb_t3_30 + (-0.19549223780632019) * emb_t3_31 + (-0.26795434951782227) * gru_0_fwd_t2_h_0 + (0.031234243884682655) * gru_0_fwd_t2_h_1 + (0.91586369276046753) * gru_0_fwd_t2_h_2 + (0.90858215093612671) * gru_0_fwd_t2_h_3 + (-0.15372847020626068) * gru_0_fwd_t2_h_4 + (0.15217134356498718) * gru_0_fwd_t2_h_5 + (0.23932318389415741) * gru_0_fwd_t2_h_6 + (-0.37173047661781311) * gru_0_fwd_t2_h_7 + (0.19593939185142517) * gru_0_fwd_t2_h_8 + (0.58938449621200562) * gru_0_fwd_t2_h_9 + (-0.72226792573928833) * gru_0_fwd_t2_h_10 + (-0.33940699696540833) * gru_0_fwd_t2_h_11 + (0.097356140613555908) * gru_0_fwd_t2_h_12 + (0.2434549480676651) * gru_0_fwd_t2_h_13 + (-0.11584145575761795) * gru_0_fwd_t2_h_14 + (0.27383130788803101) * gru_0_fwd_t2_h_15 + (0.38127899169921875) * gru_0_fwd_t2_h_16 + (0.2095736563205719) * gru_0_fwd_t2_h_17 + (-0.17231328785419464) * gru_0_fwd_t2_h_18 + (1.8202539682388306) * gru_0_fwd_t2_h_19 + (1.2393923997879028) * gru_0_fwd_t2_h_20 + (0.77455723285675049) * gru_0_fwd_t2_h_21 + (-0.31859412789344788) * gru_0_fwd_t2_h_22 + (-0.44130885601043701) * gru_0_fwd_t2_h_23 + (-0.49387469887733459) * gru_0_fwd_t2_h_24 + (-0.73759704828262329) * gru_0_fwd_t2_h_25 + (0.065525583922863007) * gru_0_fwd_t2_h_26 + (0.022106176242232323) * gru_0_fwd_t2_h_27 + (-1.8341513872146606) * gru_0_fwd_t2_h_28 + (0.37840092182159424) * gru_0_fwd_t2_h_29 + (-0.056197434663772583) * gru_0_fwd_t2_h_30 + (1.3079894781112671) * gru_0_fwd_t2_h_31);
    gate_n = tanh((-0.20379906892776489) + (0.076361149549484253) * emb_t3_0 + (-0.57323306798934937) * emb_t3_1 + (-0.19933471083641052) * emb_t3_2 + (-0.49378913640975952) * emb_t3_3 + (-0.44891390204429626) * emb_t3_4 + (0.34798762202262878) * emb_t3_5 + (-0.74374908208847046) * emb_t3_6 + (0.28492367267608643) * emb_t3_7 + (-0.6112217903137207) * emb_t3_8 + (0.91787612438201904) * emb_t3_9 + (0.87554305791854858) * emb_t3_10 + (-0.42015242576599121) * emb_t3_11 + (-1.1708619594573975) * emb_t3_12 + (-0.75946378707885742) * emb_t3_13 + (-0.043774008750915527) * emb_t3_14 + (-0.13453966379165649) * emb_t3_15 + (-0.0572701096534729) * emb_t3_16 + (-0.086511150002479553) * emb_t3_17 + (1.0237325429916382) * emb_t3_18 + (-1.0545214414596558) * emb_t3_19 + (-0.24128946661949158) * emb_t3_20 + (-0.34695819020271301) * emb_t3_21 + (2.3971941471099854) * emb_t3_22 + (0.23683333396911621) * emb_t3_23 + (-0.30926087498664856) * emb_t3_24 + (0.42572280764579773) * emb_t3_25 + (0.45578816533088684) * emb_t3_26 + (0.27811175584793091) * emb_t3_27 + (0.78862935304641724) * emb_t3_28 + (-0.4390127956867218) * emb_t3_29 + (0.66192138195037842) * emb_t3_30 + (0.86930453777313232) * emb_t3_31 + gate_r * ((0.038724146783351898) + (-0.48781463503837585) * gru_0_fwd_t2_h_0 + (-0.73099273443222046) * gru_0_fwd_t2_h_1 + (-0.0039540925063192844) * gru_0_fwd_t2_h_2 + (-0.14538967609405518) * gru_0_fwd_t2_h_3 + (-0.69688302278518677) * gru_0_fwd_t2_h_4 + (0.40897557139396667) * gru_0_fwd_t2_h_5 + (0.53698372840881348) * gru_0_fwd_t2_h_6 + (-0.22809559106826782) * gru_0_fwd_t2_h_7 + (0.069293059408664703) * gru_0_fwd_t2_h_8 + (0.093595832586288452) * gru_0_fwd_t2_h_9 + (0.14251042902469635) * gru_0_fwd_t2_h_10 + (-0.18195424973964691) * gru_0_fwd_t2_h_11 + (1.0426195859909058) * gru_0_fwd_t2_h_12 + (0.80717575550079346) * gru_0_fwd_t2_h_13 + (-0.53189635276794434) * gru_0_fwd_t2_h_14 + (0.37515166401863098) * gru_0_fwd_t2_h_15 + (0.29666870832443237) * gru_0_fwd_t2_h_16 + (0.40994295477867126) * gru_0_fwd_t2_h_17 + (0.15134435892105103) * gru_0_fwd_t2_h_18 + (0.11801391094923019) * gru_0_fwd_t2_h_19 + (0.36758047342300415) * gru_0_fwd_t2_h_20 + (0.097810804843902588) * gru_0_fwd_t2_h_21 + (0.074837684631347656) * gru_0_fwd_t2_h_22 + (-0.22011236846446991) * gru_0_fwd_t2_h_23 + (1.7738238573074341) * gru_0_fwd_t2_h_24 + (0.30645459890365601) * gru_0_fwd_t2_h_25 + (-1.9526984691619873) * gru_0_fwd_t2_h_26 + (0.065554156899452209) * gru_0_fwd_t2_h_27 + (-0.46253073215484619) * gru_0_fwd_t2_h_28 + (0.3682834804058075) * gru_0_fwd_t2_h_29 + (-0.23115412890911102) * gru_0_fwd_t2_h_30 + (1.5375627279281616) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_1 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_1;
    // h=2
    gate_r = sigmoid((-1.0380897521972656) + (-0.49953678250312805) * emb_t3_0 + (0.53072565793991089) * emb_t3_1 + (-0.30938267707824707) * emb_t3_2 + (-1.083149790763855) * emb_t3_3 + (0.34049257636070251) * emb_t3_4 + (-0.075188666582107544) * emb_t3_5 + (0.57378387451171875) * emb_t3_6 + (0.18540342152118683) * emb_t3_7 + (-0.41303351521492004) * emb_t3_8 + (-0.015425128862261772) * emb_t3_9 + (-0.26157167553901672) * emb_t3_10 + (-0.78672277927398682) * emb_t3_11 + (-0.54107207059860229) * emb_t3_12 + (0.2636360228061676) * emb_t3_13 + (0.26457589864730835) * emb_t3_14 + (0.18982620537281036) * emb_t3_15 + (-0.20015624165534973) * emb_t3_16 + (0.23595154285430908) * emb_t3_17 + (-0.33847025036811829) * emb_t3_18 + (-0.1027209460735321) * emb_t3_19 + (-0.08234848827123642) * emb_t3_20 + (0.1945563405752182) * emb_t3_21 + (0.13705295324325562) * emb_t3_22 + (-0.053252369165420532) * emb_t3_23 + (0.36643537878990173) * emb_t3_24 + (-0.54133164882659912) * emb_t3_25 + (-0.2030123770236969) * emb_t3_26 + (0.090528152883052826) * emb_t3_27 + (-0.39304694533348083) * emb_t3_28 + (0.51989978551864624) * emb_t3_29 + (-0.281951904296875) * emb_t3_30 + (0.82258868217468262) * emb_t3_31 + (0.53409236669540405) * gru_0_fwd_t2_h_0 + (0.1891348659992218) * gru_0_fwd_t2_h_1 + (-1.3408336639404297) * gru_0_fwd_t2_h_2 + (-0.71657174825668335) * gru_0_fwd_t2_h_3 + (0.50853520631790161) * gru_0_fwd_t2_h_4 + (-0.6813356876373291) * gru_0_fwd_t2_h_5 + (-1.8093869686126709) * gru_0_fwd_t2_h_6 + (0.40706777572631836) * gru_0_fwd_t2_h_7 + (0.6910858154296875) * gru_0_fwd_t2_h_8 + (-0.4596601128578186) * gru_0_fwd_t2_h_9 + (1.4270249605178833) * gru_0_fwd_t2_h_10 + (0.60212743282318115) * gru_0_fwd_t2_h_11 + (-0.45941388607025146) * gru_0_fwd_t2_h_12 + (-0.24103064835071564) * gru_0_fwd_t2_h_13 + (-0.81206357479095459) * gru_0_fwd_t2_h_14 + (-0.24250292778015137) * gru_0_fwd_t2_h_15 + (0.77786219120025635) * gru_0_fwd_t2_h_16 + (0.28454890847206116) * gru_0_fwd_t2_h_17 + (-0.19906607270240784) * gru_0_fwd_t2_h_18 + (-0.034979179501533508) * gru_0_fwd_t2_h_19 + (-0.67761313915252686) * gru_0_fwd_t2_h_20 + (1.5262935161590576) * gru_0_fwd_t2_h_21 + (0.92325437068939209) * gru_0_fwd_t2_h_22 + (-0.41080927848815918) * gru_0_fwd_t2_h_23 + (2.3788449764251709) * gru_0_fwd_t2_h_24 + (0.95587188005447388) * gru_0_fwd_t2_h_25 + (0.16162353754043579) * gru_0_fwd_t2_h_26 + (-0.5608445405960083) * gru_0_fwd_t2_h_27 + (0.28813251852989197) * gru_0_fwd_t2_h_28 + (0.041321095079183578) * gru_0_fwd_t2_h_29 + (-0.71289443969726562) * gru_0_fwd_t2_h_30 + (-0.025892132893204689) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((0.59557598829269409) + (-0.017392463982105255) * emb_t3_0 + (-0.45606103539466858) * emb_t3_1 + (0.21697993576526642) * emb_t3_2 + (0.049378287047147751) * emb_t3_3 + (-1.6374095139326528e-05) * emb_t3_4 + (0.11475842446088791) * emb_t3_5 + (-0.46809408068656921) * emb_t3_6 + (-0.036141060292720795) * emb_t3_7 + (-0.21556477248668671) * emb_t3_8 + (-0.19126288592815399) * emb_t3_9 + (0.41105896234512329) * emb_t3_10 + (0.40881797671318054) * emb_t3_11 + (-0.062162835150957108) * emb_t3_12 + (-0.1435941606760025) * emb_t3_13 + (-0.030776612460613251) * emb_t3_14 + (-0.082906909286975861) * emb_t3_15 + (0.14314372837543488) * emb_t3_16 + (-0.54513871669769287) * emb_t3_17 + (0.37482067942619324) * emb_t3_18 + (-0.20434349775314331) * emb_t3_19 + (0.39690586924552917) * emb_t3_20 + (0.025051642209291458) * emb_t3_21 + (0.22769370675086975) * emb_t3_22 + (0.07871323823928833) * emb_t3_23 + (-0.098954826593399048) * emb_t3_24 + (-0.29648685455322266) * emb_t3_25 + (0.21393376588821411) * emb_t3_26 + (0.21182559430599213) * emb_t3_27 + (0.10984400659799576) * emb_t3_28 + (-0.23499684035778046) * emb_t3_29 + (0.31506726145744324) * emb_t3_30 + (0.12899214029312134) * emb_t3_31 + (1.0552586317062378) * gru_0_fwd_t2_h_0 + (0.19757528603076935) * gru_0_fwd_t2_h_1 + (0.52107793092727661) * gru_0_fwd_t2_h_2 + (-2.1354260444641113) * gru_0_fwd_t2_h_3 + (0.43615192174911499) * gru_0_fwd_t2_h_4 + (-0.72494274377822876) * gru_0_fwd_t2_h_5 + (0.4647325873374939) * gru_0_fwd_t2_h_6 + (-0.3504166305065155) * gru_0_fwd_t2_h_7 + (-0.33796301484107971) * gru_0_fwd_t2_h_8 + (0.78930020332336426) * gru_0_fwd_t2_h_9 + (-0.50476491451263428) * gru_0_fwd_t2_h_10 + (-0.051537793129682541) * gru_0_fwd_t2_h_11 + (0.034409511834383011) * gru_0_fwd_t2_h_12 + (-0.26844742894172668) * gru_0_fwd_t2_h_13 + (0.8788037896156311) * gru_0_fwd_t2_h_14 + (-1.0153942108154297) * gru_0_fwd_t2_h_15 + (-0.34188517928123474) * gru_0_fwd_t2_h_16 + (-0.34899944067001343) * gru_0_fwd_t2_h_17 + (-0.095836363732814789) * gru_0_fwd_t2_h_18 + (0.57752382755279541) * gru_0_fwd_t2_h_19 + (1.1987779140472412) * gru_0_fwd_t2_h_20 + (-0.44032391905784607) * gru_0_fwd_t2_h_21 + (0.60819721221923828) * gru_0_fwd_t2_h_22 + (0.25165799260139465) * gru_0_fwd_t2_h_23 + (-0.56415039300918579) * gru_0_fwd_t2_h_24 + (-0.29410898685455322) * gru_0_fwd_t2_h_25 + (-0.57440894842147827) * gru_0_fwd_t2_h_26 + (-0.14908777177333832) * gru_0_fwd_t2_h_27 + (-0.66039663553237915) * gru_0_fwd_t2_h_28 + (0.3433452844619751) * gru_0_fwd_t2_h_29 + (1.1735707521438599) * gru_0_fwd_t2_h_30 + (0.20559163391590118) * gru_0_fwd_t2_h_31);
    gate_n = tanh((0.39140915870666504) + (-0.67698490619659424) * emb_t3_0 + (-0.80705404281616211) * emb_t3_1 + (1.0790296792984009) * emb_t3_2 + (1.0978012084960938) * emb_t3_3 + (-0.88060504198074341) * emb_t3_4 + (-0.84607565402984619) * emb_t3_5 + (-0.52532118558883667) * emb_t3_6 + (-0.53780955076217651) * emb_t3_7 + (-0.0068129743449389935) * emb_t3_8 + (-0.29163098335266113) * emb_t3_9 + (0.0051349555142223835) * emb_t3_10 + (0.40578261017799377) * emb_t3_11 + (0.15872283279895782) * emb_t3_12 + (-0.9215700626373291) * emb_t3_13 + (0.51005488634109497) * emb_t3_14 + (-0.72411704063415527) * emb_t3_15 + (0.96439224481582642) * emb_t3_16 + (-0.41004228591918945) * emb_t3_17 + (-0.27323082089424133) * emb_t3_18 + (-0.049840778112411499) * emb_t3_19 + (0.50790828466415405) * emb_t3_20 + (0.083430811762809753) * emb_t3_21 + (-0.32941734790802002) * emb_t3_22 + (-0.24746724963188171) * emb_t3_23 + (-0.11090182512998581) * emb_t3_24 + (0.16097165644168854) * emb_t3_25 + (0.74761050939559937) * emb_t3_26 + (-0.024324916303157806) * emb_t3_27 + (1.0168131589889526) * emb_t3_28 + (-0.6490330696105957) * emb_t3_29 + (0.58900725841522217) * emb_t3_30 + (-0.26816087961196899) * emb_t3_31 + gate_r * ((0.26287850737571716) + (-0.87151265144348145) * gru_0_fwd_t2_h_0 + (0.079764075577259064) * gru_0_fwd_t2_h_1 + (0.6464037299156189) * gru_0_fwd_t2_h_2 + (0.99149185419082642) * gru_0_fwd_t2_h_3 + (-0.4884907603263855) * gru_0_fwd_t2_h_4 + (0.81641274690628052) * gru_0_fwd_t2_h_5 + (0.70681911706924438) * gru_0_fwd_t2_h_6 + (-0.6423795223236084) * gru_0_fwd_t2_h_7 + (-0.55720096826553345) * gru_0_fwd_t2_h_8 + (-0.38112422823905945) * gru_0_fwd_t2_h_9 + (-0.67650300264358521) * gru_0_fwd_t2_h_10 + (-0.22080881893634796) * gru_0_fwd_t2_h_11 + (-0.14645957946777344) * gru_0_fwd_t2_h_12 + (0.058525077998638153) * gru_0_fwd_t2_h_13 + (0.11350750923156738) * gru_0_fwd_t2_h_14 + (0.98510921001434326) * gru_0_fwd_t2_h_15 + (-0.30893206596374512) * gru_0_fwd_t2_h_16 + (-0.34031704068183899) * gru_0_fwd_t2_h_17 + (0.28325998783111572) * gru_0_fwd_t2_h_18 + (-0.26171451807022095) * gru_0_fwd_t2_h_19 + (-0.13510438799858093) * gru_0_fwd_t2_h_20 + (-0.70780932903289795) * gru_0_fwd_t2_h_21 + (-1.1850879192352295) * gru_0_fwd_t2_h_22 + (0.39231094717979431) * gru_0_fwd_t2_h_23 + (0.41396823525428772) * gru_0_fwd_t2_h_24 + (-0.39159613847732544) * gru_0_fwd_t2_h_25 + (0.34244439005851746) * gru_0_fwd_t2_h_26 + (0.045419353991746902) * gru_0_fwd_t2_h_27 + (-0.37839597463607788) * gru_0_fwd_t2_h_28 + (-0.038326457142829895) * gru_0_fwd_t2_h_29 + (-0.55365782976150513) * gru_0_fwd_t2_h_30 + (-1.0095475912094116) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_2 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_2;
    // h=3
    gate_r = sigmoid((2.0616135597229004) + (0.71142196655273438) * emb_t3_0 + (-0.67579418420791626) * emb_t3_1 + (0.80988782644271851) * emb_t3_2 + (0.92023617029190063) * emb_t3_3 + (-0.54527401924133301) * emb_t3_4 + (-0.66617655754089355) * emb_t3_5 + (-0.41110676527023315) * emb_t3_6 + (-0.45798861980438232) * emb_t3_7 + (1.4377447366714478) * emb_t3_8 + (-0.54545134305953979) * emb_t3_9 + (-0.51568645238876343) * emb_t3_10 + (0.86354160308837891) * emb_t3_11 + (1.1853562593460083) * emb_t3_12 + (-0.44326707720756531) * emb_t3_13 + (-0.27643707394599915) * emb_t3_14 + (-0.39381590485572815) * emb_t3_15 + (0.98329824209213257) * emb_t3_16 + (-1.3900668621063232) * emb_t3_17 + (-0.73472511768341064) * emb_t3_18 + (0.62257307767868042) * emb_t3_19 + (1.1014494895935059) * emb_t3_20 + (-0.060367707163095474) * emb_t3_21 + (-0.88237887620925903) * emb_t3_22 + (0.83154028654098511) * emb_t3_23 + (-0.69370627403259277) * emb_t3_24 + (-0.026786744594573975) * emb_t3_25 + (1.432295560836792) * emb_t3_26 + (1.1666529178619385) * emb_t3_27 + (0.64240127801895142) * emb_t3_28 + (0.19445528090000153) * emb_t3_29 + (0.75998324155807495) * emb_t3_30 + (-1.4978399276733398) * emb_t3_31 + (0.0029225083999335766) * gru_0_fwd_t2_h_0 + (-0.15116763114929199) * gru_0_fwd_t2_h_1 + (-0.23434220254421234) * gru_0_fwd_t2_h_2 + (0.15430980920791626) * gru_0_fwd_t2_h_3 + (-0.041666973382234573) * gru_0_fwd_t2_h_4 + (-0.25092947483062744) * gru_0_fwd_t2_h_5 + (-0.29780954122543335) * gru_0_fwd_t2_h_6 + (0.30151170492172241) * gru_0_fwd_t2_h_7 + (-0.94460630416870117) * gru_0_fwd_t2_h_8 + (0.37143081426620483) * gru_0_fwd_t2_h_9 + (0.0040653105825185776) * gru_0_fwd_t2_h_10 + (0.15777058899402618) * gru_0_fwd_t2_h_11 + (-0.054552480578422546) * gru_0_fwd_t2_h_12 + (0.0010760886361822486) * gru_0_fwd_t2_h_13 + (0.59394961595535278) * gru_0_fwd_t2_h_14 + (-0.016164951026439667) * gru_0_fwd_t2_h_15 + (-0.77562737464904785) * gru_0_fwd_t2_h_16 + (-0.22821228206157684) * gru_0_fwd_t2_h_17 + (-0.29330494999885559) * gru_0_fwd_t2_h_18 + (0.020681081339716911) * gru_0_fwd_t2_h_19 + (0.32564654946327209) * gru_0_fwd_t2_h_20 + (-0.46010440587997437) * gru_0_fwd_t2_h_21 + (-0.81573671102523804) * gru_0_fwd_t2_h_22 + (0.92043167352676392) * gru_0_fwd_t2_h_23 + (-0.30672469735145569) * gru_0_fwd_t2_h_24 + (0.15629678964614868) * gru_0_fwd_t2_h_25 + (-0.88393104076385498) * gru_0_fwd_t2_h_26 + (-0.50379687547683716) * gru_0_fwd_t2_h_27 + (-0.19383423030376434) * gru_0_fwd_t2_h_28 + (0.20079107582569122) * gru_0_fwd_t2_h_29 + (0.83839195966720581) * gru_0_fwd_t2_h_30 + (0.36538109183311462) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((0.34568828344345093) + (0.039076611399650574) * emb_t3_0 + (-0.34323811531066895) * emb_t3_1 + (0.036192145198583603) * emb_t3_2 + (0.098099231719970703) * emb_t3_3 + (-0.64821422100067139) * emb_t3_4 + (0.033175818622112274) * emb_t3_5 + (-0.30631464719772339) * emb_t3_6 + (-0.020301338285207748) * emb_t3_7 + (0.087605379521846771) * emb_t3_8 + (-0.21309278905391693) * emb_t3_9 + (0.33025351166725159) * emb_t3_10 + (0.45017609000205994) * emb_t3_11 + (0.062943413853645325) * emb_t3_12 + (-0.12065744400024414) * emb_t3_13 + (-0.010905683971941471) * emb_t3_14 + (0.00064206327078863978) * emb_t3_15 + (0.0022179239895194769) * emb_t3_16 + (-0.83086913824081421) * emb_t3_17 + (0.043832376599311829) * emb_t3_18 + (0.27413231134414673) * emb_t3_19 + (-0.033662624657154083) * emb_t3_20 + (-0.021364977583289146) * emb_t3_21 + (0.28776085376739502) * emb_t3_22 + (-0.021695900708436966) * emb_t3_23 + (-0.099969953298568726) * emb_t3_24 + (-0.068793967366218567) * emb_t3_25 + (0.19015796482563019) * emb_t3_26 + (0.0076117902062833309) * emb_t3_27 + (0.047480151057243347) * emb_t3_28 + (-0.49421864748001099) * emb_t3_29 + (0.12573356926441193) * emb_t3_30 + (-0.15962667763233185) * emb_t3_31 + (0.16882030665874481) * gru_0_fwd_t2_h_0 + (0.092336326837539673) * gru_0_fwd_t2_h_1 + (0.76554650068283081) * gru_0_fwd_t2_h_2 + (1.1071410179138184) * gru_0_fwd_t2_h_3 + (0.12482080608606339) * gru_0_fwd_t2_h_4 + (0.36299654841423035) * gru_0_fwd_t2_h_5 + (-0.11517822742462158) * gru_0_fwd_t2_h_6 + (-0.47770243883132935) * gru_0_fwd_t2_h_7 + (1.4788484573364258) * gru_0_fwd_t2_h_8 + (0.27992838621139526) * gru_0_fwd_t2_h_9 + (-1.0805906057357788) * gru_0_fwd_t2_h_10 + (0.21662548184394836) * gru_0_fwd_t2_h_11 + (-0.005391064565628767) * gru_0_fwd_t2_h_12 + (-0.51090967655181885) * gru_0_fwd_t2_h_13 + (0.30192378163337708) * gru_0_fwd_t2_h_14 + (-0.014525953680276871) * gru_0_fwd_t2_h_15 + (-0.60952997207641602) * gru_0_fwd_t2_h_16 + (0.0054739476181566715) * gru_0_fwd_t2_h_17 + (0.66594505310058594) * gru_0_fwd_t2_h_18 + (-0.67218697071075439) * gru_0_fwd_t2_h_19 + (1.1015058755874634) * gru_0_fwd_t2_h_20 + (-0.49346360564231873) * gru_0_fwd_t2_h_21 + (0.38011345267295837) * gru_0_fwd_t2_h_22 + (-1.1572955846786499) * gru_0_fwd_t2_h_23 + (-0.025127673521637917) * gru_0_fwd_t2_h_24 + (-0.16782048344612122) * gru_0_fwd_t2_h_25 + (0.65971511602401733) * gru_0_fwd_t2_h_26 + (1.0656977891921997) * gru_0_fwd_t2_h_27 + (-1.7666223049163818) * gru_0_fwd_t2_h_28 + (-0.0043406952172517776) * gru_0_fwd_t2_h_29 + (0.42101752758026123) * gru_0_fwd_t2_h_30 + (0.28552570939064026) * gru_0_fwd_t2_h_31);
    gate_n = tanh((0.26719158887863159) + (0.073961347341537476) * emb_t3_0 + (-0.23871782422065735) * emb_t3_1 + (0.01909891702234745) * emb_t3_2 + (0.03399026021361351) * emb_t3_3 + (-0.61227846145629883) * emb_t3_4 + (-0.44694602489471436) * emb_t3_5 + (-0.13722310960292816) * emb_t3_6 + (-0.10464496165513992) * emb_t3_7 + (0.54586118459701538) * emb_t3_8 + (-0.059800054877996445) * emb_t3_9 + (-0.22064962983131409) * emb_t3_10 + (-0.39844140410423279) * emb_t3_11 + (0.082724079489707947) * emb_t3_12 + (0.020851833745837212) * emb_t3_13 + (-0.077367633581161499) * emb_t3_14 + (0.20684503018856049) * emb_t3_15 + (-0.022860409691929817) * emb_t3_16 + (-0.524647057056427) * emb_t3_17 + (0.10104715824127197) * emb_t3_18 + (0.14221270382404327) * emb_t3_19 + (0.30949804186820984) * emb_t3_20 + (0.29831352829933167) * emb_t3_21 + (-0.11125599592924118) * emb_t3_22 + (0.17298436164855957) * emb_t3_23 + (0.074098840355873108) * emb_t3_24 + (-0.014910106547176838) * emb_t3_25 + (0.45245653390884399) * emb_t3_26 + (0.15315267443656921) * emb_t3_27 + (0.259847491979599) * emb_t3_28 + (-0.11423767358064651) * emb_t3_29 + (-0.021640364080667496) * emb_t3_30 + (-0.10989490151405334) * emb_t3_31 + gate_r * ((0.26690664887428284) + (-0.022662045434117317) * gru_0_fwd_t2_h_0 + (-0.052836522459983826) * gru_0_fwd_t2_h_1 + (-0.033227104693651199) * gru_0_fwd_t2_h_2 + (-0.80096763372421265) * gru_0_fwd_t2_h_3 + (0.086029626429080963) * gru_0_fwd_t2_h_4 + (0.073501788079738617) * gru_0_fwd_t2_h_5 + (-0.77572256326675415) * gru_0_fwd_t2_h_6 + (0.17834819853305817) * gru_0_fwd_t2_h_7 + (0.92684692144393921) * gru_0_fwd_t2_h_8 + (1.8719316720962524) * gru_0_fwd_t2_h_9 + (0.2827606201171875) * gru_0_fwd_t2_h_10 + (-0.29582798480987549) * gru_0_fwd_t2_h_11 + (-0.40276676416397095) * gru_0_fwd_t2_h_12 + (-0.019562100991606712) * gru_0_fwd_t2_h_13 + (-0.28205779194831848) * gru_0_fwd_t2_h_14 + (-0.17583282291889191) * gru_0_fwd_t2_h_15 + (0.51120454072952271) * gru_0_fwd_t2_h_16 + (0.22647292912006378) * gru_0_fwd_t2_h_17 + (0.21033297479152679) * gru_0_fwd_t2_h_18 + (-0.076914645731449127) * gru_0_fwd_t2_h_19 + (0.8550066351890564) * gru_0_fwd_t2_h_20 + (0.26958692073822021) * gru_0_fwd_t2_h_21 + (-0.41717883944511414) * gru_0_fwd_t2_h_22 + (-1.0278539657592773) * gru_0_fwd_t2_h_23 + (0.40542715787887573) * gru_0_fwd_t2_h_24 + (-0.35031956434249878) * gru_0_fwd_t2_h_25 + (0.93681043386459351) * gru_0_fwd_t2_h_26 + (0.69629907608032227) * gru_0_fwd_t2_h_27 + (-0.58897274732589722) * gru_0_fwd_t2_h_28 + (0.75152206420898438) * gru_0_fwd_t2_h_29 + (-0.13744856417179108) * gru_0_fwd_t2_h_30 + (-0.93443822860717773) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_3 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_3;
    // h=4
    gate_r = sigmoid((-0.42540422081947327) + (-0.20194695889949799) * emb_t3_0 + (-0.95910543203353882) * emb_t3_1 + (0.14472165703773499) * emb_t3_2 + (-0.34521442651748657) * emb_t3_3 + (-0.48468440771102905) * emb_t3_4 + (0.11014232039451599) * emb_t3_5 + (-0.51376980543136597) * emb_t3_6 + (0.52164840698242188) * emb_t3_7 + (-1.1992356777191162) * emb_t3_8 + (1.9889419078826904) * emb_t3_9 + (1.8071471452713013) * emb_t3_10 + (-0.21530884504318237) * emb_t3_11 + (-0.89563268423080444) * emb_t3_12 + (-1.293562650680542) * emb_t3_13 + (-0.36114555597305298) * emb_t3_14 + (-0.29163080453872681) * emb_t3_15 + (0.22430737316608429) * emb_t3_16 + (0.22678232192993164) * emb_t3_17 + (1.9108097553253174) * emb_t3_18 + (-1.6922171115875244) * emb_t3_19 + (-0.031985752284526825) * emb_t3_20 + (-0.32923278212547302) * emb_t3_21 + (1.4173957109451294) * emb_t3_22 + (0.71515220403671265) * emb_t3_23 + (-0.19276925921440125) * emb_t3_24 + (0.76860618591308594) * emb_t3_25 + (0.33217763900756836) * emb_t3_26 + (-0.052287697792053223) * emb_t3_27 + (0.59960746765136719) * emb_t3_28 + (-0.80978822708129883) * emb_t3_29 + (0.14780299365520477) * emb_t3_30 + (0.89851784706115723) * emb_t3_31 + (-0.51567816734313965) * gru_0_fwd_t2_h_0 + (-0.56715703010559082) * gru_0_fwd_t2_h_1 + (-0.76100736856460571) * gru_0_fwd_t2_h_2 + (0.12674760818481445) * gru_0_fwd_t2_h_3 + (-0.77764767408370972) * gru_0_fwd_t2_h_4 + (-0.12644243240356445) * gru_0_fwd_t2_h_5 + (0.11164414137601852) * gru_0_fwd_t2_h_6 + (0.040539879351854324) * gru_0_fwd_t2_h_7 + (0.034693639725446701) * gru_0_fwd_t2_h_8 + (-0.25370112061500549) * gru_0_fwd_t2_h_9 + (0.63955771923065186) * gru_0_fwd_t2_h_10 + (0.12075168639421463) * gru_0_fwd_t2_h_11 + (0.25066637992858887) * gru_0_fwd_t2_h_12 + (0.46603596210479736) * gru_0_fwd_t2_h_13 + (-1.1255018711090088) * gru_0_fwd_t2_h_14 + (0.19626860320568085) * gru_0_fwd_t2_h_15 + (0.72975033521652222) * gru_0_fwd_t2_h_16 + (0.22281630337238312) * gru_0_fwd_t2_h_17 + (-0.2345568835735321) * gru_0_fwd_t2_h_18 + (0.042392414063215256) * gru_0_fwd_t2_h_19 + (-0.80893850326538086) * gru_0_fwd_t2_h_20 + (0.7035185694694519) * gru_0_fwd_t2_h_21 + (0.56572258472442627) * gru_0_fwd_t2_h_22 + (0.40611037611961365) * gru_0_fwd_t2_h_23 + (0.4424368143081665) * gru_0_fwd_t2_h_24 + (0.084960758686065674) * gru_0_fwd_t2_h_25 + (0.45271366834640503) * gru_0_fwd_t2_h_26 + (-0.50831377506256104) * gru_0_fwd_t2_h_27 + (0.73261266946792603) * gru_0_fwd_t2_h_28 + (-0.857352614402771) * gru_0_fwd_t2_h_29 + (-1.8184003829956055) * gru_0_fwd_t2_h_30 + (0.13682495057582855) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((-0.12614654004573822) + (0.063160456717014313) * emb_t3_0 + (0.76167243719100952) * emb_t3_1 + (-0.13877630233764648) * emb_t3_2 + (-0.24188467860221863) * emb_t3_3 + (0.12049203366041183) * emb_t3_4 + (-0.17847223579883575) * emb_t3_5 + (0.30450329184532166) * emb_t3_6 + (-0.018857929855585098) * emb_t3_7 + (-0.244153693318367) * emb_t3_8 + (-0.68224793672561646) * emb_t3_9 + (-0.58444565534591675) * emb_t3_10 + (0.10306438058614731) * emb_t3_11 + (0.37857431173324585) * emb_t3_12 + (0.61797225475311279) * emb_t3_13 + (-0.022410331293940544) * emb_t3_14 + (0.089360855519771576) * emb_t3_15 + (0.059475280344486237) * emb_t3_16 + (0.11812642216682434) * emb_t3_17 + (-0.56128388643264771) * emb_t3_18 + (0.34508559107780457) * emb_t3_19 + (0.32594844698905945) * emb_t3_20 + (0.22418150305747986) * emb_t3_21 + (-0.06485816091299057) * emb_t3_22 + (-0.18808339536190033) * emb_t3_23 + (0.17854022979736328) * emb_t3_24 + (0.013190185651183128) * emb_t3_25 + (-0.1965005099773407) * emb_t3_26 + (-0.013800891116261482) * emb_t3_27 + (-0.66975629329681396) * emb_t3_28 + (1.1487005949020386) * emb_t3_29 + (0.038125619292259216) * emb_t3_30 + (-0.019804768264293671) * emb_t3_31 + (-0.22040164470672607) * gru_0_fwd_t2_h_0 + (-0.13487111032009125) * gru_0_fwd_t2_h_1 + (0.45504340529441833) * gru_0_fwd_t2_h_2 + (0.71854871511459351) * gru_0_fwd_t2_h_3 + (0.0041064741089940071) * gru_0_fwd_t2_h_4 + (-0.083416014909744263) * gru_0_fwd_t2_h_5 + (0.47878170013427734) * gru_0_fwd_t2_h_6 + (-0.20850211381912231) * gru_0_fwd_t2_h_7 + (0.30431303381919861) * gru_0_fwd_t2_h_8 + (0.25619006156921387) * gru_0_fwd_t2_h_9 + (-0.15055945515632629) * gru_0_fwd_t2_h_10 + (-0.41622769832611084) * gru_0_fwd_t2_h_11 + (0.17886780202388763) * gru_0_fwd_t2_h_12 + (0.097652234137058258) * gru_0_fwd_t2_h_13 + (-0.2066226601600647) * gru_0_fwd_t2_h_14 + (0.16189447045326233) * gru_0_fwd_t2_h_15 + (0.40761211514472961) * gru_0_fwd_t2_h_16 + (0.36098375916481018) * gru_0_fwd_t2_h_17 + (-0.1346014142036438) * gru_0_fwd_t2_h_18 + (1.0225104093551636) * gru_0_fwd_t2_h_19 + (0.52674251794815063) * gru_0_fwd_t2_h_20 + (0.921284019947052) * gru_0_fwd_t2_h_21 + (-0.074175886809825897) * gru_0_fwd_t2_h_22 + (-0.52639615535736084) * gru_0_fwd_t2_h_23 + (-0.38648593425750732) * gru_0_fwd_t2_h_24 + (-0.22507306933403015) * gru_0_fwd_t2_h_25 + (0.0013962397351861) * gru_0_fwd_t2_h_26 + (0.65791290998458862) * gru_0_fwd_t2_h_27 + (-1.5255998373031616) * gru_0_fwd_t2_h_28 + (0.65613555908203125) * gru_0_fwd_t2_h_29 + (-0.14266866445541382) * gru_0_fwd_t2_h_30 + (1.3813296556472778) * gru_0_fwd_t2_h_31);
    gate_n = tanh((-1.76043701171875) + (-0.025369701907038689) * emb_t3_0 + (0.14386425912380219) * emb_t3_1 + (-0.012411795556545258) * emb_t3_2 + (-1.3306212425231934) * emb_t3_3 + (0.059490438550710678) * emb_t3_4 + (0.010017807595431805) * emb_t3_5 + (-0.38581046462059021) * emb_t3_6 + (0.026102280244231224) * emb_t3_7 + (-5.3316059112548828) * emb_t3_8 + (0.55693513154983521) * emb_t3_9 + (1.075499415397644) * emb_t3_10 + (-2.0826752185821533) * emb_t3_11 + (-3.896381139755249) * emb_t3_12 + (-0.012725798413157463) * emb_t3_13 + (0.012099700979888439) * emb_t3_14 + (-0.0090013118460774422) * emb_t3_15 + (-0.028221515938639641) * emb_t3_16 + (0.84943634271621704) * emb_t3_17 + (0.70072305202484131) * emb_t3_18 + (-0.91486865282058716) * emb_t3_19 + (-1.1964467763900757) * emb_t3_20 + (0.011377644725143909) * emb_t3_21 + (1.5379612445831299) * emb_t3_22 + (0.018764521926641464) * emb_t3_23 + (0.029102124273777008) * emb_t3_24 + (0.012979962863028049) * emb_t3_25 + (-0.72028487920761108) * emb_t3_26 + (0.0051553375087678432) * emb_t3_27 + (0.30544823408126831) * emb_t3_28 + (-0.11053411662578583) * emb_t3_29 + (-0.22952638566493988) * emb_t3_30 + (7.9563412666320801) * emb_t3_31 + gate_r * ((-1.7395802736282349) + (0.21468006074428558) * gru_0_fwd_t2_h_0 + (0.31632700562477112) * gru_0_fwd_t2_h_1 + (-1.3728216886520386) * gru_0_fwd_t2_h_2 + (-1.3128889799118042) * gru_0_fwd_t2_h_3 + (0.41887176036834717) * gru_0_fwd_t2_h_4 + (1.8807141780853271) * gru_0_fwd_t2_h_5 + (-0.32382175326347351) * gru_0_fwd_t2_h_6 + (0.61316955089569092) * gru_0_fwd_t2_h_7 + (0.58693748712539673) * gru_0_fwd_t2_h_8 + (0.82091033458709717) * gru_0_fwd_t2_h_9 + (0.95194673538208008) * gru_0_fwd_t2_h_10 + (0.18054668605327606) * gru_0_fwd_t2_h_11 + (-0.36203131079673767) * gru_0_fwd_t2_h_12 + (-0.33648210763931274) * gru_0_fwd_t2_h_13 + (0.10990398377180099) * gru_0_fwd_t2_h_14 + (-0.30996939539909363) * gru_0_fwd_t2_h_15 + (-0.03934512659907341) * gru_0_fwd_t2_h_16 + (0.043142590671777725) * gru_0_fwd_t2_h_17 + (0.2073424905538559) * gru_0_fwd_t2_h_18 + (0.45217365026473999) * gru_0_fwd_t2_h_19 + (0.46624067425727844) * gru_0_fwd_t2_h_20 + (0.70023840665817261) * gru_0_fwd_t2_h_21 + (-1.57627272605896) * gru_0_fwd_t2_h_22 + (-2.2531149387359619) * gru_0_fwd_t2_h_23 + (1.8536632061004639) * gru_0_fwd_t2_h_24 + (1.3966832160949707) * gru_0_fwd_t2_h_25 + (1.5252846479415894) * gru_0_fwd_t2_h_26 + (-1.3774404525756836) * gru_0_fwd_t2_h_27 + (1.5402415990829468) * gru_0_fwd_t2_h_28 + (0.60441911220550537) * gru_0_fwd_t2_h_29 + (0.22831811010837555) * gru_0_fwd_t2_h_30 + (-1.2709026336669922) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_4 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_4;
    // h=5
    gate_r = sigmoid((0.69085609912872314) + (0.31221577525138855) * emb_t3_0 + (-0.82488334178924561) * emb_t3_1 + (-0.48002389073371887) * emb_t3_2 + (0.15588852763175964) * emb_t3_3 + (-0.55411601066589355) * emb_t3_4 + (-0.87167394161224365) * emb_t3_5 + (-0.35193851590156555) * emb_t3_6 + (-0.92096197605133057) * emb_t3_7 + (0.27015870809555054) * emb_t3_8 + (0.029425617307424545) * emb_t3_9 + (-0.13232792913913727) * emb_t3_10 + (0.446541428565979) * emb_t3_11 + (0.17258265614509583) * emb_t3_12 + (-0.42043307423591614) * emb_t3_13 + (-0.22850875556468964) * emb_t3_14 + (-0.29999476671218872) * emb_t3_15 + (0.25832659006118774) * emb_t3_16 + (-0.86852681636810303) * emb_t3_17 + (0.12863753736019135) * emb_t3_18 + (0.020937630906701088) * emb_t3_19 + (-0.0073465197347104549) * emb_t3_20 + (-0.74482583999633789) * emb_t3_21 + (-0.092235080897808075) * emb_t3_22 + (-0.13648895919322968) * emb_t3_23 + (-0.64163213968276978) * emb_t3_24 + (-0.3159889280796051) * emb_t3_25 + (0.43557935953140259) * emb_t3_26 + (0.50488400459289551) * emb_t3_27 + (0.37466296553611755) * emb_t3_28 + (-0.42972543835639954) * emb_t3_29 + (0.2659851610660553) * emb_t3_30 + (0.14337827265262604) * emb_t3_31 + (0.61873674392700195) * gru_0_fwd_t2_h_0 + (-0.017917118966579437) * gru_0_fwd_t2_h_1 + (-1.8224114179611206) * gru_0_fwd_t2_h_2 + (-0.59753429889678955) * gru_0_fwd_t2_h_3 + (-0.57076460123062134) * gru_0_fwd_t2_h_4 + (-2.0504193305969238) * gru_0_fwd_t2_h_5 + (1.9493581056594849) * gru_0_fwd_t2_h_6 + (1.2902820110321045) * gru_0_fwd_t2_h_7 + (-1.5305608510971069) * gru_0_fwd_t2_h_8 + (-1.7380726337432861) * gru_0_fwd_t2_h_9 + (1.816393256187439) * gru_0_fwd_t2_h_10 + (2.3497500419616699) * gru_0_fwd_t2_h_11 + (-0.23452471196651459) * gru_0_fwd_t2_h_12 + (0.92605024576187134) * gru_0_fwd_t2_h_13 + (0.35671943426132202) * gru_0_fwd_t2_h_14 + (-1.2052809000015259) * gru_0_fwd_t2_h_15 + (-2.1646435260772705) * gru_0_fwd_t2_h_16 + (-2.3369350433349609) * gru_0_fwd_t2_h_17 + (-0.34785282611846924) * gru_0_fwd_t2_h_18 + (0.13206294178962708) * gru_0_fwd_t2_h_19 + (-3.3028016090393066) * gru_0_fwd_t2_h_20 + (-2.3300776481628418) * gru_0_fwd_t2_h_21 + (3.3226301670074463) * gru_0_fwd_t2_h_22 + (2.7316522598266602) * gru_0_fwd_t2_h_23 + (-0.023522058501839638) * gru_0_fwd_t2_h_24 + (-2.2624697685241699) * gru_0_fwd_t2_h_25 + (0.4919765293598175) * gru_0_fwd_t2_h_26 + (0.5446324348449707) * gru_0_fwd_t2_h_27 + (1.1471512317657471) * gru_0_fwd_t2_h_28 + (-1.5590293407440186) * gru_0_fwd_t2_h_29 + (-0.0038357814773917198) * gru_0_fwd_t2_h_30 + (2.4355244636535645) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((-1.3584561347961426) + (-0.0028366802725940943) * emb_t3_0 + (0.10478486865758896) * emb_t3_1 + (-0.0043737040832638741) * emb_t3_2 + (-0.12542122602462769) * emb_t3_3 + (-0.074945889413356781) * emb_t3_4 + (-0.0013680461561307311) * emb_t3_5 + (-0.60080075263977051) * emb_t3_6 + (0.0014825690304860473) * emb_t3_7 + (-0.10453623533248901) * emb_t3_8 + (0.12971755862236023) * emb_t3_9 + (-0.054391741752624512) * emb_t3_10 + (-0.1130511686205864) * emb_t3_11 + (-0.0076990043744444847) * emb_t3_12 + (-0.29454752802848816) * emb_t3_13 + (0.0013349719811230898) * emb_t3_14 + (-0.0045643039047718048) * emb_t3_15 + (0.00097404565894976258) * emb_t3_16 + (0.49722012877464294) * emb_t3_17 + (0.14380873739719391) * emb_t3_18 + (-0.20514595508575439) * emb_t3_19 + (-0.0036781732924282551) * emb_t3_20 + (-0.0014908264856785536) * emb_t3_21 + (0.12914152443408966) * emb_t3_22 + (0.0026829149574041367) * emb_t3_23 + (0.00024567241780459881) * emb_t3_24 + (-0.0021099650766700506) * emb_t3_25 + (-0.10728149116039276) * emb_t3_26 + (0.00099281745497137308) * emb_t3_27 + (0.19901151955127716) * emb_t3_28 + (0.16660270094871521) * emb_t3_29 + (0.30264109373092651) * emb_t3_30 + (0.1391928642988205) * emb_t3_31 + (-0.78484249114990234) * gru_0_fwd_t2_h_0 + (-0.22690363228321075) * gru_0_fwd_t2_h_1 + (0.20833475887775421) * gru_0_fwd_t2_h_2 + (-0.97122448682785034) * gru_0_fwd_t2_h_3 + (-0.035477478057146072) * gru_0_fwd_t2_h_4 + (-0.14066416025161743) * gru_0_fwd_t2_h_5 + (0.17683656513690948) * gru_0_fwd_t2_h_6 + (-0.18406268954277039) * gru_0_fwd_t2_h_7 + (-0.13486909866333008) * gru_0_fwd_t2_h_8 + (1.0655478239059448) * gru_0_fwd_t2_h_9 + (-0.10352278500795364) * gru_0_fwd_t2_h_10 + (-1.0076307058334351) * gru_0_fwd_t2_h_11 + (1.1224737167358398) * gru_0_fwd_t2_h_12 + (0.97996717691421509) * gru_0_fwd_t2_h_13 + (-0.72492486238479614) * gru_0_fwd_t2_h_14 + (0.048568349331617355) * gru_0_fwd_t2_h_15 + (0.9234168529510498) * gru_0_fwd_t2_h_16 + (0.85181432962417603) * gru_0_fwd_t2_h_17 + (0.44085222482681274) * gru_0_fwd_t2_h_18 + (-0.40077000856399536) * gru_0_fwd_t2_h_19 + (1.9128485918045044) * gru_0_fwd_t2_h_20 + (-0.24256855249404907) * gru_0_fwd_t2_h_21 + (-0.3128688633441925) * gru_0_fwd_t2_h_22 + (0.097645081579685211) * gru_0_fwd_t2_h_23 + (0.20936150848865509) * gru_0_fwd_t2_h_24 + (0.26143145561218262) * gru_0_fwd_t2_h_25 + (0.025976488366723061) * gru_0_fwd_t2_h_26 + (-0.1152612715959549) * gru_0_fwd_t2_h_27 + (-1.7720012664794922) * gru_0_fwd_t2_h_28 + (0.83317804336547852) * gru_0_fwd_t2_h_29 + (-0.064557112753391266) * gru_0_fwd_t2_h_30 + (-0.16293874382972717) * gru_0_fwd_t2_h_31);
    gate_n = tanh((0.58344340324401855) + (-0.02623157761991024) * emb_t3_0 + (-0.55218946933746338) * emb_t3_1 + (-0.020457925274968147) * emb_t3_2 + (0.426810622215271) * emb_t3_3 + (-0.63272702693939209) * emb_t3_4 + (0.042069733142852783) * emb_t3_5 + (-0.55493944883346558) * emb_t3_6 + (0.020925011485815048) * emb_t3_7 + (0.41323971748352051) * emb_t3_8 + (-0.45961034297943115) * emb_t3_9 + (-0.58583390712738037) * emb_t3_10 + (0.86403512954711914) * emb_t3_11 + (0.46509718894958496) * emb_t3_12 + (-0.021772902458906174) * emb_t3_13 + (0.0052866223268210888) * emb_t3_14 + (-0.0038351269904524088) * emb_t3_15 + (0.035317875444889069) * emb_t3_16 + (-0.82278656959533691) * emb_t3_17 + (-0.38640621304512024) * emb_t3_18 + (0.38335981965065002) * emb_t3_19 + (0.0016717606922611594) * emb_t3_20 + (0.065966054797172546) * emb_t3_21 + (-0.77871835231781006) * emb_t3_22 + (-0.00248179049231112) * emb_t3_23 + (0.060930978506803513) * emb_t3_24 + (0.0041049802675843239) * emb_t3_25 + (0.40128898620605469) * emb_t3_26 + (-0.012996932491660118) * emb_t3_27 + (0.053499244153499603) * emb_t3_28 + (-0.60031735897064209) * emb_t3_29 + (0.23656852543354034) * emb_t3_30 + (-0.3339596688747406) * emb_t3_31 + gate_r * ((0.64305049180984497) + (-0.58677196502685547) * gru_0_fwd_t2_h_0 + (-0.12564921379089355) * gru_0_fwd_t2_h_1 + (0.75933915376663208) * gru_0_fwd_t2_h_2 + (0.32983219623565674) * gru_0_fwd_t2_h_3 + (-0.11433876305818558) * gru_0_fwd_t2_h_4 + (-0.0088129052892327309) * gru_0_fwd_t2_h_5 + (1.1392234563827515) * gru_0_fwd_t2_h_6 + (-0.82398366928100586) * gru_0_fwd_t2_h_7 + (0.2930293083190918) * gru_0_fwd_t2_h_8 + (-0.88711154460906982) * gru_0_fwd_t2_h_9 + (-0.49756619334220886) * gru_0_fwd_t2_h_10 + (-0.56768560409545898) * gru_0_fwd_t2_h_11 + (0.017192307859659195) * gru_0_fwd_t2_h_12 + (0.1989082545042038) * gru_0_fwd_t2_h_13 + (-0.22937609255313873) * gru_0_fwd_t2_h_14 + (0.22781237959861755) * gru_0_fwd_t2_h_15 + (0.34069955348968506) * gru_0_fwd_t2_h_16 + (0.72557371854782104) * gru_0_fwd_t2_h_17 + (-0.024579359218478203) * gru_0_fwd_t2_h_18 + (-0.38082993030548096) * gru_0_fwd_t2_h_19 + (-0.7922016978263855) * gru_0_fwd_t2_h_20 + (0.19465383887290955) * gru_0_fwd_t2_h_21 + (-0.31221199035644531) * gru_0_fwd_t2_h_22 + (-0.24073119461536407) * gru_0_fwd_t2_h_23 + (-1.2072917222976685) * gru_0_fwd_t2_h_24 + (0.13368858397006989) * gru_0_fwd_t2_h_25 + (-0.075423531234264374) * gru_0_fwd_t2_h_26 + (0.018354333937168121) * gru_0_fwd_t2_h_27 + (1.2350516319274902) * gru_0_fwd_t2_h_28 + (0.26653066277503967) * gru_0_fwd_t2_h_29 + (-0.34060528874397278) * gru_0_fwd_t2_h_30 + (1.2555168867111206) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_5 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_5;
    // h=6
    gate_r = sigmoid((0.64718681573867798) + (0.19801533222198486) * emb_t3_0 + (-0.0867265984416008) * emb_t3_1 + (0.39526337385177612) * emb_t3_2 + (0.59442460536956787) * emb_t3_3 + (-1.6713958978652954) * emb_t3_4 + (-0.48412996530532837) * emb_t3_5 + (-1.2345925569534302) * emb_t3_6 + (0.3731066882610321) * emb_t3_7 + (-0.059344939887523651) * emb_t3_8 + (-0.17235365509986877) * emb_t3_9 + (0.098720982670783997) * emb_t3_10 + (0.8037988543510437) * emb_t3_11 + (0.17604853212833405) * emb_t3_12 + (-0.50221645832061768) * emb_t3_13 + (-0.072246849536895752) * emb_t3_14 + (-0.47506251931190491) * emb_t3_15 + (0.72383040189743042) * emb_t3_16 + (-1.1351902484893799) * emb_t3_17 + (-0.29391643404960632) * emb_t3_18 + (0.049772348254919052) * emb_t3_19 + (0.27598553895950317) * emb_t3_20 + (-0.43667089939117432) * emb_t3_21 + (-0.17478509247303009) * emb_t3_22 + (0.84320688247680664) * emb_t3_23 + (0.014079547487199306) * emb_t3_24 + (0.11643157154321671) * emb_t3_25 + (0.7422022819519043) * emb_t3_26 + (0.43766725063323975) * emb_t3_27 + (0.66482996940612793) * emb_t3_28 + (-0.97944372892379761) * emb_t3_29 + (1.7599998712539673) * emb_t3_30 + (-0.43428409099578857) * emb_t3_31 + (0.41334882378578186) * gru_0_fwd_t2_h_0 + (-0.1925504207611084) * gru_0_fwd_t2_h_1 + (-2.6722970008850098) * gru_0_fwd_t2_h_2 + (-1.6650885343551636) * gru_0_fwd_t2_h_3 + (-0.3213023841381073) * gru_0_fwd_t2_h_4 + (0.2936214804649353) * gru_0_fwd_t2_h_5 + (-1.6638959646224976) * gru_0_fwd_t2_h_6 + (2.747128963470459) * gru_0_fwd_t2_h_7 + (1.5438847541809082) * gru_0_fwd_t2_h_8 + (0.28904175758361816) * gru_0_fwd_t2_h_9 + (2.7759256362915039) * gru_0_fwd_t2_h_10 + (0.92301291227340698) * gru_0_fwd_t2_h_11 + (-0.0057234112173318863) * gru_0_fwd_t2_h_12 + (-0.02192533016204834) * gru_0_fwd_t2_h_13 + (0.50918436050415039) * gru_0_fwd_t2_h_14 + (-0.18030187487602234) * gru_0_fwd_t2_h_15 + (-0.30933082103729248) * gru_0_fwd_t2_h_16 + (-0.19719628989696503) * gru_0_fwd_t2_h_17 + (0.93164551258087158) * gru_0_fwd_t2_h_18 + (-2.1038591861724854) * gru_0_fwd_t2_h_19 + (-1.1186971664428711) * gru_0_fwd_t2_h_20 + (-0.55217283964157104) * gru_0_fwd_t2_h_21 + (-0.39519959688186646) * gru_0_fwd_t2_h_22 + (-0.70560318231582642) * gru_0_fwd_t2_h_23 + (2.5476551055908203) * gru_0_fwd_t2_h_24 + (1.6238029003143311) * gru_0_fwd_t2_h_25 + (1.268197774887085) * gru_0_fwd_t2_h_26 + (1.61891770362854) * gru_0_fwd_t2_h_27 + (-1.3980979919433594) * gru_0_fwd_t2_h_28 + (-0.21743656694889069) * gru_0_fwd_t2_h_29 + (0.32857745885848999) * gru_0_fwd_t2_h_30 + (-0.021983066573739052) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((0.65747576951980591) + (0.067206531763076782) * emb_t3_0 + (-1.0778428316116333) * emb_t3_1 + (0.013203871436417103) * emb_t3_2 + (0.66260325908660889) * emb_t3_3 + (-1.418946385383606) * emb_t3_4 + (0.1124672070145607) * emb_t3_5 + (-1.385934591293335) * emb_t3_6 + (0.071301370859146118) * emb_t3_7 + (-0.0080569591373205185) * emb_t3_8 + (0.87950176000595093) * emb_t3_9 + (0.783558189868927) * emb_t3_10 + (0.40700605511665344) * emb_t3_11 + (-0.21359671652317047) * emb_t3_12 + (-1.9497834444046021) * emb_t3_13 + (0.013992402702569962) * emb_t3_14 + (0.012638125568628311) * emb_t3_15 + (0.070883192121982574) * emb_t3_16 + (-0.49914065003395081) * emb_t3_17 + (0.9817812442779541) * emb_t3_18 + (-0.30810070037841797) * emb_t3_19 + (0.9564129114151001) * emb_t3_20 + (0.087537698447704315) * emb_t3_21 + (0.55111497640609741) * emb_t3_22 + (-0.18253946304321289) * emb_t3_23 + (0.020325871184468269) * emb_t3_24 + (-0.19879433512687683) * emb_t3_25 + (0.61750954389572144) * emb_t3_26 + (0.14947935938835144) * emb_t3_27 + (1.2325707674026489) * emb_t3_28 + (-1.5029821395874023) * emb_t3_29 + (0.86577075719833374) * emb_t3_30 + (0.03104882687330246) * emb_t3_31 + (0.59958583116531372) * gru_0_fwd_t2_h_0 + (0.2975432276725769) * gru_0_fwd_t2_h_1 + (1.02239990234375) * gru_0_fwd_t2_h_2 + (0.060360003262758255) * gru_0_fwd_t2_h_3 + (0.18729795515537262) * gru_0_fwd_t2_h_4 + (-0.079461477696895599) * gru_0_fwd_t2_h_5 + (0.94696670770645142) * gru_0_fwd_t2_h_6 + (-1.0941493511199951) * gru_0_fwd_t2_h_7 + (0.54810881614685059) * gru_0_fwd_t2_h_8 + (-0.23597410321235657) * gru_0_fwd_t2_h_9 + (-1.13671875) * gru_0_fwd_t2_h_10 + (0.035320322960615158) * gru_0_fwd_t2_h_11 + (-0.085650622844696045) * gru_0_fwd_t2_h_12 + (-0.0066009238362312317) * gru_0_fwd_t2_h_13 + (0.26930779218673706) * gru_0_fwd_t2_h_14 + (-0.71623456478118896) * gru_0_fwd_t2_h_15 + (-0.35170376300811768) * gru_0_fwd_t2_h_16 + (-0.23666961491107941) * gru_0_fwd_t2_h_17 + (0.27765944600105286) * gru_0_fwd_t2_h_18 + (-1.3791419267654419) * gru_0_fwd_t2_h_19 + (0.475484699010849) * gru_0_fwd_t2_h_20 + (0.26780727505683899) * gru_0_fwd_t2_h_21 + (0.76974028348922729) * gru_0_fwd_t2_h_22 + (-0.096689775586128235) * gru_0_fwd_t2_h_23 + (0.41597720980644226) * gru_0_fwd_t2_h_24 + (0.15075415372848511) * gru_0_fwd_t2_h_25 + (-0.48091259598731995) * gru_0_fwd_t2_h_26 + (0.64957869052886963) * gru_0_fwd_t2_h_27 + (-0.8535277247428894) * gru_0_fwd_t2_h_28 + (0.23530571162700653) * gru_0_fwd_t2_h_29 + (0.39489635825157166) * gru_0_fwd_t2_h_30 + (0.52870970964431763) * gru_0_fwd_t2_h_31);
    gate_n = tanh((0.099463798105716705) + (0.062709107995033264) * emb_t3_0 + (-1.2834712266921997) * emb_t3_1 + (-0.20859083533287048) * emb_t3_2 + (-0.23270703852176666) * emb_t3_3 + (-1.7919075489044189) * emb_t3_4 + (-0.14767941832542419) * emb_t3_5 + (-1.0104644298553467) * emb_t3_6 + (0.058522380888462067) * emb_t3_7 + (-0.043983135372400284) * emb_t3_8 + (0.87878221273422241) * emb_t3_9 + (0.63444536924362183) * emb_t3_10 + (0.33520248532295227) * emb_t3_11 + (0.19363673031330109) * emb_t3_12 + (-1.7711124420166016) * emb_t3_13 + (-0.071262359619140625) * emb_t3_14 + (0.23429438471794128) * emb_t3_15 + (-0.20724251866340637) * emb_t3_16 + (-0.54762935638427734) * emb_t3_17 + (0.27906295657157898) * emb_t3_18 + (-0.34379884600639343) * emb_t3_19 + (0.3323701024055481) * emb_t3_20 + (-0.067786872386932373) * emb_t3_21 + (0.44148370623588562) * emb_t3_22 + (0.070823103189468384) * emb_t3_23 + (0.046068795025348663) * emb_t3_24 + (0.0074522043578326702) * emb_t3_25 + (0.075301051139831543) * emb_t3_26 + (-0.041412565857172012) * emb_t3_27 + (0.99621200561523438) * emb_t3_28 + (-1.3909389972686768) * emb_t3_29 + (1.8566527366638184) * emb_t3_30 + (-0.0053352117538452148) * emb_t3_31 + gate_r * ((0.30352130532264709) + (0.29498741030693054) * gru_0_fwd_t2_h_0 + (0.28553986549377441) * gru_0_fwd_t2_h_1 + (-1.4457919597625732) * gru_0_fwd_t2_h_2 + (-1.5347727537155151) * gru_0_fwd_t2_h_3 + (0.31883007287979126) * gru_0_fwd_t2_h_4 + (0.24447634816169739) * gru_0_fwd_t2_h_5 + (-1.5395359992980957) * gru_0_fwd_t2_h_6 + (1.5528138875961304) * gru_0_fwd_t2_h_7 + (0.83012276887893677) * gru_0_fwd_t2_h_8 + (3.3659200668334961) * gru_0_fwd_t2_h_9 + (1.1309764385223389) * gru_0_fwd_t2_h_10 + (0.30454486608505249) * gru_0_fwd_t2_h_11 + (-0.10719244182109833) * gru_0_fwd_t2_h_12 + (-0.11211328208446503) * gru_0_fwd_t2_h_13 + (0.45527991652488708) * gru_0_fwd_t2_h_14 + (-0.20179574191570282) * gru_0_fwd_t2_h_15 + (-0.26636531949043274) * gru_0_fwd_t2_h_16 + (-0.11448907852172852) * gru_0_fwd_t2_h_17 + (0.1768258810043335) * gru_0_fwd_t2_h_18 + (2.2013874053955078) * gru_0_fwd_t2_h_19 + (5.6519656181335449) * gru_0_fwd_t2_h_20 + (0.069680765271186829) * gru_0_fwd_t2_h_21 + (-0.43679985404014587) * gru_0_fwd_t2_h_22 + (-0.86616194248199463) * gru_0_fwd_t2_h_23 + (1.6500822305679321) * gru_0_fwd_t2_h_24 + (1.1663918495178223) * gru_0_fwd_t2_h_25 + (0.0060790488496422768) * gru_0_fwd_t2_h_26 + (-1.0129396915435791) * gru_0_fwd_t2_h_27 + (-3.5183789730072021) * gru_0_fwd_t2_h_28 + (1.3851574659347534) * gru_0_fwd_t2_h_29 + (0.49753525853157043) * gru_0_fwd_t2_h_30 + (-0.61034590005874634) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_6 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_6;
    // h=7
    gate_r = sigmoid((0.51928806304931641) + (-0.66626828908920288) * emb_t3_0 + (-0.69206690788269043) * emb_t3_1 + (-0.62170642614364624) * emb_t3_2 + (0.37097975611686707) * emb_t3_3 + (-0.52362000942230225) * emb_t3_4 + (-0.77756184339523315) * emb_t3_5 + (-0.57556211948394775) * emb_t3_6 + (-0.203417107462883) * emb_t3_7 + (0.23473478853702545) * emb_t3_8 + (0.14919237792491913) * emb_t3_9 + (0.25177469849586487) * emb_t3_10 + (0.54501938819885254) * emb_t3_11 + (0.085423931479454041) * emb_t3_12 + (-0.52105075120925903) * emb_t3_13 + (0.28557261824607849) * emb_t3_14 + (0.41559216380119324) * emb_t3_15 + (-1.020171046257019) * emb_t3_16 + (-0.38878875970840454) * emb_t3_17 + (-0.0029973615892231464) * emb_t3_18 + (-0.043685823678970337) * emb_t3_19 + (0.29491478204727173) * emb_t3_20 + (0.517647385597229) * emb_t3_21 + (-0.30049300193786621) * emb_t3_22 + (0.30185249447822571) * emb_t3_23 + (0.021078580990433693) * emb_t3_24 + (-1.4541704654693604) * emb_t3_25 + (0.23514877259731293) * emb_t3_26 + (0.32835391163825989) * emb_t3_27 + (0.68314176797866821) * emb_t3_28 + (-1.168696403503418) * emb_t3_29 + (0.36824145913124084) * emb_t3_30 + (-0.071854352951049805) * emb_t3_31 + (0.067609131336212158) * gru_0_fwd_t2_h_0 + (0.44890889525413513) * gru_0_fwd_t2_h_1 + (0.6773419976234436) * gru_0_fwd_t2_h_2 + (-1.1850106716156006) * gru_0_fwd_t2_h_3 + (0.46819853782653809) * gru_0_fwd_t2_h_4 + (-0.42627942562103271) * gru_0_fwd_t2_h_5 + (1.5049042701721191) * gru_0_fwd_t2_h_6 + (-0.007247112225741148) * gru_0_fwd_t2_h_7 + (0.63717913627624512) * gru_0_fwd_t2_h_8 + (1.2650812864303589) * gru_0_fwd_t2_h_9 + (-0.70689678192138672) * gru_0_fwd_t2_h_10 + (-0.91478770971298218) * gru_0_fwd_t2_h_11 + (0.49776679277420044) * gru_0_fwd_t2_h_12 + (0.47686061263084412) * gru_0_fwd_t2_h_13 + (-0.11209805309772491) * gru_0_fwd_t2_h_14 + (0.2208324521780014) * gru_0_fwd_t2_h_15 + (0.41881099343299866) * gru_0_fwd_t2_h_16 + (0.93815094232559204) * gru_0_fwd_t2_h_17 + (0.032492909580469131) * gru_0_fwd_t2_h_18 + (-1.3166286945343018) * gru_0_fwd_t2_h_19 + (2.5782415866851807) * gru_0_fwd_t2_h_20 + (0.40010526776313782) * gru_0_fwd_t2_h_21 + (0.40507233142852783) * gru_0_fwd_t2_h_22 + (-0.64354175329208374) * gru_0_fwd_t2_h_23 + (-3.2980225086212158) * gru_0_fwd_t2_h_24 + (1.5116459131240845) * gru_0_fwd_t2_h_25 + (4.3645520210266113) * gru_0_fwd_t2_h_26 + (1.5522013902664185) * gru_0_fwd_t2_h_27 + (-1.4030581712722778) * gru_0_fwd_t2_h_28 + (1.7865886688232422) * gru_0_fwd_t2_h_29 + (0.41302406787872314) * gru_0_fwd_t2_h_30 + (-0.19169566035270691) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((0.73438847064971924) + (-0.0064645968377590179) * emb_t3_0 + (-0.18605630099773407) * emb_t3_1 + (-0.16207568347454071) * emb_t3_2 + (0.45738211274147034) * emb_t3_3 + (-0.46812623739242554) * emb_t3_4 + (-0.18255303800106049) * emb_t3_5 + (0.11743010580539703) * emb_t3_6 + (-0.12166249752044678) * emb_t3_7 + (0.29705497622489929) * emb_t3_8 + (-0.1868426501750946) * emb_t3_9 + (0.22550836205482483) * emb_t3_10 + (1.0174425840377808) * emb_t3_11 + (0.090879075229167938) * emb_t3_12 + (-0.70268082618713379) * emb_t3_13 + (-0.0981459841132164) * emb_t3_14 + (-0.11535448580980301) * emb_t3_15 + (-0.10888410359621048) * emb_t3_16 + (-0.5201079249382019) * emb_t3_17 + (0.19124570488929749) * emb_t3_18 + (-0.046256080269813538) * emb_t3_19 + (0.047293435782194138) * emb_t3_20 + (0.067851394414901733) * emb_t3_21 + (-0.34270498156547546) * emb_t3_22 + (0.073853291571140289) * emb_t3_23 + (0.22339893877506256) * emb_t3_24 + (0.24973474442958832) * emb_t3_25 + (0.49641150236129761) * emb_t3_26 + (-0.17480954527854919) * emb_t3_27 + (-0.0069416211917996407) * emb_t3_28 + (-0.66635668277740479) * emb_t3_29 + (0.090449713170528412) * emb_t3_30 + (-0.68994534015655518) * emb_t3_31 + (0.64985942840576172) * gru_0_fwd_t2_h_0 + (0.19538487493991852) * gru_0_fwd_t2_h_1 + (1.3278148174285889) * gru_0_fwd_t2_h_2 + (0.81885486841201782) * gru_0_fwd_t2_h_3 + (0.29815822839736938) * gru_0_fwd_t2_h_4 + (-0.50817477703094482) * gru_0_fwd_t2_h_5 + (-1.4653851985931396) * gru_0_fwd_t2_h_6 + (-0.80211502313613892) * gru_0_fwd_t2_h_7 + (-0.44001898169517517) * gru_0_fwd_t2_h_8 + (0.9476819634437561) * gru_0_fwd_t2_h_9 + (-0.98095953464508057) * gru_0_fwd_t2_h_10 + (0.72107189893722534) * gru_0_fwd_t2_h_11 + (-0.27601596713066101) * gru_0_fwd_t2_h_12 + (-0.79996955394744873) * gru_0_fwd_t2_h_13 + (0.10184107720851898) * gru_0_fwd_t2_h_14 + (0.14149783551692963) * gru_0_fwd_t2_h_15 + (-0.014779034070670605) * gru_0_fwd_t2_h_16 + (-0.41685998439788818) * gru_0_fwd_t2_h_17 + (0.11937406659126282) * gru_0_fwd_t2_h_18 + (1.5282425880432129) * gru_0_fwd_t2_h_19 + (0.74435275793075562) * gru_0_fwd_t2_h_20 + (-0.033118549734354019) * gru_0_fwd_t2_h_21 + (-1.0111247301101685) * gru_0_fwd_t2_h_22 + (0.60414385795593262) * gru_0_fwd_t2_h_23 + (0.82993137836456299) * gru_0_fwd_t2_h_24 + (-0.13905845582485199) * gru_0_fwd_t2_h_25 + (-0.14072522521018982) * gru_0_fwd_t2_h_26 + (-0.22697837650775909) * gru_0_fwd_t2_h_27 + (0.26962760090827942) * gru_0_fwd_t2_h_28 + (-0.12845060229301453) * gru_0_fwd_t2_h_29 + (0.38843050599098206) * gru_0_fwd_t2_h_30 + (1.9815202951431274) * gru_0_fwd_t2_h_31);
    gate_n = tanh((-0.10830821096897125) + (-0.0044161300174891949) * emb_t3_0 + (1.2483489513397217) * emb_t3_1 + (-0.20249013602733612) * emb_t3_2 + (-0.47926110029220581) * emb_t3_3 + (0.37111401557922363) * emb_t3_4 + (-0.28617849946022034) * emb_t3_5 + (0.62711554765701294) * emb_t3_6 + (-0.30587306618690491) * emb_t3_7 + (0.094337500631809235) * emb_t3_8 + (-0.37155324220657349) * emb_t3_9 + (-0.45645484328269958) * emb_t3_10 + (-0.012242344208061695) * emb_t3_11 + (0.22914335131645203) * emb_t3_12 + (0.80198967456817627) * emb_t3_13 + (-0.085915930569171906) * emb_t3_14 + (0.17644059658050537) * emb_t3_15 + (-0.10198923200368881) * emb_t3_16 + (-0.43352031707763672) * emb_t3_17 + (-0.72888320684432983) * emb_t3_18 + (0.12330874055624008) * emb_t3_19 + (-0.13199082016944885) * emb_t3_20 + (-0.080917231738567352) * emb_t3_21 + (-0.44285953044891357) * emb_t3_22 + (-0.0960673987865448) * emb_t3_23 + (0.28513142466545105) * emb_t3_24 + (4.5858068915549666e-05) * emb_t3_25 + (-0.029581915587186813) * emb_t3_26 + (-0.23752209544181824) * emb_t3_27 + (-1.454059362411499) * emb_t3_28 + (0.97153466939926147) * emb_t3_29 + (-0.49593016505241394) * emb_t3_30 + (-0.086260311305522919) * emb_t3_31 + gate_r * ((-0.10583814233541489) + (0.2016938179731369) * gru_0_fwd_t2_h_0 + (-0.00053945538820698857) * gru_0_fwd_t2_h_1 + (0.52430981397628784) * gru_0_fwd_t2_h_2 + (0.13030995428562164) * gru_0_fwd_t2_h_3 + (0.33396425843238831) * gru_0_fwd_t2_h_4 + (-1.5273259878158569) * gru_0_fwd_t2_h_5 + (-2.1187100410461426) * gru_0_fwd_t2_h_6 + (-1.2772527933120728) * gru_0_fwd_t2_h_7 + (-0.29961082339286804) * gru_0_fwd_t2_h_8 + (-0.34424695372581482) * gru_0_fwd_t2_h_9 + (-0.48198172450065613) * gru_0_fwd_t2_h_10 + (0.19718103110790253) * gru_0_fwd_t2_h_11 + (-0.33281877636909485) * gru_0_fwd_t2_h_12 + (-2.7101144790649414) * gru_0_fwd_t2_h_13 + (0.31475695967674255) * gru_0_fwd_t2_h_14 + (0.6801379919052124) * gru_0_fwd_t2_h_15 + (-0.53060495853424072) * gru_0_fwd_t2_h_16 + (-0.51198530197143555) * gru_0_fwd_t2_h_17 + (0.73494291305541992) * gru_0_fwd_t2_h_18 + (0.34764328598976135) * gru_0_fwd_t2_h_19 + (0.060747481882572174) * gru_0_fwd_t2_h_20 + (-0.22968952357769012) * gru_0_fwd_t2_h_21 + (0.098106242716312408) * gru_0_fwd_t2_h_22 + (0.61107033491134644) * gru_0_fwd_t2_h_23 + (-2.3478710651397705) * gru_0_fwd_t2_h_24 + (-0.69849437475204468) * gru_0_fwd_t2_h_25 + (-1.4497916698455811) * gru_0_fwd_t2_h_26 + (0.09782053530216217) * gru_0_fwd_t2_h_27 + (-0.4207339882850647) * gru_0_fwd_t2_h_28 + (-0.34333661198616028) * gru_0_fwd_t2_h_29 + (0.088049121201038361) * gru_0_fwd_t2_h_30 + (1.1988066434860229) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_7 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_7;
    // h=8
    gate_r = sigmoid((-2.1102445125579834) + (-0.64099812507629395) * emb_t3_0 + (0.18297652900218964) * emb_t3_1 + (-0.51232028007507324) * emb_t3_2 + (-1.0240108966827393) * emb_t3_3 + (0.42605817317962646) * emb_t3_4 + (0.98251241445541382) * emb_t3_5 + (0.69444173574447632) * emb_t3_6 + (0.85641461610794067) * emb_t3_7 + (-0.46913030743598938) * emb_t3_8 + (0.89420026540756226) * emb_t3_9 + (1.0797944068908691) * emb_t3_10 + (-1.0541499853134155) * emb_t3_11 + (-0.99826115369796753) * emb_t3_12 + (0.71844381093978882) * emb_t3_13 + (-0.16584454476833344) * emb_t3_14 + (0.79723727703094482) * emb_t3_15 + (-0.7281801700592041) * emb_t3_16 + (0.99311363697052002) * emb_t3_17 + (0.95930564403533936) * emb_t3_18 + (-0.67892605066299438) * emb_t3_19 + (-1.1966795921325684) * emb_t3_20 + (0.63275575637817383) * emb_t3_21 + (0.66495704650878906) * emb_t3_22 + (-0.72578388452529907) * emb_t3_23 + (0.84590631723403931) * emb_t3_24 + (-0.016845034435391426) * emb_t3_25 + (-0.73735642433166504) * emb_t3_26 + (-0.71553987264633179) * emb_t3_27 + (-0.30125522613525391) * emb_t3_28 + (0.38057148456573486) * emb_t3_29 + (-0.67262250185012817) * emb_t3_30 + (1.2060506343841553) * emb_t3_31 + (-0.84894436597824097) * gru_0_fwd_t2_h_0 + (-0.6338922381401062) * gru_0_fwd_t2_h_1 + (-0.040596727281808853) * gru_0_fwd_t2_h_2 + (1.1929042339324951) * gru_0_fwd_t2_h_3 + (-0.88270598649978638) * gru_0_fwd_t2_h_4 + (-1.2015831470489502) * gru_0_fwd_t2_h_5 + (0.53035688400268555) * gru_0_fwd_t2_h_6 + (-0.42501905560493469) * gru_0_fwd_t2_h_7 + (0.20497411489486694) * gru_0_fwd_t2_h_8 + (-0.13920921087265015) * gru_0_fwd_t2_h_9 + (-0.28797104954719543) * gru_0_fwd_t2_h_10 + (0.24502329528331757) * gru_0_fwd_t2_h_11 + (0.57306188344955444) * gru_0_fwd_t2_h_12 + (0.29016351699829102) * gru_0_fwd_t2_h_13 + (-0.64894348382949829) * gru_0_fwd_t2_h_14 + (1.4499149322509766) * gru_0_fwd_t2_h_15 + (0.87094360589981079) * gru_0_fwd_t2_h_16 + (-0.10382547229528427) * gru_0_fwd_t2_h_17 + (0.50576967000961304) * gru_0_fwd_t2_h_18 + (0.32818934321403503) * gru_0_fwd_t2_h_19 + (-0.1549752801656723) * gru_0_fwd_t2_h_20 + (0.13845831155776978) * gru_0_fwd_t2_h_21 + (-0.38481009006500244) * gru_0_fwd_t2_h_22 + (0.21326933801174164) * gru_0_fwd_t2_h_23 + (0.21375775337219238) * gru_0_fwd_t2_h_24 + (0.053267087787389755) * gru_0_fwd_t2_h_25 + (0.72237354516983032) * gru_0_fwd_t2_h_26 + (-0.52174323797225952) * gru_0_fwd_t2_h_27 + (0.18771404027938843) * gru_0_fwd_t2_h_28 + (-0.38091662526130676) * gru_0_fwd_t2_h_29 + (-0.92795312404632568) * gru_0_fwd_t2_h_30 + (0.66399639844894409) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((0.6772809624671936) + (-0.0032808671239763498) * emb_t3_0 + (-0.3112979531288147) * emb_t3_1 + (-0.010762996971607208) * emb_t3_2 + (0.079995937645435333) * emb_t3_3 + (0.059131823480129242) * emb_t3_4 + (0.0050346935167908669) * emb_t3_5 + (-0.10491648316383362) * emb_t3_6 + (-0.0042254058644175529) * emb_t3_7 + (0.50806194543838501) * emb_t3_8 + (-0.049719773232936859) * emb_t3_9 + (-0.048791203647851944) * emb_t3_10 + (0.52275699377059937) * emb_t3_11 + (-0.1125863790512085) * emb_t3_12 + (-0.22505795955657959) * emb_t3_13 + (-0.00020142269204370677) * emb_t3_14 + (0.00065615866333246231) * emb_t3_15 + (-0.0057878624647855759) * emb_t3_16 + (-0.42166346311569214) * emb_t3_17 + (0.04228254035115242) * emb_t3_18 + (0.085595965385437012) * emb_t3_19 + (0.22659857571125031) * emb_t3_20 + (-0.002691956702619791) * emb_t3_21 + (0.33013865351676941) * emb_t3_22 + (-0.0034022859763354063) * emb_t3_23 + (-0.0040348111651837826) * emb_t3_24 + (-0.0038222384173423052) * emb_t3_25 + (-0.013078427873551846) * emb_t3_26 + (-0.0054868278093636036) * emb_t3_27 + (0.048570383340120316) * emb_t3_28 + (-0.018936770036816597) * emb_t3_29 + (0.53899973630905151) * emb_t3_30 + (0.12751126289367676) * emb_t3_31 + (-0.82060790061950684) * gru_0_fwd_t2_h_0 + (-0.77872204780578613) * gru_0_fwd_t2_h_1 + (-0.34278988838195801) * gru_0_fwd_t2_h_2 + (0.99013000726699829) * gru_0_fwd_t2_h_3 + (-0.83292549848556519) * gru_0_fwd_t2_h_4 + (0.02025747112929821) * gru_0_fwd_t2_h_5 + (1.9733446836471558) * gru_0_fwd_t2_h_6 + (0.54976308345794678) * gru_0_fwd_t2_h_7 + (-0.73911535739898682) * gru_0_fwd_t2_h_8 + (-1.1636242866516113) * gru_0_fwd_t2_h_9 + (0.26721858978271484) * gru_0_fwd_t2_h_10 + (-0.69625484943389893) * gru_0_fwd_t2_h_11 + (1.1293892860412598) * gru_0_fwd_t2_h_12 + (0.64323961734771729) * gru_0_fwd_t2_h_13 + (-0.46308672428131104) * gru_0_fwd_t2_h_14 + (1.0495226383209229) * gru_0_fwd_t2_h_15 + (0.55621910095214844) * gru_0_fwd_t2_h_16 + (0.32059207558631897) * gru_0_fwd_t2_h_17 + (-1.0575906038284302) * gru_0_fwd_t2_h_18 + (1.0924899578094482) * gru_0_fwd_t2_h_19 + (-0.94153982400894165) * gru_0_fwd_t2_h_20 + (-1.0066181421279907) * gru_0_fwd_t2_h_21 + (0.15435196459293365) * gru_0_fwd_t2_h_22 + (-0.24547705054283142) * gru_0_fwd_t2_h_23 + (0.34429788589477539) * gru_0_fwd_t2_h_24 + (0.18252860009670258) * gru_0_fwd_t2_h_25 + (-0.00036616771831177175) * gru_0_fwd_t2_h_26 + (-0.44742515683174133) * gru_0_fwd_t2_h_27 + (-0.19489307701587677) * gru_0_fwd_t2_h_28 + (-0.13575111329555511) * gru_0_fwd_t2_h_29 + (-0.74507838487625122) * gru_0_fwd_t2_h_30 + (0.77776861190795898) * gru_0_fwd_t2_h_31);
    gate_n = tanh((-0.14400477707386017) + (0.017657605931162834) * emb_t3_0 + (0.52903920412063599) * emb_t3_1 + (0.19074809551239014) * emb_t3_2 + (-0.13002277910709381) * emb_t3_3 + (0.81449234485626221) * emb_t3_4 + (-0.046540670096874237) * emb_t3_5 + (-0.16178229451179504) * emb_t3_6 + (-0.070509575307369232) * emb_t3_7 + (-0.28544071316719055) * emb_t3_8 + (-0.28470435738563538) * emb_t3_9 + (-0.017579587176442146) * emb_t3_10 + (-0.28403806686401367) * emb_t3_11 + (0.19652369618415833) * emb_t3_12 + (0.63823056221008301) * emb_t3_13 + (0.049733228981494904) * emb_t3_14 + (-0.056254390627145767) * emb_t3_15 + (0.081860765814781189) * emb_t3_16 + (0.50213766098022461) * emb_t3_17 + (-0.15268562734127045) * emb_t3_18 + (-0.28229197859764099) * emb_t3_19 + (-0.2869446873664856) * emb_t3_20 + (-0.10242445766925812) * emb_t3_21 + (-0.15779213607311249) * emb_t3_22 + (0.037097692489624023) * emb_t3_23 + (-0.029618021100759506) * emb_t3_24 + (-0.086710184812545776) * emb_t3_25 + (-0.55746769905090332) * emb_t3_26 + (0.026910783722996712) * emb_t3_27 + (-0.58989018201828003) * emb_t3_28 + (0.23668175935745239) * emb_t3_29 + (-0.71780180931091309) * emb_t3_30 + (-0.043909285217523575) * emb_t3_31 + gate_r * ((0.087005168199539185) + (0.063888326287269592) * gru_0_fwd_t2_h_0 + (-0.35430386662483215) * gru_0_fwd_t2_h_1 + (0.41224220395088196) * gru_0_fwd_t2_h_2 + (0.58040314912796021) * gru_0_fwd_t2_h_3 + (-0.4396074116230011) * gru_0_fwd_t2_h_4 + (-0.77431201934814453) * gru_0_fwd_t2_h_5 + (0.37736198306083679) * gru_0_fwd_t2_h_6 + (-0.040429241955280304) * gru_0_fwd_t2_h_7 + (-0.34044015407562256) * gru_0_fwd_t2_h_8 + (-0.095932386815547943) * gru_0_fwd_t2_h_9 + (0.013764162547886372) * gru_0_fwd_t2_h_10 + (0.14016297459602356) * gru_0_fwd_t2_h_11 + (0.25288084149360657) * gru_0_fwd_t2_h_12 + (0.16335810720920563) * gru_0_fwd_t2_h_13 + (0.37526193261146545) * gru_0_fwd_t2_h_14 + (0.35459306836128235) * gru_0_fwd_t2_h_15 + (-0.1204790398478508) * gru_0_fwd_t2_h_16 + (-0.23970738053321838) * gru_0_fwd_t2_h_17 + (0.23090445995330811) * gru_0_fwd_t2_h_18 + (-0.047148708254098892) * gru_0_fwd_t2_h_19 + (-0.54039394855499268) * gru_0_fwd_t2_h_20 + (-0.088330924510955811) * gru_0_fwd_t2_h_21 + (0.0024632676504552364) * gru_0_fwd_t2_h_22 + (0.18685212731361389) * gru_0_fwd_t2_h_23 + (-0.11592207849025726) * gru_0_fwd_t2_h_24 + (-0.64342427253723145) * gru_0_fwd_t2_h_25 + (0.43200528621673584) * gru_0_fwd_t2_h_26 + (-0.14468787610530853) * gru_0_fwd_t2_h_27 + (-0.099868424236774445) * gru_0_fwd_t2_h_28 + (-0.085422948002815247) * gru_0_fwd_t2_h_29 + (0.20468093454837799) * gru_0_fwd_t2_h_30 + (0.60648691654205322) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_8 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_8;
    // h=9
    gate_r = sigmoid((-1.0291666984558105) + (-0.21775640547275543) * emb_t3_0 + (-1.8440258502960205) * emb_t3_1 + (-0.93004554510116577) * emb_t3_2 + (-0.30066102743148804) * emb_t3_3 + (0.34967991709709167) * emb_t3_4 + (0.14449562132358551) * emb_t3_5 + (0.64237546920776367) * emb_t3_6 + (0.92417067289352417) * emb_t3_7 + (-0.57878071069717407) * emb_t3_8 + (1.0784271955490112) * emb_t3_9 + (0.81259322166442871) * emb_t3_10 + (0.2183707058429718) * emb_t3_11 + (-0.060155056416988373) * emb_t3_12 + (-0.47093659639358521) * emb_t3_13 + (0.36868727207183838) * emb_t3_14 + (0.037063281983137131) * emb_t3_15 + (-1.0734480619430542) * emb_t3_16 + (0.10764206945896149) * emb_t3_17 + (0.4209350049495697) * emb_t3_18 + (-0.3842143714427948) * emb_t3_19 + (-0.65933746099472046) * emb_t3_20 + (0.68210357427597046) * emb_t3_21 + (0.55667674541473389) * emb_t3_22 + (-0.87310385704040527) * emb_t3_23 + (0.14842422306537628) * emb_t3_24 + (0.10924425721168518) * emb_t3_25 + (-0.72992944717407227) * emb_t3_26 + (-0.93228572607040405) * emb_t3_27 + (1.7560552358627319) * emb_t3_28 + (-0.79292899370193481) * emb_t3_29 + (-0.46273943781852722) * emb_t3_30 + (0.59081840515136719) * emb_t3_31 + (-1.3595693111419678) * gru_0_fwd_t2_h_0 + (0.3105807900428772) * gru_0_fwd_t2_h_1 + (0.03615405410528183) * gru_0_fwd_t2_h_2 + (0.42669129371643066) * gru_0_fwd_t2_h_3 + (-0.11484607309103012) * gru_0_fwd_t2_h_4 + (0.39541345834732056) * gru_0_fwd_t2_h_5 + (-0.9882960319519043) * gru_0_fwd_t2_h_6 + (-0.31572169065475464) * gru_0_fwd_t2_h_7 + (0.65913540124893188) * gru_0_fwd_t2_h_8 + (-0.94910144805908203) * gru_0_fwd_t2_h_9 + (0.34012278914451599) * gru_0_fwd_t2_h_10 + (-0.47219425439834595) * gru_0_fwd_t2_h_11 + (0.26353141665458679) * gru_0_fwd_t2_h_12 + (0.067969560623168945) * gru_0_fwd_t2_h_13 + (-0.92074286937713623) * gru_0_fwd_t2_h_14 + (1.4525289535522461) * gru_0_fwd_t2_h_15 + (0.60223031044006348) * gru_0_fwd_t2_h_16 + (0.7999541163444519) * gru_0_fwd_t2_h_17 + (1.0592775344848633) * gru_0_fwd_t2_h_18 + (-1.8160401582717896) * gru_0_fwd_t2_h_19 + (-1.5269317626953125) * gru_0_fwd_t2_h_20 + (0.30956953763961792) * gru_0_fwd_t2_h_21 + (-1.4395476579666138) * gru_0_fwd_t2_h_22 + (-0.3491356372833252) * gru_0_fwd_t2_h_23 + (1.3573189973831177) * gru_0_fwd_t2_h_24 + (0.62004417181015015) * gru_0_fwd_t2_h_25 + (-0.61518222093582153) * gru_0_fwd_t2_h_26 + (1.9287381172180176) * gru_0_fwd_t2_h_27 + (2.0179994106292725) * gru_0_fwd_t2_h_28 + (0.50569581985473633) * gru_0_fwd_t2_h_29 + (-0.36348322033882141) * gru_0_fwd_t2_h_30 + (-1.7054089307785034) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((0.85079783201217651) + (0.027700528502464294) * emb_t3_0 + (-1.6402249336242676) * emb_t3_1 + (0.003532967995852232) * emb_t3_2 + (0.77251291275024414) * emb_t3_3 + (-1.3702539205551147) * emb_t3_4 + (-0.063031569123268127) * emb_t3_5 + (-1.3805216550827026) * emb_t3_6 + (0.028332382440567017) * emb_t3_7 + (0.25258532166481018) * emb_t3_8 + (0.87281262874603271) * emb_t3_9 + (0.63106030225753784) * emb_t3_10 + (0.51318782567977905) * emb_t3_11 + (0.20813657343387604) * emb_t3_12 + (-1.4596974849700928) * emb_t3_13 + (-0.11888401210308075) * emb_t3_14 + (-0.087026022374629974) * emb_t3_15 + (0.14262071251869202) * emb_t3_16 + (-0.98146480321884155) * emb_t3_17 + (0.26782575249671936) * emb_t3_18 + (-0.46255949139595032) * emb_t3_19 + (0.74560445547103882) * emb_t3_20 + (-0.2749481201171875) * emb_t3_21 + (-0.33875569701194763) * emb_t3_22 + (0.39340636134147644) * emb_t3_23 + (-0.22331483662128448) * emb_t3_24 + (0.14061516523361206) * emb_t3_25 + (0.79723787307739258) * emb_t3_26 + (0.13435083627700806) * emb_t3_27 + (1.3481860160827637) * emb_t3_28 + (-1.299435019493103) * emb_t3_29 + (1.7842432260513306) * emb_t3_30 + (-0.33600029349327087) * emb_t3_31 + (0.04364752396941185) * gru_0_fwd_t2_h_0 + (0.76857584714889526) * gru_0_fwd_t2_h_1 + (-0.064171619713306427) * gru_0_fwd_t2_h_2 + (-1.4456877708435059) * gru_0_fwd_t2_h_3 + (0.73483419418334961) * gru_0_fwd_t2_h_4 + (0.50353491306304932) * gru_0_fwd_t2_h_5 + (1.2429378032684326) * gru_0_fwd_t2_h_6 + (0.24548597633838654) * gru_0_fwd_t2_h_7 + (-0.044744715094566345) * gru_0_fwd_t2_h_8 + (-2.2741949558258057) * gru_0_fwd_t2_h_9 + (-0.16652980446815491) * gru_0_fwd_t2_h_10 + (-0.40498128533363342) * gru_0_fwd_t2_h_11 + (-0.78659147024154663) * gru_0_fwd_t2_h_12 + (0.32747757434844971) * gru_0_fwd_t2_h_13 + (0.46970006823539734) * gru_0_fwd_t2_h_14 + (-0.75661355257034302) * gru_0_fwd_t2_h_15 + (-0.50469964742660522) * gru_0_fwd_t2_h_16 + (-0.19922125339508057) * gru_0_fwd_t2_h_17 + (0.19081026315689087) * gru_0_fwd_t2_h_18 + (-1.5592091083526611) * gru_0_fwd_t2_h_19 + (-2.318049430847168) * gru_0_fwd_t2_h_20 + (-0.096753008663654327) * gru_0_fwd_t2_h_21 + (-0.88264548778533936) * gru_0_fwd_t2_h_22 + (-0.24940571188926697) * gru_0_fwd_t2_h_23 + (0.22806352376937866) * gru_0_fwd_t2_h_24 + (0.51703208684921265) * gru_0_fwd_t2_h_25 + (-0.2743927538394928) * gru_0_fwd_t2_h_26 + (0.2976660430431366) * gru_0_fwd_t2_h_27 + (0.42707479000091553) * gru_0_fwd_t2_h_28 + (2.4570937156677246) * gru_0_fwd_t2_h_29 + (0.28030979633331299) * gru_0_fwd_t2_h_30 + (-1.1908520460128784) * gru_0_fwd_t2_h_31);
    gate_n = tanh((-0.055959109216928482) + (-0.051719106733798981) * emb_t3_0 + (2.6439423561096191) * emb_t3_1 + (-0.03181258961558342) * emb_t3_2 + (-0.39270472526550293) * emb_t3_3 + (0.44733655452728271) * emb_t3_4 + (-0.019772948697209358) * emb_t3_5 + (0.25335595011711121) * emb_t3_6 + (-0.011402004398405552) * emb_t3_7 + (-0.11188554763793945) * emb_t3_8 + (-1.1831616163253784) * emb_t3_9 + (-0.53981113433837891) * emb_t3_10 + (0.11820565164089203) * emb_t3_11 + (-0.049987800419330597) * emb_t3_12 + (2.0571584701538086) * emb_t3_13 + (0.011857649311423302) * emb_t3_14 + (0.0038197364192456007) * emb_t3_15 + (-0.027544032782316208) * emb_t3_16 + (0.67758220434188843) * emb_t3_17 + (-0.68091249465942383) * emb_t3_18 + (-0.011754167266190052) * emb_t3_19 + (0.14636367559432983) * emb_t3_20 + (0.051333952695131302) * emb_t3_21 + (-0.057307995855808258) * emb_t3_22 + (-0.003894260386005044) * emb_t3_23 + (0.0083711054176092148) * emb_t3_24 + (-0.022006513550877571) * emb_t3_25 + (0.40414318442344666) * emb_t3_26 + (0.028273157775402069) * emb_t3_27 + (-1.8429552316665649) * emb_t3_28 + (1.1191720962524414) * emb_t3_29 + (-0.14868780970573425) * emb_t3_30 + (0.076381869614124298) * emb_t3_31 + gate_r * ((-0.27155947685241699) + (0.50994867086410522) * gru_0_fwd_t2_h_0 + (0.064687661826610565) * gru_0_fwd_t2_h_1 + (-0.26204624772071838) * gru_0_fwd_t2_h_2 + (-0.76411658525466919) * gru_0_fwd_t2_h_3 + (0.03781445324420929) * gru_0_fwd_t2_h_4 + (0.020905639976263046) * gru_0_fwd_t2_h_5 + (2.6629087924957275) * gru_0_fwd_t2_h_6 + (0.27694472670555115) * gru_0_fwd_t2_h_7 + (0.12950915098190308) * gru_0_fwd_t2_h_8 + (0.3509196937084198) * gru_0_fwd_t2_h_9 + (0.18956245481967926) * gru_0_fwd_t2_h_10 + (0.37658938765525818) * gru_0_fwd_t2_h_11 + (-0.13181357085704803) * gru_0_fwd_t2_h_12 + (-0.13751678168773651) * gru_0_fwd_t2_h_13 + (0.024980755522847176) * gru_0_fwd_t2_h_14 + (-0.033619947731494904) * gru_0_fwd_t2_h_15 + (0.26171833276748657) * gru_0_fwd_t2_h_16 + (0.091965459287166595) * gru_0_fwd_t2_h_17 + (-1.1338552236557007) * gru_0_fwd_t2_h_18 + (1.4432523250579834) * gru_0_fwd_t2_h_19 + (0.84344375133514404) * gru_0_fwd_t2_h_20 + (0.038401640951633453) * gru_0_fwd_t2_h_21 + (1.7251847982406616) * gru_0_fwd_t2_h_22 + (0.079124584794044495) * gru_0_fwd_t2_h_23 + (-1.2314834594726562) * gru_0_fwd_t2_h_24 + (-0.26243951916694641) * gru_0_fwd_t2_h_25 + (0.90659612417221069) * gru_0_fwd_t2_h_26 + (-0.66635364294052124) * gru_0_fwd_t2_h_27 + (-0.90394556522369385) * gru_0_fwd_t2_h_28 + (-0.043215785175561905) * gru_0_fwd_t2_h_29 + (-0.42130252718925476) * gru_0_fwd_t2_h_30 + (1.0876805782318115) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_9 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_9;
    // h=10
    gate_r = sigmoid((-0.2903326153755188) + (0.37272307276725769) * emb_t3_0 + (2.1254901885986328) * emb_t3_1 + (0.51294076442718506) * emb_t3_2 + (-0.28422167897224426) * emb_t3_3 + (1.0091205835342407) * emb_t3_4 + (0.28378525376319885) * emb_t3_5 + (0.4720015823841095) * emb_t3_6 + (0.54543757438659668) * emb_t3_7 + (-0.060786671936511993) * emb_t3_8 + (-1.2298010587692261) * emb_t3_9 + (-0.42318448424339294) * emb_t3_10 + (-0.058135654777288437) * emb_t3_11 + (-0.13925759494304657) * emb_t3_12 + (2.0293993949890137) * emb_t3_13 + (0.045136716216802597) * emb_t3_14 + (-0.010812145657837391) * emb_t3_15 + (0.14596937596797943) * emb_t3_16 + (0.77113783359527588) * emb_t3_17 + (-0.4976145327091217) * emb_t3_18 + (0.28042915463447571) * emb_t3_19 + (-0.2694212794303894) * emb_t3_20 + (0.71386456489562988) * emb_t3_21 + (-0.38260719180107117) * emb_t3_22 + (-0.42595985531806946) * emb_t3_23 + (0.58858376741409302) * emb_t3_24 + (-1.0039747953414917) * emb_t3_25 + (-0.71076148748397827) * emb_t3_26 + (-0.3871326744556427) * emb_t3_27 + (-1.5637490749359131) * emb_t3_28 + (1.9813101291656494) * emb_t3_29 + (-0.6420896053314209) * emb_t3_30 + (-0.4590383768081665) * emb_t3_31 + (0.24292473495006561) * gru_0_fwd_t2_h_0 + (1.1668368577957153) * gru_0_fwd_t2_h_1 + (-1.4260040521621704) * gru_0_fwd_t2_h_2 + (0.081427648663520813) * gru_0_fwd_t2_h_3 + (-0.27907374501228333) * gru_0_fwd_t2_h_4 + (-0.62538629770278931) * gru_0_fwd_t2_h_5 + (1.6038655042648315) * gru_0_fwd_t2_h_6 + (1.5079123973846436) * gru_0_fwd_t2_h_7 + (0.62992048263549805) * gru_0_fwd_t2_h_8 + (-0.7392544150352478) * gru_0_fwd_t2_h_9 + (1.1289826631546021) * gru_0_fwd_t2_h_10 + (-0.20437446236610413) * gru_0_fwd_t2_h_11 + (0.60902053117752075) * gru_0_fwd_t2_h_12 + (0.76403748989105225) * gru_0_fwd_t2_h_13 + (0.13490474224090576) * gru_0_fwd_t2_h_14 + (0.86240559816360474) * gru_0_fwd_t2_h_15 + (0.43386802077293396) * gru_0_fwd_t2_h_16 + (0.21007892489433289) * gru_0_fwd_t2_h_17 + (0.59327840805053711) * gru_0_fwd_t2_h_18 + (0.673908531665802) * gru_0_fwd_t2_h_19 + (-0.1562994122505188) * gru_0_fwd_t2_h_20 + (0.3929002583026886) * gru_0_fwd_t2_h_21 + (0.78684711456298828) * gru_0_fwd_t2_h_22 + (-0.47935879230499268) * gru_0_fwd_t2_h_23 + (-0.86181312799453735) * gru_0_fwd_t2_h_24 + (-0.17392794787883759) * gru_0_fwd_t2_h_25 + (0.49387761950492859) * gru_0_fwd_t2_h_26 + (1.1017006635665894) * gru_0_fwd_t2_h_27 + (0.44429120421409607) * gru_0_fwd_t2_h_28 + (0.047304622828960419) * gru_0_fwd_t2_h_29 + (-0.21966002881526947) * gru_0_fwd_t2_h_30 + (1.1421937942504883) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((0.57233887910842896) + (0.090228058397769928) * emb_t3_0 + (-0.36436763405799866) * emb_t3_1 + (-0.0051405825652182102) * emb_t3_2 + (0.95805394649505615) * emb_t3_3 + (-0.1199549064040184) * emb_t3_4 + (-0.30429720878601074) * emb_t3_5 + (-0.12012226134538651) * emb_t3_6 + (-0.042424552142620087) * emb_t3_7 + (0.26405581831932068) * emb_t3_8 + (0.43321284651756287) * emb_t3_9 + (0.60185432434082031) * emb_t3_10 + (0.17534030973911285) * emb_t3_11 + (-0.36868458986282349) * emb_t3_12 + (-0.13284038007259369) * emb_t3_13 + (0.053552355617284775) * emb_t3_14 + (0.010950467549264431) * emb_t3_15 + (0.22625735402107239) * emb_t3_16 + (-0.54855036735534668) * emb_t3_17 + (0.1969267725944519) * emb_t3_18 + (-0.12199658155441284) * emb_t3_19 + (0.11403308063745499) * emb_t3_20 + (-0.22981852293014526) * emb_t3_21 + (0.57611727714538574) * emb_t3_22 + (-0.094779215753078461) * emb_t3_23 + (-0.20558524131774902) * emb_t3_24 + (0.16236050426959991) * emb_t3_25 + (0.33887395262718201) * emb_t3_26 + (0.13582667708396912) * emb_t3_27 + (0.32426339387893677) * emb_t3_28 + (0.023488067090511322) * emb_t3_29 + (0.90272992849349976) * emb_t3_30 + (-0.12089567631483078) * emb_t3_31 + (-0.30256864428520203) * gru_0_fwd_t2_h_0 + (0.36382913589477539) * gru_0_fwd_t2_h_1 + (0.69661259651184082) * gru_0_fwd_t2_h_2 + (-2.5443358421325684) * gru_0_fwd_t2_h_3 + (0.70908015966415405) * gru_0_fwd_t2_h_4 + (-0.39497953653335571) * gru_0_fwd_t2_h_5 + (-1.2060931921005249) * gru_0_fwd_t2_h_6 + (-0.99475961923599243) * gru_0_fwd_t2_h_7 + (-0.26585802435874939) * gru_0_fwd_t2_h_8 + (1.1499350070953369) * gru_0_fwd_t2_h_9 + (-0.86988794803619385) * gru_0_fwd_t2_h_10 + (-0.86657655239105225) * gru_0_fwd_t2_h_11 + (-0.56321561336517334) * gru_0_fwd_t2_h_12 + (-0.66391599178314209) * gru_0_fwd_t2_h_13 + (0.96256345510482788) * gru_0_fwd_t2_h_14 + (-1.9237656593322754) * gru_0_fwd_t2_h_15 + (-0.69726389646530151) * gru_0_fwd_t2_h_16 + (-0.45243427157402039) * gru_0_fwd_t2_h_17 + (-0.82856094837188721) * gru_0_fwd_t2_h_18 + (-0.26724031567573547) * gru_0_fwd_t2_h_19 + (0.98476874828338623) * gru_0_fwd_t2_h_20 + (-0.40161135792732239) * gru_0_fwd_t2_h_21 + (-1.4788168668746948) * gru_0_fwd_t2_h_22 + (0.13274243474006653) * gru_0_fwd_t2_h_23 + (1.873927116394043) * gru_0_fwd_t2_h_24 + (0.047955486923456192) * gru_0_fwd_t2_h_25 + (-0.65096127986907959) * gru_0_fwd_t2_h_26 + (-0.27890083193778992) * gru_0_fwd_t2_h_27 + (-0.86823314428329468) * gru_0_fwd_t2_h_28 + (0.60682368278503418) * gru_0_fwd_t2_h_29 + (0.90974825620651245) * gru_0_fwd_t2_h_30 + (-0.83886760473251343) * gru_0_fwd_t2_h_31);
    gate_n = tanh((-0.40624549984931946) + (0.19553357362747192) * emb_t3_0 + (0.61454755067825317) * emb_t3_1 + (0.22711406648159027) * emb_t3_2 + (-0.47619748115539551) * emb_t3_3 + (0.5250057578086853) * emb_t3_4 + (-0.30787089467048645) * emb_t3_5 + (0.58269178867340088) * emb_t3_6 + (0.2436896413564682) * emb_t3_7 + (-0.56383085250854492) * emb_t3_8 + (-0.066878989338874817) * emb_t3_9 + (0.07875882089138031) * emb_t3_10 + (-0.02602069079875946) * emb_t3_11 + (-0.54256433248519897) * emb_t3_12 + (0.59359228610992432) * emb_t3_13 + (-0.64823770523071289) * emb_t3_14 + (0.84101134538650513) * emb_t3_15 + (-0.66109991073608398) * emb_t3_16 + (0.95889270305633545) * emb_t3_17 + (0.31039738655090332) * emb_t3_18 + (-0.25118133425712585) * emb_t3_19 + (-0.53400975465774536) * emb_t3_20 + (0.42753329873085022) * emb_t3_21 + (0.42158985137939453) * emb_t3_22 + (-0.27095669507980347) * emb_t3_23 + (-0.020703541114926338) * emb_t3_24 + (-0.51858866214752197) * emb_t3_25 + (-0.3015424907207489) * emb_t3_26 + (-0.28902149200439453) * emb_t3_27 + (-0.44251716136932373) * emb_t3_28 + (1.1271430253982544) * emb_t3_29 + (-0.9146265983581543) * emb_t3_30 + (0.71135240793228149) * emb_t3_31 + gate_r * ((0.168348029255867) + (-0.38537079095840454) * gru_0_fwd_t2_h_0 + (0.41060531139373779) * gru_0_fwd_t2_h_1 + (-0.70355117321014404) * gru_0_fwd_t2_h_2 + (0.99690449237823486) * gru_0_fwd_t2_h_3 + (0.22493129968643188) * gru_0_fwd_t2_h_4 + (0.0051134857349097729) * gru_0_fwd_t2_h_5 + (-0.0041355774737894535) * gru_0_fwd_t2_h_6 + (0.57902765274047852) * gru_0_fwd_t2_h_7 + (-0.094685196876525879) * gru_0_fwd_t2_h_8 + (0.20434698462486267) * gru_0_fwd_t2_h_9 + (0.88527071475982666) * gru_0_fwd_t2_h_10 + (-0.67636287212371826) * gru_0_fwd_t2_h_11 + (0.63379651308059692) * gru_0_fwd_t2_h_12 + (-0.48752933740615845) * gru_0_fwd_t2_h_13 + (-0.6990436315536499) * gru_0_fwd_t2_h_14 + (0.75626653432846069) * gru_0_fwd_t2_h_15 + (0.041450876742601395) * gru_0_fwd_t2_h_16 + (0.33057296276092529) * gru_0_fwd_t2_h_17 + (0.11691021919250488) * gru_0_fwd_t2_h_18 + (0.10554688423871994) * gru_0_fwd_t2_h_19 + (0.35515418648719788) * gru_0_fwd_t2_h_20 + (-0.37428972125053406) * gru_0_fwd_t2_h_21 + (-0.43946847319602966) * gru_0_fwd_t2_h_22 + (0.14420497417449951) * gru_0_fwd_t2_h_23 + (0.97654640674591064) * gru_0_fwd_t2_h_24 + (0.51884651184082031) * gru_0_fwd_t2_h_25 + (-0.031644299626350403) * gru_0_fwd_t2_h_26 + (-0.081154756247997284) * gru_0_fwd_t2_h_27 + (0.3023676872253418) * gru_0_fwd_t2_h_28 + (0.20551168918609619) * gru_0_fwd_t2_h_29 + (0.12971283495426178) * gru_0_fwd_t2_h_30 + (-4.1572079658508301) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_10 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_10;
    // h=11
    gate_r = sigmoid((0.1956886500120163) + (0.0029698507860302925) * emb_t3_0 + (0.65398687124252319) * emb_t3_1 + (0.059658382087945938) * emb_t3_2 + (-0.18636082112789154) * emb_t3_3 + (-0.13120843470096588) * emb_t3_4 + (-0.3475576639175415) * emb_t3_5 + (0.11475776880979538) * emb_t3_6 + (-0.12411230802536011) * emb_t3_7 + (-0.065247401595115662) * emb_t3_8 + (-1.1529113054275513) * emb_t3_9 + (-1.7391422986984253) * emb_t3_10 + (0.48048648238182068) * emb_t3_11 + (0.5705493688583374) * emb_t3_12 + (0.15491962432861328) * emb_t3_13 + (-0.17362949252128601) * emb_t3_14 + (0.12102485448122025) * emb_t3_15 + (0.046184800565242767) * emb_t3_16 + (0.36707079410552979) * emb_t3_17 + (-1.5311754941940308) * emb_t3_18 + (1.3056511878967285) * emb_t3_19 + (0.22978360950946808) * emb_t3_20 + (-0.15438579022884369) * emb_t3_21 + (-0.71544802188873291) * emb_t3_22 + (0.0093332389369606972) * emb_t3_23 + (-0.12306014448404312) * emb_t3_24 + (0.37900832295417786) * emb_t3_25 + (0.056395094841718674) * emb_t3_26 + (-0.037252459675073624) * emb_t3_27 + (-0.79381108283996582) * emb_t3_28 + (0.078465789556503296) * emb_t3_29 + (0.41637760400772095) * emb_t3_30 + (-0.2509402334690094) * emb_t3_31 + (0.24902075529098511) * gru_0_fwd_t2_h_0 + (0.18872329592704773) * gru_0_fwd_t2_h_1 + (-1.156943678855896) * gru_0_fwd_t2_h_2 + (-0.26141980290412903) * gru_0_fwd_t2_h_3 + (0.12621775269508362) * gru_0_fwd_t2_h_4 + (-0.14882530272006989) * gru_0_fwd_t2_h_5 + (-0.92031693458557129) * gru_0_fwd_t2_h_6 + (0.21755166351795197) * gru_0_fwd_t2_h_7 + (-0.14906533062458038) * gru_0_fwd_t2_h_8 + (0.26624387502670288) * gru_0_fwd_t2_h_9 + (1.4410631656646729) * gru_0_fwd_t2_h_10 + (0.30767664313316345) * gru_0_fwd_t2_h_11 + (-0.11122284084558487) * gru_0_fwd_t2_h_12 + (-0.42663794755935669) * gru_0_fwd_t2_h_13 + (0.25622057914733887) * gru_0_fwd_t2_h_14 + (-0.26118564605712891) * gru_0_fwd_t2_h_15 + (-0.03057689405977726) * gru_0_fwd_t2_h_16 + (-0.13202273845672607) * gru_0_fwd_t2_h_17 + (-0.020579682663083076) * gru_0_fwd_t2_h_18 + (-1.667967677116394) * gru_0_fwd_t2_h_19 + (-0.16229031980037689) * gru_0_fwd_t2_h_20 + (0.12047503143548965) * gru_0_fwd_t2_h_21 + (-0.55972546339035034) * gru_0_fwd_t2_h_22 + (0.41362357139587402) * gru_0_fwd_t2_h_23 + (0.57131630182266235) * gru_0_fwd_t2_h_24 + (0.14650556445121765) * gru_0_fwd_t2_h_25 + (-0.034010078758001328) * gru_0_fwd_t2_h_26 + (-0.53238606452941895) * gru_0_fwd_t2_h_27 + (-0.41153216361999512) * gru_0_fwd_t2_h_28 + (-0.5209735631942749) * gru_0_fwd_t2_h_29 + (0.22027134895324707) * gru_0_fwd_t2_h_30 + (-0.49471953511238098) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((-1.1835981607437134) + (-0.38325873017311096) * emb_t3_0 + (1.2180261611938477) * emb_t3_1 + (-0.50477433204650879) * emb_t3_2 + (-0.71793818473815918) * emb_t3_3 + (1.185329794883728) * emb_t3_4 + (-0.47439354658126831) * emb_t3_5 + (0.69456666707992554) * emb_t3_6 + (0.42801237106323242) * emb_t3_7 + (-0.74283206462860107) * emb_t3_8 + (0.050644747912883759) * emb_t3_9 + (-0.0024067610502243042) * emb_t3_10 + (-0.50373858213424683) * emb_t3_11 + (-0.28058198094367981) * emb_t3_12 + (1.210016131401062) * emb_t3_13 + (0.11959413439035416) * emb_t3_14 + (0.5850263237953186) * emb_t3_15 + (-0.6549835205078125) * emb_t3_16 + (0.81251460313796997) * emb_t3_17 + (-0.36874586343765259) * emb_t3_18 + (-0.54592388868331909) * emb_t3_19 + (-0.9350135326385498) * emb_t3_20 + (0.37382754683494568) * emb_t3_21 + (0.38894951343536377) * emb_t3_22 + (-0.30774560570716858) * emb_t3_23 + (0.45080414414405823) * emb_t3_24 + (-0.3780987560749054) * emb_t3_25 + (-1.2254502773284912) * emb_t3_26 + (0.13949069380760193) * emb_t3_27 + (-1.1461809873580933) * emb_t3_28 + (1.0603877305984497) * emb_t3_29 + (-1.4554656744003296) * emb_t3_30 + (0.30579391121864319) * emb_t3_31 + (-0.10615801066160202) * gru_0_fwd_t2_h_0 + (0.062277205288410187) * gru_0_fwd_t2_h_1 + (-2.9809088706970215) * gru_0_fwd_t2_h_2 + (-1.3029937744140625) * gru_0_fwd_t2_h_3 + (0.080119766294956207) * gru_0_fwd_t2_h_4 + (-0.57045543193817139) * gru_0_fwd_t2_h_5 + (0.17521990835666656) * gru_0_fwd_t2_h_6 + (2.1046972274780273) * gru_0_fwd_t2_h_7 + (-0.55869829654693604) * gru_0_fwd_t2_h_8 + (-0.57184040546417236) * gru_0_fwd_t2_h_9 + (2.8678064346313477) * gru_0_fwd_t2_h_10 + (0.31140592694282532) * gru_0_fwd_t2_h_11 + (-0.04938780888915062) * gru_0_fwd_t2_h_12 + (-0.052740257233381271) * gru_0_fwd_t2_h_13 + (-0.48869532346725464) * gru_0_fwd_t2_h_14 + (-0.039912566542625427) * gru_0_fwd_t2_h_15 + (0.38393378257751465) * gru_0_fwd_t2_h_16 + (0.09867868572473526) * gru_0_fwd_t2_h_17 + (0.16850613057613373) * gru_0_fwd_t2_h_18 + (2.2231631278991699) * gru_0_fwd_t2_h_19 + (-1.355987548828125) * gru_0_fwd_t2_h_20 + (1.3890461921691895) * gru_0_fwd_t2_h_21 + (-0.45556288957595825) * gru_0_fwd_t2_h_22 + (0.55173391103744507) * gru_0_fwd_t2_h_23 + (2.1711466312408447) * gru_0_fwd_t2_h_24 + (1.5733431577682495) * gru_0_fwd_t2_h_25 + (-0.31027799844741821) * gru_0_fwd_t2_h_26 + (-0.71380138397216797) * gru_0_fwd_t2_h_27 + (0.53722262382507324) * gru_0_fwd_t2_h_28 + (-0.24148008227348328) * gru_0_fwd_t2_h_29 + (-0.59723645448684692) * gru_0_fwd_t2_h_30 + (-1.0308324098587036) * gru_0_fwd_t2_h_31);
    gate_n = tanh((0.093171462416648865) + (-0.0026334382127970457) * emb_t3_0 + (-0.18988069891929626) * emb_t3_1 + (-0.0021763790864497423) * emb_t3_2 + (0.41077297925949097) * emb_t3_3 + (-0.22049932181835175) * emb_t3_4 + (-0.011800613254308701) * emb_t3_5 + (-0.66309380531311035) * emb_t3_6 + (-0.013310860842466354) * emb_t3_7 + (-0.4265671968460083) * emb_t3_8 + (0.26797905564308167) * emb_t3_9 + (0.61712539196014404) * emb_t3_10 + (0.16253611445426941) * emb_t3_11 + (-0.14216451346874237) * emb_t3_12 + (-0.63450866937637329) * emb_t3_13 + (-0.024728493764996529) * emb_t3_14 + (0.018113439902663231) * emb_t3_15 + (-0.0097484393045306206) * emb_t3_16 + (-0.81316870450973511) * emb_t3_17 + (0.166947141289711) * emb_t3_18 + (-0.38231483101844788) * emb_t3_19 + (0.33632215857505798) * emb_t3_20 + (0.014915128238499165) * emb_t3_21 + (0.53567588329315186) * emb_t3_22 + (-0.016212737187743187) * emb_t3_23 + (0.010487335734069347) * emb_t3_24 + (0.022374428808689117) * emb_t3_25 + (0.14556528627872467) * emb_t3_26 + (-0.0049680685624480247) * emb_t3_27 + (0.008115917444229126) * emb_t3_28 + (-0.62235081195831299) * emb_t3_29 + (0.3570418655872345) * emb_t3_30 + (0.11953973025083542) * emb_t3_31 + gate_r * ((0.23773778975009918) + (-0.2487059086561203) * gru_0_fwd_t2_h_0 + (0.028771974146366119) * gru_0_fwd_t2_h_1 + (0.46639904379844666) * gru_0_fwd_t2_h_2 + (-0.032455295324325562) * gru_0_fwd_t2_h_3 + (-0.082337528467178345) * gru_0_fwd_t2_h_4 + (0.020752320066094398) * gru_0_fwd_t2_h_5 + (0.60596978664398193) * gru_0_fwd_t2_h_6 + (0.91006499528884888) * gru_0_fwd_t2_h_7 + (0.2911192774772644) * gru_0_fwd_t2_h_8 + (-0.058060787618160248) * gru_0_fwd_t2_h_9 + (-0.17348109185695648) * gru_0_fwd_t2_h_10 + (-0.53574538230895996) * gru_0_fwd_t2_h_11 + (0.13039921224117279) * gru_0_fwd_t2_h_12 + (0.14083090424537659) * gru_0_fwd_t2_h_13 + (-0.35861220955848694) * gru_0_fwd_t2_h_14 + (0.021743543446063995) * gru_0_fwd_t2_h_15 + (0.34549611806869507) * gru_0_fwd_t2_h_16 + (0.0046041081659495831) * gru_0_fwd_t2_h_17 + (0.020699158310890198) * gru_0_fwd_t2_h_18 + (0.31412455439567566) * gru_0_fwd_t2_h_19 + (0.11900006234645844) * gru_0_fwd_t2_h_20 + (-0.23512519896030426) * gru_0_fwd_t2_h_21 + (-0.021319052204489708) * gru_0_fwd_t2_h_22 + (-0.088279232382774353) * gru_0_fwd_t2_h_23 + (-0.36241886019706726) * gru_0_fwd_t2_h_24 + (-0.13654504716396332) * gru_0_fwd_t2_h_25 + (0.042143896222114563) * gru_0_fwd_t2_h_26 + (0.17744766175746918) * gru_0_fwd_t2_h_27 + (-0.042073432356119156) * gru_0_fwd_t2_h_28 + (0.70212197303771973) * gru_0_fwd_t2_h_29 + (0.18689286708831787) * gru_0_fwd_t2_h_30 + (-0.064656473696231842) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_11 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_11;
    // h=12
    gate_r = sigmoid((-0.13819116353988647) + (0.71213573217391968) * emb_t3_0 + (1.8283154964447021) * emb_t3_1 + (-0.43105298280715942) * emb_t3_2 + (-0.5775381326675415) * emb_t3_3 + (0.79101389646530151) * emb_t3_4 + (0.10034384578466415) * emb_t3_5 + (0.38175764679908752) * emb_t3_6 + (0.048554982990026474) * emb_t3_7 + (0.033263951539993286) * emb_t3_8 + (-2.5481750965118408) * emb_t3_9 + (-2.3444526195526123) * emb_t3_10 + (0.13829174637794495) * emb_t3_11 + (0.36406019330024719) * emb_t3_12 + (0.91075325012207031) * emb_t3_13 + (-0.47730499505996704) * emb_t3_14 + (-0.10274036228656769) * emb_t3_15 + (-0.75440347194671631) * emb_t3_16 + (0.43904596567153931) * emb_t3_17 + (-1.9574978351593018) * emb_t3_18 + (1.7656664848327637) * emb_t3_19 + (-0.29784631729125977) * emb_t3_20 + (-0.56409049034118652) * emb_t3_21 + (-0.33933252096176147) * emb_t3_22 + (0.14233733713626862) * emb_t3_23 + (-0.83454227447509766) * emb_t3_24 + (-0.54138535261154175) * emb_t3_25 + (-0.12354942411184311) * emb_t3_26 + (0.2123880535364151) * emb_t3_27 + (-1.4417906999588013) * emb_t3_28 + (1.2856999635696411) * emb_t3_29 + (-0.95881056785583496) * emb_t3_30 + (-0.10788094997406006) * emb_t3_31 + (0.0090473564341664314) * gru_0_fwd_t2_h_0 + (0.8950456976890564) * gru_0_fwd_t2_h_1 + (2.4839749336242676) * gru_0_fwd_t2_h_2 + (-0.37794238328933716) * gru_0_fwd_t2_h_3 + (1.0362467765808105) * gru_0_fwd_t2_h_4 + (-0.74827289581298828) * gru_0_fwd_t2_h_5 + (-1.6676448583602905) * gru_0_fwd_t2_h_6 + (-1.2527164220809937) * gru_0_fwd_t2_h_7 + (0.091055743396282196) * gru_0_fwd_t2_h_8 + (0.89740616083145142) * gru_0_fwd_t2_h_9 + (-2.1588451862335205) * gru_0_fwd_t2_h_10 + (0.049445953220129013) * gru_0_fwd_t2_h_11 + (-0.81097656488418579) * gru_0_fwd_t2_h_12 + (-2.4401075839996338) * gru_0_fwd_t2_h_13 + (1.3959482908248901) * gru_0_fwd_t2_h_14 + (-0.030937181785702705) * gru_0_fwd_t2_h_15 + (-0.50152140855789185) * gru_0_fwd_t2_h_16 + (0.047568630427122116) * gru_0_fwd_t2_h_17 + (-0.92836695909500122) * gru_0_fwd_t2_h_18 + (-0.056089095771312714) * gru_0_fwd_t2_h_19 + (0.85286045074462891) * gru_0_fwd_t2_h_20 + (0.014015817083418369) * gru_0_fwd_t2_h_21 + (-1.0862104892730713) * gru_0_fwd_t2_h_22 + (-0.38725745677947998) * gru_0_fwd_t2_h_23 + (1.593845009803772) * gru_0_fwd_t2_h_24 + (-0.23849309980869293) * gru_0_fwd_t2_h_25 + (-0.40643125772476196) * gru_0_fwd_t2_h_26 + (0.51577633619308472) * gru_0_fwd_t2_h_27 + (-0.59974658489227295) * gru_0_fwd_t2_h_28 + (0.18683210015296936) * gru_0_fwd_t2_h_29 + (0.80650776624679565) * gru_0_fwd_t2_h_30 + (-0.46420764923095703) * gru_0_fwd_t2_h_31);
    gate_z = sigmoid((-0.27623444795608521) + (-0.089181937277317047) * emb_t3_0 + (0.76283031702041626) * emb_t3_1 + (0.11799173802137375) * emb_t3_2 + (-0.15994881093502045) * emb_t3_3 + (0.53601408004760742) * emb_t3_4 + (-0.032277382910251617) * emb_t3_5 + (0.40841758251190186) * emb_t3_6 + (0.085295476019382477) * emb_t3_7 + (0.034288864582777023) * emb_t3_8 + (-0.35551208257675171) * emb_t3_9 + (-0.23638394474983215) * emb_t3_10 + (-0.13408811390399933) * emb_t3_11 + (-0.28604474663734436) * emb_t3_12 + (0.93144750595092773) * emb_t3_13 + (0.12393957376480103) * emb_t3_14 + (-0.037020359188318253) * emb_t3_15 + (0.014558936469256878) * emb_t3_16 + (-0.042967621237039566) * emb_t3_17 + (-0.43295100331306458) * emb_t3_18 + (0.043752454221248627) * emb_t3_19 + (0.036420885473489761) * emb_t3_20 + (0.07897331565618515) * emb_t3_21 + (0.21949999034404755) * emb_t3_22 + (0.052591770887374878) * emb_t3_23 + (-0.0051065650768578053) * emb_t3_24 + (-0.099439755082130432) * emb_t3_25 + (-0.56317055225372314) * emb_t3_26 + (0.087972633540630341) * emb_t3_27 + (-0.79017859697341919) * emb_t3_28 + (0.45507970452308655) * emb_t3_29 + (-0.91383707523345947) * emb_t3_30 + (-0.088416539132595062) * emb_t3_31 + (-0.021238697692751884) * gru_0_fwd_t2_h_0 + (-0.24551065266132355) * gru_0_fwd_t2_h_1 + (0.59170997142791748) * gru_0_fwd_t2_h_2 + (-0.13845841586589813) * gru_0_fwd_t2_h_3 + (-0.2295953631401062) * gru_0_fwd_t2_h_4 + (-0.20016495883464813) * gru_0_fwd_t2_h_5 + (-2.2545435428619385) * gru_0_fwd_t2_h_6 + (-0.087938807904720306) * gru_0_fwd_t2_h_7 + (-1.0665727853775024) * gru_0_fwd_t2_h_8 + (0.77216607332229614) * gru_0_fwd_t2_h_9 + (-0.26303356885910034) * gru_0_fwd_t2_h_10 + (-0.28161472082138062) * gru_0_fwd_t2_h_11 + (0.36923268437385559) * gru_0_fwd_t2_h_12 + (0.23734328150749207) * gru_0_fwd_t2_h_13 + (-0.16878208518028259) * gru_0_fwd_t2_h_14 + (0.19129160046577454) * gru_0_fwd_t2_h_15 + (0.08678784966468811) * gru_0_fwd_t2_h_16 + (0.12244928628206253) * gru_0_fwd_t2_h_17 + (-0.075215756893157959) * gru_0_fwd_t2_h_18 + (0.54215341806411743) * gru_0_fwd_t2_h_19 + (0.56646305322647095) * gru_0_fwd_t2_h_20 + (-0.97092926502227783) * gru_0_fwd_t2_h_21 + (0.023204375058412552) * gru_0_fwd_t2_h_22 + (0.90324562788009644) * gru_0_fwd_t2_h_23 + (-0.60343492031097412) * gru_0_fwd_t2_h_24 + (-0.57573312520980835) * gru_0_fwd_t2_h_25 + (-0.22784486413002014) * gru_0_fwd_t2_h_26 + (-0.36288154125213623) * gru_0_fwd_t2_h_27 + (-0.4593643844127655) * gru_0_fwd_t2_h_28 + (0.46129304170608521) * gru_0_fwd_t2_h_29 + (-0.044744506478309631) * gru_0_fwd_t2_h_30 + (0.94160538911819458) * gru_0_fwd_t2_h_31);
    gate_n = tanh((0.13113819062709808) + (0.22662451863288879) * emb_t3_0 + (1.5104523897171021) * emb_t3_1 + (0.092487126588821411) * emb_t3_2 + (-0.19270691275596619) * emb_t3_3 + (0.61304205656051636) * emb_t3_4 + (0.14026537537574768) * emb_t3_5 + (0.84852981567382812) * emb_t3_6 + (-0.22449961304664612) * emb_t3_7 + (0.77730453014373779) * emb_t3_8 + (-1.432608962059021) * emb_t3_9 + (-1.0286837816238403) * emb_t3_10 + (0.40930461883544922) * emb_t3_11 + (0.44087821245193481) * emb_t3_12 + (0.78888535499572754) * emb_t3_13 + (-0.026853414252400398) * emb_t3_14 + (0.0083698723465204239) * emb_t3_15 + (-0.094677470624446869) * emb_t3_16 + (-0.12160506099462509) * emb_t3_17 + (-0.64910811185836792) * emb_t3_18 + (0.8080596923828125) * emb_t3_19 + (-0.045504763722419739) * emb_t3_20 + (0.07694593071937561) * emb_t3_21 + (-0.26050093770027161) * emb_t3_22 + (-0.2208828330039978) * emb_t3_23 + (0.042329814285039902) * emb_t3_24 + (-0.3294677734375) * emb_t3_25 + (-0.19749502837657928) * emb_t3_26 + (-0.023264419287443161) * emb_t3_27 + (-1.450143575668335) * emb_t3_28 + (0.89601916074752808) * emb_t3_29 + (-0.1187267005443573) * emb_t3_30 + (0.10795458406209946) * emb_t3_31 + gate_r * ((0.37629064917564392) + (0.69379758834838867) * gru_0_fwd_t2_h_0 + (0.12566670775413513) * gru_0_fwd_t2_h_1 + (-0.83343267440795898) * gru_0_fwd_t2_h_2 + (0.022798594087362289) * gru_0_fwd_t2_h_3 + (0.4766353964805603) * gru_0_fwd_t2_h_4 + (-0.17307616770267487) * gru_0_fwd_t2_h_5 + (0.0065453494898974895) * gru_0_fwd_t2_h_6 + (1.3504506349563599) * gru_0_fwd_t2_h_7 + (-0.2527967095375061) * gru_0_fwd_t2_h_8 + (-0.13116355240345001) * gru_0_fwd_t2_h_9 + (0.75132447481155396) * gru_0_fwd_t2_h_10 + (0.0869012251496315) * gru_0_fwd_t2_h_11 + (0.31392928957939148) * gru_0_fwd_t2_h_12 + (0.47258263826370239) * gru_0_fwd_t2_h_13 + (0.20868019759654999) * gru_0_fwd_t2_h_14 + (-0.42683520913124084) * gru_0_fwd_t2_h_15 + (-1.7988011837005615) * gru_0_fwd_t2_h_16 + (-0.55691534280776978) * gru_0_fwd_t2_h_17 + (0.13598142564296722) * gru_0_fwd_t2_h_18 + (0.60253244638442993) * gru_0_fwd_t2_h_19 + (-0.033223610371351242) * gru_0_fwd_t2_h_20 + (-2.9145157337188721) * gru_0_fwd_t2_h_21 + (0.16910871863365173) * gru_0_fwd_t2_h_22 + (0.56474870443344116) * gru_0_fwd_t2_h_23 + (-1.2080322504043579) * gru_0_fwd_t2_h_24 + (-0.049844924360513687) * gru_0_fwd_t2_h_25 + (0.51085406541824341) * gru_0_fwd_t2_h_26 + (0.34663772583007812) * gru_0_fwd_t2_h_27 + (0.22599013149738312) * gru_0_fwd_t2_h_28 + (0.13649067282676697) * gru_0_fwd_t2_h_29 + (0.71261942386627197) * gru_0_fwd_t2_h_30 + (0.55585193634033203) * gru_0_fwd_t2_h_31));
    gru_0_fwd_t3_h_12 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t2_h_12;
    // h=13
