    gate_r = sigmoid((0.43509262800216675) + (0.38591518998146057) * gru_0_out_t1_0 + (-0.32747700810432434) * gru_0_out_t1_1 + (-0.31397691369056702) * gru_0_out_t1_2 + (-1.0062137842178345) * gru_0_out_t1_3 + (0.090118043124675751) * gru_0_out_t1_4 + (-0.9443819522857666) * gru_0_out_t1_5 + (0.72979682683944702) * gru_0_out_t1_6 + (0.25065755844116211) * gru_0_out_t1_7 + (-0.29402622580528259) * gru_0_out_t1_8 + (1.057439923286438) * gru_0_out_t1_9 + (0.42256805300712585) * gru_0_out_t1_10 + (0.12718275189399719) * gru_0_out_t1_11 + (-0.08947327733039856) * gru_0_out_t1_12 + (0.1933409571647644) * gru_0_out_t1_13 + (0.2830672562122345) * gru_0_out_t1_14 + (-0.50181752443313599) * gru_0_out_t1_15 + (-0.1109703928232193) * gru_0_out_t1_16 + (-0.34983474016189575) * gru_0_out_t1_17 + (-0.3887898325920105) * gru_0_out_t1_18 + (5.887631893157959) * gru_0_out_t1_19 + (2.0297629833221436) * gru_0_out_t1_20 + (-1.0529803037643433) * gru_0_out_t1_21 + (0.65658813714981079) * gru_0_out_t1_22 + (0.35956710577011108) * gru_0_out_t1_23 + (-0.18145817518234253) * gru_0_out_t1_24 + (0.16407138109207153) * gru_0_out_t1_25 + (-1.5412025451660156) * gru_0_out_t1_26 + (-0.41400974988937378) * gru_0_out_t1_27 + (-0.62290757894515991) * gru_0_out_t1_28 + (0.57952666282653809) * gru_0_out_t1_29 + (0.30749931931495667) * gru_0_out_t1_30 + (0.062277834862470627) * gru_0_out_t1_31 + (-0.027396680787205696) * gru_0_out_t1_32 + (-0.15558430552482605) * gru_0_out_t1_33 + (0.13866870105266571) * gru_0_out_t1_34 + (0.049737658351659775) * gru_0_out_t1_35 + (-0.15231405198574066) * gru_0_out_t1_36 + (0.2091619074344635) * gru_0_out_t1_37 + (-0.32669484615325928) * gru_0_out_t1_38 + (1.0885552167892456) * gru_0_out_t1_39 + (0.5635523796081543) * gru_0_out_t1_40 + (-0.054122116416692734) * gru_0_out_t1_41 + (0.8637700080871582) * gru_0_out_t1_42 + (-0.07494623214006424) * gru_0_out_t1_43 + (-0.3040747344493866) * gru_0_out_t1_44 + (-0.1117178350687027) * gru_0_out_t1_45 + (-0.76064079999923706) * gru_0_out_t1_46 + (0.68738353252410889) * gru_0_out_t1_47 + (0.69195759296417236) * gru_0_out_t1_48 + (-0.82645273208618164) * gru_0_out_t1_49 + (-1.748950719833374) * gru_0_out_t1_50 + (0.13695614039897919) * gru_0_out_t1_51 + (-0.27650779485702515) * gru_0_out_t1_52 + (0.2359863817691803) * gru_0_out_t1_53 + (-1.103547215461731) * gru_0_out_t1_54 + (-0.047154862433671951) * gru_0_out_t1_55 + (1.6823813915252686) * gru_0_out_t1_56 + (-0.59031301736831665) * gru_0_out_t1_57 + (0.5997200608253479) * gru_0_out_t1_58 + (0.51232630014419556) * gru_0_out_t1_59 + (0.55954128503799438) * gru_0_out_t1_60 + (-0.76222634315490723) * gru_0_out_t1_61 + (0.72130531072616577) * gru_0_out_t1_62 + (-0.23224765062332153) * gru_0_out_t1_63 + (-0.58504164218902588) * gru_1_fwd_t0_h_0 + (-0.25709608197212219) * gru_1_fwd_t0_h_1 + (-0.24257880449295044) * gru_1_fwd_t0_h_2 + (-0.18858402967453003) * gru_1_fwd_t0_h_3 + (0.79846185445785522) * gru_1_fwd_t0_h_4 + (2.1325123310089111) * gru_1_fwd_t0_h_5 + (0.33260747790336609) * gru_1_fwd_t0_h_6 + (-0.85465133190155029) * gru_1_fwd_t0_h_7 + (-0.42772006988525391) * gru_1_fwd_t0_h_8 + (0.35138016939163208) * gru_1_fwd_t0_h_9 + (-0.30612242221832275) * gru_1_fwd_t0_h_10 + (-0.44762870669364929) * gru_1_fwd_t0_h_11 + (-0.66137909889221191) * gru_1_fwd_t0_h_12 + (-0.35698062181472778) * gru_1_fwd_t0_h_13 + (-0.96980029344558716) * gru_1_fwd_t0_h_14 + (1.6976799964904785) * gru_1_fwd_t0_h_15 + (-0.16869796812534332) * gru_1_fwd_t0_h_16 + (-2.2967054843902588) * gru_1_fwd_t0_h_17 + (0.39973399043083191) * gru_1_fwd_t0_h_18 + (-0.80288374423980713) * gru_1_fwd_t0_h_19 + (0.88682937622070312) * gru_1_fwd_t0_h_20 + (1.9015952348709106) * gru_1_fwd_t0_h_21 + (-1.5845749378204346) * gru_1_fwd_t0_h_22 + (-1.2260398864746094) * gru_1_fwd_t0_h_23 + (1.2047275304794312) * gru_1_fwd_t0_h_24 + (1.8833355903625488) * gru_1_fwd_t0_h_25 + (0.65857887268066406) * gru_1_fwd_t0_h_26 + (-0.011704790405929089) * gru_1_fwd_t0_h_27 + (0.019964538514614105) * gru_1_fwd_t0_h_28 + (-1.5064451694488525) * gru_1_fwd_t0_h_29 + (0.54687958955764771) * gru_1_fwd_t0_h_30 + (-0.81841552257537842) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((0.51432788372039795) + (0.11289842426776886) * gru_0_out_t1_0 + (-0.26762405037879944) * gru_0_out_t1_1 + (0.78463321924209595) * gru_0_out_t1_2 + (-0.43576321005821228) * gru_0_out_t1_3 + (-0.49026969075202942) * gru_0_out_t1_4 + (0.1936413049697876) * gru_0_out_t1_5 + (-0.73305946588516235) * gru_0_out_t1_6 + (-0.3723469078540802) * gru_0_out_t1_7 + (0.36472713947296143) * gru_0_out_t1_8 + (0.43684163689613342) * gru_0_out_t1_9 + (-0.64519679546356201) * gru_0_out_t1_10 + (-0.48837083578109741) * gru_0_out_t1_11 + (0.062260068953037262) * gru_0_out_t1_12 + (-0.052425567060709) * gru_0_out_t1_13 + (0.071124263107776642) * gru_0_out_t1_14 + (0.45537930727005005) * gru_0_out_t1_15 + (0.037050239741802216) * gru_0_out_t1_16 + (0.10675768554210663) * gru_0_out_t1_17 + (-0.1298975795507431) * gru_0_out_t1_18 + (2.3403890132904053) * gru_0_out_t1_19 + (0.29279321432113647) * gru_0_out_t1_20 + (-0.41195172071456909) * gru_0_out_t1_21 + (-0.83271527290344238) * gru_0_out_t1_22 + (-0.37574741244316101) * gru_0_out_t1_23 + (-0.50411224365234375) * gru_0_out_t1_24 + (-0.54167342185974121) * gru_0_out_t1_25 + (-0.26256781816482544) * gru_0_out_t1_26 + (0.44973737001419067) * gru_0_out_t1_27 + (0.84666728973388672) * gru_0_out_t1_28 + (-0.2062159925699234) * gru_0_out_t1_29 + (0.29007872939109802) * gru_0_out_t1_30 + (-0.76124697923660278) * gru_0_out_t1_31 + (1.0611113309860229) * gru_0_out_t1_32 + (-0.11152104288339615) * gru_0_out_t1_33 + (-0.16499555110931396) * gru_0_out_t1_34 + (-0.16733741760253906) * gru_0_out_t1_35 + (-0.21883960068225861) * gru_0_out_t1_36 + (-0.4049379825592041) * gru_0_out_t1_37 + (-0.041414901614189148) * gru_0_out_t1_38 + (-0.45436537265777588) * gru_0_out_t1_39 + (0.30430430173873901) * gru_0_out_t1_40 + (0.49648571014404297) * gru_0_out_t1_41 + (-0.15206412971019745) * gru_0_out_t1_42 + (-0.65548646450042725) * gru_0_out_t1_43 + (0.19895894825458527) * gru_0_out_t1_44 + (-0.11196598410606384) * gru_0_out_t1_45 + (-0.66343063116073608) * gru_0_out_t1_46 + (-0.92472994327545166) * gru_0_out_t1_47 + (-0.6357429027557373) * gru_0_out_t1_48 + (0.30115112662315369) * gru_0_out_t1_49 + (1.2445659637451172) * gru_0_out_t1_50 + (0.096673719584941864) * gru_0_out_t1_51 + (0.43040570616722107) * gru_0_out_t1_52 + (-0.42013263702392578) * gru_0_out_t1_53 + (-0.51939862966537476) * gru_0_out_t1_54 + (0.45673197507858276) * gru_0_out_t1_55 + (-0.46647343039512634) * gru_0_out_t1_56 + (0.61639666557312012) * gru_0_out_t1_57 + (-0.38771575689315796) * gru_0_out_t1_58 + (0.092840604484081268) * gru_0_out_t1_59 + (-0.53582239151000977) * gru_0_out_t1_60 + (0.63283836841583252) * gru_0_out_t1_61 + (-2.5337040424346924) * gru_0_out_t1_62 + (-0.82687747478485107) * gru_0_out_t1_63 + (0.66889053583145142) * gru_1_fwd_t0_h_0 + (0.54824918508529663) * gru_1_fwd_t0_h_1 + (0.2713046669960022) * gru_1_fwd_t0_h_2 + (0.18272869288921356) * gru_1_fwd_t0_h_3 + (-0.46410062909126282) * gru_1_fwd_t0_h_4 + (-0.62431943416595459) * gru_1_fwd_t0_h_5 + (-0.12731318175792694) * gru_1_fwd_t0_h_6 + (-0.33913567662239075) * gru_1_fwd_t0_h_7 + (0.30635908246040344) * gru_1_fwd_t0_h_8 + (-0.71809786558151245) * gru_1_fwd_t0_h_9 + (0.25712475180625916) * gru_1_fwd_t0_h_10 + (-0.60687774419784546) * gru_1_fwd_t0_h_11 + (0.042603511363267899) * gru_1_fwd_t0_h_12 + (-0.6943817138671875) * gru_1_fwd_t0_h_13 + (-0.43504568934440613) * gru_1_fwd_t0_h_14 + (0.44583281874656677) * gru_1_fwd_t0_h_15 + (0.29137018322944641) * gru_1_fwd_t0_h_16 + (0.20578879117965698) * gru_1_fwd_t0_h_17 + (0.36437469720840454) * gru_1_fwd_t0_h_18 + (-0.24922876060009003) * gru_1_fwd_t0_h_19 + (-0.082598380744457245) * gru_1_fwd_t0_h_20 + (0.26127517223358154) * gru_1_fwd_t0_h_21 + (0.37084925174713135) * gru_1_fwd_t0_h_22 + (-0.49937564134597778) * gru_1_fwd_t0_h_23 + (-1.3182768821716309) * gru_1_fwd_t0_h_24 + (0.15996529161930084) * gru_1_fwd_t0_h_25 + (0.029081488028168678) * gru_1_fwd_t0_h_26 + (-0.94583910703659058) * gru_1_fwd_t0_h_27 + (-0.79961216449737549) * gru_1_fwd_t0_h_28 + (0.50110197067260742) * gru_1_fwd_t0_h_29 + (0.57482069730758667) * gru_1_fwd_t0_h_30 + (-0.29071363806724548) * gru_1_fwd_t0_h_31);
    gate_n = tanh((0.039114959537982941) + (0.0023950028698891401) * gru_0_out_t1_0 + (0.21926088631153107) * gru_0_out_t1_1 + (0.67397981882095337) * gru_0_out_t1_2 + (0.11899778991937637) * gru_0_out_t1_3 + (-0.28685611486434937) * gru_0_out_t1_4 + (-0.66319453716278076) * gru_0_out_t1_5 + (-1.6514712572097778) * gru_0_out_t1_6 + (-1.5019286870956421) * gru_0_out_t1_7 + (-0.086422309279441833) * gru_0_out_t1_8 + (0.81714338064193726) * gru_0_out_t1_9 + (0.54448026418685913) * gru_0_out_t1_10 + (-0.34092822670936584) * gru_0_out_t1_11 + (-0.087344907224178314) * gru_0_out_t1_12 + (0.094212085008621216) * gru_0_out_t1_13 + (-0.2189936488866806) * gru_0_out_t1_14 + (-0.31758204102516174) * gru_0_out_t1_15 + (-0.16069424152374268) * gru_0_out_t1_16 + (-0.44163632392883301) * gru_0_out_t1_17 + (-0.062354303896427155) * gru_0_out_t1_18 + (2.4423258304595947) * gru_0_out_t1_19 + (0.66531425714492798) * gru_0_out_t1_20 + (-0.21771624684333801) * gru_0_out_t1_21 + (0.34395381808280945) * gru_0_out_t1_22 + (-0.25098699331283569) * gru_0_out_t1_23 + (-0.93102395534515381) * gru_0_out_t1_24 + (-0.29571405053138733) * gru_0_out_t1_25 + (-0.064366079866886139) * gru_0_out_t1_26 + (0.06669645756483078) * gru_0_out_t1_27 + (0.81671911478042603) * gru_0_out_t1_28 + (-0.055667806416749954) * gru_0_out_t1_29 + (0.046038810163736343) * gru_0_out_t1_30 + (1.0249530076980591) * gru_0_out_t1_31 + (-0.067164219915866852) * gru_0_out_t1_32 + (0.076418474316596985) * gru_0_out_t1_33 + (-0.025692170485854149) * gru_0_out_t1_34 + (0.34281322360038757) * gru_0_out_t1_35 + (0.087087810039520264) * gru_0_out_t1_36 + (0.175267294049263) * gru_0_out_t1_37 + (-0.041517697274684906) * gru_0_out_t1_38 + (0.42566853761672974) * gru_0_out_t1_39 + (2.4249124526977539) * gru_0_out_t1_40 + (-0.19823606312274933) * gru_0_out_t1_41 + (0.040898218750953674) * gru_0_out_t1_42 + (0.23090088367462158) * gru_0_out_t1_43 + (0.14099183678627014) * gru_0_out_t1_44 + (0.021987520158290863) * gru_0_out_t1_45 + (-0.031861085444688797) * gru_0_out_t1_46 + (0.43984568119049072) * gru_0_out_t1_47 + (0.05984913557767868) * gru_0_out_t1_48 + (-0.47422137856483459) * gru_0_out_t1_49 + (-1.3122358322143555) * gru_0_out_t1_50 + (-0.1107628270983696) * gru_0_out_t1_51 + (0.00087232672376558185) * gru_0_out_t1_52 + (-0.17246446013450623) * gru_0_out_t1_53 + (-0.38974106311798096) * gru_0_out_t1_54 + (-0.81881099939346313) * gru_0_out_t1_55 + (0.5410192608833313) * gru_0_out_t1_56 + (-0.041958414018154144) * gru_0_out_t1_57 + (-0.075381927192211151) * gru_0_out_t1_58 + (-0.5384671688079834) * gru_0_out_t1_59 + (1.2136861085891724) * gru_0_out_t1_60 + (0.16526138782501221) * gru_0_out_t1_61 + (0.37392604351043701) * gru_0_out_t1_62 + (0.41102740168571472) * gru_0_out_t1_63 + gate_r * ((0.43865671753883362) + (0.62537086009979248) * gru_1_fwd_t0_h_0 + (-0.74091112613677979) * gru_1_fwd_t0_h_1 + (0.23210690915584564) * gru_1_fwd_t0_h_2 + (0.19552870094776154) * gru_1_fwd_t0_h_3 + (0.38348975777626038) * gru_1_fwd_t0_h_4 + (-0.79432386159896851) * gru_1_fwd_t0_h_5 + (0.73081570863723755) * gru_1_fwd_t0_h_6 + (0.50658726692199707) * gru_1_fwd_t0_h_7 + (-0.14737163484096527) * gru_1_fwd_t0_h_8 + (-0.42823049426078796) * gru_1_fwd_t0_h_9 + (-0.25390326976776123) * gru_1_fwd_t0_h_10 + (-1.0577816963195801) * gru_1_fwd_t0_h_11 + (0.001883208635263145) * gru_1_fwd_t0_h_12 + (-0.90593063831329346) * gru_1_fwd_t0_h_13 + (0.39244240522384644) * gru_1_fwd_t0_h_14 + (1.1968843936920166) * gru_1_fwd_t0_h_15 + (-0.26617276668548584) * gru_1_fwd_t0_h_16 + (-0.64043134450912476) * gru_1_fwd_t0_h_17 + (0.38692235946655273) * gru_1_fwd_t0_h_18 + (-0.35272136330604553) * gru_1_fwd_t0_h_19 + (-0.22276060283184052) * gru_1_fwd_t0_h_20 + (-0.78180080652236938) * gru_1_fwd_t0_h_21 + (-0.13515168428421021) * gru_1_fwd_t0_h_22 + (-1.3200618028640747) * gru_1_fwd_t0_h_23 + (0.11425834149122238) * gru_1_fwd_t0_h_24 + (-0.69640642404556274) * gru_1_fwd_t0_h_25 + (1.2620557546615601) * gru_1_fwd_t0_h_26 + (0.88249218463897705) * gru_1_fwd_t0_h_27 + (-1.3738139867782593) * gru_1_fwd_t0_h_28 + (-0.15458497405052185) * gru_1_fwd_t0_h_29 + (-1.6893235445022583) * gru_1_fwd_t0_h_30 + (1.1944317817687988) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_13 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_13;
    // h=14
    gate_r = sigmoid((-0.7322998046875) + (-0.55080431699752808) * gru_0_out_t1_0 + (0.17692682147026062) * gru_0_out_t1_1 + (-0.29682469367980957) * gru_0_out_t1_2 + (-0.19187059998512268) * gru_0_out_t1_3 + (0.1955077201128006) * gru_0_out_t1_4 + (0.19937810301780701) * gru_0_out_t1_5 + (-0.4303373396396637) * gru_0_out_t1_6 + (-1.5627362728118896) * gru_0_out_t1_7 + (-0.17026637494564056) * gru_0_out_t1_8 + (0.14900580048561096) * gru_0_out_t1_9 + (-0.46745225787162781) * gru_0_out_t1_10 + (-0.37139192223548889) * gru_0_out_t1_11 + (0.076101973652839661) * gru_0_out_t1_12 + (0.61001485586166382) * gru_0_out_t1_13 + (0.13555888831615448) * gru_0_out_t1_14 + (-0.14079084992408752) * gru_0_out_t1_15 + (0.28336349129676819) * gru_0_out_t1_16 + (0.19230291247367859) * gru_0_out_t1_17 + (0.49239477515220642) * gru_0_out_t1_18 + (1.8485497236251831) * gru_0_out_t1_19 + (-0.80951118469238281) * gru_0_out_t1_20 + (0.44873875379562378) * gru_0_out_t1_21 + (-0.00090501981321722269) * gru_0_out_t1_22 + (0.036082267761230469) * gru_0_out_t1_23 + (-0.28521168231964111) * gru_0_out_t1_24 + (-0.36188378930091858) * gru_0_out_t1_25 + (0.086555056273937225) * gru_0_out_t1_26 + (-0.34277728199958801) * gru_0_out_t1_27 + (0.29941961169242859) * gru_0_out_t1_28 + (-0.28493231534957886) * gru_0_out_t1_29 + (-0.66237431764602661) * gru_0_out_t1_30 + (1.010175347328186) * gru_0_out_t1_31 + (0.032905504107475281) * gru_0_out_t1_32 + (0.55509346723556519) * gru_0_out_t1_33 + (0.29262539744377136) * gru_0_out_t1_34 + (0.5885699987411499) * gru_0_out_t1_35 + (0.6056256890296936) * gru_0_out_t1_36 + (-0.35247701406478882) * gru_0_out_t1_37 + (-0.14046141505241394) * gru_0_out_t1_38 + (1.2940018177032471) * gru_0_out_t1_39 + (0.6850656270980835) * gru_0_out_t1_40 + (0.88575375080108643) * gru_0_out_t1_41 + (-0.10188610106706619) * gru_0_out_t1_42 + (0.16904768347740173) * gru_0_out_t1_43 + (0.85066777467727661) * gru_0_out_t1_44 + (0.88443714380264282) * gru_0_out_t1_45 + (-0.71691060066223145) * gru_0_out_t1_46 + (-0.30236634612083435) * gru_0_out_t1_47 + (-0.86307603120803833) * gru_0_out_t1_48 + (0.84335094690322876) * gru_0_out_t1_49 + (0.31988513469696045) * gru_0_out_t1_50 + (0.23529228568077087) * gru_0_out_t1_51 + (-0.93715131282806396) * gru_0_out_t1_52 + (0.003754141042008996) * gru_0_out_t1_53 + (0.13462789356708527) * gru_0_out_t1_54 + (-0.65104693174362183) * gru_0_out_t1_55 + (-1.3752061128616333) * gru_0_out_t1_56 + (0.51433652639389038) * gru_0_out_t1_57 + (-0.27617257833480835) * gru_0_out_t1_58 + (-2.7495675086975098) * gru_0_out_t1_59 + (0.13888546824455261) * gru_0_out_t1_60 + (-0.27406489849090576) * gru_0_out_t1_61 + (-0.41494840383529663) * gru_0_out_t1_62 + (1.3362240791320801) * gru_0_out_t1_63 + (-0.041732165962457657) * gru_1_fwd_t0_h_0 + (-0.016576563939452171) * gru_1_fwd_t0_h_1 + (-0.245015949010849) * gru_1_fwd_t0_h_2 + (0.23846179246902466) * gru_1_fwd_t0_h_3 + (-0.32932841777801514) * gru_1_fwd_t0_h_4 + (-0.21227425336837769) * gru_1_fwd_t0_h_5 + (0.47178182005882263) * gru_1_fwd_t0_h_6 + (-0.0023707954678684473) * gru_1_fwd_t0_h_7 + (0.41096729040145874) * gru_1_fwd_t0_h_8 + (0.20910212397575378) * gru_1_fwd_t0_h_9 + (-0.33496865630149841) * gru_1_fwd_t0_h_10 + (-0.028084451332688332) * gru_1_fwd_t0_h_11 + (0.34780052304267883) * gru_1_fwd_t0_h_12 + (-0.17077605426311493) * gru_1_fwd_t0_h_13 + (-0.2009197324514389) * gru_1_fwd_t0_h_14 + (0.053950972855091095) * gru_1_fwd_t0_h_15 + (0.052494004368782043) * gru_1_fwd_t0_h_16 + (0.43999680876731873) * gru_1_fwd_t0_h_17 + (0.82535898685455322) * gru_1_fwd_t0_h_18 + (-0.6448860764503479) * gru_1_fwd_t0_h_19 + (0.0205240398645401) * gru_1_fwd_t0_h_20 + (0.15798042714595795) * gru_1_fwd_t0_h_21 + (0.059097722172737122) * gru_1_fwd_t0_h_22 + (-1.1104462146759033) * gru_1_fwd_t0_h_23 + (0.24538725614547729) * gru_1_fwd_t0_h_24 + (-0.28571489453315735) * gru_1_fwd_t0_h_25 + (0.42187216877937317) * gru_1_fwd_t0_h_26 + (0.80645447969436646) * gru_1_fwd_t0_h_27 + (-0.33080679178237915) * gru_1_fwd_t0_h_28 + (0.62054038047790527) * gru_1_fwd_t0_h_29 + (-0.21589159965515137) * gru_1_fwd_t0_h_30 + (-0.21121154725551605) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((0.0071336678229272366) + (0.061321601271629333) * gru_0_out_t1_0 + (-0.40985801815986633) * gru_0_out_t1_1 + (0.18714253604412079) * gru_0_out_t1_2 + (-0.17197036743164062) * gru_0_out_t1_3 + (-0.29947495460510254) * gru_0_out_t1_4 + (0.14685589075088501) * gru_0_out_t1_5 + (0.27177944779396057) * gru_0_out_t1_6 + (0.16077294945716858) * gru_0_out_t1_7 + (0.024070888757705688) * gru_0_out_t1_8 + (-1.5642459392547607) * gru_0_out_t1_9 + (-0.38952153921127319) * gru_0_out_t1_10 + (-0.37884166836738586) * gru_0_out_t1_11 + (0.45900392532348633) * gru_0_out_t1_12 + (0.16189673542976379) * gru_0_out_t1_13 + (0.10609824955463409) * gru_0_out_t1_14 + (0.13015526533126831) * gru_0_out_t1_15 + (-0.29942485690116882) * gru_0_out_t1_16 + (0.11639967560768127) * gru_0_out_t1_17 + (-0.32770180702209473) * gru_0_out_t1_18 + (0.50745826959609985) * gru_0_out_t1_19 + (-0.087120719254016876) * gru_0_out_t1_20 + (-0.11347895115613937) * gru_0_out_t1_21 + (0.43825647234916687) * gru_0_out_t1_22 + (0.016274094581604004) * gru_0_out_t1_23 + (-0.27412733435630798) * gru_0_out_t1_24 + (0.096948191523551941) * gru_0_out_t1_25 + (0.29073867201805115) * gru_0_out_t1_26 + (0.31920126080513) * gru_0_out_t1_27 + (-1.3736724853515625) * gru_0_out_t1_28 + (-0.94266194105148315) * gru_0_out_t1_29 + (-0.067986682057380676) * gru_0_out_t1_30 + (0.29914399981498718) * gru_0_out_t1_31 + (-0.33566519618034363) * gru_0_out_t1_32 + (-0.31247183680534363) * gru_0_out_t1_33 + (0.21962806582450867) * gru_0_out_t1_34 + (0.19625480473041534) * gru_0_out_t1_35 + (0.53571218252182007) * gru_0_out_t1_36 + (-0.50366801023483276) * gru_0_out_t1_37 + (0.021223613992333412) * gru_0_out_t1_38 + (0.81688666343688965) * gru_0_out_t1_39 + (0.45373529195785522) * gru_0_out_t1_40 + (0.096980728209018707) * gru_0_out_t1_41 + (0.2138754278421402) * gru_0_out_t1_42 + (1.0157727003097534) * gru_0_out_t1_43 + (0.23796339333057404) * gru_0_out_t1_44 + (0.02629191055893898) * gru_0_out_t1_45 + (0.024832934141159058) * gru_0_out_t1_46 + (-0.044953234493732452) * gru_0_out_t1_47 + (-0.50564908981323242) * gru_0_out_t1_48 + (0.43396738171577454) * gru_0_out_t1_49 + (0.0042607169598340988) * gru_0_out_t1_50 + (0.37425318360328674) * gru_0_out_t1_51 + (-0.067060679197311401) * gru_0_out_t1_52 + (-0.060896962881088257) * gru_0_out_t1_53 + (-0.052947431802749634) * gru_0_out_t1_54 + (0.11198531836271286) * gru_0_out_t1_55 + (0.11253343522548676) * gru_0_out_t1_56 + (0.15130850672721863) * gru_0_out_t1_57 + (-0.29437318444252014) * gru_0_out_t1_58 + (0.24619533121585846) * gru_0_out_t1_59 + (0.13050547242164612) * gru_0_out_t1_60 + (0.013341153040528297) * gru_0_out_t1_61 + (-0.059861715883016586) * gru_0_out_t1_62 + (-0.11001855880022049) * gru_0_out_t1_63 + (-0.067381739616394043) * gru_1_fwd_t0_h_0 + (-0.18727526068687439) * gru_1_fwd_t0_h_1 + (-0.27475965023040771) * gru_1_fwd_t0_h_2 + (-0.2333810031414032) * gru_1_fwd_t0_h_3 + (-0.53831315040588379) * gru_1_fwd_t0_h_4 + (-0.10168656706809998) * gru_1_fwd_t0_h_5 + (0.28506731986999512) * gru_1_fwd_t0_h_6 + (-0.15104110538959503) * gru_1_fwd_t0_h_7 + (-0.39193767309188843) * gru_1_fwd_t0_h_8 + (-0.02357780747115612) * gru_1_fwd_t0_h_9 + (0.12735253572463989) * gru_1_fwd_t0_h_10 + (0.68009883165359497) * gru_1_fwd_t0_h_11 + (0.12446372210979462) * gru_1_fwd_t0_h_12 + (0.12010499835014343) * gru_1_fwd_t0_h_13 + (0.19572994112968445) * gru_1_fwd_t0_h_14 + (-0.21900112926959991) * gru_1_fwd_t0_h_15 + (-0.16851170361042023) * gru_1_fwd_t0_h_16 + (0.20427238941192627) * gru_1_fwd_t0_h_17 + (-0.14343179762363434) * gru_1_fwd_t0_h_18 + (-0.13019101321697235) * gru_1_fwd_t0_h_19 + (-0.23662476241588593) * gru_1_fwd_t0_h_20 + (0.013105894438922405) * gru_1_fwd_t0_h_21 + (-0.015328638255596161) * gru_1_fwd_t0_h_22 + (0.18555033206939697) * gru_1_fwd_t0_h_23 + (0.16685807704925537) * gru_1_fwd_t0_h_24 + (0.28616365790367126) * gru_1_fwd_t0_h_25 + (-0.60642784833908081) * gru_1_fwd_t0_h_26 + (-0.18876057863235474) * gru_1_fwd_t0_h_27 + (0.93627655506134033) * gru_1_fwd_t0_h_28 + (-0.090905338525772095) * gru_1_fwd_t0_h_29 + (0.14891539514064789) * gru_1_fwd_t0_h_30 + (-0.027689650654792786) * gru_1_fwd_t0_h_31);
    gate_n = tanh((0.096124112606048584) + (-0.38427659869194031) * gru_0_out_t1_0 + (0.070049688220024109) * gru_0_out_t1_1 + (-0.055394962430000305) * gru_0_out_t1_2 + (-0.23749922215938568) * gru_0_out_t1_3 + (-0.032686695456504822) * gru_0_out_t1_4 + (-0.0015806993469595909) * gru_0_out_t1_5 + (0.57977229356765747) * gru_0_out_t1_6 + (-0.20226961374282837) * gru_0_out_t1_7 + (-0.46314910054206848) * gru_0_out_t1_8 + (0.46615245938301086) * gru_0_out_t1_9 + (-0.15350691974163055) * gru_0_out_t1_10 + (-0.0019299390260130167) * gru_0_out_t1_11 + (-0.15327197313308716) * gru_0_out_t1_12 + (0.023031879216432571) * gru_0_out_t1_13 + (0.073992908000946045) * gru_0_out_t1_14 + (0.17573116719722748) * gru_0_out_t1_15 + (-0.32039368152618408) * gru_0_out_t1_16 + (-0.19048731029033661) * gru_0_out_t1_17 + (-0.091667309403419495) * gru_0_out_t1_18 + (-0.62564849853515625) * gru_0_out_t1_19 + (0.062167968600988388) * gru_0_out_t1_20 + (-0.27274632453918457) * gru_0_out_t1_21 + (0.11623002588748932) * gru_0_out_t1_22 + (0.15481224656105042) * gru_0_out_t1_23 + (-0.03005792573094368) * gru_0_out_t1_24 + (-0.049482453614473343) * gru_0_out_t1_25 + (0.020882545039057732) * gru_0_out_t1_26 + (0.016499297693371773) * gru_0_out_t1_27 + (0.055536545813083649) * gru_0_out_t1_28 + (0.45674505829811096) * gru_0_out_t1_29 + (-0.19262437522411346) * gru_0_out_t1_30 + (0.062675170600414276) * gru_0_out_t1_31 + (-0.19511221349239349) * gru_0_out_t1_32 + (0.090337380766868591) * gru_0_out_t1_33 + (-0.22088406980037689) * gru_0_out_t1_34 + (0.15848396718502045) * gru_0_out_t1_35 + (0.050301223993301392) * gru_0_out_t1_36 + (0.2811870276927948) * gru_0_out_t1_37 + (0.17899945378303528) * gru_0_out_t1_38 + (-0.4378095269203186) * gru_0_out_t1_39 + (-0.76556414365768433) * gru_0_out_t1_40 + (-0.091834485530853271) * gru_0_out_t1_41 + (-0.11335230618715286) * gru_0_out_t1_42 + (0.23445148766040802) * gru_0_out_t1_43 + (0.35661101341247559) * gru_0_out_t1_44 + (0.62727963924407959) * gru_0_out_t1_45 + (0.038305513560771942) * gru_0_out_t1_46 + (0.32794162631034851) * gru_0_out_t1_47 + (0.45793217420578003) * gru_0_out_t1_48 + (-0.22803770005702972) * gru_0_out_t1_49 + (0.071381725370883942) * gru_0_out_t1_50 + (-0.045355048030614853) * gru_0_out_t1_51 + (0.10306844860315323) * gru_0_out_t1_52 + (0.076342448592185974) * gru_0_out_t1_53 + (-0.10961225628852844) * gru_0_out_t1_54 + (-0.59295517206192017) * gru_0_out_t1_55 + (0.029434345662593842) * gru_0_out_t1_56 + (-0.18059845268726349) * gru_0_out_t1_57 + (0.23845726251602173) * gru_0_out_t1_58 + (-0.028557509183883667) * gru_0_out_t1_59 + (0.093887537717819214) * gru_0_out_t1_60 + (0.27662676572799683) * gru_0_out_t1_61 + (0.88219749927520752) * gru_0_out_t1_62 + (0.19515010714530945) * gru_0_out_t1_63 + gate_r * ((0.034245166927576065) + (-0.77074599266052246) * gru_1_fwd_t0_h_0 + (0.099380888044834137) * gru_1_fwd_t0_h_1 + (-0.054463043808937073) * gru_1_fwd_t0_h_2 + (-0.12775819003582001) * gru_1_fwd_t0_h_3 + (0.5962710976600647) * gru_1_fwd_t0_h_4 + (0.0080833267420530319) * gru_1_fwd_t0_h_5 + (-0.030090240761637688) * gru_1_fwd_t0_h_6 + (-0.16068761050701141) * gru_1_fwd_t0_h_7 + (0.22550457715988159) * gru_1_fwd_t0_h_8 + (-0.16060830652713776) * gru_1_fwd_t0_h_9 + (0.47746774554252625) * gru_1_fwd_t0_h_10 + (0.28645774722099304) * gru_1_fwd_t0_h_11 + (0.090604014694690704) * gru_1_fwd_t0_h_12 + (-0.33011943101882935) * gru_1_fwd_t0_h_13 + (0.1352289617061615) * gru_1_fwd_t0_h_14 + (-0.1631234735250473) * gru_1_fwd_t0_h_15 + (-0.15875649452209473) * gru_1_fwd_t0_h_16 + (0.047294583171606064) * gru_1_fwd_t0_h_17 + (0.37092176079750061) * gru_1_fwd_t0_h_18 + (0.17070020735263824) * gru_1_fwd_t0_h_19 + (0.17905627191066742) * gru_1_fwd_t0_h_20 + (0.042319614440202713) * gru_1_fwd_t0_h_21 + (-0.1152726411819458) * gru_1_fwd_t0_h_22 + (1.1376104354858398) * gru_1_fwd_t0_h_23 + (0.20985528826713562) * gru_1_fwd_t0_h_24 + (0.95099472999572754) * gru_1_fwd_t0_h_25 + (-0.63805234432220459) * gru_1_fwd_t0_h_26 + (0.011583583429455757) * gru_1_fwd_t0_h_27 + (1.1962337493896484) * gru_1_fwd_t0_h_28 + (0.11202040314674377) * gru_1_fwd_t0_h_29 + (0.15463393926620483) * gru_1_fwd_t0_h_30 + (-0.13114038109779358) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_14 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_14;
    // h=15
    gate_r = sigmoid((-0.14252696931362152) + (-0.1273108571767807) * gru_0_out_t1_0 + (0.13209371268749237) * gru_0_out_t1_1 + (-0.27649807929992676) * gru_0_out_t1_2 + (-0.0099655613303184509) * gru_0_out_t1_3 + (0.10868848860263824) * gru_0_out_t1_4 + (0.5941234827041626) * gru_0_out_t1_5 + (0.032085347920656204) * gru_0_out_t1_6 + (-0.8950156569480896) * gru_0_out_t1_7 + (1.2804546356201172) * gru_0_out_t1_8 + (1.0697314739227295) * gru_0_out_t1_9 + (0.14049191772937775) * gru_0_out_t1_10 + (-0.024638650938868523) * gru_0_out_t1_11 + (-0.14962819218635559) * gru_0_out_t1_12 + (-0.041989404708147049) * gru_0_out_t1_13 + (-0.30899831652641296) * gru_0_out_t1_14 + (-0.16325952112674713) * gru_0_out_t1_15 + (0.35378620028495789) * gru_0_out_t1_16 + (-0.17614762485027313) * gru_0_out_t1_17 + (0.5205073356628418) * gru_0_out_t1_18 + (2.3674690723419189) * gru_0_out_t1_19 + (0.41909164190292358) * gru_0_out_t1_20 + (1.0414119958877563) * gru_0_out_t1_21 + (0.42300298810005188) * gru_0_out_t1_22 + (-1.6564027070999146) * gru_0_out_t1_23 + (-1.239443302154541) * gru_0_out_t1_24 + (-1.1604893207550049) * gru_0_out_t1_25 + (0.49952754378318787) * gru_0_out_t1_26 + (0.6091504693031311) * gru_0_out_t1_27 + (-2.1779499053955078) * gru_0_out_t1_28 + (-0.74442142248153687) * gru_0_out_t1_29 + (-0.16004063189029694) * gru_0_out_t1_30 + (-1.8758703470230103) * gru_0_out_t1_31 + (-0.18648026883602142) * gru_0_out_t1_32 + (0.31585228443145752) * gru_0_out_t1_33 + (0.15462078154087067) * gru_0_out_t1_34 + (0.098539508879184723) * gru_0_out_t1_35 + (0.04049186035990715) * gru_0_out_t1_36 + (0.28540173172950745) * gru_0_out_t1_37 + (-0.39856112003326416) * gru_0_out_t1_38 + (0.47101417183876038) * gru_0_out_t1_39 + (-1.414319634437561) * gru_0_out_t1_40 + (0.16349148750305176) * gru_0_out_t1_41 + (0.26332685351371765) * gru_0_out_t1_42 + (-0.038379114121198654) * gru_0_out_t1_43 + (-0.24572345614433289) * gru_0_out_t1_44 + (-0.23756125569343567) * gru_0_out_t1_45 + (0.62001961469650269) * gru_0_out_t1_46 + (-0.5900687575340271) * gru_0_out_t1_47 + (0.094671629369258881) * gru_0_out_t1_48 + (-0.057108063250780106) * gru_0_out_t1_49 + (-0.073551937937736511) * gru_0_out_t1_50 + (0.55618304014205933) * gru_0_out_t1_51 + (-0.062850795686244965) * gru_0_out_t1_52 + (0.10332390666007996) * gru_0_out_t1_53 + (1.3049144744873047) * gru_0_out_t1_54 + (-0.19350026547908783) * gru_0_out_t1_55 + (-0.021466055884957314) * gru_0_out_t1_56 + (0.028373481705784798) * gru_0_out_t1_57 + (0.26017984747886658) * gru_0_out_t1_58 + (1.1394516229629517) * gru_0_out_t1_59 + (0.72652536630630493) * gru_0_out_t1_60 + (0.2654549777507782) * gru_0_out_t1_61 + (-0.25978207588195801) * gru_0_out_t1_62 + (1.061166524887085) * gru_0_out_t1_63 + (0.9225272536277771) * gru_1_fwd_t0_h_0 + (0.54736500978469849) * gru_1_fwd_t0_h_1 + (-0.99681371450424194) * gru_1_fwd_t0_h_2 + (-0.4158480167388916) * gru_1_fwd_t0_h_3 + (-0.34156540036201477) * gru_1_fwd_t0_h_4 + (-1.0619323253631592) * gru_1_fwd_t0_h_5 + (1.6103748083114624) * gru_1_fwd_t0_h_6 + (-0.032484941184520721) * gru_1_fwd_t0_h_7 + (-1.8735204935073853) * gru_1_fwd_t0_h_8 + (-0.24988490343093872) * gru_1_fwd_t0_h_9 + (-0.33532038331031799) * gru_1_fwd_t0_h_10 + (1.1532289981842041) * gru_1_fwd_t0_h_11 + (-0.26214775443077087) * gru_1_fwd_t0_h_12 + (-0.67231756448745728) * gru_1_fwd_t0_h_13 + (-0.040990851819515228) * gru_1_fwd_t0_h_14 + (-0.8349500298500061) * gru_1_fwd_t0_h_15 + (-0.22177739441394806) * gru_1_fwd_t0_h_16 + (0.47193285822868347) * gru_1_fwd_t0_h_17 + (-0.33817058801651001) * gru_1_fwd_t0_h_18 + (0.29424202442169189) * gru_1_fwd_t0_h_19 + (-0.21899332106113434) * gru_1_fwd_t0_h_20 + (-1.5138702392578125) * gru_1_fwd_t0_h_21 + (-1.4406968355178833) * gru_1_fwd_t0_h_22 + (-0.10625933855772018) * gru_1_fwd_t0_h_23 + (0.22119729220867157) * gru_1_fwd_t0_h_24 + (-0.70695710182189941) * gru_1_fwd_t0_h_25 + (-2.1485846042633057) * gru_1_fwd_t0_h_26 + (-0.14369969069957733) * gru_1_fwd_t0_h_27 + (-0.48045995831489563) * gru_1_fwd_t0_h_28 + (-0.20452511310577393) * gru_1_fwd_t0_h_29 + (-0.61336880922317505) * gru_1_fwd_t0_h_30 + (0.159974604845047) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((-0.20010054111480713) + (0.20837114751338959) * gru_0_out_t1_0 + (0.01103175338357687) * gru_0_out_t1_1 + (1.4599847793579102) * gru_0_out_t1_2 + (-0.82316410541534424) * gru_0_out_t1_3 + (0.20982158184051514) * gru_0_out_t1_4 + (-1.5093766450881958) * gru_0_out_t1_5 + (-1.0777796506881714) * gru_0_out_t1_6 + (-0.43025398254394531) * gru_0_out_t1_7 + (0.73049712181091309) * gru_0_out_t1_8 + (2.2380328178405762) * gru_0_out_t1_9 + (-1.3304436206817627) * gru_0_out_t1_10 + (0.30146953463554382) * gru_0_out_t1_11 + (-0.014563877135515213) * gru_0_out_t1_12 + (0.24543450772762299) * gru_0_out_t1_13 + (-0.37925195693969727) * gru_0_out_t1_14 + (0.56397521495819092) * gru_0_out_t1_15 + (1.2668452262878418) * gru_0_out_t1_16 + (0.19709737598896027) * gru_0_out_t1_17 + (0.36501863598823547) * gru_0_out_t1_18 + (0.32603225111961365) * gru_0_out_t1_19 + (1.1689451932907104) * gru_0_out_t1_20 + (0.83956372737884521) * gru_0_out_t1_21 + (0.37466534972190857) * gru_0_out_t1_22 + (0.42630356550216675) * gru_0_out_t1_23 + (-0.79960572719573975) * gru_0_out_t1_24 + (0.19976326823234558) * gru_0_out_t1_25 + (-0.079449132084846497) * gru_0_out_t1_26 + (-0.032034266740083694) * gru_0_out_t1_27 + (-1.041562557220459) * gru_0_out_t1_28 + (0.33244732022285461) * gru_0_out_t1_29 + (0.19705168902873993) * gru_0_out_t1_30 + (0.2167586088180542) * gru_0_out_t1_31 + (-1.1369268894195557) * gru_0_out_t1_32 + (0.6370273232460022) * gru_0_out_t1_33 + (-0.48087617754936218) * gru_0_out_t1_34 + (-0.13734914362430573) * gru_0_out_t1_35 + (-0.056470133364200592) * gru_0_out_t1_36 + (0.074742585420608521) * gru_0_out_t1_37 + (0.099214352667331696) * gru_0_out_t1_38 + (-0.86935544013977051) * gru_0_out_t1_39 + (-1.042494535446167) * gru_0_out_t1_40 + (0.042564816772937775) * gru_0_out_t1_41 + (0.17438636720180511) * gru_0_out_t1_42 + (-0.2369200587272644) * gru_0_out_t1_43 + (0.0059458939358592033) * gru_0_out_t1_44 + (0.10548446327447891) * gru_0_out_t1_45 + (0.28301936388015747) * gru_0_out_t1_46 + (0.23119893670082092) * gru_0_out_t1_47 + (-0.12024985253810883) * gru_0_out_t1_48 + (0.30621486902236938) * gru_0_out_t1_49 + (-0.0053261634893715382) * gru_0_out_t1_50 + (0.055038966238498688) * gru_0_out_t1_51 + (-0.043306399136781693) * gru_0_out_t1_52 + (-0.2367749810218811) * gru_0_out_t1_53 + (0.060773830860853195) * gru_0_out_t1_54 + (-0.13898658752441406) * gru_0_out_t1_55 + (-0.22388049960136414) * gru_0_out_t1_56 + (-0.056070476770401001) * gru_0_out_t1_57 + (0.31873193383216858) * gru_0_out_t1_58 + (0.042977135628461838) * gru_0_out_t1_59 + (-0.33431950211524963) * gru_0_out_t1_60 + (-0.38221061229705811) * gru_0_out_t1_61 + (0.51840907335281372) * gru_0_out_t1_62 + (0.66650509834289551) * gru_0_out_t1_63 + (0.89041239023208618) * gru_1_fwd_t0_h_0 + (0.48555842041969299) * gru_1_fwd_t0_h_1 + (-0.1131487563252449) * gru_1_fwd_t0_h_2 + (0.19706635177135468) * gru_1_fwd_t0_h_3 + (-0.25381040573120117) * gru_1_fwd_t0_h_4 + (-0.80056107044219971) * gru_1_fwd_t0_h_5 + (0.08113793283700943) * gru_1_fwd_t0_h_6 + (-0.47052842378616333) * gru_1_fwd_t0_h_7 + (0.37915930151939392) * gru_1_fwd_t0_h_8 + (-0.19041734933853149) * gru_1_fwd_t0_h_9 + (1.6031692028045654) * gru_1_fwd_t0_h_10 + (1.0791275501251221) * gru_1_fwd_t0_h_11 + (0.15339197218418121) * gru_1_fwd_t0_h_12 + (-0.19778591394424438) * gru_1_fwd_t0_h_13 + (0.086621254682540894) * gru_1_fwd_t0_h_14 + (0.4531891942024231) * gru_1_fwd_t0_h_15 + (0.41358399391174316) * gru_1_fwd_t0_h_16 + (-0.19029928743839264) * gru_1_fwd_t0_h_17 + (0.37494802474975586) * gru_1_fwd_t0_h_18 + (0.063745178282260895) * gru_1_fwd_t0_h_19 + (0.14925503730773926) * gru_1_fwd_t0_h_20 + (-0.41758465766906738) * gru_1_fwd_t0_h_21 + (0.46809226274490356) * gru_1_fwd_t0_h_22 + (0.11447564512491226) * gru_1_fwd_t0_h_23 + (0.2613576352596283) * gru_1_fwd_t0_h_24 + (1.2266989946365356) * gru_1_fwd_t0_h_25 + (-0.4682915210723877) * gru_1_fwd_t0_h_26 + (0.13888901472091675) * gru_1_fwd_t0_h_27 + (-0.08909279853105545) * gru_1_fwd_t0_h_28 + (0.22793951630592346) * gru_1_fwd_t0_h_29 + (-0.029005277901887894) * gru_1_fwd_t0_h_30 + (0.077649384737014771) * gru_1_fwd_t0_h_31);
    gate_n = tanh((-0.27310928702354431) + (0.13068944215774536) * gru_0_out_t1_0 + (0.44534191489219666) * gru_0_out_t1_1 + (-0.52533513307571411) * gru_0_out_t1_2 + (0.037337087094783783) * gru_0_out_t1_3 + (0.44608861207962036) * gru_0_out_t1_4 + (0.083989568054676056) * gru_0_out_t1_5 + (-0.61942631006240845) * gru_0_out_t1_6 + (0.11928364634513855) * gru_0_out_t1_7 + (1.0010055303573608) * gru_0_out_t1_8 + (0.86570531129837036) * gru_0_out_t1_9 + (-0.67394012212753296) * gru_0_out_t1_10 + (-0.031762424856424332) * gru_0_out_t1_11 + (-0.18867084383964539) * gru_0_out_t1_12 + (-0.43164819478988647) * gru_0_out_t1_13 + (0.084357358515262604) * gru_0_out_t1_14 + (-0.091652952134609222) * gru_0_out_t1_15 + (0.73219025135040283) * gru_0_out_t1_16 + (0.25531294941902161) * gru_0_out_t1_17 + (0.12771874666213989) * gru_0_out_t1_18 + (-0.39284190535545349) * gru_0_out_t1_19 + (-0.070826590061187744) * gru_0_out_t1_20 + (0.78559744358062744) * gru_0_out_t1_21 + (-0.47350525856018066) * gru_0_out_t1_22 + (-1.1793445348739624) * gru_0_out_t1_23 + (-0.19741111993789673) * gru_0_out_t1_24 + (0.33291855454444885) * gru_0_out_t1_25 + (-0.11186069995164871) * gru_0_out_t1_26 + (0.031002603471279144) * gru_0_out_t1_27 + (0.96631467342376709) * gru_0_out_t1_28 + (-0.38327184319496155) * gru_0_out_t1_29 + (-0.37440729141235352) * gru_0_out_t1_30 + (-0.48583304882049561) * gru_0_out_t1_31 + (-0.045444726943969727) * gru_0_out_t1_32 + (0.17876286804676056) * gru_0_out_t1_33 + (-0.55092191696166992) * gru_0_out_t1_34 + (-0.016904372721910477) * gru_0_out_t1_35 + (0.19009539484977722) * gru_0_out_t1_36 + (0.34925100207328796) * gru_0_out_t1_37 + (-0.14794503152370453) * gru_0_out_t1_38 + (-0.57555007934570312) * gru_0_out_t1_39 + (1.3538603782653809) * gru_0_out_t1_40 + (-0.24438515305519104) * gru_0_out_t1_41 + (0.32886520028114319) * gru_0_out_t1_42 + (0.016996392980217934) * gru_0_out_t1_43 + (-0.93078523874282837) * gru_0_out_t1_44 + (-0.50831836462020874) * gru_0_out_t1_45 + (-0.16950492560863495) * gru_0_out_t1_46 + (-0.089502573013305664) * gru_0_out_t1_47 + (-0.27272287011146545) * gru_0_out_t1_48 + (0.027521057054400444) * gru_0_out_t1_49 + (-0.0030496451072394848) * gru_0_out_t1_50 + (0.0091908760368824005) * gru_0_out_t1_51 + (-0.14111720025539398) * gru_0_out_t1_52 + (-0.61911410093307495) * gru_0_out_t1_53 + (0.74847781658172607) * gru_0_out_t1_54 + (0.015259590931236744) * gru_0_out_t1_55 + (0.24447356164455414) * gru_0_out_t1_56 + (-0.075419157743453979) * gru_0_out_t1_57 + (0.16044260561466217) * gru_0_out_t1_58 + (-0.010633731260895729) * gru_0_out_t1_59 + (1.2168402671813965) * gru_0_out_t1_60 + (0.72344702482223511) * gru_0_out_t1_61 + (-0.48917239904403687) * gru_0_out_t1_62 + (-0.23016200959682465) * gru_0_out_t1_63 + gate_r * ((-0.39011108875274658) + (0.54748284816741943) * gru_1_fwd_t0_h_0 + (0.028262393549084663) * gru_1_fwd_t0_h_1 + (0.99697232246398926) * gru_1_fwd_t0_h_2 + (0.33071178197860718) * gru_1_fwd_t0_h_3 + (-0.20900626480579376) * gru_1_fwd_t0_h_4 + (-0.024302165955305099) * gru_1_fwd_t0_h_5 + (-0.26677075028419495) * gru_1_fwd_t0_h_6 + (0.060709256678819656) * gru_1_fwd_t0_h_7 + (-0.0065368674695491791) * gru_1_fwd_t0_h_8 + (-0.21267244219779968) * gru_1_fwd_t0_h_9 + (0.11591779440641403) * gru_1_fwd_t0_h_10 + (-0.83535641431808472) * gru_1_fwd_t0_h_11 + (0.033392433077096939) * gru_1_fwd_t0_h_12 + (0.056867994368076324) * gru_1_fwd_t0_h_13 + (-0.3345550000667572) * gru_1_fwd_t0_h_14 + (-0.44265261292457581) * gru_1_fwd_t0_h_15 + (-0.012428202666342258) * gru_1_fwd_t0_h_16 + (-0.18101565539836884) * gru_1_fwd_t0_h_17 + (-0.025231409817934036) * gru_1_fwd_t0_h_18 + (-0.31299403309822083) * gru_1_fwd_t0_h_19 + (0.51982003450393677) * gru_1_fwd_t0_h_20 + (-0.31096053123474121) * gru_1_fwd_t0_h_21 + (-0.0092970440164208412) * gru_1_fwd_t0_h_22 + (0.50608259439468384) * gru_1_fwd_t0_h_23 + (1.1007579565048218) * gru_1_fwd_t0_h_24 + (0.301230788230896) * gru_1_fwd_t0_h_25 + (-0.22389601171016693) * gru_1_fwd_t0_h_26 + (-0.82675635814666748) * gru_1_fwd_t0_h_27 + (-0.053431857377290726) * gru_1_fwd_t0_h_28 + (0.21673603355884552) * gru_1_fwd_t0_h_29 + (0.48022615909576416) * gru_1_fwd_t0_h_30 + (0.2123757004737854) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_15 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_15;
    // h=16
    gate_r = sigmoid((-0.29410448670387268) + (-0.64615559577941895) * gru_0_out_t1_0 + (1.4186617136001587) * gru_0_out_t1_1 + (-1.0398908853530884) * gru_0_out_t1_2 + (-0.68223631381988525) * gru_0_out_t1_3 + (0.053732812404632568) * gru_0_out_t1_4 + (-0.50579380989074707) * gru_0_out_t1_5 + (-0.11160075664520264) * gru_0_out_t1_6 + (-0.68993586301803589) * gru_0_out_t1_7 + (0.2862686812877655) * gru_0_out_t1_8 + (-0.29196858406066895) * gru_0_out_t1_9 + (1.2952944040298462) * gru_0_out_t1_10 + (0.1911855936050415) * gru_0_out_t1_11 + (0.084379449486732483) * gru_0_out_t1_12 + (0.39103186130523682) * gru_0_out_t1_13 + (-0.2205733060836792) * gru_0_out_t1_14 + (-0.78194600343704224) * gru_0_out_t1_15 + (0.25682789087295532) * gru_0_out_t1_16 + (0.34257283806800842) * gru_0_out_t1_17 + (-0.25675708055496216) * gru_0_out_t1_18 + (0.69322538375854492) * gru_0_out_t1_19 + (-0.58638018369674683) * gru_0_out_t1_20 + (0.035921018570661545) * gru_0_out_t1_21 + (-1.3290404081344604) * gru_0_out_t1_22 + (-0.15674965083599091) * gru_0_out_t1_23 + (1.5568701028823853) * gru_0_out_t1_24 + (0.1607079952955246) * gru_0_out_t1_25 + (-0.20773473381996155) * gru_0_out_t1_26 + (-0.77457445859909058) * gru_0_out_t1_27 + (0.53829407691955566) * gru_0_out_t1_28 + (0.075575165450572968) * gru_0_out_t1_29 + (0.2209957093000412) * gru_0_out_t1_30 + (2.1318554878234863) * gru_0_out_t1_31 + (3.6907036304473877) * gru_0_out_t1_32 + (1.0573219060897827) * gru_0_out_t1_33 + (0.38706481456756592) * gru_0_out_t1_34 + (-1.8441382646560669) * gru_0_out_t1_35 + (-0.31447711586952209) * gru_0_out_t1_36 + (0.11242479085922241) * gru_0_out_t1_37 + (-0.44741994142532349) * gru_0_out_t1_38 + (-0.90080368518829346) * gru_0_out_t1_39 + (-3.827888011932373) * gru_0_out_t1_40 + (0.48193979263305664) * gru_0_out_t1_41 + (0.96341961622238159) * gru_0_out_t1_42 + (-1.7891477346420288) * gru_0_out_t1_43 + (-0.71881502866744995) * gru_0_out_t1_44 + (-0.63431823253631592) * gru_0_out_t1_45 + (0.57844573259353638) * gru_0_out_t1_46 + (-2.4977519512176514) * gru_0_out_t1_47 + (-0.38457313179969788) * gru_0_out_t1_48 + (0.5209355354309082) * gru_0_out_t1_49 + (0.0060571278445422649) * gru_0_out_t1_50 + (-0.12831979990005493) * gru_0_out_t1_51 + (0.31226179003715515) * gru_0_out_t1_52 + (0.44886913895606995) * gru_0_out_t1_53 + (0.045342497527599335) * gru_0_out_t1_54 + (0.27190998196601868) * gru_0_out_t1_55 + (0.30759355425834656) * gru_0_out_t1_56 + (0.52536672353744507) * gru_0_out_t1_57 + (-0.2799641489982605) * gru_0_out_t1_58 + (4.4690742492675781) * gru_0_out_t1_59 + (0.15575703978538513) * gru_0_out_t1_60 + (0.0026140378322452307) * gru_0_out_t1_61 + (-0.099210225045681) * gru_0_out_t1_62 + (2.3683121204376221) * gru_0_out_t1_63 + (-2.7111828327178955) * gru_1_fwd_t0_h_0 + (1.2488409280776978) * gru_1_fwd_t0_h_1 + (-0.80689710378646851) * gru_1_fwd_t0_h_2 + (-0.9205324649810791) * gru_1_fwd_t0_h_3 + (-0.12060008198022842) * gru_1_fwd_t0_h_4 + (-0.0023304985370486975) * gru_1_fwd_t0_h_5 + (0.96697801351547241) * gru_1_fwd_t0_h_6 + (1.0441755056381226) * gru_1_fwd_t0_h_7 + (0.53406774997711182) * gru_1_fwd_t0_h_8 + (0.82018065452575684) * gru_1_fwd_t0_h_9 + (0.38070765137672424) * gru_1_fwd_t0_h_10 + (-0.6820443868637085) * gru_1_fwd_t0_h_11 + (1.3043214082717896) * gru_1_fwd_t0_h_12 + (-0.37380287051200867) * gru_1_fwd_t0_h_13 + (1.0409265756607056) * gru_1_fwd_t0_h_14 + (-0.74934357404708862) * gru_1_fwd_t0_h_15 + (0.65143537521362305) * gru_1_fwd_t0_h_16 + (-0.72782385349273682) * gru_1_fwd_t0_h_17 + (1.1853723526000977) * gru_1_fwd_t0_h_18 + (-0.45256069302558899) * gru_1_fwd_t0_h_19 + (-0.40377748012542725) * gru_1_fwd_t0_h_20 + (3.1520791053771973) * gru_1_fwd_t0_h_21 + (0.72287839651107788) * gru_1_fwd_t0_h_22 + (2.4087786674499512) * gru_1_fwd_t0_h_23 + (-0.016056898981332779) * gru_1_fwd_t0_h_24 + (0.58438271284103394) * gru_1_fwd_t0_h_25 + (-2.1881868839263916) * gru_1_fwd_t0_h_26 + (-0.23527480661869049) * gru_1_fwd_t0_h_27 + (1.4907263517379761) * gru_1_fwd_t0_h_28 + (-0.81724625825881958) * gru_1_fwd_t0_h_29 + (1.1501772403717041) * gru_1_fwd_t0_h_30 + (-1.3607919216156006) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((-0.97060859203338623) + (-0.037337504327297211) * gru_0_out_t1_0 + (0.27543348073959351) * gru_0_out_t1_1 + (-0.06484648585319519) * gru_0_out_t1_2 + (0.092112518846988678) * gru_0_out_t1_3 + (-0.53779476881027222) * gru_0_out_t1_4 + (0.1989690363407135) * gru_0_out_t1_5 + (0.81809419393539429) * gru_0_out_t1_6 + (-1.4531619548797607) * gru_0_out_t1_7 + (0.28458157181739807) * gru_0_out_t1_8 + (-0.62000107765197754) * gru_0_out_t1_9 + (0.35276502370834351) * gru_0_out_t1_10 + (0.043119531124830246) * gru_0_out_t1_11 + (-0.10890460014343262) * gru_0_out_t1_12 + (0.095366917550563812) * gru_0_out_t1_13 + (-0.12012272328138351) * gru_0_out_t1_14 + (0.33950242400169373) * gru_0_out_t1_15 + (1.0166375637054443) * gru_0_out_t1_16 + (0.22579401731491089) * gru_0_out_t1_17 + (0.42682340741157532) * gru_0_out_t1_18 + (1.5678606033325195) * gru_0_out_t1_19 + (-0.4683399498462677) * gru_0_out_t1_20 + (1.3571635484695435) * gru_0_out_t1_21 + (0.65204781293869019) * gru_0_out_t1_22 + (-0.5366026759147644) * gru_0_out_t1_23 + (-0.4994320273399353) * gru_0_out_t1_24 + (-0.3614422082901001) * gru_0_out_t1_25 + (-0.24203141033649445) * gru_0_out_t1_26 + (0.33753257989883423) * gru_0_out_t1_27 + (2.1065077781677246) * gru_0_out_t1_28 + (-0.8456043004989624) * gru_0_out_t1_29 + (-0.89641201496124268) * gru_0_out_t1_30 + (0.14637118577957153) * gru_0_out_t1_31 + (-3.1288564205169678) * gru_0_out_t1_32 + (-0.38054487109184265) * gru_0_out_t1_33 + (-0.24205127358436584) * gru_0_out_t1_34 + (-0.07553911954164505) * gru_0_out_t1_35 + (0.10474294424057007) * gru_0_out_t1_36 + (0.13916096091270447) * gru_0_out_t1_37 + (0.034799873828887939) * gru_0_out_t1_38 + (-0.43294656276702881) * gru_0_out_t1_39 + (0.091682225465774536) * gru_0_out_t1_40 + (0.64046889543533325) * gru_0_out_t1_41 + (-0.31308954954147339) * gru_0_out_t1_42 + (-0.31525006890296936) * gru_0_out_t1_43 + (-0.074149109423160553) * gru_0_out_t1_44 + (-0.32027631998062134) * gru_0_out_t1_45 + (-0.21475879848003387) * gru_0_out_t1_46 + (1.3514038324356079) * gru_0_out_t1_47 + (-0.3134523332118988) * gru_0_out_t1_48 + (0.14589816331863403) * gru_0_out_t1_49 + (-0.80087816715240479) * gru_0_out_t1_50 + (0.0068223909474909306) * gru_0_out_t1_51 + (0.38784906268119812) * gru_0_out_t1_52 + (-0.77051353454589844) * gru_0_out_t1_53 + (0.06820080429315567) * gru_0_out_t1_54 + (-0.30778107047080994) * gru_0_out_t1_55 + (1.1999181509017944) * gru_0_out_t1_56 + (0.60534501075744629) * gru_0_out_t1_57 + (-0.32900020480155945) * gru_0_out_t1_58 + (0.2913983166217804) * gru_0_out_t1_59 + (0.20297254621982574) * gru_0_out_t1_60 + (-0.22547332942485809) * gru_0_out_t1_61 + (-0.54179054498672485) * gru_0_out_t1_62 + (1.5167461633682251) * gru_0_out_t1_63 + (0.44947418570518494) * gru_1_fwd_t0_h_0 + (-0.53886228799819946) * gru_1_fwd_t0_h_1 + (-0.53234708309173584) * gru_1_fwd_t0_h_2 + (0.89293324947357178) * gru_1_fwd_t0_h_3 + (-0.00094895320944488049) * gru_1_fwd_t0_h_4 + (0.47871148586273193) * gru_1_fwd_t0_h_5 + (0.26120111346244812) * gru_1_fwd_t0_h_6 + (-0.61157423257827759) * gru_1_fwd_t0_h_7 + (-0.74095445871353149) * gru_1_fwd_t0_h_8 + (0.17440888285636902) * gru_1_fwd_t0_h_9 + (0.86495769023895264) * gru_1_fwd_t0_h_10 + (-0.016308361664414406) * gru_1_fwd_t0_h_11 + (-0.27331531047821045) * gru_1_fwd_t0_h_12 + (0.15217790007591248) * gru_1_fwd_t0_h_13 + (1.1521637439727783) * gru_1_fwd_t0_h_14 + (-0.2883039116859436) * gru_1_fwd_t0_h_15 + (-0.62530416250228882) * gru_1_fwd_t0_h_16 + (0.54128408432006836) * gru_1_fwd_t0_h_17 + (-1.4101169109344482) * gru_1_fwd_t0_h_18 + (-0.02296452596783638) * gru_1_fwd_t0_h_19 + (-0.046477440744638443) * gru_1_fwd_t0_h_20 + (-0.10003414005041122) * gru_1_fwd_t0_h_21 + (0.42140623927116394) * gru_1_fwd_t0_h_22 + (-2.5295350551605225) * gru_1_fwd_t0_h_23 + (-0.057407446205615997) * gru_1_fwd_t0_h_24 + (-0.37359309196472168) * gru_1_fwd_t0_h_25 + (-0.17729708552360535) * gru_1_fwd_t0_h_26 + (0.99514114856719971) * gru_1_fwd_t0_h_27 + (-0.93953120708465576) * gru_1_fwd_t0_h_28 + (-0.060108032077550888) * gru_1_fwd_t0_h_29 + (0.78097081184387207) * gru_1_fwd_t0_h_30 + (0.46018317341804504) * gru_1_fwd_t0_h_31);
    gate_n = tanh((-0.5933833122253418) + (0.019754273816943169) * gru_0_out_t1_0 + (2.6644489765167236) * gru_0_out_t1_1 + (0.043807491660118103) * gru_0_out_t1_2 + (-0.13925927877426147) * gru_0_out_t1_3 + (-0.1834932267665863) * gru_0_out_t1_4 + (-0.86176717281341553) * gru_0_out_t1_5 + (0.4760972261428833) * gru_0_out_t1_6 + (1.115276575088501) * gru_0_out_t1_7 + (-0.22560754418373108) * gru_0_out_t1_8 + (0.37708494067192078) * gru_0_out_t1_9 + (-0.13993830978870392) * gru_0_out_t1_10 + (-0.3410625159740448) * gru_0_out_t1_11 + (-0.2422889918088913) * gru_0_out_t1_12 + (-1.1451092958450317) * gru_0_out_t1_13 + (-0.10507015138864517) * gru_0_out_t1_14 + (-0.96366012096405029) * gru_0_out_t1_15 + (0.36831417679786682) * gru_0_out_t1_16 + (0.078452207148075104) * gru_0_out_t1_17 + (0.39467808604240417) * gru_0_out_t1_18 + (1.1776833534240723) * gru_0_out_t1_19 + (0.32065474987030029) * gru_0_out_t1_20 + (1.6158574819564819) * gru_0_out_t1_21 + (-0.54503059387207031) * gru_0_out_t1_22 + (-0.45511823892593384) * gru_0_out_t1_23 + (-0.77460801601409912) * gru_0_out_t1_24 + (0.36026141047477722) * gru_0_out_t1_25 + (-0.09381372481584549) * gru_0_out_t1_26 + (-1.3670574426651001) * gru_0_out_t1_27 + (0.45654091238975525) * gru_0_out_t1_28 + (0.66345483064651489) * gru_0_out_t1_29 + (0.38188013434410095) * gru_0_out_t1_30 + (-1.4395555257797241) * gru_0_out_t1_31 + (0.31092935800552368) * gru_0_out_t1_32 + (0.56428623199462891) * gru_0_out_t1_33 + (-0.38335809111595154) * gru_0_out_t1_34 + (-3.1057138442993164) * gru_0_out_t1_35 + (-0.026680737733840942) * gru_0_out_t1_36 + (1.1241950988769531) * gru_0_out_t1_37 + (0.044988054782152176) * gru_0_out_t1_38 + (0.78339022397994995) * gru_0_out_t1_39 + (0.57983523607254028) * gru_0_out_t1_40 + (-0.55712032318115234) * gru_0_out_t1_41 + (0.51464420557022095) * gru_0_out_t1_42 + (-0.014154508709907532) * gru_0_out_t1_43 + (-0.51596003770828247) * gru_0_out_t1_44 + (-0.57639098167419434) * gru_0_out_t1_45 + (0.42564752697944641) * gru_0_out_t1_46 + (-0.90847045183181763) * gru_0_out_t1_47 + (-0.61161273717880249) * gru_0_out_t1_48 + (-0.28582248091697693) * gru_0_out_t1_49 + (0.10884002596139908) * gru_0_out_t1_50 + (-0.53468751907348633) * gru_0_out_t1_51 + (0.19121696054935455) * gru_0_out_t1_52 + (-0.10358615219593048) * gru_0_out_t1_53 + (0.02262437529861927) * gru_0_out_t1_54 + (0.19122141599655151) * gru_0_out_t1_55 + (0.68889975547790527) * gru_0_out_t1_56 + (0.33800831437110901) * gru_0_out_t1_57 + (0.025625260546803474) * gru_0_out_t1_58 + (0.82837897539138794) * gru_0_out_t1_59 + (-0.081156149506568909) * gru_0_out_t1_60 + (-0.010824074037373066) * gru_0_out_t1_61 + (-0.54488962888717651) * gru_0_out_t1_62 + (-1.9135136604309082) * gru_0_out_t1_63 + gate_r * ((1.3445340394973755) + (-0.72670108079910278) * gru_1_fwd_t0_h_0 + (-0.98379713296890259) * gru_1_fwd_t0_h_1 + (1.1309353113174438) * gru_1_fwd_t0_h_2 + (-0.23982429504394531) * gru_1_fwd_t0_h_3 + (1.1368358135223389) * gru_1_fwd_t0_h_4 + (0.44870331883430481) * gru_1_fwd_t0_h_5 + (0.45607438683509827) * gru_1_fwd_t0_h_6 + (-0.66903722286224365) * gru_1_fwd_t0_h_7 + (-1.0165234804153442) * gru_1_fwd_t0_h_8 + (0.61388140916824341) * gru_1_fwd_t0_h_9 + (1.1479865312576294) * gru_1_fwd_t0_h_10 + (1.3086510896682739) * gru_1_fwd_t0_h_11 + (-0.52618718147277832) * gru_1_fwd_t0_h_12 + (-0.33545377850532532) * gru_1_fwd_t0_h_13 + (0.52494603395462036) * gru_1_fwd_t0_h_14 + (0.27716478705406189) * gru_1_fwd_t0_h_15 + (-1.024301290512085) * gru_1_fwd_t0_h_16 + (-0.15380613505840302) * gru_1_fwd_t0_h_17 + (0.85772573947906494) * gru_1_fwd_t0_h_18 + (1.6784783601760864) * gru_1_fwd_t0_h_19 + (-0.073591180145740509) * gru_1_fwd_t0_h_20 + (-0.16970914602279663) * gru_1_fwd_t0_h_21 + (0.65429937839508057) * gru_1_fwd_t0_h_22 + (-0.27311456203460693) * gru_1_fwd_t0_h_23 + (2.2529256343841553) * gru_1_fwd_t0_h_24 + (-1.5689877271652222) * gru_1_fwd_t0_h_25 + (1.9697020053863525) * gru_1_fwd_t0_h_26 + (1.1341851949691772) * gru_1_fwd_t0_h_27 + (-0.1124720573425293) * gru_1_fwd_t0_h_28 + (-0.23632447421550751) * gru_1_fwd_t0_h_29 + (-0.4775625467300415) * gru_1_fwd_t0_h_30 + (0.34884184598922729) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_16 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_16;
    // h=17
    gate_r = sigmoid((-0.41148003935813904) + (0.47238573431968689) * gru_0_out_t1_0 + (0.66103261709213257) * gru_0_out_t1_1 + (-0.98806369304656982) * gru_0_out_t1_2 + (-0.42350888252258301) * gru_0_out_t1_3 + (0.4640190601348877) * gru_0_out_t1_4 + (-0.74383640289306641) * gru_0_out_t1_5 + (-2.1639344692230225) * gru_0_out_t1_6 + (-1.2958414554595947) * gru_0_out_t1_7 + (-0.19463802874088287) * gru_0_out_t1_8 + (1.4465732574462891) * gru_0_out_t1_9 + (1.0512278079986572) * gru_0_out_t1_10 + (-0.35838231444358826) * gru_0_out_t1_11 + (-0.36811384558677673) * gru_0_out_t1_12 + (1.3973922729492188) * gru_0_out_t1_13 + (-0.67438089847564697) * gru_0_out_t1_14 + (-1.2710835933685303) * gru_0_out_t1_15 + (0.12473719567060471) * gru_0_out_t1_16 + (0.13504362106323242) * gru_0_out_t1_17 + (0.33399808406829834) * gru_0_out_t1_18 + (2.9357411861419678) * gru_0_out_t1_19 + (-2.29567551612854) * gru_0_out_t1_20 + (0.15434952080249786) * gru_0_out_t1_21 + (-1.7308231592178345) * gru_0_out_t1_22 + (-0.10938715934753418) * gru_0_out_t1_23 + (0.12009493261575699) * gru_0_out_t1_24 + (0.21539868414402008) * gru_0_out_t1_25 + (0.44444450736045837) * gru_0_out_t1_26 + (-0.20681340992450714) * gru_0_out_t1_27 + (-0.24683965742588043) * gru_0_out_t1_28 + (-0.25147664546966553) * gru_0_out_t1_29 + (-0.54391962289810181) * gru_0_out_t1_30 + (3.9395337104797363) * gru_0_out_t1_31 + (0.60500240325927734) * gru_0_out_t1_32 + (-0.58866328001022339) * gru_0_out_t1_33 + (0.25301980972290039) * gru_0_out_t1_34 + (-0.66588348150253296) * gru_0_out_t1_35 + (-1.9679735898971558) * gru_0_out_t1_36 + (-0.32015416026115417) * gru_0_out_t1_37 + (0.40246737003326416) * gru_0_out_t1_38 + (0.46883094310760498) * gru_0_out_t1_39 + (1.367402195930481) * gru_0_out_t1_40 + (-1.295067310333252) * gru_0_out_t1_41 + (-0.20777805149555206) * gru_0_out_t1_42 + (-0.43703430891036987) * gru_0_out_t1_43 + (-0.35505858063697815) * gru_0_out_t1_44 + (-0.14413580298423767) * gru_0_out_t1_45 + (1.395282506942749) * gru_0_out_t1_46 + (0.064788401126861572) * gru_0_out_t1_47 + (0.26926514506340027) * gru_0_out_t1_48 + (-0.63569307327270508) * gru_0_out_t1_49 + (-0.67407858371734619) * gru_0_out_t1_50 + (-1.3780974149703979) * gru_0_out_t1_51 + (-0.011366341263055801) * gru_0_out_t1_52 + (-0.15577498078346252) * gru_0_out_t1_53 + (-0.46138247847557068) * gru_0_out_t1_54 + (-0.12100930511951447) * gru_0_out_t1_55 + (1.4568145275115967) * gru_0_out_t1_56 + (-0.71388602256774902) * gru_0_out_t1_57 + (0.51148396730422974) * gru_0_out_t1_58 + (0.026473948732018471) * gru_0_out_t1_59 + (-0.13368572294712067) * gru_0_out_t1_60 + (0.3639971911907196) * gru_0_out_t1_61 + (-3.9786458015441895) * gru_0_out_t1_62 + (0.69883072376251221) * gru_0_out_t1_63 + (0.27167186141014099) * gru_1_fwd_t0_h_0 + (0.020365992560982704) * gru_1_fwd_t0_h_1 + (1.2854567766189575) * gru_1_fwd_t0_h_2 + (0.20891593396663666) * gru_1_fwd_t0_h_3 + (-0.26299148797988892) * gru_1_fwd_t0_h_4 + (-1.8146891593933105) * gru_1_fwd_t0_h_5 + (-0.027107665315270424) * gru_1_fwd_t0_h_6 + (0.82493817806243896) * gru_1_fwd_t0_h_7 + (0.046666420996189117) * gru_1_fwd_t0_h_8 + (0.50535362958908081) * gru_1_fwd_t0_h_9 + (-0.055275328457355499) * gru_1_fwd_t0_h_10 + (1.7068792581558228) * gru_1_fwd_t0_h_11 + (-0.33011564612388611) * gru_1_fwd_t0_h_12 + (0.68490976095199585) * gru_1_fwd_t0_h_13 + (0.36785873770713806) * gru_1_fwd_t0_h_14 + (-0.68023234605789185) * gru_1_fwd_t0_h_15 + (0.43559971451759338) * gru_1_fwd_t0_h_16 + (-0.54693436622619629) * gru_1_fwd_t0_h_17 + (0.10778649151325226) * gru_1_fwd_t0_h_18 + (-0.45565295219421387) * gru_1_fwd_t0_h_19 + (0.97338038682937622) * gru_1_fwd_t0_h_20 + (-1.3887478113174438) * gru_1_fwd_t0_h_21 + (1.1298952102661133) * gru_1_fwd_t0_h_22 + (-0.50673162937164307) * gru_1_fwd_t0_h_23 + (-3.2248141765594482) * gru_1_fwd_t0_h_24 + (-0.81580626964569092) * gru_1_fwd_t0_h_25 + (-0.43484845757484436) * gru_1_fwd_t0_h_26 + (0.72725510597229004) * gru_1_fwd_t0_h_27 + (-1.294333815574646) * gru_1_fwd_t0_h_28 + (1.024578332901001) * gru_1_fwd_t0_h_29 + (-1.2793688774108887) * gru_1_fwd_t0_h_30 + (1.3361537456512451) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((0.764637291431427) + (-0.38635200262069702) * gru_0_out_t1_0 + (-0.40014761686325073) * gru_0_out_t1_1 + (2.4240093231201172) * gru_0_out_t1_2 + (-0.56269538402557373) * gru_0_out_t1_3 + (-0.17769171297550201) * gru_0_out_t1_4 + (0.46267414093017578) * gru_0_out_t1_5 + (0.16072991490364075) * gru_0_out_t1_6 + (-1.5523312091827393) * gru_0_out_t1_7 + (0.28363028168678284) * gru_0_out_t1_8 + (-0.14460667967796326) * gru_0_out_t1_9 + (-1.4602681398391724) * gru_0_out_t1_10 + (0.57768934965133667) * gru_0_out_t1_11 + (-0.70759761333465576) * gru_0_out_t1_12 + (-0.11177968233823776) * gru_0_out_t1_13 + (0.11393314599990845) * gru_0_out_t1_14 + (0.64546823501586914) * gru_0_out_t1_15 + (0.15875080227851868) * gru_0_out_t1_16 + (0.28666570782661438) * gru_0_out_t1_17 + (-0.12255144864320755) * gru_0_out_t1_18 + (-0.25357347726821899) * gru_0_out_t1_19 + (1.1201801300048828) * gru_0_out_t1_20 + (-0.081488229334354401) * gru_0_out_t1_21 + (-0.5998038649559021) * gru_0_out_t1_22 + (-0.46479368209838867) * gru_0_out_t1_23 + (-0.75020867586135864) * gru_0_out_t1_24 + (-0.69816911220550537) * gru_0_out_t1_25 + (-0.0023969360627233982) * gru_0_out_t1_26 + (0.24285534024238586) * gru_0_out_t1_27 + (-1.316237211227417) * gru_0_out_t1_28 + (-0.1372210830450058) * gru_0_out_t1_29 + (0.50853478908538818) * gru_0_out_t1_30 + (0.0051748482510447502) * gru_0_out_t1_31 + (0.00076241814531385899) * gru_0_out_t1_32 + (-0.1740880012512207) * gru_0_out_t1_33 + (0.0094936061650514603) * gru_0_out_t1_34 + (-0.71370965242385864) * gru_0_out_t1_35 + (-0.55613267421722412) * gru_0_out_t1_36 + (-0.30314946174621582) * gru_0_out_t1_37 + (0.14988988637924194) * gru_0_out_t1_38 + (-0.11570865660905838) * gru_0_out_t1_39 + (-0.37169775366783142) * gru_0_out_t1_40 + (0.63421612977981567) * gru_0_out_t1_41 + (-0.63877660036087036) * gru_0_out_t1_42 + (-0.51200926303863525) * gru_0_out_t1_43 + (0.30854851007461548) * gru_0_out_t1_44 + (-0.7897651195526123) * gru_0_out_t1_45 + (0.34715563058853149) * gru_0_out_t1_46 + (0.041685491800308228) * gru_0_out_t1_47 + (0.46840125322341919) * gru_0_out_t1_48 + (-0.23999869823455811) * gru_0_out_t1_49 + (-0.20149403810501099) * gru_0_out_t1_50 + (-0.60607033967971802) * gru_0_out_t1_51 + (0.53305822610855103) * gru_0_out_t1_52 + (0.25261446833610535) * gru_0_out_t1_53 + (-0.12006900459527969) * gru_0_out_t1_54 + (-0.075961902737617493) * gru_0_out_t1_55 + (0.076765738427639008) * gru_0_out_t1_56 + (-0.12261445820331573) * gru_0_out_t1_57 + (0.10041086375713348) * gru_0_out_t1_58 + (-0.53630739450454712) * gru_0_out_t1_59 + (-0.29484662413597107) * gru_0_out_t1_60 + (-0.30708962678909302) * gru_0_out_t1_61 + (-0.49881666898727417) * gru_0_out_t1_62 + (0.36483666300773621) * gru_0_out_t1_63 + (0.15004463493824005) * gru_1_fwd_t0_h_0 + (-0.088696181774139404) * gru_1_fwd_t0_h_1 + (-0.54319077730178833) * gru_1_fwd_t0_h_2 + (0.18371888995170593) * gru_1_fwd_t0_h_3 + (0.47454535961151123) * gru_1_fwd_t0_h_4 + (0.087245240807533264) * gru_1_fwd_t0_h_5 + (0.25205522775650024) * gru_1_fwd_t0_h_6 + (0.16222724318504333) * gru_1_fwd_t0_h_7 + (0.15323103964328766) * gru_1_fwd_t0_h_8 + (0.038162022829055786) * gru_1_fwd_t0_h_9 + (1.0611019134521484) * gru_1_fwd_t0_h_10 + (0.22682023048400879) * gru_1_fwd_t0_h_11 + (0.020265521481633186) * gru_1_fwd_t0_h_12 + (-0.02462959848344326) * gru_1_fwd_t0_h_13 + (0.27212360501289368) * gru_1_fwd_t0_h_14 + (0.17232020199298859) * gru_1_fwd_t0_h_15 + (-0.50968289375305176) * gru_1_fwd_t0_h_16 + (0.21244867146015167) * gru_1_fwd_t0_h_17 + (-0.14514261484146118) * gru_1_fwd_t0_h_18 + (-0.30012339353561401) * gru_1_fwd_t0_h_19 + (-0.21556679904460907) * gru_1_fwd_t0_h_20 + (-0.14933310449123383) * gru_1_fwd_t0_h_21 + (0.35361453890800476) * gru_1_fwd_t0_h_22 + (-0.51695835590362549) * gru_1_fwd_t0_h_23 + (0.25989583134651184) * gru_1_fwd_t0_h_24 + (0.25310659408569336) * gru_1_fwd_t0_h_25 + (0.84243804216384888) * gru_1_fwd_t0_h_26 + (-0.50366717576980591) * gru_1_fwd_t0_h_27 + (1.426155686378479) * gru_1_fwd_t0_h_28 + (0.28992122411727905) * gru_1_fwd_t0_h_29 + (-0.83955562114715576) * gru_1_fwd_t0_h_30 + (-0.065013259649276733) * gru_1_fwd_t0_h_31);
    gate_n = tanh((-0.02798701636493206) + (0.054011281579732895) * gru_0_out_t1_0 + (-0.49930581450462341) * gru_0_out_t1_1 + (0.52970230579376221) * gru_0_out_t1_2 + (0.4737151563167572) * gru_0_out_t1_3 + (0.15142902731895447) * gru_0_out_t1_4 + (-0.15612494945526123) * gru_0_out_t1_5 + (1.0054217576980591) * gru_0_out_t1_6 + (0.79292172193527222) * gru_0_out_t1_7 + (-0.071434557437896729) * gru_0_out_t1_8 + (-0.14579230546951294) * gru_0_out_t1_9 + (-0.74811768531799316) * gru_0_out_t1_10 + (0.58895868062973022) * gru_0_out_t1_11 + (0.39210242033004761) * gru_0_out_t1_12 + (0.38702660799026489) * gru_0_out_t1_13 + (0.0045525007881224155) * gru_0_out_t1_14 + (0.5961449146270752) * gru_0_out_t1_15 + (0.0004642338608391583) * gru_0_out_t1_16 + (0.43989062309265137) * gru_0_out_t1_17 + (-0.22468841075897217) * gru_0_out_t1_18 + (1.4088281393051147) * gru_0_out_t1_19 + (0.34005051851272583) * gru_0_out_t1_20 + (-0.16137288510799408) * gru_0_out_t1_21 + (-0.020395329222083092) * gru_0_out_t1_22 + (-0.35417789220809937) * gru_0_out_t1_23 + (-0.68552416563034058) * gru_0_out_t1_24 + (-0.038087423890829086) * gru_0_out_t1_25 + (-0.043236155062913895) * gru_0_out_t1_26 + (0.33996090292930603) * gru_0_out_t1_27 + (-1.4470556974411011) * gru_0_out_t1_28 + (0.79092955589294434) * gru_0_out_t1_29 + (-0.22945457696914673) * gru_0_out_t1_30 + (0.76781779527664185) * gru_0_out_t1_31 + (-0.2208503931760788) * gru_0_out_t1_32 + (0.46004757285118103) * gru_0_out_t1_33 + (-0.11591313034296036) * gru_0_out_t1_34 + (0.17627586424350739) * gru_0_out_t1_35 + (0.36979728937149048) * gru_0_out_t1_36 + (-0.070795111358165741) * gru_0_out_t1_37 + (0.14010477066040039) * gru_0_out_t1_38 + (0.011498434469103813) * gru_0_out_t1_39 + (-3.7190825939178467) * gru_0_out_t1_40 + (0.89090675115585327) * gru_0_out_t1_41 + (0.18355785310268402) * gru_0_out_t1_42 + (0.50188428163528442) * gru_0_out_t1_43 + (0.24833840131759644) * gru_0_out_t1_44 + (0.081104077398777008) * gru_0_out_t1_45 + (0.1338428258895874) * gru_0_out_t1_46 + (0.33014419674873352) * gru_0_out_t1_47 + (-0.52534216642379761) * gru_0_out_t1_48 + (-0.10141061991453171) * gru_0_out_t1_49 + (0.36117023229598999) * gru_0_out_t1_50 + (-0.24445481598377228) * gru_0_out_t1_51 + (-0.15164883434772491) * gru_0_out_t1_52 + (-0.43070724606513977) * gru_0_out_t1_53 + (0.0077728233300149441) * gru_0_out_t1_54 + (0.65161103010177612) * gru_0_out_t1_55 + (-0.30940639972686768) * gru_0_out_t1_56 + (0.12393079698085785) * gru_0_out_t1_57 + (-0.53707945346832275) * gru_0_out_t1_58 + (-0.41703009605407715) * gru_0_out_t1_59 + (0.51151394844055176) * gru_0_out_t1_60 + (0.22281837463378906) * gru_0_out_t1_61 + (-2.4077327251434326) * gru_0_out_t1_62 + (1.3233685493469238) * gru_0_out_t1_63 + gate_r * ((-0.14635650813579559) + (-0.62920159101486206) * gru_1_fwd_t0_h_0 + (-0.19425962865352631) * gru_1_fwd_t0_h_1 + (-0.063780099153518677) * gru_1_fwd_t0_h_2 + (-0.81707984209060669) * gru_1_fwd_t0_h_3 + (-0.24857026338577271) * gru_1_fwd_t0_h_4 + (-0.040016941726207733) * gru_1_fwd_t0_h_5 + (-0.20857198536396027) * gru_1_fwd_t0_h_6 + (-0.0039613568224012852) * gru_1_fwd_t0_h_7 + (0.16065487265586853) * gru_1_fwd_t0_h_8 + (0.023922540247440338) * gru_1_fwd_t0_h_9 + (-0.015233422629535198) * gru_1_fwd_t0_h_10 + (1.500346302986145) * gru_1_fwd_t0_h_11 + (0.19053171575069427) * gru_1_fwd_t0_h_12 + (0.44485482573509216) * gru_1_fwd_t0_h_13 + (-0.91621613502502441) * gru_1_fwd_t0_h_14 + (0.20424409210681915) * gru_1_fwd_t0_h_15 + (0.25733184814453125) * gru_1_fwd_t0_h_16 + (-0.60079222917556763) * gru_1_fwd_t0_h_17 + (-0.059542819857597351) * gru_1_fwd_t0_h_18 + (0.33392578363418579) * gru_1_fwd_t0_h_19 + (0.13135933876037598) * gru_1_fwd_t0_h_20 + (0.11628855764865875) * gru_1_fwd_t0_h_21 + (-0.26727744936943054) * gru_1_fwd_t0_h_22 + (-0.80372905731201172) * gru_1_fwd_t0_h_23 + (-0.37681031227111816) * gru_1_fwd_t0_h_24 + (1.3074864149093628) * gru_1_fwd_t0_h_25 + (-0.36248338222503662) * gru_1_fwd_t0_h_26 + (0.018732354044914246) * gru_1_fwd_t0_h_27 + (-0.68293124437332153) * gru_1_fwd_t0_h_28 + (-0.40635597705841064) * gru_1_fwd_t0_h_29 + (0.31109011173248291) * gru_1_fwd_t0_h_30 + (-0.052935916930437088) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_17 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_17;
    // h=18
    gate_r = sigmoid((-0.26545426249504089) + (-0.89171987771987915) * gru_0_out_t1_0 + (-0.14711882174015045) * gru_0_out_t1_1 + (1.431216835975647) * gru_0_out_t1_2 + (-0.88631480932235718) * gru_0_out_t1_3 + (-0.042791515588760376) * gru_0_out_t1_4 + (-1.4263224601745605) * gru_0_out_t1_5 + (-1.4125267267227173) * gru_0_out_t1_6 + (-1.9287781715393066) * gru_0_out_t1_7 + (1.7384178638458252) * gru_0_out_t1_8 + (-0.13778068125247955) * gru_0_out_t1_9 + (-1.1224737167358398) * gru_0_out_t1_10 + (-0.34192538261413574) * gru_0_out_t1_11 + (-0.096887052059173584) * gru_0_out_t1_12 + (0.063838750123977661) * gru_0_out_t1_13 + (-0.19947640597820282) * gru_0_out_t1_14 + (0.14792335033416748) * gru_0_out_t1_15 + (0.39715102314949036) * gru_0_out_t1_16 + (-0.23609015345573425) * gru_0_out_t1_17 + (0.58513426780700684) * gru_0_out_t1_18 + (0.8923068642616272) * gru_0_out_t1_19 + (0.058364853262901306) * gru_0_out_t1_20 + (0.63839554786682129) * gru_0_out_t1_21 + (-1.0828745365142822) * gru_0_out_t1_22 + (-0.80349272489547729) * gru_0_out_t1_23 + (0.75735634565353394) * gru_0_out_t1_24 + (-0.061466515064239502) * gru_0_out_t1_25 + (-2.5244216918945312) * gru_0_out_t1_26 + (0.70825529098510742) * gru_0_out_t1_27 + (1.0499652624130249) * gru_0_out_t1_28 + (1.0552661418914795) * gru_0_out_t1_29 + (-0.036444954574108124) * gru_0_out_t1_30 + (3.1354067325592041) * gru_0_out_t1_31 + (-1.3201682567596436) * gru_0_out_t1_32 + (-0.26050189137458801) * gru_0_out_t1_33 + (0.67592751979827881) * gru_0_out_t1_34 + (0.14620457589626312) * gru_0_out_t1_35 + (0.43809321522712708) * gru_0_out_t1_36 + (-0.54078733921051025) * gru_0_out_t1_37 + (0.41957035660743713) * gru_0_out_t1_38 + (0.10027614235877991) * gru_0_out_t1_39 + (2.3291826248168945) * gru_0_out_t1_40 + (0.45135307312011719) * gru_0_out_t1_41 + (1.8394701480865479) * gru_0_out_t1_42 + (-0.28979086875915527) * gru_0_out_t1_43 + (0.21835435926914215) * gru_0_out_t1_44 + (0.28140890598297119) * gru_0_out_t1_45 + (0.10227799415588379) * gru_0_out_t1_46 + (0.73193418979644775) * gru_0_out_t1_47 + (0.01708601787686348) * gru_0_out_t1_48 + (0.038629971444606781) * gru_0_out_t1_49 + (-0.95869201421737671) * gru_0_out_t1_50 + (-0.65919262170791626) * gru_0_out_t1_51 + (0.35723164677619934) * gru_0_out_t1_52 + (-0.44966605305671692) * gru_0_out_t1_53 + (-0.85331368446350098) * gru_0_out_t1_54 + (-0.36975163221359253) * gru_0_out_t1_55 + (0.36524006724357605) * gru_0_out_t1_56 + (-0.010250807739794254) * gru_0_out_t1_57 + (0.057101037353277206) * gru_0_out_t1_58 + (0.9014132022857666) * gru_0_out_t1_59 + (-0.60690206289291382) * gru_0_out_t1_60 + (0.27420318126678467) * gru_0_out_t1_61 + (0.18549928069114685) * gru_0_out_t1_62 + (0.90848731994628906) * gru_0_out_t1_63 + (-0.18887799978256226) * gru_1_fwd_t0_h_0 + (-0.42572006583213806) * gru_1_fwd_t0_h_1 + (-0.69529896974563599) * gru_1_fwd_t0_h_2 + (0.095908477902412415) * gru_1_fwd_t0_h_3 + (0.021165447309613228) * gru_1_fwd_t0_h_4 + (-1.0041283369064331) * gru_1_fwd_t0_h_5 + (0.71536058187484741) * gru_1_fwd_t0_h_6 + (0.074085608124732971) * gru_1_fwd_t0_h_7 + (0.96617662906646729) * gru_1_fwd_t0_h_8 + (0.78232145309448242) * gru_1_fwd_t0_h_9 + (1.5504696369171143) * gru_1_fwd_t0_h_10 + (-1.0828292369842529) * gru_1_fwd_t0_h_11 + (-0.68159329891204834) * gru_1_fwd_t0_h_12 + (0.13404151797294617) * gru_1_fwd_t0_h_13 + (-0.71757984161376953) * gru_1_fwd_t0_h_14 + (-0.44785067439079285) * gru_1_fwd_t0_h_15 + (-0.31369751691818237) * gru_1_fwd_t0_h_16 + (0.53218942880630493) * gru_1_fwd_t0_h_17 + (-1.9608831405639648) * gru_1_fwd_t0_h_18 + (0.61070907115936279) * gru_1_fwd_t0_h_19 + (0.25004425644874573) * gru_1_fwd_t0_h_20 + (0.69705545902252197) * gru_1_fwd_t0_h_21 + (0.6467355489730835) * gru_1_fwd_t0_h_22 + (-0.042218197137117386) * gru_1_fwd_t0_h_23 + (1.0223734378814697) * gru_1_fwd_t0_h_24 + (0.61429888010025024) * gru_1_fwd_t0_h_25 + (-0.090147726237773895) * gru_1_fwd_t0_h_26 + (-2.522733211517334) * gru_1_fwd_t0_h_27 + (0.27274134755134583) * gru_1_fwd_t0_h_28 + (0.028112282976508141) * gru_1_fwd_t0_h_29 + (0.6845894455909729) * gru_1_fwd_t0_h_30 + (0.14956018328666687) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((0.83454203605651855) + (0.51016038656234741) * gru_0_out_t1_0 + (-0.27175581455230713) * gru_0_out_t1_1 + (0.77933347225189209) * gru_0_out_t1_2 + (-0.42917385697364807) * gru_0_out_t1_3 + (0.18129141628742218) * gru_0_out_t1_4 + (-0.36838170886039734) * gru_0_out_t1_5 + (0.57990634441375732) * gru_0_out_t1_6 + (-0.43917471170425415) * gru_0_out_t1_7 + (-0.12411060929298401) * gru_0_out_t1_8 + (0.16235774755477905) * gru_0_out_t1_9 + (-0.71797364950180054) * gru_0_out_t1_10 + (0.0042833816260099411) * gru_0_out_t1_11 + (0.079833947122097015) * gru_0_out_t1_12 + (0.33018037676811218) * gru_0_out_t1_13 + (-0.071026250720024109) * gru_0_out_t1_14 + (-0.1903974860906601) * gru_0_out_t1_15 + (-0.13693419098854065) * gru_0_out_t1_16 + (-0.17653438448905945) * gru_0_out_t1_17 + (0.32118728756904602) * gru_0_out_t1_18 + (-1.0494686365127563) * gru_0_out_t1_19 + (-0.046684227883815765) * gru_0_out_t1_20 + (-0.55580669641494751) * gru_0_out_t1_21 + (-0.14526934921741486) * gru_0_out_t1_22 + (-1.0786162614822388) * gru_0_out_t1_23 + (-2.0760235786437988) * gru_0_out_t1_24 + (-0.93071061372756958) * gru_0_out_t1_25 + (0.49828585982322693) * gru_0_out_t1_26 + (0.433491051197052) * gru_0_out_t1_27 + (-0.090623512864112854) * gru_0_out_t1_28 + (0.49229338765144348) * gru_0_out_t1_29 + (0.47725147008895874) * gru_0_out_t1_30 + (0.49352428317070007) * gru_0_out_t1_31 + (0.040151972323656082) * gru_0_out_t1_32 + (0.23458336293697357) * gru_0_out_t1_33 + (0.19429241120815277) * gru_0_out_t1_34 + (-0.26751574873924255) * gru_0_out_t1_35 + (0.0032494545448571444) * gru_0_out_t1_36 + (0.13468840718269348) * gru_0_out_t1_37 + (-0.070425719022750854) * gru_0_out_t1_38 + (0.27335885167121887) * gru_0_out_t1_39 + (0.76278603076934814) * gru_0_out_t1_40 + (0.24780069291591644) * gru_0_out_t1_41 + (-0.0017698145238682628) * gru_0_out_t1_42 + (0.04777120053768158) * gru_0_out_t1_43 + (-0.009277738630771637) * gru_0_out_t1_44 + (0.049351323395967484) * gru_0_out_t1_45 + (-0.66593879461288452) * gru_0_out_t1_46 + (0.33963516354560852) * gru_0_out_t1_47 + (-0.018058765679597855) * gru_0_out_t1_48 + (-0.16917666792869568) * gru_0_out_t1_49 + (0.18458093702793121) * gru_0_out_t1_50 + (-0.12737555801868439) * gru_0_out_t1_51 + (-0.27084803581237793) * gru_0_out_t1_52 + (-0.033225730061531067) * gru_0_out_t1_53 + (0.46488600969314575) * gru_0_out_t1_54 + (-0.16997583210468292) * gru_0_out_t1_55 + (0.025382399559020996) * gru_0_out_t1_56 + (0.38311311602592468) * gru_0_out_t1_57 + (-0.071106262505054474) * gru_0_out_t1_58 + (-0.57767140865325928) * gru_0_out_t1_59 + (-0.45581880211830139) * gru_0_out_t1_60 + (-0.0044395062141120434) * gru_0_out_t1_61 + (0.097954213619232178) * gru_0_out_t1_62 + (0.060721501708030701) * gru_0_out_t1_63 + (-0.16429093480110168) * gru_1_fwd_t0_h_0 + (0.04869457334280014) * gru_1_fwd_t0_h_1 + (-1.3686339855194092) * gru_1_fwd_t0_h_2 + (-0.51798552274703979) * gru_1_fwd_t0_h_3 + (-0.3038155734539032) * gru_1_fwd_t0_h_4 + (-0.50408881902694702) * gru_1_fwd_t0_h_5 + (0.27853500843048096) * gru_1_fwd_t0_h_6 + (0.33243313431739807) * gru_1_fwd_t0_h_7 + (-0.27005711197853088) * gru_1_fwd_t0_h_8 + (0.14805698394775391) * gru_1_fwd_t0_h_9 + (-0.25179946422576904) * gru_1_fwd_t0_h_10 + (1.0273177623748779) * gru_1_fwd_t0_h_11 + (-0.087860934436321259) * gru_1_fwd_t0_h_12 + (0.17302536964416504) * gru_1_fwd_t0_h_13 + (-0.023543160408735275) * gru_1_fwd_t0_h_14 + (-0.23144684731960297) * gru_1_fwd_t0_h_15 + (-0.24091064929962158) * gru_1_fwd_t0_h_16 + (-0.15786971151828766) * gru_1_fwd_t0_h_17 + (0.46415454149246216) * gru_1_fwd_t0_h_18 + (-0.89962035417556763) * gru_1_fwd_t0_h_19 + (-0.24532763659954071) * gru_1_fwd_t0_h_20 + (-0.59257495403289795) * gru_1_fwd_t0_h_21 + (-0.68678665161132812) * gru_1_fwd_t0_h_22 + (0.35628962516784668) * gru_1_fwd_t0_h_23 + (-0.84459871053695679) * gru_1_fwd_t0_h_24 + (0.86810904741287231) * gru_1_fwd_t0_h_25 + (0.95815861225128174) * gru_1_fwd_t0_h_26 + (-0.49412748217582703) * gru_1_fwd_t0_h_27 + (0.16758327186107635) * gru_1_fwd_t0_h_28 + (-0.028868747875094414) * gru_1_fwd_t0_h_29 + (-0.37758567929267883) * gru_1_fwd_t0_h_30 + (0.55202829837799072) * gru_1_fwd_t0_h_31);
    gate_n = tanh((0.16364885866641998) + (0.61796313524246216) * gru_0_out_t1_0 + (0.025010205805301666) * gru_0_out_t1_1 + (0.34159523248672485) * gru_0_out_t1_2 + (0.68374764919281006) * gru_0_out_t1_3 + (-0.4403546154499054) * gru_0_out_t1_4 + (0.43695679306983948) * gru_0_out_t1_5 + (0.44106006622314453) * gru_0_out_t1_6 + (-1.1462807655334473) * gru_0_out_t1_7 + (-0.28287014365196228) * gru_0_out_t1_8 + (0.55738288164138794) * gru_0_out_t1_9 + (-0.11419957876205444) * gru_0_out_t1_10 + (0.84815222024917603) * gru_0_out_t1_11 + (-0.078989654779434204) * gru_0_out_t1_12 + (-0.15754285454750061) * gru_0_out_t1_13 + (0.27858734130859375) * gru_0_out_t1_14 + (0.20828400552272797) * gru_0_out_t1_15 + (-0.16347454488277435) * gru_0_out_t1_16 + (-0.2830054759979248) * gru_0_out_t1_17 + (0.09949599951505661) * gru_0_out_t1_18 + (-1.159549355506897) * gru_0_out_t1_19 + (1.2729897499084473) * gru_0_out_t1_20 + (-0.13110257685184479) * gru_0_out_t1_21 + (0.91520094871520996) * gru_0_out_t1_22 + (0.020907407626509666) * gru_0_out_t1_23 + (-0.047117535024881363) * gru_0_out_t1_24 + (-0.15060260891914368) * gru_0_out_t1_25 + (-0.10456959158182144) * gru_0_out_t1_26 + (-0.28710472583770752) * gru_0_out_t1_27 + (-0.25540688633918762) * gru_0_out_t1_28 + (0.60114777088165283) * gru_0_out_t1_29 + (0.074120767414569855) * gru_0_out_t1_30 + (-0.20555378496646881) * gru_0_out_t1_31 + (-0.20009979605674744) * gru_0_out_t1_32 + (-0.24899579584598541) * gru_0_out_t1_33 + (-0.30741056799888611) * gru_0_out_t1_34 + (-0.12792231142520905) * gru_0_out_t1_35 + (0.33521625399589539) * gru_0_out_t1_36 + (-0.072519086301326752) * gru_0_out_t1_37 + (0.0027174041606485844) * gru_0_out_t1_38 + (-0.71989482641220093) * gru_0_out_t1_39 + (0.12663498520851135) * gru_0_out_t1_40 + (-0.036858335137367249) * gru_0_out_t1_41 + (0.17811959981918335) * gru_0_out_t1_42 + (0.49165740609169006) * gru_0_out_t1_43 + (0.057818770408630371) * gru_0_out_t1_44 + (0.89773648977279663) * gru_0_out_t1_45 + (0.044372152537107468) * gru_0_out_t1_46 + (0.40009540319442749) * gru_0_out_t1_47 + (0.063416115939617157) * gru_0_out_t1_48 + (0.1070193275809288) * gru_0_out_t1_49 + (-0.026652341708540916) * gru_0_out_t1_50 + (-0.018241498619318008) * gru_0_out_t1_51 + (-0.0152331767603755) * gru_0_out_t1_52 + (-0.018808262422680855) * gru_0_out_t1_53 + (-0.25292229652404785) * gru_0_out_t1_54 + (-0.68571138381958008) * gru_0_out_t1_55 + (-0.28387358784675598) * gru_0_out_t1_56 + (0.22108162939548492) * gru_0_out_t1_57 + (-0.73379063606262207) * gru_0_out_t1_58 + (-0.28541776537895203) * gru_0_out_t1_59 + (-0.026600237935781479) * gru_0_out_t1_60 + (-0.00013979031064081937) * gru_0_out_t1_61 + (0.028137663379311562) * gru_0_out_t1_62 + (0.0066284984350204468) * gru_0_out_t1_63 + gate_r * ((0.27120113372802734) + (0.070794366300106049) * gru_1_fwd_t0_h_0 + (1.0478872060775757) * gru_1_fwd_t0_h_1 + (-0.47745966911315918) * gru_1_fwd_t0_h_2 + (0.66106492280960083) * gru_1_fwd_t0_h_3 + (-0.14472532272338867) * gru_1_fwd_t0_h_4 + (0.024646848440170288) * gru_1_fwd_t0_h_5 + (-0.24244067072868347) * gru_1_fwd_t0_h_6 + (0.078029826283454895) * gru_1_fwd_t0_h_7 + (-0.0080286366865038872) * gru_1_fwd_t0_h_8 + (0.056525465101003647) * gru_1_fwd_t0_h_9 + (0.58835631608963013) * gru_1_fwd_t0_h_10 + (0.67307901382446289) * gru_1_fwd_t0_h_11 + (-0.22049570083618164) * gru_1_fwd_t0_h_12 + (-0.18597342073917389) * gru_1_fwd_t0_h_13 + (1.3354793787002563) * gru_1_fwd_t0_h_14 + (-1.2646929025650024) * gru_1_fwd_t0_h_15 + (0.42369037866592407) * gru_1_fwd_t0_h_16 + (-1.376018762588501) * gru_1_fwd_t0_h_17 + (-1.9172918796539307) * gru_1_fwd_t0_h_18 + (-0.55637693405151367) * gru_1_fwd_t0_h_19 + (-0.20025244355201721) * gru_1_fwd_t0_h_20 + (-0.16976642608642578) * gru_1_fwd_t0_h_21 + (-0.66273403167724609) * gru_1_fwd_t0_h_22 + (-0.45675665140151978) * gru_1_fwd_t0_h_23 + (0.47187647223472595) * gru_1_fwd_t0_h_24 + (-0.45811745524406433) * gru_1_fwd_t0_h_25 + (-0.0037213345058262348) * gru_1_fwd_t0_h_26 + (-1.3292819261550903) * gru_1_fwd_t0_h_27 + (0.24851641058921814) * gru_1_fwd_t0_h_28 + (-0.25921231508255005) * gru_1_fwd_t0_h_29 + (-0.63332349061965942) * gru_1_fwd_t0_h_30 + (-0.22161048650741577) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_18 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_18;
    // h=19
    gate_r = sigmoid((-1.8526585102081299) + (-0.018787266686558723) * gru_0_out_t1_0 + (0.23146736621856689) * gru_0_out_t1_1 + (-1.3263881206512451) * gru_0_out_t1_2 + (-0.93332594633102417) * gru_0_out_t1_3 + (-0.099179133772850037) * gru_0_out_t1_4 + (2.6688146591186523) * gru_0_out_t1_5 + (1.1423527002334595) * gru_0_out_t1_6 + (0.82077902555465698) * gru_0_out_t1_7 + (0.99237561225891113) * gru_0_out_t1_8 + (-2.3567652702331543) * gru_0_out_t1_9 + (1.0362616777420044) * gru_0_out_t1_10 + (0.14775820076465607) * gru_0_out_t1_11 + (-0.32346418499946594) * gru_0_out_t1_12 + (-0.42393282055854797) * gru_0_out_t1_13 + (-0.29720118641853333) * gru_0_out_t1_14 + (-0.010968072339892387) * gru_0_out_t1_15 + (0.68952995538711548) * gru_0_out_t1_16 + (0.036487329751253128) * gru_0_out_t1_17 + (0.67047065496444702) * gru_0_out_t1_18 + (0.55376148223876953) * gru_0_out_t1_19 + (-1.491391658782959) * gru_0_out_t1_20 + (1.5732290744781494) * gru_0_out_t1_21 + (-0.57767993211746216) * gru_0_out_t1_22 + (0.70601081848144531) * gru_0_out_t1_23 + (0.92456322908401489) * gru_0_out_t1_24 + (0.2056073397397995) * gru_0_out_t1_25 + (0.42933300137519836) * gru_0_out_t1_26 + (-1.352304220199585) * gru_0_out_t1_27 + (2.0330796241760254) * gru_0_out_t1_28 + (-1.1516090631484985) * gru_0_out_t1_29 + (-1.2903603315353394) * gru_0_out_t1_30 + (0.89606773853302002) * gru_0_out_t1_31 + (-0.68357664346694946) * gru_0_out_t1_32 + (0.44748300313949585) * gru_0_out_t1_33 + (-0.037482645362615585) * gru_0_out_t1_34 + (-0.048763606697320938) * gru_0_out_t1_35 + (0.26135817170143127) * gru_0_out_t1_36 + (0.04730534553527832) * gru_0_out_t1_37 + (-0.055356808006763458) * gru_0_out_t1_38 + (-1.7237874269485474) * gru_0_out_t1_39 + (-0.1564251184463501) * gru_0_out_t1_40 + (0.035093363374471664) * gru_0_out_t1_41 + (1.3016924858093262) * gru_0_out_t1_42 + (-0.22320689260959625) * gru_0_out_t1_43 + (-0.62106424570083618) * gru_0_out_t1_44 + (-0.35933798551559448) * gru_0_out_t1_45 + (-0.03669608011841774) * gru_0_out_t1_46 + (-0.51293939352035522) * gru_0_out_t1_47 + (-1.0065891742706299) * gru_0_out_t1_48 + (1.050722599029541) * gru_0_out_t1_49 + (0.72977334260940552) * gru_0_out_t1_50 + (0.36016988754272461) * gru_0_out_t1_51 + (-0.26452374458312988) * gru_0_out_t1_52 + (0.076091870665550232) * gru_0_out_t1_53 + (-0.76141071319580078) * gru_0_out_t1_54 + (0.24391366541385651) * gru_0_out_t1_55 + (-0.302878737449646) * gru_0_out_t1_56 + (0.48982685804367065) * gru_0_out_t1_57 + (0.10044987499713898) * gru_0_out_t1_58 + (-0.38008925318717957) * gru_0_out_t1_59 + (-0.22934843599796295) * gru_0_out_t1_60 + (1.318184494972229) * gru_0_out_t1_61 + (-0.31201252341270447) * gru_0_out_t1_62 + (2.4664731025695801) * gru_0_out_t1_63 + (-1.7960832118988037) * gru_1_fwd_t0_h_0 + (-1.3290693759918213) * gru_1_fwd_t0_h_1 + (1.2395086288452148) * gru_1_fwd_t0_h_2 + (0.46057593822479248) * gru_1_fwd_t0_h_3 + (0.35587039589881897) * gru_1_fwd_t0_h_4 + (-0.84295576810836792) * gru_1_fwd_t0_h_5 + (-2.7236652374267578) * gru_1_fwd_t0_h_6 + (0.20572578907012939) * gru_1_fwd_t0_h_7 + (-0.65384280681610107) * gru_1_fwd_t0_h_8 + (-1.0448691844940186) * gru_1_fwd_t0_h_9 + (-0.66544336080551147) * gru_1_fwd_t0_h_10 + (-0.77474838495254517) * gru_1_fwd_t0_h_11 + (0.10013418644666672) * gru_1_fwd_t0_h_12 + (-1.9896997213363647) * gru_1_fwd_t0_h_13 + (-0.73830169439315796) * gru_1_fwd_t0_h_14 + (0.71709489822387695) * gru_1_fwd_t0_h_15 + (-0.3250262439250946) * gru_1_fwd_t0_h_16 + (1.1683673858642578) * gru_1_fwd_t0_h_17 + (0.033319290727376938) * gru_1_fwd_t0_h_18 + (1.6575809717178345) * gru_1_fwd_t0_h_19 + (0.49718090891838074) * gru_1_fwd_t0_h_20 + (2.0018410682678223) * gru_1_fwd_t0_h_21 + (1.0074919462203979) * gru_1_fwd_t0_h_22 + (-1.5418457984924316) * gru_1_fwd_t0_h_23 + (-1.7297191619873047) * gru_1_fwd_t0_h_24 + (0.52108758687973022) * gru_1_fwd_t0_h_25 + (-1.4556560516357422) * gru_1_fwd_t0_h_26 + (-0.33912909030914307) * gru_1_fwd_t0_h_27 + (0.21716852486133575) * gru_1_fwd_t0_h_28 + (1.9063683748245239) * gru_1_fwd_t0_h_29 + (-1.0588998794555664) * gru_1_fwd_t0_h_30 + (0.10528906434774399) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((0.32984411716461182) + (0.094709202647209167) * gru_0_out_t1_0 + (-0.032557319849729538) * gru_0_out_t1_1 + (1.0526591539382935) * gru_0_out_t1_2 + (-1.2972768545150757) * gru_0_out_t1_3 + (-0.084496304392814636) * gru_0_out_t1_4 + (-0.10593945533037186) * gru_0_out_t1_5 + (-0.54010206460952759) * gru_0_out_t1_6 + (-0.48525682091712952) * gru_0_out_t1_7 + (0.05189124122262001) * gru_0_out_t1_8 + (-1.2043406963348389) * gru_0_out_t1_9 + (-1.1216480731964111) * gru_0_out_t1_10 + (0.18922458589076996) * gru_0_out_t1_11 + (0.012619988061487675) * gru_0_out_t1_12 + (-0.26433300971984863) * gru_0_out_t1_13 + (0.077577561140060425) * gru_0_out_t1_14 + (-0.30777376890182495) * gru_0_out_t1_15 + (-0.049444656819105148) * gru_0_out_t1_16 + (-0.39421379566192627) * gru_0_out_t1_17 + (-0.32197174429893494) * gru_0_out_t1_18 + (1.0167546272277832) * gru_0_out_t1_19 + (0.50850355625152588) * gru_0_out_t1_20 + (-0.69116318225860596) * gru_0_out_t1_21 + (-0.22989080846309662) * gru_0_out_t1_22 + (0.36351385712623596) * gru_0_out_t1_23 + (-1.1813477277755737) * gru_0_out_t1_24 + (-0.15447598695755005) * gru_0_out_t1_25 + (-0.067565940320491791) * gru_0_out_t1_26 + (0.37153381109237671) * gru_0_out_t1_27 + (-2.3141818046569824) * gru_0_out_t1_28 + (-0.12378764897584915) * gru_0_out_t1_29 + (0.053320471197366714) * gru_0_out_t1_30 + (1.1902854442596436) * gru_0_out_t1_31 + (-0.043593160808086395) * gru_0_out_t1_32 + (-0.19327174127101898) * gru_0_out_t1_33 + (0.13580389320850372) * gru_0_out_t1_34 + (-0.088078342378139496) * gru_0_out_t1_35 + (0.27228271961212158) * gru_0_out_t1_36 + (-0.035504404455423355) * gru_0_out_t1_37 + (0.016506990417838097) * gru_0_out_t1_38 + (0.37897348403930664) * gru_0_out_t1_39 + (0.25948157906532288) * gru_0_out_t1_40 + (0.23168079555034637) * gru_0_out_t1_41 + (-0.37157970666885376) * gru_0_out_t1_42 + (-0.21516183018684387) * gru_0_out_t1_43 + (-0.053073219954967499) * gru_0_out_t1_44 + (-0.52064222097396851) * gru_0_out_t1_45 + (-0.76919084787368774) * gru_0_out_t1_46 + (0.19261758029460907) * gru_0_out_t1_47 + (-0.85872143507003784) * gru_0_out_t1_48 + (0.57999873161315918) * gru_0_out_t1_49 + (0.27053290605545044) * gru_0_out_t1_50 + (-0.048831790685653687) * gru_0_out_t1_51 + (-0.057747021317481995) * gru_0_out_t1_52 + (-0.092676699161529541) * gru_0_out_t1_53 + (-0.21469363570213318) * gru_0_out_t1_54 + (1.003268837928772) * gru_0_out_t1_55 + (0.22990973293781281) * gru_0_out_t1_56 + (0.99787247180938721) * gru_0_out_t1_57 + (0.32891052961349487) * gru_0_out_t1_58 + (0.31211388111114502) * gru_0_out_t1_59 + (-0.23376005887985229) * gru_0_out_t1_60 + (-0.25790059566497803) * gru_0_out_t1_61 + (-0.54692894220352173) * gru_0_out_t1_62 + (-0.96172767877578735) * gru_0_out_t1_63 + (0.38281741738319397) * gru_1_fwd_t0_h_0 + (0.061281707137823105) * gru_1_fwd_t0_h_1 + (-0.45641502737998962) * gru_1_fwd_t0_h_2 + (-0.090298406779766083) * gru_1_fwd_t0_h_3 + (-0.10794778168201447) * gru_1_fwd_t0_h_4 + (0.0045257131569087505) * gru_1_fwd_t0_h_5 + (0.36475813388824463) * gru_1_fwd_t0_h_6 + (-0.11822421103715897) * gru_1_fwd_t0_h_7 + (-0.4352608323097229) * gru_1_fwd_t0_h_8 + (-0.14166782796382904) * gru_1_fwd_t0_h_9 + (0.16978144645690918) * gru_1_fwd_t0_h_10 + (0.5385480523109436) * gru_1_fwd_t0_h_11 + (-0.27226027846336365) * gru_1_fwd_t0_h_12 + (-0.31668370962142944) * gru_1_fwd_t0_h_13 + (0.51006656885147095) * gru_1_fwd_t0_h_14 + (0.59143269062042236) * gru_1_fwd_t0_h_15 + (-0.34663087129592896) * gru_1_fwd_t0_h_16 + (-0.086491107940673828) * gru_1_fwd_t0_h_17 + (0.3908085823059082) * gru_1_fwd_t0_h_18 + (-0.38046851754188538) * gru_1_fwd_t0_h_19 + (0.23882642388343811) * gru_1_fwd_t0_h_20 + (-0.38521862030029297) * gru_1_fwd_t0_h_21 + (-0.43094572424888611) * gru_1_fwd_t0_h_22 + (0.20174229145050049) * gru_1_fwd_t0_h_23 + (-0.28828555345535278) * gru_1_fwd_t0_h_24 + (0.53871047496795654) * gru_1_fwd_t0_h_25 + (-0.20021799206733704) * gru_1_fwd_t0_h_26 + (0.36606237292289734) * gru_1_fwd_t0_h_27 + (-0.21764965355396271) * gru_1_fwd_t0_h_28 + (0.37323948740959167) * gru_1_fwd_t0_h_29 + (-0.080184996128082275) * gru_1_fwd_t0_h_30 + (-0.24070160090923309) * gru_1_fwd_t0_h_31);
    gate_n = tanh((-0.29251444339752197) + (0.026830151677131653) * gru_0_out_t1_0 + (-0.12948521971702576) * gru_0_out_t1_1 + (0.27467355132102966) * gru_0_out_t1_2 + (-0.059903938323259354) * gru_0_out_t1_3 + (0.052837342023849487) * gru_0_out_t1_4 + (0.17700819671154022) * gru_0_out_t1_5 + (1.1752376556396484) * gru_0_out_t1_6 + (-0.41206124424934387) * gru_0_out_t1_7 + (0.33663409948348999) * gru_0_out_t1_8 + (-0.87714946269989014) * gru_0_out_t1_9 + (0.19340027868747711) * gru_0_out_t1_10 + (0.27655187249183655) * gru_0_out_t1_11 + (0.24503844976425171) * gru_0_out_t1_12 + (0.031700789928436279) * gru_0_out_t1_13 + (-0.31356456875801086) * gru_0_out_t1_14 + (0.051690898835659027) * gru_0_out_t1_15 + (0.39647403359413147) * gru_0_out_t1_16 + (0.14088538289070129) * gru_0_out_t1_17 + (-0.26146954298019409) * gru_0_out_t1_18 + (0.0080361152067780495) * gru_0_out_t1_19 + (0.47543990612030029) * gru_0_out_t1_20 + (0.28557687997817993) * gru_0_out_t1_21 + (0.28839012980461121) * gru_0_out_t1_22 + (-0.11987888067960739) * gru_0_out_t1_23 + (0.11407956480979919) * gru_0_out_t1_24 + (0.8898235559463501) * gru_0_out_t1_25 + (0.46476039290428162) * gru_0_out_t1_26 + (-0.21232528984546661) * gru_0_out_t1_27 + (0.23082010447978973) * gru_0_out_t1_28 + (0.41002580523490906) * gru_0_out_t1_29 + (-0.51700443029403687) * gru_0_out_t1_30 + (-0.43231847882270813) * gru_0_out_t1_31 + (-0.82508409023284912) * gru_0_out_t1_32 + (-0.21479296684265137) * gru_0_out_t1_33 + (-0.73385167121887207) * gru_0_out_t1_34 + (-0.40458407998085022) * gru_0_out_t1_35 + (-0.067305400967597961) * gru_0_out_t1_36 + (-0.12753619253635406) * gru_0_out_t1_37 + (-0.0055721476674079895) * gru_0_out_t1_38 + (0.10639890283346176) * gru_0_out_t1_39 + (-0.54028606414794922) * gru_0_out_t1_40 + (-0.20570182800292969) * gru_0_out_t1_41 + (-0.27402195334434509) * gru_0_out_t1_42 + (0.14525134861469269) * gru_0_out_t1_43 + (-0.34303975105285645) * gru_0_out_t1_44 + (-0.38593956828117371) * gru_0_out_t1_45 + (0.20048145949840546) * gru_0_out_t1_46 + (0.29963567852973938) * gru_0_out_t1_47 + (-0.029207715764641762) * gru_0_out_t1_48 + (-0.40316545963287354) * gru_0_out_t1_49 + (-0.34238719940185547) * gru_0_out_t1_50 + (0.16187761723995209) * gru_0_out_t1_51 + (-0.10254108905792236) * gru_0_out_t1_52 + (-0.52675521373748779) * gru_0_out_t1_53 + (-0.13777926564216614) * gru_0_out_t1_54 + (0.5058211088180542) * gru_0_out_t1_55 + (-0.003554090391844511) * gru_0_out_t1_56 + (-0.050308138132095337) * gru_0_out_t1_57 + (0.64174258708953857) * gru_0_out_t1_58 + (-0.508342444896698) * gru_0_out_t1_59 + (0.65733540058135986) * gru_0_out_t1_60 + (0.36407449841499329) * gru_0_out_t1_61 + (-0.27135136723518372) * gru_0_out_t1_62 + (0.15568053722381592) * gru_0_out_t1_63 + gate_r * ((-0.32279935479164124) + (1.1437923908233643) * gru_1_fwd_t0_h_0 + (0.32568028569221497) * gru_1_fwd_t0_h_1 + (-0.56981301307678223) * gru_1_fwd_t0_h_2 + (-0.75587260723114014) * gru_1_fwd_t0_h_3 + (-0.39798828959465027) * gru_1_fwd_t0_h_4 + (0.62853491306304932) * gru_1_fwd_t0_h_5 + (1.3885971307754517) * gru_1_fwd_t0_h_6 + (0.68579638004302979) * gru_1_fwd_t0_h_7 + (0.15096454322338104) * gru_1_fwd_t0_h_8 + (0.53237402439117432) * gru_1_fwd_t0_h_9 + (0.92598134279251099) * gru_1_fwd_t0_h_10 + (1.2241053581237793) * gru_1_fwd_t0_h_11 + (-0.27677345275878906) * gru_1_fwd_t0_h_12 + (2.1847970485687256) * gru_1_fwd_t0_h_13 + (0.52348619699478149) * gru_1_fwd_t0_h_14 + (-0.41622611880302429) * gru_1_fwd_t0_h_15 + (-0.50309902429580688) * gru_1_fwd_t0_h_16 + (-0.55013746023178101) * gru_1_fwd_t0_h_17 + (0.91259688138961792) * gru_1_fwd_t0_h_18 + (-0.75689911842346191) * gru_1_fwd_t0_h_19 + (-0.081816300749778748) * gru_1_fwd_t0_h_20 + (-2.2009150981903076) * gru_1_fwd_t0_h_21 + (-0.24990512430667877) * gru_1_fwd_t0_h_22 + (0.7308843731880188) * gru_1_fwd_t0_h_23 + (-0.36886399984359741) * gru_1_fwd_t0_h_24 + (0.49137243628501892) * gru_1_fwd_t0_h_25 + (-0.44015917181968689) * gru_1_fwd_t0_h_26 + (-0.64191555976867676) * gru_1_fwd_t0_h_27 + (0.11956638842821121) * gru_1_fwd_t0_h_28 + (-0.91458630561828613) * gru_1_fwd_t0_h_29 + (-1.010636568069458) * gru_1_fwd_t0_h_30 + (-1.5189944505691528) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_19 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_19;
    // h=20
    gate_r = sigmoid((-1.2817106246948242) + (-0.48983830213546753) * gru_0_out_t1_0 + (0.26076200604438782) * gru_0_out_t1_1 + (-2.0339467525482178) * gru_0_out_t1_2 + (-0.7943655252456665) * gru_0_out_t1_3 + (0.065380431711673737) * gru_0_out_t1_4 + (-1.9250783920288086) * gru_0_out_t1_5 + (0.61275762319564819) * gru_0_out_t1_6 + (4.4645047187805176) * gru_0_out_t1_7 + (-0.41770091652870178) * gru_0_out_t1_8 + (-2.4737174510955811) * gru_0_out_t1_9 + (1.9250880479812622) * gru_0_out_t1_10 + (0.56847888231277466) * gru_0_out_t1_11 + (-0.64444941282272339) * gru_0_out_t1_12 + (0.1959405392408371) * gru_0_out_t1_13 + (-0.57659471035003662) * gru_0_out_t1_14 + (-0.20287524163722992) * gru_0_out_t1_15 + (0.29061686992645264) * gru_0_out_t1_16 + (-0.78408008813858032) * gru_0_out_t1_17 + (-0.36424306035041809) * gru_0_out_t1_18 + (-1.9746310710906982) * gru_0_out_t1_19 + (-2.3035664558410645) * gru_0_out_t1_20 + (0.38996464014053345) * gru_0_out_t1_21 + (-0.71755260229110718) * gru_0_out_t1_22 + (1.176018238067627) * gru_0_out_t1_23 + (0.8680378794670105) * gru_0_out_t1_24 + (0.69510316848754883) * gru_0_out_t1_25 + (-0.45407024025917053) * gru_0_out_t1_26 + (0.92619991302490234) * gru_0_out_t1_27 + (1.436305046081543) * gru_0_out_t1_28 + (0.11339384317398071) * gru_0_out_t1_29 + (-0.60003936290740967) * gru_0_out_t1_30 + (1.480060338973999) * gru_0_out_t1_31 + (-1.0097053050994873) * gru_0_out_t1_32 + (-1.0582259893417358) * gru_0_out_t1_33 + (-1.6620794534683228) * gru_0_out_t1_34 + (0.00091572350356727839) * gru_0_out_t1_35 + (-0.5328947901725769) * gru_0_out_t1_36 + (-0.39754354953765869) * gru_0_out_t1_37 + (-1.0054599046707153) * gru_0_out_t1_38 + (-0.34544891119003296) * gru_0_out_t1_39 + (-1.2044377326965332) * gru_0_out_t1_40 + (0.2425118088722229) * gru_0_out_t1_41 + (-0.72249853610992432) * gru_0_out_t1_42 + (1.0901083946228027) * gru_0_out_t1_43 + (-0.11071000248193741) * gru_0_out_t1_44 + (-0.0079990271478891373) * gru_0_out_t1_45 + (-0.57627654075622559) * gru_0_out_t1_46 + (0.34137451648712158) * gru_0_out_t1_47 + (-0.65458297729492188) * gru_0_out_t1_48 + (0.85728693008422852) * gru_0_out_t1_49 + (-0.36919191479682922) * gru_0_out_t1_50 + (0.48018693923950195) * gru_0_out_t1_51 + (0.10771072655916214) * gru_0_out_t1_52 + (0.57193011045455933) * gru_0_out_t1_53 + (0.32601609826087952) * gru_0_out_t1_54 + (0.39585083723068237) * gru_0_out_t1_55 + (-0.07703901082277298) * gru_0_out_t1_56 + (0.36514389514923096) * gru_0_out_t1_57 + (-0.40096607804298401) * gru_0_out_t1_58 + (-0.29119917750358582) * gru_0_out_t1_59 + (0.15617626905441284) * gru_0_out_t1_60 + (-1.5166794061660767) * gru_0_out_t1_61 + (1.7377892732620239) * gru_0_out_t1_62 + (1.7023379802703857) * gru_0_out_t1_63 + (-0.33521488308906555) * gru_1_fwd_t0_h_0 + (-0.32187202572822571) * gru_1_fwd_t0_h_1 + (-0.57641243934631348) * gru_1_fwd_t0_h_2 + (0.16520436108112335) * gru_1_fwd_t0_h_3 + (0.42208504676818848) * gru_1_fwd_t0_h_4 + (-0.59827929735183716) * gru_1_fwd_t0_h_5 + (0.50468939542770386) * gru_1_fwd_t0_h_6 + (0.65825116634368896) * gru_1_fwd_t0_h_7 + (-0.27057138085365295) * gru_1_fwd_t0_h_8 + (0.78022670745849609) * gru_1_fwd_t0_h_9 + (1.1752244234085083) * gru_1_fwd_t0_h_10 + (1.4211736917495728) * gru_1_fwd_t0_h_11 + (-1.9868612289428711) * gru_1_fwd_t0_h_12 + (-1.7980130910873413) * gru_1_fwd_t0_h_13 + (-0.55381166934967041) * gru_1_fwd_t0_h_14 + (-1.0283242464065552) * gru_1_fwd_t0_h_15 + (0.22629804909229279) * gru_1_fwd_t0_h_16 + (-0.64106714725494385) * gru_1_fwd_t0_h_17 + (-0.82097464799880981) * gru_1_fwd_t0_h_18 + (-0.26980084180831909) * gru_1_fwd_t0_h_19 + (0.16065406799316406) * gru_1_fwd_t0_h_20 + (-0.01949925534427166) * gru_1_fwd_t0_h_21 + (0.57618439197540283) * gru_1_fwd_t0_h_22 + (-1.9955564737319946) * gru_1_fwd_t0_h_23 + (1.6437255144119263) * gru_1_fwd_t0_h_24 + (-0.58922475576400757) * gru_1_fwd_t0_h_25 + (0.45950746536254883) * gru_1_fwd_t0_h_26 + (0.43752372264862061) * gru_1_fwd_t0_h_27 + (-0.22521600127220154) * gru_1_fwd_t0_h_28 + (-0.53467386960983276) * gru_1_fwd_t0_h_29 + (-1.2152405977249146) * gru_1_fwd_t0_h_30 + (-0.88326185941696167) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((-0.17312385141849518) + (0.14970517158508301) * gru_0_out_t1_0 + (-0.38636276125907898) * gru_0_out_t1_1 + (0.56152725219726562) * gru_0_out_t1_2 + (-0.22224454581737518) * gru_0_out_t1_3 + (-0.24877025187015533) * gru_0_out_t1_4 + (0.0087913032621145248) * gru_0_out_t1_5 + (-1.0320265293121338) * gru_0_out_t1_6 + (0.35578665137290955) * gru_0_out_t1_7 + (0.50566589832305908) * gru_0_out_t1_8 + (0.40748491883277893) * gru_0_out_t1_9 + (-0.26413393020629883) * gru_0_out_t1_10 + (0.77450782060623169) * gru_0_out_t1_11 + (-0.015219733119010925) * gru_0_out_t1_12 + (0.32364383339881897) * gru_0_out_t1_13 + (-0.17424628138542175) * gru_0_out_t1_14 + (0.23067599534988403) * gru_0_out_t1_15 + (-0.23119036853313446) * gru_0_out_t1_16 + (0.076736398041248322) * gru_0_out_t1_17 + (-0.41830915212631226) * gru_0_out_t1_18 + (-0.053435388952493668) * gru_0_out_t1_19 + (-0.38996493816375732) * gru_0_out_t1_20 + (-0.66914260387420654) * gru_0_out_t1_21 + (0.30278286337852478) * gru_0_out_t1_22 + (-0.4447612464427948) * gru_0_out_t1_23 + (-1.1095203161239624) * gru_0_out_t1_24 + (0.42436224222183228) * gru_0_out_t1_25 + (0.034619506448507309) * gru_0_out_t1_26 + (0.19181223213672638) * gru_0_out_t1_27 + (-0.74360889196395874) * gru_0_out_t1_28 + (-0.28956553339958191) * gru_0_out_t1_29 + (-0.41535887122154236) * gru_0_out_t1_30 + (-1.1370761394500732) * gru_0_out_t1_31 + (0.61764043569564819) * gru_0_out_t1_32 + (0.67983359098434448) * gru_0_out_t1_33 + (0.19368462264537811) * gru_0_out_t1_34 + (-0.41565233469009399) * gru_0_out_t1_35 + (-0.093325160443782806) * gru_0_out_t1_36 + (0.38772040605545044) * gru_0_out_t1_37 + (-0.25220435857772827) * gru_0_out_t1_38 + (-0.20623686909675598) * gru_0_out_t1_39 + (-1.2610181570053101) * gru_0_out_t1_40 + (-0.65647000074386597) * gru_0_out_t1_41 + (0.040898140519857407) * gru_0_out_t1_42 + (-0.046225473284721375) * gru_0_out_t1_43 + (-0.44436731934547424) * gru_0_out_t1_44 + (0.56600433588027954) * gru_0_out_t1_45 + (-0.36236506700515747) * gru_0_out_t1_46 + (0.38397184014320374) * gru_0_out_t1_47 + (-0.26508453488349915) * gru_0_out_t1_48 + (-0.0040701050311326981) * gru_0_out_t1_49 + (0.25089821219444275) * gru_0_out_t1_50 + (0.70271188020706177) * gru_0_out_t1_51 + (-0.2321012020111084) * gru_0_out_t1_52 + (-0.019074326381087303) * gru_0_out_t1_53 + (-0.17519956827163696) * gru_0_out_t1_54 + (0.44246190786361694) * gru_0_out_t1_55 + (-0.42229366302490234) * gru_0_out_t1_56 + (-0.016487764194607735) * gru_0_out_t1_57 + (-0.5290372371673584) * gru_0_out_t1_58 + (-0.36430618166923523) * gru_0_out_t1_59 + (0.52517753839492798) * gru_0_out_t1_60 + (0.55844056606292725) * gru_0_out_t1_61 + (1.1980520486831665) * gru_0_out_t1_62 + (0.66427648067474365) * gru_0_out_t1_63 + (0.10294567793607712) * gru_1_fwd_t0_h_0 + (-0.27567645907402039) * gru_1_fwd_t0_h_1 + (0.24168230593204498) * gru_1_fwd_t0_h_2 + (-0.38725849986076355) * gru_1_fwd_t0_h_3 + (-0.064500465989112854) * gru_1_fwd_t0_h_4 + (-0.00063728727400302887) * gru_1_fwd_t0_h_5 + (1.3210464715957642) * gru_1_fwd_t0_h_6 + (-0.61923027038574219) * gru_1_fwd_t0_h_7 + (0.13474206626415253) * gru_1_fwd_t0_h_8 + (0.083223365247249603) * gru_1_fwd_t0_h_9 + (0.1716928631067276) * gru_1_fwd_t0_h_10 + (0.60996562242507935) * gru_1_fwd_t0_h_11 + (0.38387036323547363) * gru_1_fwd_t0_h_12 + (-0.31448632478713989) * gru_1_fwd_t0_h_13 + (0.075321055948734283) * gru_1_fwd_t0_h_14 + (0.090761251747608185) * gru_1_fwd_t0_h_15 + (-0.70088052749633789) * gru_1_fwd_t0_h_16 + (0.029526742175221443) * gru_1_fwd_t0_h_17 + (0.31767386198043823) * gru_1_fwd_t0_h_18 + (-0.22582297027111053) * gru_1_fwd_t0_h_19 + (0.029199108481407166) * gru_1_fwd_t0_h_20 + (-0.021042803302407265) * gru_1_fwd_t0_h_21 + (-0.30595192313194275) * gru_1_fwd_t0_h_22 + (0.3468906581401825) * gru_1_fwd_t0_h_23 + (0.25035470724105835) * gru_1_fwd_t0_h_24 + (0.48981243371963501) * gru_1_fwd_t0_h_25 + (-0.4514734148979187) * gru_1_fwd_t0_h_26 + (-0.84741389751434326) * gru_1_fwd_t0_h_27 + (-0.22727245092391968) * gru_1_fwd_t0_h_28 + (0.21625961363315582) * gru_1_fwd_t0_h_29 + (-0.20036995410919189) * gru_1_fwd_t0_h_30 + (0.12982822954654694) * gru_1_fwd_t0_h_31);
    gate_n = tanh((0.14517863094806671) + (-0.3137567937374115) * gru_0_out_t1_0 + (-0.13946141302585602) * gru_0_out_t1_1 + (-0.47565659880638123) * gru_0_out_t1_2 + (-0.34183803200721741) * gru_0_out_t1_3 + (0.21821098029613495) * gru_0_out_t1_4 + (-0.015212906524538994) * gru_0_out_t1_5 + (0.3494468629360199) * gru_0_out_t1_6 + (1.1272504329681396) * gru_0_out_t1_7 + (-0.35477888584136963) * gru_0_out_t1_8 + (-0.49726229906082153) * gru_0_out_t1_9 + (0.44370880722999573) * gru_0_out_t1_10 + (-0.19282530248165131) * gru_0_out_t1_11 + (0.17688289284706116) * gru_0_out_t1_12 + (-0.01379067450761795) * gru_0_out_t1_13 + (0.025039201602339745) * gru_0_out_t1_14 + (-0.14378471672534943) * gru_0_out_t1_15 + (-0.26954445242881775) * gru_0_out_t1_16 + (-0.21467207372188568) * gru_0_out_t1_17 + (-0.026149852201342583) * gru_0_out_t1_18 + (0.31923958659172058) * gru_0_out_t1_19 + (-0.37810808420181274) * gru_0_out_t1_20 + (-0.52649116516113281) * gru_0_out_t1_21 + (-0.43426588177680969) * gru_0_out_t1_22 + (0.17634622752666473) * gru_0_out_t1_23 + (0.55884265899658203) * gru_0_out_t1_24 + (0.33705848455429077) * gru_0_out_t1_25 + (0.012912916019558907) * gru_0_out_t1_26 + (0.20079140365123749) * gru_0_out_t1_27 + (-0.081835731863975525) * gru_0_out_t1_28 + (-0.41591396927833557) * gru_0_out_t1_29 + (0.54674732685089111) * gru_0_out_t1_30 + (-0.83932298421859741) * gru_0_out_t1_31 + (0.83749878406524658) * gru_0_out_t1_32 + (-0.11164047569036484) * gru_0_out_t1_33 + (0.13896012306213379) * gru_0_out_t1_34 + (-0.32776570320129395) * gru_0_out_t1_35 + (0.031428039073944092) * gru_0_out_t1_36 + (0.17911738157272339) * gru_0_out_t1_37 + (0.20719631016254425) * gru_0_out_t1_38 + (-0.2341323047876358) * gru_0_out_t1_39 + (-1.0062003135681152) * gru_0_out_t1_40 + (0.20318098366260529) * gru_0_out_t1_41 + (-0.072444707155227661) * gru_0_out_t1_42 + (0.074775561690330505) * gru_0_out_t1_43 + (0.23928366601467133) * gru_0_out_t1_44 + (-0.29708567261695862) * gru_0_out_t1_45 + (-0.098189614713191986) * gru_0_out_t1_46 + (-0.90723490715026855) * gru_0_out_t1_47 + (-0.69157421588897705) * gru_0_out_t1_48 + (0.56777030229568481) * gru_0_out_t1_49 + (0.42417523264884949) * gru_0_out_t1_50 + (-0.1543581634759903) * gru_0_out_t1_51 + (-0.14930815994739532) * gru_0_out_t1_52 + (0.13046346604824066) * gru_0_out_t1_53 + (0.044927783310413361) * gru_0_out_t1_54 + (-0.083579011261463165) * gru_0_out_t1_55 + (-0.025028487667441368) * gru_0_out_t1_56 + (0.37587285041809082) * gru_0_out_t1_57 + (0.37373507022857666) * gru_0_out_t1_58 + (0.12707950174808502) * gru_0_out_t1_59 + (-0.53156471252441406) * gru_0_out_t1_60 + (-0.059414796531200409) * gru_0_out_t1_61 + (0.19793474674224854) * gru_0_out_t1_62 + (-0.11455708742141724) * gru_0_out_t1_63 + gate_r * ((-0.18165589869022369) + (0.25941604375839233) * gru_1_fwd_t0_h_0 + (0.09543851763010025) * gru_1_fwd_t0_h_1 + (-0.32985812425613403) * gru_1_fwd_t0_h_2 + (-1.0468642711639404) * gru_1_fwd_t0_h_3 + (0.30117380619049072) * gru_1_fwd_t0_h_4 + (0.42603185772895813) * gru_1_fwd_t0_h_5 + (0.47205516695976257) * gru_1_fwd_t0_h_6 + (-1.3281594514846802) * gru_1_fwd_t0_h_7 + (0.43004047870635986) * gru_1_fwd_t0_h_8 + (-0.59216713905334473) * gru_1_fwd_t0_h_9 + (0.032118130475282669) * gru_1_fwd_t0_h_10 + (-0.26255717873573303) * gru_1_fwd_t0_h_11 + (0.28919783234596252) * gru_1_fwd_t0_h_12 + (0.58789092302322388) * gru_1_fwd_t0_h_13 + (-0.42499157786369324) * gru_1_fwd_t0_h_14 + (0.43090471625328064) * gru_1_fwd_t0_h_15 + (-0.23091495037078857) * gru_1_fwd_t0_h_16 + (-0.33794435858726501) * gru_1_fwd_t0_h_17 + (-1.2708356380462646) * gru_1_fwd_t0_h_18 + (0.27788400650024414) * gru_1_fwd_t0_h_19 + (-1.1976678371429443) * gru_1_fwd_t0_h_20 + (0.52629983425140381) * gru_1_fwd_t0_h_21 + (1.8896212577819824) * gru_1_fwd_t0_h_22 + (1.2512897253036499) * gru_1_fwd_t0_h_23 + (-0.42488965392112732) * gru_1_fwd_t0_h_24 + (0.16756696999073029) * gru_1_fwd_t0_h_25 + (-0.8294597864151001) * gru_1_fwd_t0_h_26 + (-1.5811538696289062) * gru_1_fwd_t0_h_27 + (0.85369092226028442) * gru_1_fwd_t0_h_28 + (-0.39516863226890564) * gru_1_fwd_t0_h_29 + (0.38887488842010498) * gru_1_fwd_t0_h_30 + (-0.39943104982376099) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_20 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_20;
    // h=21
    gate_r = sigmoid((-0.97572582960128784) + (-0.095662973821163177) * gru_0_out_t1_0 + (0.36371147632598877) * gru_0_out_t1_1 + (-0.3994843065738678) * gru_0_out_t1_2 + (0.24410293996334076) * gru_0_out_t1_3 + (-0.25856077671051025) * gru_0_out_t1_4 + (-0.85858243703842163) * gru_0_out_t1_5 + (0.47278743982315063) * gru_0_out_t1_6 + (-0.81376951932907104) * gru_0_out_t1_7 + (1.4860039949417114) * gru_0_out_t1_8 + (-0.86087960004806519) * gru_0_out_t1_9 + (1.1848442554473877) * gru_0_out_t1_10 + (-0.21700465679168701) * gru_0_out_t1_11 + (-0.34250277280807495) * gru_0_out_t1_12 + (-0.17672990262508392) * gru_0_out_t1_13 + (0.32325455546379089) * gru_0_out_t1_14 + (0.12373548746109009) * gru_0_out_t1_15 + (0.65120428800582886) * gru_0_out_t1_16 + (-0.02976401150226593) * gru_0_out_t1_17 + (0.69171345233917236) * gru_0_out_t1_18 + (1.3637052774429321) * gru_0_out_t1_19 + (-0.20415022969245911) * gru_0_out_t1_20 + (1.2128101587295532) * gru_0_out_t1_21 + (-0.34202760457992554) * gru_0_out_t1_22 + (1.3982101678848267) * gru_0_out_t1_23 + (2.2721931934356689) * gru_0_out_t1_24 + (0.18512848019599915) * gru_0_out_t1_25 + (0.56006723642349243) * gru_0_out_t1_26 + (-1.5779100656509399) * gru_0_out_t1_27 + (4.0672054290771484) * gru_0_out_t1_28 + (-0.3156503438949585) * gru_0_out_t1_29 + (-0.85022866725921631) * gru_0_out_t1_30 + (0.93937748670578003) * gru_0_out_t1_31 + (0.60415029525756836) * gru_0_out_t1_32 + (-0.15187413990497589) * gru_0_out_t1_33 + (1.1231993436813354) * gru_0_out_t1_34 + (-0.38286492228507996) * gru_0_out_t1_35 + (0.1260366290807724) * gru_0_out_t1_36 + (-0.2329193651676178) * gru_0_out_t1_37 + (-0.062392231076955795) * gru_0_out_t1_38 + (-3.9326751232147217) * gru_0_out_t1_39 + (0.35190856456756592) * gru_0_out_t1_40 + (0.040233485400676727) * gru_0_out_t1_41 + (-1.2722417116165161) * gru_0_out_t1_42 + (-0.35438230633735657) * gru_0_out_t1_43 + (0.0074670491740107536) * gru_0_out_t1_44 + (-0.52326440811157227) * gru_0_out_t1_45 + (-1.2080467939376831) * gru_0_out_t1_46 + (0.0097133731469511986) * gru_0_out_t1_47 + (0.59461390972137451) * gru_0_out_t1_48 + (-1.0890825986862183) * gru_0_out_t1_49 + (1.3913891315460205) * gru_0_out_t1_50 + (-0.36905133724212646) * gru_0_out_t1_51 + (0.098983816802501678) * gru_0_out_t1_52 + (0.21289213001728058) * gru_0_out_t1_53 + (1.2363343238830566) * gru_0_out_t1_54 + (1.503623366355896) * gru_0_out_t1_55 + (-1.8754136562347412) * gru_0_out_t1_56 + (-0.74406617879867554) * gru_0_out_t1_57 + (-0.087981894612312317) * gru_0_out_t1_58 + (-1.7327289581298828) * gru_0_out_t1_59 + (-0.017352107912302017) * gru_0_out_t1_60 + (-0.79450058937072754) * gru_0_out_t1_61 + (-0.089709028601646423) * gru_0_out_t1_62 + (-0.45183461904525757) * gru_0_out_t1_63 + (0.94540101289749146) * gru_1_fwd_t0_h_0 + (1.4062687158584595) * gru_1_fwd_t0_h_1 + (0.2991408109664917) * gru_1_fwd_t0_h_2 + (0.14129117131233215) * gru_1_fwd_t0_h_3 + (-1.3963797092437744) * gru_1_fwd_t0_h_4 + (-0.18941077589988708) * gru_1_fwd_t0_h_5 + (-0.58182764053344727) * gru_1_fwd_t0_h_6 + (0.15551835298538208) * gru_1_fwd_t0_h_7 + (0.03945733979344368) * gru_1_fwd_t0_h_8 + (0.58527541160583496) * gru_1_fwd_t0_h_9 + (0.45746269822120667) * gru_1_fwd_t0_h_10 + (-1.1680364608764648) * gru_1_fwd_t0_h_11 + (-0.27155080437660217) * gru_1_fwd_t0_h_12 + (-0.79760289192199707) * gru_1_fwd_t0_h_13 + (-0.4256344735622406) * gru_1_fwd_t0_h_14 + (-1.8206816911697388) * gru_1_fwd_t0_h_15 + (0.20938366651535034) * gru_1_fwd_t0_h_16 + (0.10282550752162933) * gru_1_fwd_t0_h_17 + (-0.62015575170516968) * gru_1_fwd_t0_h_18 + (0.91579151153564453) * gru_1_fwd_t0_h_19 + (-0.13205398619174957) * gru_1_fwd_t0_h_20 + (-2.8778417110443115) * gru_1_fwd_t0_h_21 + (1.0177972316741943) * gru_1_fwd_t0_h_22 + (-0.90135782957077026) * gru_1_fwd_t0_h_23 + (0.90904390811920166) * gru_1_fwd_t0_h_24 + (0.56791514158248901) * gru_1_fwd_t0_h_25 + (0.37335243821144104) * gru_1_fwd_t0_h_26 + (-1.4614157676696777) * gru_1_fwd_t0_h_27 + (-0.21565286815166473) * gru_1_fwd_t0_h_28 + (-0.26224705576896667) * gru_1_fwd_t0_h_29 + (-1.3020766973495483) * gru_1_fwd_t0_h_30 + (-0.57850831747055054) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((0.38889366388320923) + (0.25210043787956238) * gru_0_out_t1_0 + (-0.061205539852380753) * gru_0_out_t1_1 + (0.31897264719009399) * gru_0_out_t1_2 + (-0.27405631542205811) * gru_0_out_t1_3 + (-0.20512163639068604) * gru_0_out_t1_4 + (-0.24994079768657684) * gru_0_out_t1_5 + (0.23984207212924957) * gru_0_out_t1_6 + (0.5860639214515686) * gru_0_out_t1_7 + (-0.0267220139503479) * gru_0_out_t1_8 + (-0.071945317089557648) * gru_0_out_t1_9 + (-0.3343711793422699) * gru_0_out_t1_10 + (0.081579349935054779) * gru_0_out_t1_11 + (-0.3215559720993042) * gru_0_out_t1_12 + (0.40715038776397705) * gru_0_out_t1_13 + (0.57827103137969971) * gru_0_out_t1_14 + (-0.2624344527721405) * gru_0_out_t1_15 + (0.10224200040102005) * gru_0_out_t1_16 + (-0.087222129106521606) * gru_0_out_t1_17 + (-0.03484799712896347) * gru_0_out_t1_18 + (-0.58153557777404785) * gru_0_out_t1_19 + (0.13023479282855988) * gru_0_out_t1_20 + (0.22022579610347748) * gru_0_out_t1_21 + (-0.015459101647138596) * gru_0_out_t1_22 + (0.23503805696964264) * gru_0_out_t1_23 + (-0.46167305111885071) * gru_0_out_t1_24 + (-0.37427979707717896) * gru_0_out_t1_25 + (-0.093848459422588348) * gru_0_out_t1_26 + (1.5073754787445068) * gru_0_out_t1_27 + (2.5815598964691162) * gru_0_out_t1_28 + (-0.46528550982475281) * gru_0_out_t1_29 + (0.55191642045974731) * gru_0_out_t1_30 + (-0.60217362642288208) * gru_0_out_t1_31 + (0.31667441129684448) * gru_0_out_t1_32 + (0.17841628193855286) * gru_0_out_t1_33 + (-0.35002243518829346) * gru_0_out_t1_34 + (-0.053544670343399048) * gru_0_out_t1_35 + (-0.048704363405704498) * gru_0_out_t1_36 + (-0.10971169173717499) * gru_0_out_t1_37 + (-0.51504451036453247) * gru_0_out_t1_38 + (0.21998918056488037) * gru_0_out_t1_39 + (-2.3165395259857178) * gru_0_out_t1_40 + (0.55651754140853882) * gru_0_out_t1_41 + (-0.11226580291986465) * gru_0_out_t1_42 + (0.045597050338983536) * gru_0_out_t1_43 + (-0.057641245424747467) * gru_0_out_t1_44 + (-0.11208820343017578) * gru_0_out_t1_45 + (0.078309565782546997) * gru_0_out_t1_46 + (0.31334125995635986) * gru_0_out_t1_47 + (0.939400315284729) * gru_0_out_t1_48 + (-1.0069636106491089) * gru_0_out_t1_49 + (-0.12932273745536804) * gru_0_out_t1_50 + (0.017252612859010696) * gru_0_out_t1_51 + (0.26695558428764343) * gru_0_out_t1_52 + (0.37706893682479858) * gru_0_out_t1_53 + (-0.054132770746946335) * gru_0_out_t1_54 + (1.1879684925079346) * gru_0_out_t1_55 + (-0.50723469257354736) * gru_0_out_t1_56 + (0.044946156442165375) * gru_0_out_t1_57 + (-0.36188656091690063) * gru_0_out_t1_58 + (-0.096934519708156586) * gru_0_out_t1_59 + (0.26043671369552612) * gru_0_out_t1_60 + (-0.54119807481765747) * gru_0_out_t1_61 + (-0.49144372344017029) * gru_0_out_t1_62 + (0.11413858085870743) * gru_0_out_t1_63 + (0.001500828773714602) * gru_1_fwd_t0_h_0 + (-0.61324876546859741) * gru_1_fwd_t0_h_1 + (-0.57265204191207886) * gru_1_fwd_t0_h_2 + (-0.47856146097183228) * gru_1_fwd_t0_h_3 + (0.33077239990234375) * gru_1_fwd_t0_h_4 + (0.33221468329429626) * gru_1_fwd_t0_h_5 + (0.72083097696304321) * gru_1_fwd_t0_h_6 + (-0.4478583037853241) * gru_1_fwd_t0_h_7 + (-0.37333717942237854) * gru_1_fwd_t0_h_8 + (-0.020392835140228271) * gru_1_fwd_t0_h_9 + (-0.35804826021194458) * gru_1_fwd_t0_h_10 + (0.070721171796321869) * gru_1_fwd_t0_h_11 + (0.16184750199317932) * gru_1_fwd_t0_h_12 + (-0.05844588577747345) * gru_1_fwd_t0_h_13 + (-0.39776349067687988) * gru_1_fwd_t0_h_14 + (0.033588282763957977) * gru_1_fwd_t0_h_15 + (-0.43139004707336426) * gru_1_fwd_t0_h_16 + (-0.010245521552860737) * gru_1_fwd_t0_h_17 + (0.5273972749710083) * gru_1_fwd_t0_h_18 + (0.19962255656719208) * gru_1_fwd_t0_h_19 + (-0.33443549275398254) * gru_1_fwd_t0_h_20 + (-1.2251861095428467) * gru_1_fwd_t0_h_21 + (-0.76087421178817749) * gru_1_fwd_t0_h_22 + (-1.5698533058166504) * gru_1_fwd_t0_h_23 + (-0.4871990978717804) * gru_1_fwd_t0_h_24 + (-0.23817773163318634) * gru_1_fwd_t0_h_25 + (-0.39214852452278137) * gru_1_fwd_t0_h_26 + (-0.073740839958190918) * gru_1_fwd_t0_h_27 + (-0.84004074335098267) * gru_1_fwd_t0_h_28 + (-0.53973430395126343) * gru_1_fwd_t0_h_29 + (-0.58572214841842651) * gru_1_fwd_t0_h_30 + (0.40000990033149719) * gru_1_fwd_t0_h_31);
    gate_n = tanh((-0.045062098652124405) + (-0.30754965543746948) * gru_0_out_t1_0 + (-0.12149661779403687) * gru_0_out_t1_1 + (0.19865764677524567) * gru_0_out_t1_2 + (0.32590010762214661) * gru_0_out_t1_3 + (0.79506593942642212) * gru_0_out_t1_4 + (0.41803479194641113) * gru_0_out_t1_5 + (-0.65782171487808228) * gru_0_out_t1_6 + (0.36040440201759338) * gru_0_out_t1_7 + (-0.3558921217918396) * gru_0_out_t1_8 + (2.2671072483062744) * gru_0_out_t1_9 + (-0.16764411330223083) * gru_0_out_t1_10 + (-0.38314792513847351) * gru_0_out_t1_11 + (0.32389107346534729) * gru_0_out_t1_12 + (-0.065801337361335754) * gru_0_out_t1_13 + (0.20528718829154968) * gru_0_out_t1_14 + (-0.042872603982686996) * gru_0_out_t1_15 + (-0.28424081206321716) * gru_0_out_t1_16 + (0.083119519054889679) * gru_0_out_t1_17 + (0.068105518817901611) * gru_0_out_t1_18 + (-0.53487563133239746) * gru_0_out_t1_19 + (0.20002442598342896) * gru_0_out_t1_20 + (0.3039085865020752) * gru_0_out_t1_21 + (0.28855222463607788) * gru_0_out_t1_22 + (-0.350516676902771) * gru_0_out_t1_23 + (-0.84799104928970337) * gru_0_out_t1_24 + (0.37663167715072632) * gru_0_out_t1_25 + (0.086711093783378601) * gru_0_out_t1_26 + (0.31585264205932617) * gru_0_out_t1_27 + (0.40005302429199219) * gru_0_out_t1_28 + (-0.14315222203731537) * gru_0_out_t1_29 + (1.0299261808395386) * gru_0_out_t1_30 + (1.2327816486358643) * gru_0_out_t1_31 + (0.044263832271099091) * gru_0_out_t1_32 + (0.10651897639036179) * gru_0_out_t1_33 + (-0.49660834670066833) * gru_0_out_t1_34 + (-0.28042599558830261) * gru_0_out_t1_35 + (-0.0015521731693297625) * gru_0_out_t1_36 + (-0.57655757665634155) * gru_0_out_t1_37 + (0.038994506001472473) * gru_0_out_t1_38 + (0.55303603410720825) * gru_0_out_t1_39 + (-0.68304049968719482) * gru_0_out_t1_40 + (-0.0031028364319354296) * gru_0_out_t1_41 + (1.1204543113708496) * gru_0_out_t1_42 + (0.35415223240852356) * gru_0_out_t1_43 + (-0.11834608018398285) * gru_0_out_t1_44 + (0.15548183023929596) * gru_0_out_t1_45 + (1.4937592744827271) * gru_0_out_t1_46 + (0.11292536556720734) * gru_0_out_t1_47 + (-0.24004001915454865) * gru_0_out_t1_48 + (0.00033956512925215065) * gru_0_out_t1_49 + (0.049456294625997543) * gru_0_out_t1_50 + (-0.34014573693275452) * gru_0_out_t1_51 + (-0.42333364486694336) * gru_0_out_t1_52 + (-0.27375081181526184) * gru_0_out_t1_53 + (0.33247467875480652) * gru_0_out_t1_54 + (-0.6417158842086792) * gru_0_out_t1_55 + (0.26806887984275818) * gru_0_out_t1_56 + (0.22909116744995117) * gru_0_out_t1_57 + (0.15555201470851898) * gru_0_out_t1_58 + (0.46147942543029785) * gru_0_out_t1_59 + (-0.10734757035970688) * gru_0_out_t1_60 + (0.28036239743232727) * gru_0_out_t1_61 + (-0.9336693286895752) * gru_0_out_t1_62 + (-0.69945693016052246) * gru_0_out_t1_63 + gate_r * ((-0.1166287362575531) + (0.17004188895225525) * gru_1_fwd_t0_h_0 + (-0.59564369916915894) * gru_1_fwd_t0_h_1 + (0.38626798987388611) * gru_1_fwd_t0_h_2 + (0.93474912643432617) * gru_1_fwd_t0_h_3 + (-0.69351708889007568) * gru_1_fwd_t0_h_4 + (0.278034508228302) * gru_1_fwd_t0_h_5 + (0.025181323289871216) * gru_1_fwd_t0_h_6 + (0.045095451176166534) * gru_1_fwd_t0_h_7 + (0.37426236271858215) * gru_1_fwd_t0_h_8 + (-0.33249852061271667) * gru_1_fwd_t0_h_9 + (-1.027288556098938) * gru_1_fwd_t0_h_10 + (0.43408668041229248) * gru_1_fwd_t0_h_11 + (0.52003622055053711) * gru_1_fwd_t0_h_12 + (0.21184597909450531) * gru_1_fwd_t0_h_13 + (0.40146660804748535) * gru_1_fwd_t0_h_14 + (-0.32578077912330627) * gru_1_fwd_t0_h_15 + (0.25039857625961304) * gru_1_fwd_t0_h_16 + (0.2578827440738678) * gru_1_fwd_t0_h_17 + (0.69051986932754517) * gru_1_fwd_t0_h_18 + (0.14950898289680481) * gru_1_fwd_t0_h_19 + (0.052200499922037125) * gru_1_fwd_t0_h_20 + (-3.2490236759185791) * gru_1_fwd_t0_h_21 + (-1.2018259763717651) * gru_1_fwd_t0_h_22 + (1.1734403371810913) * gru_1_fwd_t0_h_23 + (1.0182715654373169) * gru_1_fwd_t0_h_24 + (-0.029313376173377037) * gru_1_fwd_t0_h_25 + (-0.62022459506988525) * gru_1_fwd_t0_h_26 + (-1.4238991737365723) * gru_1_fwd_t0_h_27 + (0.2260095626115799) * gru_1_fwd_t0_h_28 + (-0.26308217644691467) * gru_1_fwd_t0_h_29 + (0.64933031797409058) * gru_1_fwd_t0_h_30 + (0.26363199949264526) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_21 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_21;
    // h=22
    gate_r = sigmoid((-0.36216527223587036) + (-0.74367058277130127) * gru_0_out_t1_0 + (-0.58084571361541748) * gru_0_out_t1_1 + (-0.6232532262802124) * gru_0_out_t1_2 + (-1.1707674264907837) * gru_0_out_t1_3 + (-0.63045680522918701) * gru_0_out_t1_4 + (0.41954532265663147) * gru_0_out_t1_5 + (0.38541865348815918) * gru_0_out_t1_6 + (0.77768945693969727) * gru_0_out_t1_7 + (1.2543720006942749) * gru_0_out_t1_8 + (-0.11024962365627289) * gru_0_out_t1_9 + (0.23102028667926788) * gru_0_out_t1_10 + (-0.61773043870925903) * gru_0_out_t1_11 + (0.36243525147438049) * gru_0_out_t1_12 + (0.10716316103935242) * gru_0_out_t1_13 + (0.1254047304391861) * gru_0_out_t1_14 + (-0.31630715727806091) * gru_0_out_t1_15 + (0.049033720046281815) * gru_0_out_t1_16 + (-0.18428747355937958) * gru_0_out_t1_17 + (-0.47675997018814087) * gru_0_out_t1_18 + (0.94643503427505493) * gru_0_out_t1_19 + (-0.27927249670028687) * gru_0_out_t1_20 + (0.052847821265459061) * gru_0_out_t1_21 + (0.085995577275753021) * gru_0_out_t1_22 + (-1.212965726852417) * gru_0_out_t1_23 + (-0.10241477936506271) * gru_0_out_t1_24 + (0.85734277963638306) * gru_0_out_t1_25 + (0.050860211253166199) * gru_0_out_t1_26 + (-1.4734209775924683) * gru_0_out_t1_27 + (0.76380032300949097) * gru_0_out_t1_28 + (-0.28551328182220459) * gru_0_out_t1_29 + (-0.097737841308116913) * gru_0_out_t1_30 + (1.7435916662216187) * gru_0_out_t1_31 + (-1.6127448081970215) * gru_0_out_t1_32 + (-0.1934209018945694) * gru_0_out_t1_33 + (-0.29889637231826782) * gru_0_out_t1_34 + (0.13532045483589172) * gru_0_out_t1_35 + (0.08543434739112854) * gru_0_out_t1_36 + (-0.2295016348361969) * gru_0_out_t1_37 + (0.054275631904602051) * gru_0_out_t1_38 + (-1.1048449277877808) * gru_0_out_t1_39 + (3.9845700263977051) * gru_0_out_t1_40 + (0.02328520268201828) * gru_0_out_t1_41 + (0.2412593811750412) * gru_0_out_t1_42 + (0.37626537680625916) * gru_0_out_t1_43 + (0.39688685536384583) * gru_0_out_t1_44 + (0.17796045541763306) * gru_0_out_t1_45 + (-0.56956946849822998) * gru_0_out_t1_46 + (0.54836058616638184) * gru_0_out_t1_47 + (0.1468479186296463) * gru_0_out_t1_48 + (-0.21168020367622375) * gru_0_out_t1_49 + (0.86784827709197998) * gru_0_out_t1_50 + (-0.25251609086990356) * gru_0_out_t1_51 + (0.065298765897750854) * gru_0_out_t1_52 + (-0.22561034560203552) * gru_0_out_t1_53 + (-0.036766119301319122) * gru_0_out_t1_54 + (1.9545638561248779) * gru_0_out_t1_55 + (0.17516636848449707) * gru_0_out_t1_56 + (0.082415349781513214) * gru_0_out_t1_57 + (0.08480362594127655) * gru_0_out_t1_58 + (-0.067344009876251221) * gru_0_out_t1_59 + (-0.33597517013549805) * gru_0_out_t1_60 + (0.12900063395500183) * gru_0_out_t1_61 + (-2.0098869800567627) * gru_0_out_t1_62 + (-0.46273058652877808) * gru_0_out_t1_63 + (-0.22307366132736206) * gru_1_fwd_t0_h_0 + (-0.38731664419174194) * gru_1_fwd_t0_h_1 + (0.34636914730072021) * gru_1_fwd_t0_h_2 + (-0.9253736138343811) * gru_1_fwd_t0_h_3 + (-0.37741521000862122) * gru_1_fwd_t0_h_4 + (0.4415690004825592) * gru_1_fwd_t0_h_5 + (-1.0355105400085449) * gru_1_fwd_t0_h_6 + (-0.36815246939659119) * gru_1_fwd_t0_h_7 + (0.36872577667236328) * gru_1_fwd_t0_h_8 + (1.0609010457992554) * gru_1_fwd_t0_h_9 + (0.092126265168190002) * gru_1_fwd_t0_h_10 + (-0.58784961700439453) * gru_1_fwd_t0_h_11 + (-0.12356256693601608) * gru_1_fwd_t0_h_12 + (-1.9940776824951172) * gru_1_fwd_t0_h_13 + (-0.77973639965057373) * gru_1_fwd_t0_h_14 + (0.24378851056098938) * gru_1_fwd_t0_h_15 + (0.80571448802947998) * gru_1_fwd_t0_h_16 + (-1.5486207008361816) * gru_1_fwd_t0_h_17 + (-0.9952729344367981) * gru_1_fwd_t0_h_18 + (0.43098270893096924) * gru_1_fwd_t0_h_19 + (0.034936763346195221) * gru_1_fwd_t0_h_20 + (-1.999408483505249) * gru_1_fwd_t0_h_21 + (2.0075929164886475) * gru_1_fwd_t0_h_22 + (0.61375582218170166) * gru_1_fwd_t0_h_23 + (-0.10233233869075775) * gru_1_fwd_t0_h_24 + (0.86497467756271362) * gru_1_fwd_t0_h_25 + (-0.81204378604888916) * gru_1_fwd_t0_h_26 + (-1.1856577396392822) * gru_1_fwd_t0_h_27 + (0.83700573444366455) * gru_1_fwd_t0_h_28 + (0.28791341185569763) * gru_1_fwd_t0_h_29 + (0.098517134785652161) * gru_1_fwd_t0_h_30 + (0.51134318113327026) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((0.69649475812911987) + (-0.096710130572319031) * gru_0_out_t1_0 + (-0.38425016403198242) * gru_0_out_t1_1 + (1.0357855558395386) * gru_0_out_t1_2 + (0.53613054752349854) * gru_0_out_t1_3 + (-0.35610267519950867) * gru_0_out_t1_4 + (-0.42359805107116699) * gru_0_out_t1_5 + (0.055762294679880142) * gru_0_out_t1_6 + (0.12940327823162079) * gru_0_out_t1_7 + (-0.63902425765991211) * gru_0_out_t1_8 + (0.90616178512573242) * gru_0_out_t1_9 + (-0.31552636623382568) * gru_0_out_t1_10 + (0.073895767331123352) * gru_0_out_t1_11 + (-0.3393285870552063) * gru_0_out_t1_12 + (0.17125611007213593) * gru_0_out_t1_13 + (0.20609880983829498) * gru_0_out_t1_14 + (0.0023923639673739672) * gru_0_out_t1_15 + (-0.44156631827354431) * gru_0_out_t1_16 + (-0.76151663064956665) * gru_0_out_t1_17 + (0.32226154208183289) * gru_0_out_t1_18 + (0.029781077057123184) * gru_0_out_t1_19 + (0.35592487454414368) * gru_0_out_t1_20 + (-0.94051629304885864) * gru_0_out_t1_21 + (-0.0044304132461547852) * gru_0_out_t1_22 + (0.7417559027671814) * gru_0_out_t1_23 + (-0.13795426487922668) * gru_0_out_t1_24 + (-0.10423746705055237) * gru_0_out_t1_25 + (-0.55129021406173706) * gru_0_out_t1_26 + (0.70528841018676758) * gru_0_out_t1_27 + (0.43005052208900452) * gru_0_out_t1_28 + (-0.18941231071949005) * gru_0_out_t1_29 + (-0.43907079100608826) * gru_0_out_t1_30 + (0.51787149906158447) * gru_0_out_t1_31 + (0.67564558982849121) * gru_0_out_t1_32 + (0.3502642810344696) * gru_0_out_t1_33 + (0.19018258154392242) * gru_0_out_t1_34 + (0.017173301428556442) * gru_0_out_t1_35 + (-0.22175869345664978) * gru_0_out_t1_36 + (0.54629999399185181) * gru_0_out_t1_37 + (-0.43758967518806458) * gru_0_out_t1_38 + (0.99299043416976929) * gru_0_out_t1_39 + (0.82782375812530518) * gru_0_out_t1_40 + (0.2593027651309967) * gru_0_out_t1_41 + (-0.50448614358901978) * gru_0_out_t1_42 + (0.0039015770889818668) * gru_0_out_t1_43 + (0.31250867247581482) * gru_0_out_t1_44 + (-0.4797222912311554) * gru_0_out_t1_45 + (0.4963030219078064) * gru_0_out_t1_46 + (-0.43982282280921936) * gru_0_out_t1_47 + (0.013091869652271271) * gru_0_out_t1_48 + (0.27531039714813232) * gru_0_out_t1_49 + (0.013123373501002789) * gru_0_out_t1_50 + (0.41175121068954468) * gru_0_out_t1_51 + (-0.54692244529724121) * gru_0_out_t1_52 + (-0.23871973156929016) * gru_0_out_t1_53 + (0.055909749120473862) * gru_0_out_t1_54 + (1.3040136098861694) * gru_0_out_t1_55 + (-0.32727795839309692) * gru_0_out_t1_56 + (0.087840825319290161) * gru_0_out_t1_57 + (-0.43928411602973938) * gru_0_out_t1_58 + (-0.32226157188415527) * gru_0_out_t1_59 + (-0.064606055617332458) * gru_0_out_t1_60 + (0.14720143377780914) * gru_0_out_t1_61 + (0.046903591603040695) * gru_0_out_t1_62 + (0.39568430185317993) * gru_0_out_t1_63 + (-0.049899641424417496) * gru_1_fwd_t0_h_0 + (-0.072983458638191223) * gru_1_fwd_t0_h_1 + (0.1921866238117218) * gru_1_fwd_t0_h_2 + (-0.34291890263557434) * gru_1_fwd_t0_h_3 + (0.20353040099143982) * gru_1_fwd_t0_h_4 + (-0.5564882755279541) * gru_1_fwd_t0_h_5 + (-0.27699118852615356) * gru_1_fwd_t0_h_6 + (0.35071194171905518) * gru_1_fwd_t0_h_7 + (0.57345998287200928) * gru_1_fwd_t0_h_8 + (-0.38401314616203308) * gru_1_fwd_t0_h_9 + (-0.52446681261062622) * gru_1_fwd_t0_h_10 + (-0.32773593068122864) * gru_1_fwd_t0_h_11 + (-0.46593365073204041) * gru_1_fwd_t0_h_12 + (-0.041239842772483826) * gru_1_fwd_t0_h_13 + (-0.40622571110725403) * gru_1_fwd_t0_h_14 + (-0.40598160028457642) * gru_1_fwd_t0_h_15 + (0.25963205099105835) * gru_1_fwd_t0_h_16 + (0.34022533893585205) * gru_1_fwd_t0_h_17 + (0.15966564416885376) * gru_1_fwd_t0_h_18 + (-0.73818528652191162) * gru_1_fwd_t0_h_19 + (-0.10658656805753708) * gru_1_fwd_t0_h_20 + (-1.0331251621246338) * gru_1_fwd_t0_h_21 + (-0.41626673936843872) * gru_1_fwd_t0_h_22 + (0.37667614221572876) * gru_1_fwd_t0_h_23 + (-0.63568532466888428) * gru_1_fwd_t0_h_24 + (-0.17843867838382721) * gru_1_fwd_t0_h_25 + (0.2292180210351944) * gru_1_fwd_t0_h_26 + (0.68002796173095703) * gru_1_fwd_t0_h_27 + (0.24892494082450867) * gru_1_fwd_t0_h_28 + (0.0056247152388095856) * gru_1_fwd_t0_h_29 + (0.073280535638332367) * gru_1_fwd_t0_h_30 + (-0.16032294929027557) * gru_1_fwd_t0_h_31);
    gate_n = tanh((-0.00076227332465350628) + (-0.22902296483516693) * gru_0_out_t1_0 + (-0.27836352586746216) * gru_0_out_t1_1 + (0.55331069231033325) * gru_0_out_t1_2 + (-0.27809971570968628) * gru_0_out_t1_3 + (-0.10055508464574814) * gru_0_out_t1_4 + (-0.29612839221954346) * gru_0_out_t1_5 + (-1.3244835138320923) * gru_0_out_t1_6 + (-0.35527399182319641) * gru_0_out_t1_7 + (-1.011773943901062) * gru_0_out_t1_8 + (-0.8966529369354248) * gru_0_out_t1_9 + (-0.71478605270385742) * gru_0_out_t1_10 + (0.075667828321456909) * gru_0_out_t1_11 + (-0.42687380313873291) * gru_0_out_t1_12 + (0.329856276512146) * gru_0_out_t1_13 + (0.18555057048797607) * gru_0_out_t1_14 + (0.24662607908248901) * gru_0_out_t1_15 + (-0.54740059375762939) * gru_0_out_t1_16 + (-0.56040525436401367) * gru_0_out_t1_17 + (0.45544415712356567) * gru_0_out_t1_18 + (0.18060263991355896) * gru_0_out_t1_19 + (0.16692431271076202) * gru_0_out_t1_20 + (-0.20792624354362488) * gru_0_out_t1_21 + (-0.62150639295578003) * gru_0_out_t1_22 + (0.71988999843597412) * gru_0_out_t1_23 + (1.4547996520996094) * gru_0_out_t1_24 + (-0.86005204916000366) * gru_0_out_t1_25 + (0.052233044058084488) * gru_0_out_t1_26 + (0.25267946720123291) * gru_0_out_t1_27 + (-0.21297857165336609) * gru_0_out_t1_28 + (-0.020412670448422432) * gru_0_out_t1_29 + (-0.20165015757083893) * gru_0_out_t1_30 + (-0.35401824116706848) * gru_0_out_t1_31 + (0.48200708627700806) * gru_0_out_t1_32 + (-0.52854591608047485) * gru_0_out_t1_33 + (0.11353141069412231) * gru_0_out_t1_34 + (0.08713250607252121) * gru_0_out_t1_35 + (0.013717825524508953) * gru_0_out_t1_36 + (-0.27733644843101501) * gru_0_out_t1_37 + (0.44160148501396179) * gru_0_out_t1_38 + (-0.98695707321166992) * gru_0_out_t1_39 + (-0.046613708138465881) * gru_0_out_t1_40 + (0.092703647911548615) * gru_0_out_t1_41 + (-0.10834440588951111) * gru_0_out_t1_42 + (-0.136924147605896) * gru_0_out_t1_43 + (-0.69988292455673218) * gru_0_out_t1_44 + (0.078827075660228729) * gru_0_out_t1_45 + (-0.66135859489440918) * gru_0_out_t1_46 + (-0.39453041553497314) * gru_0_out_t1_47 + (0.52347451448440552) * gru_0_out_t1_48 + (-0.43252164125442505) * gru_0_out_t1_49 + (0.4888511598110199) * gru_0_out_t1_50 + (0.15185999870300293) * gru_0_out_t1_51 + (0.39450916647911072) * gru_0_out_t1_52 + (0.64434957504272461) * gru_0_out_t1_53 + (1.4324482679367065) * gru_0_out_t1_54 + (-1.4638803005218506) * gru_0_out_t1_55 + (-0.24163506925106049) * gru_0_out_t1_56 + (0.20733650028705597) * gru_0_out_t1_57 + (0.051474880427122116) * gru_0_out_t1_58 + (-0.01142557617276907) * gru_0_out_t1_59 + (0.91145944595336914) * gru_0_out_t1_60 + (0.5920223593711853) * gru_0_out_t1_61 + (1.0308057069778442) * gru_0_out_t1_62 + (-0.0062385816127061844) * gru_0_out_t1_63 + gate_r * ((-0.35027316212654114) + (-1.4193401336669922) * gru_1_fwd_t0_h_0 + (-0.46640273928642273) * gru_1_fwd_t0_h_1 + (0.078222706913948059) * gru_1_fwd_t0_h_2 + (-0.46454206109046936) * gru_1_fwd_t0_h_3 + (0.5499495267868042) * gru_1_fwd_t0_h_4 + (0.64025551080703735) * gru_1_fwd_t0_h_5 + (-1.1813725233078003) * gru_1_fwd_t0_h_6 + (-0.2666352391242981) * gru_1_fwd_t0_h_7 + (-0.22054161131381989) * gru_1_fwd_t0_h_8 + (0.7341960072517395) * gru_1_fwd_t0_h_9 + (-0.12650138139724731) * gru_1_fwd_t0_h_10 + (0.54635626077651978) * gru_1_fwd_t0_h_11 + (0.10001052916049957) * gru_1_fwd_t0_h_12 + (0.027572464197874069) * gru_1_fwd_t0_h_13 + (-1.1973471641540527) * gru_1_fwd_t0_h_14 + (-0.12909846007823944) * gru_1_fwd_t0_h_15 + (-0.012160650454461575) * gru_1_fwd_t0_h_16 + (0.60037904977798462) * gru_1_fwd_t0_h_17 + (-0.63369292020797729) * gru_1_fwd_t0_h_18 + (-0.80045747756958008) * gru_1_fwd_t0_h_19 + (0.2914033830165863) * gru_1_fwd_t0_h_20 + (0.16861151158809662) * gru_1_fwd_t0_h_21 + (-0.92693275213241577) * gru_1_fwd_t0_h_22 + (0.31253629922866821) * gru_1_fwd_t0_h_23 + (0.66055810451507568) * gru_1_fwd_t0_h_24 + (-0.10935722291469574) * gru_1_fwd_t0_h_25 + (-0.89687573909759521) * gru_1_fwd_t0_h_26 + (0.24638865888118744) * gru_1_fwd_t0_h_27 + (1.5749073028564453) * gru_1_fwd_t0_h_28 + (-0.57198172807693481) * gru_1_fwd_t0_h_29 + (-0.66686713695526123) * gru_1_fwd_t0_h_30 + (0.62695193290710449) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_22 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_22;
    // h=23
    gate_r = sigmoid((-0.37737375497817993) + (-0.79503357410430908) * gru_0_out_t1_0 + (0.068538494408130646) * gru_0_out_t1_1 + (0.20416095852851868) * gru_0_out_t1_2 + (-0.26548156142234802) * gru_0_out_t1_3 + (-0.70045971870422363) * gru_0_out_t1_4 + (0.77639025449752808) * gru_0_out_t1_5 + (0.13428539037704468) * gru_0_out_t1_6 + (0.2342989593744278) * gru_0_out_t1_7 + (-0.17787046730518341) * gru_0_out_t1_8 + (-0.47323006391525269) * gru_0_out_t1_9 + (-1.2252817153930664) * gru_0_out_t1_10 + (0.14471831917762756) * gru_0_out_t1_11 + (-0.19823853671550751) * gru_0_out_t1_12 + (-0.77416467666625977) * gru_0_out_t1_13 + (0.21379135549068451) * gru_0_out_t1_14 + (0.96714437007904053) * gru_0_out_t1_15 + (0.26352331042289734) * gru_0_out_t1_16 + (-0.22273299098014832) * gru_0_out_t1_17 + (-0.28035879135131836) * gru_0_out_t1_18 + (1.2696213722229004) * gru_0_out_t1_19 + (-0.0061995214782655239) * gru_0_out_t1_20 + (0.75150167942047119) * gru_0_out_t1_21 + (-0.034218180924654007) * gru_0_out_t1_22 + (0.52240067720413208) * gru_0_out_t1_23 + (-0.91591286659240723) * gru_0_out_t1_24 + (-1.176419734954834) * gru_0_out_t1_25 + (0.85171782970428467) * gru_0_out_t1_26 + (1.2482680082321167) * gru_0_out_t1_27 + (-0.11940784007310867) * gru_0_out_t1_28 + (-0.39296808838844299) * gru_0_out_t1_29 + (-0.18432345986366272) * gru_0_out_t1_30 + (0.76933199167251587) * gru_0_out_t1_31 + (-0.083392210304737091) * gru_0_out_t1_32 + (3.0442266464233398) * gru_0_out_t1_33 + (0.082386456429958344) * gru_0_out_t1_34 + (0.057291429489850998) * gru_0_out_t1_35 + (0.34498786926269531) * gru_0_out_t1_36 + (0.18979761004447937) * gru_0_out_t1_37 + (-2.6722040176391602) * gru_0_out_t1_38 + (0.89488029479980469) * gru_0_out_t1_39 + (-0.26715415716171265) * gru_0_out_t1_40 + (0.49999827146530151) * gru_0_out_t1_41 + (-0.57614648342132568) * gru_0_out_t1_42 + (0.28703239560127258) * gru_0_out_t1_43 + (0.060748394578695297) * gru_0_out_t1_44 + (-0.44752448797225952) * gru_0_out_t1_45 + (1.926239013671875) * gru_0_out_t1_46 + (-0.45975783467292786) * gru_0_out_t1_47 + (-0.48401820659637451) * gru_0_out_t1_48 + (0.97299635410308838) * gru_0_out_t1_49 + (-0.20765344798564911) * gru_0_out_t1_50 + (0.038622204214334488) * gru_0_out_t1_51 + (-3.3229861259460449) * gru_0_out_t1_52 + (0.41831788420677185) * gru_0_out_t1_53 + (0.21645171940326691) * gru_0_out_t1_54 + (-1.606818675994873) * gru_0_out_t1_55 + (-0.43441274762153625) * gru_0_out_t1_56 + (0.40787917375564575) * gru_0_out_t1_57 + (-0.37236413359642029) * gru_0_out_t1_58 + (-0.87850737571716309) * gru_0_out_t1_59 + (-0.54532349109649658) * gru_0_out_t1_60 + (-0.47573274374008179) * gru_0_out_t1_61 + (-0.069479554891586304) * gru_0_out_t1_62 + (1.3320877552032471) * gru_0_out_t1_63 + (-0.22558419406414032) * gru_1_fwd_t0_h_0 + (0.69185453653335571) * gru_1_fwd_t0_h_1 + (0.079887442290782928) * gru_1_fwd_t0_h_2 + (0.056931454688310623) * gru_1_fwd_t0_h_3 + (1.0718625783920288) * gru_1_fwd_t0_h_4 + (-0.20790429413318634) * gru_1_fwd_t0_h_5 + (0.21381668746471405) * gru_1_fwd_t0_h_6 + (0.19933830201625824) * gru_1_fwd_t0_h_7 + (-0.99202573299407959) * gru_1_fwd_t0_h_8 + (0.4927636981010437) * gru_1_fwd_t0_h_9 + (0.26296001672744751) * gru_1_fwd_t0_h_10 + (0.00016545277321711183) * gru_1_fwd_t0_h_11 + (-0.10316966474056244) * gru_1_fwd_t0_h_12 + (-0.1180804967880249) * gru_1_fwd_t0_h_13 + (1.4954652786254883) * gru_1_fwd_t0_h_14 + (0.31283754110336304) * gru_1_fwd_t0_h_15 + (0.85124635696411133) * gru_1_fwd_t0_h_16 + (0.043368775397539139) * gru_1_fwd_t0_h_17 + (1.4958066940307617) * gru_1_fwd_t0_h_18 + (-0.16446287930011749) * gru_1_fwd_t0_h_19 + (-0.05331028625369072) * gru_1_fwd_t0_h_20 + (0.29236409068107605) * gru_1_fwd_t0_h_21 + (0.80650436878204346) * gru_1_fwd_t0_h_22 + (0.38654071092605591) * gru_1_fwd_t0_h_23 + (1.4080207347869873) * gru_1_fwd_t0_h_24 + (0.15401634573936462) * gru_1_fwd_t0_h_25 + (-1.9987717866897583) * gru_1_fwd_t0_h_26 + (0.73389369249343872) * gru_1_fwd_t0_h_27 + (-0.10106315463781357) * gru_1_fwd_t0_h_28 + (1.9111822843551636) * gru_1_fwd_t0_h_29 + (-0.52861112356185913) * gru_1_fwd_t0_h_30 + (-0.91695904731750488) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((0.45544227957725525) + (-0.39899855852127075) * gru_0_out_t1_0 + (-0.48115536570549011) * gru_0_out_t1_1 + (0.90719711780548096) * gru_0_out_t1_2 + (0.27937033772468567) * gru_0_out_t1_3 + (0.14508701860904694) * gru_0_out_t1_4 + (0.26283589005470276) * gru_0_out_t1_5 + (-0.60269701480865479) * gru_0_out_t1_6 + (0.037988651543855667) * gru_0_out_t1_7 + (0.39225947856903076) * gru_0_out_t1_8 + (-0.28212738037109375) * gru_0_out_t1_9 + (0.35572734475135803) * gru_0_out_t1_10 + (-0.14603516459465027) * gru_0_out_t1_11 + (0.10748191922903061) * gru_0_out_t1_12 + (0.10269225388765335) * gru_0_out_t1_13 + (-0.36092615127563477) * gru_0_out_t1_14 + (-0.098021067678928375) * gru_0_out_t1_15 + (0.14099012315273285) * gru_0_out_t1_16 + (-0.17394551634788513) * gru_0_out_t1_17 + (-0.20500774681568146) * gru_0_out_t1_18 + (-0.31262242794036865) * gru_0_out_t1_19 + (0.33173412084579468) * gru_0_out_t1_20 + (-0.86121088266372681) * gru_0_out_t1_21 + (0.12776444852352142) * gru_0_out_t1_22 + (-0.49597838521003723) * gru_0_out_t1_23 + (-2.045438289642334) * gru_0_out_t1_24 + (-1.3676438331604004) * gru_0_out_t1_25 + (0.1861143559217453) * gru_0_out_t1_26 + (0.63738226890563965) * gru_0_out_t1_27 + (-0.68421661853790283) * gru_0_out_t1_28 + (-0.13278044760227203) * gru_0_out_t1_29 + (1.1435256004333496) * gru_0_out_t1_30 + (0.27671867609024048) * gru_0_out_t1_31 + (0.33940234780311584) * gru_0_out_t1_32 + (0.31611856818199158) * gru_0_out_t1_33 + (0.62803435325622559) * gru_0_out_t1_34 + (-0.41935685276985168) * gru_0_out_t1_35 + (0.11273257434368134) * gru_0_out_t1_36 + (-0.19025450944900513) * gru_0_out_t1_37 + (0.29654133319854736) * gru_0_out_t1_38 + (0.68210971355438232) * gru_0_out_t1_39 + (0.10617898404598236) * gru_0_out_t1_40 + (-0.23240180313587189) * gru_0_out_t1_41 + (0.17919887602329254) * gru_0_out_t1_42 + (-0.12985126674175262) * gru_0_out_t1_43 + (0.24262621998786926) * gru_0_out_t1_44 + (0.011309117078781128) * gru_0_out_t1_45 + (-0.39774432778358459) * gru_0_out_t1_46 + (-0.74535369873046875) * gru_0_out_t1_47 + (-0.065180718898773193) * gru_0_out_t1_48 + (-0.36947664618492126) * gru_0_out_t1_49 + (0.66724401712417603) * gru_0_out_t1_50 + (0.18067219853401184) * gru_0_out_t1_51 + (-0.44212111830711365) * gru_0_out_t1_52 + (0.044253259897232056) * gru_0_out_t1_53 + (-0.031454134732484818) * gru_0_out_t1_54 + (-0.12599039077758789) * gru_0_out_t1_55 + (0.36419066786766052) * gru_0_out_t1_56 + (-0.022863099351525307) * gru_0_out_t1_57 + (-0.48885723948478699) * gru_0_out_t1_58 + (-0.12259184569120407) * gru_0_out_t1_59 + (0.93494224548339844) * gru_0_out_t1_60 + (0.21224284172058105) * gru_0_out_t1_61 + (-0.1794813871383667) * gru_0_out_t1_62 + (-1.4116814136505127) * gru_0_out_t1_63 + (0.33855846524238586) * gru_1_fwd_t0_h_0 + (0.33340916037559509) * gru_1_fwd_t0_h_1 + (0.25691697001457214) * gru_1_fwd_t0_h_2 + (-0.088857978582382202) * gru_1_fwd_t0_h_3 + (-0.50371259450912476) * gru_1_fwd_t0_h_4 + (0.27996665239334106) * gru_1_fwd_t0_h_5 + (0.021345930173993111) * gru_1_fwd_t0_h_6 + (0.21396076679229736) * gru_1_fwd_t0_h_7 + (0.26442518830299377) * gru_1_fwd_t0_h_8 + (-0.45566862821578979) * gru_1_fwd_t0_h_9 + (-0.32641083002090454) * gru_1_fwd_t0_h_10 + (-0.35645607113838196) * gru_1_fwd_t0_h_11 + (0.1318848580121994) * gru_1_fwd_t0_h_12 + (-0.032120939344167709) * gru_1_fwd_t0_h_13 + (0.27831482887268066) * gru_1_fwd_t0_h_14 + (0.25805753469467163) * gru_1_fwd_t0_h_15 + (-0.043106522411108017) * gru_1_fwd_t0_h_16 + (-0.33511468768119812) * gru_1_fwd_t0_h_17 + (0.0158672034740448) * gru_1_fwd_t0_h_18 + (0.12873886525630951) * gru_1_fwd_t0_h_19 + (0.2443963885307312) * gru_1_fwd_t0_h_20 + (-0.27350205183029175) * gru_1_fwd_t0_h_21 + (-0.035453695803880692) * gru_1_fwd_t0_h_22 + (1.0342872142791748) * gru_1_fwd_t0_h_23 + (0.53374177217483521) * gru_1_fwd_t0_h_24 + (0.15318283438682556) * gru_1_fwd_t0_h_25 + (-0.15730394423007965) * gru_1_fwd_t0_h_26 + (0.095434121787548065) * gru_1_fwd_t0_h_27 + (-0.68715572357177734) * gru_1_fwd_t0_h_28 + (-0.083020403981208801) * gru_1_fwd_t0_h_29 + (-0.015377921983599663) * gru_1_fwd_t0_h_30 + (0.5191536545753479) * gru_1_fwd_t0_h_31);
    gate_n = tanh((-0.12708337604999542) + (-0.3775753378868103) * gru_0_out_t1_0 + (0.071000121533870697) * gru_0_out_t1_1 + (-0.17115998268127441) * gru_0_out_t1_2 + (-0.027634432539343834) * gru_0_out_t1_3 + (1.9491946697235107) * gru_0_out_t1_4 + (0.33124926686286926) * gru_0_out_t1_5 + (0.10106968134641647) * gru_0_out_t1_6 + (0.47922497987747192) * gru_0_out_t1_7 + (0.24611705541610718) * gru_0_out_t1_8 + (0.70045185089111328) * gru_0_out_t1_9 + (-0.75680041313171387) * gru_0_out_t1_10 + (0.41613885760307312) * gru_0_out_t1_11 + (-0.23472994565963745) * gru_0_out_t1_12 + (0.23338544368743896) * gru_0_out_t1_13 + (-0.13358327746391296) * gru_0_out_t1_14 + (0.33610391616821289) * gru_0_out_t1_15 + (-0.38329371809959412) * gru_0_out_t1_16 + (0.076051756739616394) * gru_0_out_t1_17 + (-0.1995847076177597) * gru_0_out_t1_18 + (-0.84019213914871216) * gru_0_out_t1_19 + (0.45215386152267456) * gru_0_out_t1_20 + (-0.19130167365074158) * gru_0_out_t1_21 + (0.22812074422836304) * gru_0_out_t1_22 + (0.20229272544384003) * gru_0_out_t1_23 + (-1.1922892332077026) * gru_0_out_t1_24 + (0.50652492046356201) * gru_0_out_t1_25 + (0.30163002014160156) * gru_0_out_t1_26 + (0.060001920908689499) * gru_0_out_t1_27 + (1.2401506900787354) * gru_0_out_t1_28 + (-0.15144385397434235) * gru_0_out_t1_29 + (-0.41856268048286438) * gru_0_out_t1_30 + (0.85530644655227661) * gru_0_out_t1_31 + (0.054100662469863892) * gru_0_out_t1_32 + (0.61326122283935547) * gru_0_out_t1_33 + (0.02422199584543705) * gru_0_out_t1_34 + (-0.26219069957733154) * gru_0_out_t1_35 + (-0.20073725283145905) * gru_0_out_t1_36 + (-0.045202244073152542) * gru_0_out_t1_37 + (0.077366091310977936) * gru_0_out_t1_38 + (0.12203789502382278) * gru_0_out_t1_39 + (-0.080158956348896027) * gru_0_out_t1_40 + (0.36362916231155396) * gru_0_out_t1_41 + (1.3904612064361572) * gru_0_out_t1_42 + (-0.49838230013847351) * gru_0_out_t1_43 + (-0.13585658371448517) * gru_0_out_t1_44 + (-0.31171712279319763) * gru_0_out_t1_45 + (0.1360081285238266) * gru_0_out_t1_46 + (-0.046464815735816956) * gru_0_out_t1_47 + (-0.35809218883514404) * gru_0_out_t1_48 + (0.10360386967658997) * gru_0_out_t1_49 + (0.18613453209400177) * gru_0_out_t1_50 + (0.84443825483322144) * gru_0_out_t1_51 + (-0.087376691401004791) * gru_0_out_t1_52 + (-0.1009569987654686) * gru_0_out_t1_53 + (0.40546774864196777) * gru_0_out_t1_54 + (0.31482881307601929) * gru_0_out_t1_55 + (0.47466245293617249) * gru_0_out_t1_56 + (0.99652975797653198) * gru_0_out_t1_57 + (2.2593605518341064) * gru_0_out_t1_58 + (0.45841583609580994) * gru_0_out_t1_59 + (-0.75548893213272095) * gru_0_out_t1_60 + (-0.034613218158483505) * gru_0_out_t1_61 + (-0.38672104477882385) * gru_0_out_t1_62 + (0.31936001777648926) * gru_0_out_t1_63 + gate_r * ((-0.18739134073257446) + (-0.9760444164276123) * gru_1_fwd_t0_h_0 + (0.06566377729177475) * gru_1_fwd_t0_h_1 + (-0.69682967662811279) * gru_1_fwd_t0_h_2 + (0.67474645376205444) * gru_1_fwd_t0_h_3 + (-0.12590846419334412) * gru_1_fwd_t0_h_4 + (2.7951047420501709) * gru_1_fwd_t0_h_5 + (-2.4594869613647461) * gru_1_fwd_t0_h_6 + (0.18574291467666626) * gru_1_fwd_t0_h_7 + (0.67748141288757324) * gru_1_fwd_t0_h_8 + (0.88543069362640381) * gru_1_fwd_t0_h_9 + (-0.28565296530723572) * gru_1_fwd_t0_h_10 + (0.37619304656982422) * gru_1_fwd_t0_h_11 + (1.3425275087356567) * gru_1_fwd_t0_h_12 + (0.19111302495002747) * gru_1_fwd_t0_h_13 + (0.8162960410118103) * gru_1_fwd_t0_h_14 + (1.1571131944656372) * gru_1_fwd_t0_h_15 + (0.73377668857574463) * gru_1_fwd_t0_h_16 + (-0.38701635599136353) * gru_1_fwd_t0_h_17 + (-0.68871545791625977) * gru_1_fwd_t0_h_18 + (0.86174392700195312) * gru_1_fwd_t0_h_19 + (-0.268048495054245) * gru_1_fwd_t0_h_20 + (0.80881321430206299) * gru_1_fwd_t0_h_21 + (-0.36324295401573181) * gru_1_fwd_t0_h_22 + (-1.3227510452270508) * gru_1_fwd_t0_h_23 + (1.5481479167938232) * gru_1_fwd_t0_h_24 + (1.3994145393371582) * gru_1_fwd_t0_h_25 + (1.2413047552108765) * gru_1_fwd_t0_h_26 + (-0.13214625418186188) * gru_1_fwd_t0_h_27 + (1.0640256404876709) * gru_1_fwd_t0_h_28 + (-0.093985691666603088) * gru_1_fwd_t0_h_29 + (0.66725242137908936) * gru_1_fwd_t0_h_30 + (-1.7524372339248657) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_23 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_23;
    // h=24
    gate_r = sigmoid((-0.42758944630622864) + (0.12086772173643112) * gru_0_out_t1_0 + (0.62144660949707031) * gru_0_out_t1_1 + (-0.48935985565185547) * gru_0_out_t1_2 + (0.82100313901901245) * gru_0_out_t1_3 + (0.58317899703979492) * gru_0_out_t1_4 + (-0.037164997309446335) * gru_0_out_t1_5 + (0.83828717470169067) * gru_0_out_t1_6 + (3.6263875961303711) * gru_0_out_t1_7 + (-0.11508907377719879) * gru_0_out_t1_8 + (0.69054818153381348) * gru_0_out_t1_9 + (1.4990606307983398) * gru_0_out_t1_10 + (-0.38191047310829163) * gru_0_out_t1_11 + (-0.15011025965213776) * gru_0_out_t1_12 + (0.16466595232486725) * gru_0_out_t1_13 + (-1.1594454050064087) * gru_0_out_t1_14 + (-0.34800395369529724) * gru_0_out_t1_15 + (-0.20061704516410828) * gru_0_out_t1_16 + (0.65713697671890259) * gru_0_out_t1_17 + (0.16145654022693634) * gru_0_out_t1_18 + (-0.86239135265350342) * gru_0_out_t1_19 + (-0.95374882221221924) * gru_0_out_t1_20 + (-0.205863356590271) * gru_0_out_t1_21 + (0.11541922390460968) * gru_0_out_t1_22 + (-0.21241161227226257) * gru_0_out_t1_23 + (1.3760771751403809) * gru_0_out_t1_24 + (1.1482911109924316) * gru_0_out_t1_25 + (0.7347751259803772) * gru_0_out_t1_26 + (-0.70580005645751953) * gru_0_out_t1_27 + (-3.0640332698822021) * gru_0_out_t1_28 + (1.1274573802947998) * gru_0_out_t1_29 + (-0.19769212603569031) * gru_0_out_t1_30 + (-0.18449895083904266) * gru_0_out_t1_31 + (1.2661093473434448) * gru_0_out_t1_32 + (-0.95003730058670044) * gru_0_out_t1_33 + (-0.06093200296163559) * gru_0_out_t1_34 + (0.097939915955066681) * gru_0_out_t1_35 + (-0.079813390970230103) * gru_0_out_t1_36 + (-0.13495349884033203) * gru_0_out_t1_37 + (0.050990164279937744) * gru_0_out_t1_38 + (-0.88927257061004639) * gru_0_out_t1_39 + (0.65421175956726074) * gru_0_out_t1_40 + (-0.018331075087189674) * gru_0_out_t1_41 + (-3.0811080932617188) * gru_0_out_t1_42 + (0.051750306040048599) * gru_0_out_t1_43 + (-0.39471191167831421) * gru_0_out_t1_44 + (0.10638084262609482) * gru_0_out_t1_45 + (1.1174187660217285) * gru_0_out_t1_46 + (-0.31018084287643433) * gru_0_out_t1_47 + (0.13067001104354858) * gru_0_out_t1_48 + (0.36544689536094666) * gru_0_out_t1_49 + (0.70908272266387939) * gru_0_out_t1_50 + (-0.016749322414398193) * gru_0_out_t1_51 + (-0.31273907423019409) * gru_0_out_t1_52 + (-1.5906529426574707) * gru_0_out_t1_53 + (2.4757986068725586) * gru_0_out_t1_54 + (1.9600518941879272) * gru_0_out_t1_55 + (-1.0278855562210083) * gru_0_out_t1_56 + (-0.12055318802595139) * gru_0_out_t1_57 + (-0.076821371912956238) * gru_0_out_t1_58 + (1.0920866727828979) * gru_0_out_t1_59 + (0.069194577634334564) * gru_0_out_t1_60 + (0.040167413651943207) * gru_0_out_t1_61 + (0.3773486316204071) * gru_0_out_t1_62 + (-1.1114168167114258) * gru_0_out_t1_63 + (-0.24208344519138336) * gru_1_fwd_t0_h_0 + (-0.24073134362697601) * gru_1_fwd_t0_h_1 + (-0.1428060382604599) * gru_1_fwd_t0_h_2 + (0.0089311953634023666) * gru_1_fwd_t0_h_3 + (-0.23874388635158539) * gru_1_fwd_t0_h_4 + (-0.054213043302297592) * gru_1_fwd_t0_h_5 + (1.7490541934967041) * gru_1_fwd_t0_h_6 + (-0.73903536796569824) * gru_1_fwd_t0_h_7 + (0.48096740245819092) * gru_1_fwd_t0_h_8 + (-1.2369050979614258) * gru_1_fwd_t0_h_9 + (-0.5758967399597168) * gru_1_fwd_t0_h_10 + (0.70241433382034302) * gru_1_fwd_t0_h_11 + (-0.18149466812610626) * gru_1_fwd_t0_h_12 + (2.2021093368530273) * gru_1_fwd_t0_h_13 + (-0.47695502638816833) * gru_1_fwd_t0_h_14 + (0.93204718828201294) * gru_1_fwd_t0_h_15 + (0.59389299154281616) * gru_1_fwd_t0_h_16 + (0.38335880637168884) * gru_1_fwd_t0_h_17 + (1.0328997373580933) * gru_1_fwd_t0_h_18 + (-1.9945676326751709) * gru_1_fwd_t0_h_19 + (-0.52833348512649536) * gru_1_fwd_t0_h_20 + (1.1750813722610474) * gru_1_fwd_t0_h_21 + (-0.81881839036941528) * gru_1_fwd_t0_h_22 + (-2.2842061519622803) * gru_1_fwd_t0_h_23 + (0.012994259595870972) * gru_1_fwd_t0_h_24 + (-0.10590313374996185) * gru_1_fwd_t0_h_25 + (1.2527496814727783) * gru_1_fwd_t0_h_26 + (-0.7362746000289917) * gru_1_fwd_t0_h_27 + (-0.93378257751464844) * gru_1_fwd_t0_h_28 + (-0.86448389291763306) * gru_1_fwd_t0_h_29 + (0.98721224069595337) * gru_1_fwd_t0_h_30 + (-0.38127896189689636) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((1.1156911849975586) + (0.2067362517118454) * gru_0_out_t1_0 + (0.45901015400886536) * gru_0_out_t1_1 + (0.16873574256896973) * gru_0_out_t1_2 + (0.040558263659477234) * gru_0_out_t1_3 + (0.36925461888313293) * gru_0_out_t1_4 + (-0.75656312704086304) * gru_0_out_t1_5 + (-0.49349683523178101) * gru_0_out_t1_6 + (-1.7207624912261963) * gru_0_out_t1_7 + (0.040076028555631638) * gru_0_out_t1_8 + (1.6206469535827637) * gru_0_out_t1_9 + (0.099422045052051544) * gru_0_out_t1_10 + (0.28604069352149963) * gru_0_out_t1_11 + (0.13634529709815979) * gru_0_out_t1_12 + (-0.29863083362579346) * gru_0_out_t1_13 + (0.22858324646949768) * gru_0_out_t1_14 + (0.032321449369192123) * gru_0_out_t1_15 + (-0.2906852662563324) * gru_0_out_t1_16 + (-1.0008165836334229) * gru_0_out_t1_17 + (0.16583551466464996) * gru_0_out_t1_18 + (0.15338918566703796) * gru_0_out_t1_19 + (2.3819572925567627) * gru_0_out_t1_20 + (-0.16571304202079773) * gru_0_out_t1_21 + (-0.8238835334777832) * gru_0_out_t1_22 + (0.22420667111873627) * gru_0_out_t1_23 + (-1.5137735605239868) * gru_0_out_t1_24 + (-0.46699687838554382) * gru_0_out_t1_25 + (-4.1895208358764648) * gru_0_out_t1_26 + (-0.3666473925113678) * gru_0_out_t1_27 + (-0.12122910469770432) * gru_0_out_t1_28 + (0.71206539869308472) * gru_0_out_t1_29 + (0.86293983459472656) * gru_0_out_t1_30 + (0.56048786640167236) * gru_0_out_t1_31 + (1.6777205467224121) * gru_0_out_t1_32 + (0.1641516387462616) * gru_0_out_t1_33 + (-0.065599530935287476) * gru_0_out_t1_34 + (0.27819746732711792) * gru_0_out_t1_35 + (-0.12058231979608536) * gru_0_out_t1_36 + (0.10296791046857834) * gru_0_out_t1_37 + (-0.28723397850990295) * gru_0_out_t1_38 + (1.5552459955215454) * gru_0_out_t1_39 + (-2.9317526817321777) * gru_0_out_t1_40 + (-0.049384173005819321) * gru_0_out_t1_41 + (1.6772211790084839) * gru_0_out_t1_42 + (0.040334638208150864) * gru_0_out_t1_43 + (-0.15124237537384033) * gru_0_out_t1_44 + (0.017531076446175575) * gru_0_out_t1_45 + (0.63452231884002686) * gru_0_out_t1_46 + (-0.98695510625839233) * gru_0_out_t1_47 + (0.12054946273565292) * gru_0_out_t1_48 + (-0.17302136123180389) * gru_0_out_t1_49 + (-0.24665583670139313) * gru_0_out_t1_50 + (-0.11118730157613754) * gru_0_out_t1_51 + (0.018669627606868744) * gru_0_out_t1_52 + (0.33077138662338257) * gru_0_out_t1_53 + (-1.2292557954788208) * gru_0_out_t1_54 + (-0.030067063868045807) * gru_0_out_t1_55 + (-1.0358577966690063) * gru_0_out_t1_56 + (-0.23500505089759827) * gru_0_out_t1_57 + (0.62989252805709839) * gru_0_out_t1_58 + (0.2566676139831543) * gru_0_out_t1_59 + (0.19906796514987946) * gru_0_out_t1_60 + (0.24773694574832916) * gru_0_out_t1_61 + (-0.12312977015972137) * gru_0_out_t1_62 + (-0.43776637315750122) * gru_0_out_t1_63 + (0.48242917656898499) * gru_1_fwd_t0_h_0 + (-0.97838449478149414) * gru_1_fwd_t0_h_1 + (0.2489217072725296) * gru_1_fwd_t0_h_2 + (0.068997018039226532) * gru_1_fwd_t0_h_3 + (-0.16308574378490448) * gru_1_fwd_t0_h_4 + (1.4264696836471558) * gru_1_fwd_t0_h_5 + (-0.8929142951965332) * gru_1_fwd_t0_h_6 + (-0.28379344940185547) * gru_1_fwd_t0_h_7 + (-0.073374234139919281) * gru_1_fwd_t0_h_8 + (0.013847000896930695) * gru_1_fwd_t0_h_9 + (0.058372940868139267) * gru_1_fwd_t0_h_10 + (0.25810223817825317) * gru_1_fwd_t0_h_11 + (0.12700542807579041) * gru_1_fwd_t0_h_12 + (0.3059687614440918) * gru_1_fwd_t0_h_13 + (-0.37692174315452576) * gru_1_fwd_t0_h_14 + (0.63697117567062378) * gru_1_fwd_t0_h_15 + (-0.18778844177722931) * gru_1_fwd_t0_h_16 + (-0.81331616640090942) * gru_1_fwd_t0_h_17 + (0.45402747392654419) * gru_1_fwd_t0_h_18 + (-0.88660067319869995) * gru_1_fwd_t0_h_19 + (-0.052612617611885071) * gru_1_fwd_t0_h_20 + (0.14876019954681396) * gru_1_fwd_t0_h_21 + (-0.53237664699554443) * gru_1_fwd_t0_h_22 + (-1.1151003837585449) * gru_1_fwd_t0_h_23 + (-0.82767593860626221) * gru_1_fwd_t0_h_24 + (0.32392951846122742) * gru_1_fwd_t0_h_25 + (0.12181582301855087) * gru_1_fwd_t0_h_26 + (0.19431865215301514) * gru_1_fwd_t0_h_27 + (0.27386400103569031) * gru_1_fwd_t0_h_28 + (-0.17857563495635986) * gru_1_fwd_t0_h_29 + (1.4011279344558716) * gru_1_fwd_t0_h_30 + (0.28979033231735229) * gru_1_fwd_t0_h_31);
    gate_n = tanh((0.099766649305820465) + (0.79422277212142944) * gru_0_out_t1_0 + (-0.13146984577178955) * gru_0_out_t1_1 + (0.68063259124755859) * gru_0_out_t1_2 + (-1.4121799468994141) * gru_0_out_t1_3 + (-0.20353361964225769) * gru_0_out_t1_4 + (-1.9995404481887817) * gru_0_out_t1_5 + (0.99538254737854004) * gru_0_out_t1_6 + (-2.3008580207824707) * gru_0_out_t1_7 + (-0.27305147051811218) * gru_0_out_t1_8 + (0.53454345464706421) * gru_0_out_t1_9 + (-0.20906434953212738) * gru_0_out_t1_10 + (0.17557224631309509) * gru_0_out_t1_11 + (-0.0078884139657020569) * gru_0_out_t1_12 + (0.70538461208343506) * gru_0_out_t1_13 + (0.20952446758747101) * gru_0_out_t1_14 + (0.041410204023122787) * gru_0_out_t1_15 + (0.13891369104385376) * gru_0_out_t1_16 + (-0.73623198270797729) * gru_0_out_t1_17 + (-0.19460342824459076) * gru_0_out_t1_18 + (0.98889803886413574) * gru_0_out_t1_19 + (-1.9283545017242432) * gru_0_out_t1_20 + (-0.35630026459693909) * gru_0_out_t1_21 + (1.2524850368499756) * gru_0_out_t1_22 + (1.029994010925293) * gru_0_out_t1_23 + (-0.0016773607349023223) * gru_0_out_t1_24 + (0.1536717414855957) * gru_0_out_t1_25 + (-3.1089491844177246) * gru_0_out_t1_26 + (-0.093742832541465759) * gru_0_out_t1_27 + (1.5900143384933472) * gru_0_out_t1_28 + (-0.4670257568359375) * gru_0_out_t1_29 + (0.19406507909297943) * gru_0_out_t1_30 + (0.4946863055229187) * gru_0_out_t1_31 + (-0.068529583513736725) * gru_0_out_t1_32 + (-0.052060294896364212) * gru_0_out_t1_33 + (0.05117681622505188) * gru_0_out_t1_34 + (-0.020836209878325462) * gru_0_out_t1_35 + (0.0073959198780357838) * gru_0_out_t1_36 + (0.08229856938123703) * gru_0_out_t1_37 + (-0.35446077585220337) * gru_0_out_t1_38 + (-1.4802600145339966) * gru_0_out_t1_39 + (-0.086178183555603027) * gru_0_out_t1_40 + (0.044513918459415436) * gru_0_out_t1_41 + (-0.62879770994186401) * gru_0_out_t1_42 + (-0.059979565441608429) * gru_0_out_t1_43 + (-0.29184356331825256) * gru_0_out_t1_44 + (-0.010597847402095795) * gru_0_out_t1_45 + (-1.3601990938186646) * gru_0_out_t1_46 + (0.19431939721107483) * gru_0_out_t1_47 + (0.32661902904510498) * gru_0_out_t1_48 + (-0.1624201238155365) * gru_0_out_t1_49 + (-0.14355216920375824) * gru_0_out_t1_50 + (-0.69916337728500366) * gru_0_out_t1_51 + (0.22632761299610138) * gru_0_out_t1_52 + (0.030855134129524231) * gru_0_out_t1_53 + (-1.4554181098937988) * gru_0_out_t1_54 + (-0.23731909692287445) * gru_0_out_t1_55 + (-0.6211739182472229) * gru_0_out_t1_56 + (0.35931473970413208) * gru_0_out_t1_57 + (-0.13164091110229492) * gru_0_out_t1_58 + (1.1322357654571533) * gru_0_out_t1_59 + (0.24162067472934723) * gru_0_out_t1_60 + (0.027392243966460228) * gru_0_out_t1_61 + (0.27378550171852112) * gru_0_out_t1_62 + (0.28950351476669312) * gru_0_out_t1_63 + gate_r * ((0.67133527994155884) + (-0.54307109117507935) * gru_1_fwd_t0_h_0 + (-0.030634650960564613) * gru_1_fwd_t0_h_1 + (1.1986756324768066) * gru_1_fwd_t0_h_2 + (0.055342502892017365) * gru_1_fwd_t0_h_3 + (-0.15252111852169037) * gru_1_fwd_t0_h_4 + (-0.11533195525407791) * gru_1_fwd_t0_h_5 + (-0.47048330307006836) * gru_1_fwd_t0_h_6 + (-0.89376562833786011) * gru_1_fwd_t0_h_7 + (-0.19907191395759583) * gru_1_fwd_t0_h_8 + (-0.43490391969680786) * gru_1_fwd_t0_h_9 + (-0.74443268775939941) * gru_1_fwd_t0_h_10 + (-0.94426196813583374) * gru_1_fwd_t0_h_11 + (-0.27109059691429138) * gru_1_fwd_t0_h_12 + (0.2263442724943161) * gru_1_fwd_t0_h_13 + (-1.3278659582138062) * gru_1_fwd_t0_h_14 + (0.98372995853424072) * gru_1_fwd_t0_h_15 + (-0.20286515355110168) * gru_1_fwd_t0_h_16 + (-0.48449328541755676) * gru_1_fwd_t0_h_17 + (-0.39689072966575623) * gru_1_fwd_t0_h_18 + (1.1849886178970337) * gru_1_fwd_t0_h_19 + (-0.1632220447063446) * gru_1_fwd_t0_h_20 + (1.9962568283081055) * gru_1_fwd_t0_h_21 + (0.30892255902290344) * gru_1_fwd_t0_h_22 + (0.21853812038898468) * gru_1_fwd_t0_h_23 + (0.34960725903511047) * gru_1_fwd_t0_h_24 + (-0.52084469795227051) * gru_1_fwd_t0_h_25 + (0.021700959652662277) * gru_1_fwd_t0_h_26 + (1.0712031126022339) * gru_1_fwd_t0_h_27 + (-0.28299990296363831) * gru_1_fwd_t0_h_28 + (-0.68790632486343384) * gru_1_fwd_t0_h_29 + (1.8765798807144165) * gru_1_fwd_t0_h_30 + (0.62687420845031738) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_24 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_24;
    // h=25
    gate_r = sigmoid((0.14784069359302521) + (0.64793628454208374) * gru_0_out_t1_0 + (-0.34771654009819031) * gru_0_out_t1_1 + (-0.1077476367354393) * gru_0_out_t1_2 + (-1.3351753950119019) * gru_0_out_t1_3 + (0.54230111837387085) * gru_0_out_t1_4 + (-0.37961503863334656) * gru_0_out_t1_5 + (-1.4525712728500366) * gru_0_out_t1_6 + (-1.0458427667617798) * gru_0_out_t1_7 + (0.33517831563949585) * gru_0_out_t1_8 + (0.45465004444122314) * gru_0_out_t1_9 + (0.48269376158714294) * gru_0_out_t1_10 + (-0.84214550256729126) * gru_0_out_t1_11 + (-0.14486022293567657) * gru_0_out_t1_12 + (-0.55970525741577148) * gru_0_out_t1_13 + (0.34367987513542175) * gru_0_out_t1_14 + (-0.65948504209518433) * gru_0_out_t1_15 + (0.22284576296806335) * gru_0_out_t1_16 + (0.34964841604232788) * gru_0_out_t1_17 + (-0.2622896134853363) * gru_0_out_t1_18 + (1.9099991321563721) * gru_0_out_t1_19 + (0.80364990234375) * gru_0_out_t1_20 + (0.5130038857460022) * gru_0_out_t1_21 + (-0.54142594337463379) * gru_0_out_t1_22 + (-0.29513469338417053) * gru_0_out_t1_23 + (0.15972298383712769) * gru_0_out_t1_24 + (0.14560438692569733) * gru_0_out_t1_25 + (-0.15405340492725372) * gru_0_out_t1_26 + (0.047758512198925018) * gru_0_out_t1_27 + (1.252642035484314) * gru_0_out_t1_28 + (-0.39247065782546997) * gru_0_out_t1_29 + (-0.22103966772556305) * gru_0_out_t1_30 + (-0.40724647045135498) * gru_0_out_t1_31 + (-0.30491158366203308) * gru_0_out_t1_32 + (1.3470684289932251) * gru_0_out_t1_33 + (-2.0241944789886475) * gru_0_out_t1_34 + (0.13163977861404419) * gru_0_out_t1_35 + (-0.83819496631622314) * gru_0_out_t1_36 + (0.34586027264595032) * gru_0_out_t1_37 + (-1.1876521110534668) * gru_0_out_t1_38 + (0.99915981292724609) * gru_0_out_t1_39 + (-0.046838141977787018) * gru_0_out_t1_40 + (0.48856762051582336) * gru_0_out_t1_41 + (-2.0180153846740723) * gru_0_out_t1_42 + (-0.58891177177429199) * gru_0_out_t1_43 + (-0.23416215181350708) * gru_0_out_t1_44 + (-0.13047674298286438) * gru_0_out_t1_45 + (1.1867121458053589) * gru_0_out_t1_46 + (0.34221929311752319) * gru_0_out_t1_47 + (-0.52082628011703491) * gru_0_out_t1_48 + (0.34655129909515381) * gru_0_out_t1_49 + (-0.05729476734995842) * gru_0_out_t1_50 + (-1.3149265050888062) * gru_0_out_t1_51 + (-3.2103996276855469) * gru_0_out_t1_52 + (0.40847468376159668) * gru_0_out_t1_53 + (-0.37452656030654907) * gru_0_out_t1_54 + (-0.097612030804157257) * gru_0_out_t1_55 + (-0.5286109447479248) * gru_0_out_t1_56 + (0.24556656181812286) * gru_0_out_t1_57 + (-0.25311177968978882) * gru_0_out_t1_58 + (-0.42517393827438354) * gru_0_out_t1_59 + (-0.68144220113754272) * gru_0_out_t1_60 + (0.074595451354980469) * gru_0_out_t1_61 + (-0.54633671045303345) * gru_0_out_t1_62 + (2.4225177764892578) * gru_0_out_t1_63 + (0.15641732513904572) * gru_1_fwd_t0_h_0 + (0.74148523807525635) * gru_1_fwd_t0_h_1 + (-0.48388603329658508) * gru_1_fwd_t0_h_2 + (0.13604530692100525) * gru_1_fwd_t0_h_3 + (-0.1152515709400177) * gru_1_fwd_t0_h_4 + (-0.10808464139699936) * gru_1_fwd_t0_h_5 + (1.2408928871154785) * gru_1_fwd_t0_h_6 + (-0.19285210967063904) * gru_1_fwd_t0_h_7 + (0.31102627515792847) * gru_1_fwd_t0_h_8 + (0.45243814587593079) * gru_1_fwd_t0_h_9 + (-0.17910075187683105) * gru_1_fwd_t0_h_10 + (0.19186586141586304) * gru_1_fwd_t0_h_11 + (-0.0399915911257267) * gru_1_fwd_t0_h_12 + (-1.7821557521820068) * gru_1_fwd_t0_h_13 + (0.46693545579910278) * gru_1_fwd_t0_h_14 + (-0.014894533902406693) * gru_1_fwd_t0_h_15 + (0.008108614943921566) * gru_1_fwd_t0_h_16 + (-0.0026562465354800224) * gru_1_fwd_t0_h_17 + (-0.10477922111749649) * gru_1_fwd_t0_h_18 + (-0.12384292483329773) * gru_1_fwd_t0_h_19 + (-0.10854751616716385) * gru_1_fwd_t0_h_20 + (-1.11553955078125) * gru_1_fwd_t0_h_21 + (-0.58235716819763184) * gru_1_fwd_t0_h_22 + (-0.62650507688522339) * gru_1_fwd_t0_h_23 + (-1.1862962245941162) * gru_1_fwd_t0_h_24 + (0.26390752196311951) * gru_1_fwd_t0_h_25 + (0.91641604900360107) * gru_1_fwd_t0_h_26 + (-0.07503923773765564) * gru_1_fwd_t0_h_27 + (-0.13762123882770538) * gru_1_fwd_t0_h_28 + (-0.015423152595758438) * gru_1_fwd_t0_h_29 + (-0.91263562440872192) * gru_1_fwd_t0_h_30 + (-1.0171694755554199) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((-0.038963977247476578) + (0.26227423548698425) * gru_0_out_t1_0 + (-0.044254723936319351) * gru_0_out_t1_1 + (0.14953374862670898) * gru_0_out_t1_2 + (-0.085310317575931549) * gru_0_out_t1_3 + (-0.12765650451183319) * gru_0_out_t1_4 + (0.0038044764660298824) * gru_0_out_t1_5 + (-0.89216727018356323) * gru_0_out_t1_6 + (-1.4744287729263306) * gru_0_out_t1_7 + (0.06135641410946846) * gru_0_out_t1_8 + (0.076689273118972778) * gru_0_out_t1_9 + (-0.21587233245372772) * gru_0_out_t1_10 + (0.1863962709903717) * gru_0_out_t1_11 + (0.14475254714488983) * gru_0_out_t1_12 + (-0.34739425778388977) * gru_0_out_t1_13 + (0.020500931888818741) * gru_0_out_t1_14 + (0.062400579452514648) * gru_0_out_t1_15 + (-0.016422979533672333) * gru_0_out_t1_16 + (0.15034559369087219) * gru_0_out_t1_17 + (-0.021572383120656013) * gru_0_out_t1_18 + (1.6864110231399536) * gru_0_out_t1_19 + (0.3316500186920166) * gru_0_out_t1_20 + (0.21687550842761993) * gru_0_out_t1_21 + (-0.12529541552066803) * gru_0_out_t1_22 + (0.13238830864429474) * gru_0_out_t1_23 + (-0.4468996524810791) * gru_0_out_t1_24 + (-0.24838323891162872) * gru_0_out_t1_25 + (-0.083773508667945862) * gru_0_out_t1_26 + (0.035819485783576965) * gru_0_out_t1_27 + (-0.46202012896537781) * gru_0_out_t1_28 + (-1.127859354019165) * gru_0_out_t1_29 + (0.080040901899337769) * gru_0_out_t1_30 + (0.632362961769104) * gru_0_out_t1_31 + (-0.13813994824886322) * gru_0_out_t1_32 + (0.073160521686077118) * gru_0_out_t1_33 + (0.1619332879781723) * gru_0_out_t1_34 + (-0.010452740825712681) * gru_0_out_t1_35 + (0.19558590650558472) * gru_0_out_t1_36 + (0.088207222521305084) * gru_0_out_t1_37 + (-1.0314953327178955) * gru_0_out_t1_38 + (-0.069221466779708862) * gru_0_out_t1_39 + (-0.14552101492881775) * gru_0_out_t1_40 + (-0.17307686805725098) * gru_0_out_t1_41 + (0.042232789099216461) * gru_0_out_t1_42 + (0.11225001513957977) * gru_0_out_t1_43 + (0.15610048174858093) * gru_0_out_t1_44 + (-0.014081462286412716) * gru_0_out_t1_45 + (0.2135934978723526) * gru_0_out_t1_46 + (-0.053089141845703125) * gru_0_out_t1_47 + (0.11143424361944199) * gru_0_out_t1_48 + (-0.29267230629920959) * gru_0_out_t1_49 + (0.26094776391983032) * gru_0_out_t1_50 + (-0.25470837950706482) * gru_0_out_t1_51 + (-0.91952008008956909) * gru_0_out_t1_52 + (0.20079958438873291) * gru_0_out_t1_53 + (-0.11304932832717896) * gru_0_out_t1_54 + (-0.61127817630767822) * gru_0_out_t1_55 + (-0.056505654007196426) * gru_0_out_t1_56 + (0.16422541439533234) * gru_0_out_t1_57 + (0.22805671393871307) * gru_0_out_t1_58 + (-0.18545420467853546) * gru_0_out_t1_59 + (-0.14823460578918457) * gru_0_out_t1_60 + (-0.33449450135231018) * gru_0_out_t1_61 + (0.53247404098510742) * gru_0_out_t1_62 + (-0.50986897945404053) * gru_0_out_t1_63 + (0.69462263584136963) * gru_1_fwd_t0_h_0 + (-0.1002110168337822) * gru_1_fwd_t0_h_1 + (0.35464364290237427) * gru_1_fwd_t0_h_2 + (-0.40514007210731506) * gru_1_fwd_t0_h_3 + (-0.025220884010195732) * gru_1_fwd_t0_h_4 + (-0.72757589817047119) * gru_1_fwd_t0_h_5 + (0.021767821162939072) * gru_1_fwd_t0_h_6 + (0.20600779354572296) * gru_1_fwd_t0_h_7 + (-0.52136105298995972) * gru_1_fwd_t0_h_8 + (-0.083963841199874878) * gru_1_fwd_t0_h_9 + (0.4351021945476532) * gru_1_fwd_t0_h_10 + (0.25151899456977844) * gru_1_fwd_t0_h_11 + (0.051527820527553558) * gru_1_fwd_t0_h_12 + (-0.14021706581115723) * gru_1_fwd_t0_h_13 + (0.10451799631118774) * gru_1_fwd_t0_h_14 + (-0.12368157505989075) * gru_1_fwd_t0_h_15 + (-0.48293519020080566) * gru_1_fwd_t0_h_16 + (0.23997761309146881) * gru_1_fwd_t0_h_17 + (0.31865918636322021) * gru_1_fwd_t0_h_18 + (0.058318644762039185) * gru_1_fwd_t0_h_19 + (-0.097787119448184967) * gru_1_fwd_t0_h_20 + (0.10991073399782181) * gru_1_fwd_t0_h_21 + (-0.2901337742805481) * gru_1_fwd_t0_h_22 + (0.047333300113677979) * gru_1_fwd_t0_h_23 + (0.32429832220077515) * gru_1_fwd_t0_h_24 + (0.13376836478710175) * gru_1_fwd_t0_h_25 + (-1.2719895839691162) * gru_1_fwd_t0_h_26 + (-0.22373615205287933) * gru_1_fwd_t0_h_27 + (0.26340678334236145) * gru_1_fwd_t0_h_28 + (0.030275162309408188) * gru_1_fwd_t0_h_29 + (-0.10419816523790359) * gru_1_fwd_t0_h_30 + (0.55240947008132935) * gru_1_fwd_t0_h_31);
    gate_n = tanh((0.24099402129650116) + (-0.081720493733882904) * gru_0_out_t1_0 + (-0.22350789606571198) * gru_0_out_t1_1 + (0.22498087584972382) * gru_0_out_t1_2 + (-1.0923663377761841) * gru_0_out_t1_3 + (0.0526115782558918) * gru_0_out_t1_4 + (-0.37810736894607544) * gru_0_out_t1_5 + (0.96148020029067993) * gru_0_out_t1_6 + (0.59036350250244141) * gru_0_out_t1_7 + (-0.24858054518699646) * gru_0_out_t1_8 + (-0.13005098700523376) * gru_0_out_t1_9 + (0.10471072793006897) * gru_0_out_t1_10 + (0.12695799767971039) * gru_0_out_t1_11 + (0.43793290853500366) * gru_0_out_t1_12 + (0.18344719707965851) * gru_0_out_t1_13 + (0.2254004031419754) * gru_0_out_t1_14 + (-0.41001760959625244) * gru_0_out_t1_15 + (-0.84588253498077393) * gru_0_out_t1_16 + (-0.19655579328536987) * gru_0_out_t1_17 + (0.018302859738469124) * gru_0_out_t1_18 + (0.054398465901613235) * gru_0_out_t1_19 + (-0.12775120139122009) * gru_0_out_t1_20 + (-1.0025448799133301) * gru_0_out_t1_21 + (0.1243298202753067) * gru_0_out_t1_22 + (0.38433283567428589) * gru_0_out_t1_23 + (-0.34269148111343384) * gru_0_out_t1_24 + (0.47426825761795044) * gru_0_out_t1_25 + (-0.12940236926078796) * gru_0_out_t1_26 + (-0.15284371376037598) * gru_0_out_t1_27 + (0.5323798656463623) * gru_0_out_t1_28 + (0.70586252212524414) * gru_0_out_t1_29 + (0.34467661380767822) * gru_0_out_t1_30 + (0.46733993291854858) * gru_0_out_t1_31 + (0.45396775007247925) * gru_0_out_t1_32 + (-0.88176864385604858) * gru_0_out_t1_33 + (-0.31487029790878296) * gru_0_out_t1_34 + (0.78852522373199463) * gru_0_out_t1_35 + (0.12848441302776337) * gru_0_out_t1_36 + (-0.16874648630619049) * gru_0_out_t1_37 + (0.11007984727621078) * gru_0_out_t1_38 + (-0.11136472225189209) * gru_0_out_t1_39 + (-0.20182853937149048) * gru_0_out_t1_40 + (-0.090640440583229065) * gru_0_out_t1_41 + (-0.21501393616199493) * gru_0_out_t1_42 + (0.22762294113636017) * gru_0_out_t1_43 + (0.06663484126329422) * gru_0_out_t1_44 + (-0.12869471311569214) * gru_0_out_t1_45 + (0.59350168704986572) * gru_0_out_t1_46 + (0.3770759105682373) * gru_0_out_t1_47 + (0.68285977840423584) * gru_0_out_t1_48 + (-0.3896510899066925) * gru_0_out_t1_49 + (-0.0016163914697244763) * gru_0_out_t1_50 + (-0.029232924804091454) * gru_0_out_t1_51 + (0.25509113073348999) * gru_0_out_t1_52 + (0.17764553427696228) * gru_0_out_t1_53 + (-0.01939515583217144) * gru_0_out_t1_54 + (-0.2801215648651123) * gru_0_out_t1_55 + (-0.12825670838356018) * gru_0_out_t1_56 + (-0.83580923080444336) * gru_0_out_t1_57 + (0.73483800888061523) * gru_0_out_t1_58 + (0.46928948163986206) * gru_0_out_t1_59 + (0.30807730555534363) * gru_0_out_t1_60 + (-0.22999167442321777) * gru_0_out_t1_61 + (0.42728477716445923) * gru_0_out_t1_62 + (-0.54261273145675659) * gru_0_out_t1_63 + gate_r * ((0.40620821714401245) + (-0.53987020254135132) * gru_1_fwd_t0_h_0 + (0.027536109089851379) * gru_1_fwd_t0_h_1 + (-0.30609163641929626) * gru_1_fwd_t0_h_2 + (-0.07976260781288147) * gru_1_fwd_t0_h_3 + (-0.17717054486274719) * gru_1_fwd_t0_h_4 + (0.047017008066177368) * gru_1_fwd_t0_h_5 + (-0.11404813826084137) * gru_1_fwd_t0_h_6 + (0.0010864792857319117) * gru_1_fwd_t0_h_7 + (0.26438748836517334) * gru_1_fwd_t0_h_8 + (-0.25429537892341614) * gru_1_fwd_t0_h_9 + (-0.1414773017168045) * gru_1_fwd_t0_h_10 + (0.011593489907681942) * gru_1_fwd_t0_h_11 + (0.099501855671405792) * gru_1_fwd_t0_h_12 + (0.044257987290620804) * gru_1_fwd_t0_h_13 + (0.59119158983230591) * gru_1_fwd_t0_h_14 + (-0.67416554689407349) * gru_1_fwd_t0_h_15 + (0.18975499272346497) * gru_1_fwd_t0_h_16 + (0.369637131690979) * gru_1_fwd_t0_h_17 + (0.056145794689655304) * gru_1_fwd_t0_h_18 + (0.45151400566101074) * gru_1_fwd_t0_h_19 + (0.1689552515745163) * gru_1_fwd_t0_h_20 + (0.42627620697021484) * gru_1_fwd_t0_h_21 + (-0.11651196330785751) * gru_1_fwd_t0_h_22 + (0.22095082700252533) * gru_1_fwd_t0_h_23 + (1.9643646478652954) * gru_1_fwd_t0_h_24 + (-0.060385908931493759) * gru_1_fwd_t0_h_25 + (0.24690881371498108) * gru_1_fwd_t0_h_26 + (0.060700837522745132) * gru_1_fwd_t0_h_27 + (0.79758715629577637) * gru_1_fwd_t0_h_28 + (0.10627193003892899) * gru_1_fwd_t0_h_29 + (0.49125882983207703) * gru_1_fwd_t0_h_30 + (-0.6533658504486084) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_25 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_25;
    // h=26
    gate_r = sigmoid((-0.076467685401439667) + (0.2769375741481781) * gru_0_out_t1_0 + (0.070832394063472748) * gru_0_out_t1_1 + (0.077094525098800659) * gru_0_out_t1_2 + (-0.19162987172603607) * gru_0_out_t1_3 + (-0.19423547387123108) * gru_0_out_t1_4 + (0.026720158755779266) * gru_0_out_t1_5 + (-0.24736309051513672) * gru_0_out_t1_6 + (-2.7226133346557617) * gru_0_out_t1_7 + (-0.32351279258728027) * gru_0_out_t1_8 + (-0.48526784777641296) * gru_0_out_t1_9 + (-0.59297895431518555) * gru_0_out_t1_10 + (0.49966245889663696) * gru_0_out_t1_11 + (0.1938680112361908) * gru_0_out_t1_12 + (0.71319013833999634) * gru_0_out_t1_13 + (0.44350463151931763) * gru_0_out_t1_14 + (0.23444966971874237) * gru_0_out_t1_15 + (-0.31931421160697937) * gru_0_out_t1_16 + (-0.19063882529735565) * gru_0_out_t1_17 + (-0.69299006462097168) * gru_0_out_t1_18 + (3.5240192413330078) * gru_0_out_t1_19 + (-1.1968563795089722) * gru_0_out_t1_20 + (0.045003660023212433) * gru_0_out_t1_21 + (-0.099213354289531708) * gru_0_out_t1_22 + (-0.31207022070884705) * gru_0_out_t1_23 + (-0.11669807136058807) * gru_0_out_t1_24 + (-0.69829446077346802) * gru_0_out_t1_25 + (1.6557317972183228) * gru_0_out_t1_26 + (-0.27660062909126282) * gru_0_out_t1_27 + (-0.028498351573944092) * gru_0_out_t1_28 + (0.37796938419342041) * gru_0_out_t1_29 + (0.28396308422088623) * gru_0_out_t1_30 + (0.81037449836730957) * gru_0_out_t1_31 + (0.0056192944757640362) * gru_0_out_t1_32 + (1.0521278381347656) * gru_0_out_t1_33 + (-0.33769500255584717) * gru_0_out_t1_34 + (0.055799674242734909) * gru_0_out_t1_35 + (0.29136011004447937) * gru_0_out_t1_36 + (-0.43240243196487427) * gru_0_out_t1_37 + (0.21832938492298126) * gru_0_out_t1_38 + (-1.5849900245666504) * gru_0_out_t1_39 + (0.33850547671318054) * gru_0_out_t1_40 + (0.070698849856853485) * gru_0_out_t1_41 + (-0.84558069705963135) * gru_0_out_t1_42 + (0.50241130590438843) * gru_0_out_t1_43 + (-0.036095958203077316) * gru_0_out_t1_44 + (-0.15989252924919128) * gru_0_out_t1_45 + (1.5869982242584229) * gru_0_out_t1_46 + (-0.6398465633392334) * gru_0_out_t1_47 + (-0.083037480711936951) * gru_0_out_t1_48 + (0.62104636430740356) * gru_0_out_t1_49 + (0.85020703077316284) * gru_0_out_t1_50 + (-2.1015548706054688) * gru_0_out_t1_51 + (-0.80198603868484497) * gru_0_out_t1_52 + (0.43366053700447083) * gru_0_out_t1_53 + (0.32981520891189575) * gru_0_out_t1_54 + (-0.35246410965919495) * gru_0_out_t1_55 + (-1.1228047609329224) * gru_0_out_t1_56 + (0.43610963225364685) * gru_0_out_t1_57 + (0.064198508858680725) * gru_0_out_t1_58 + (-0.61314660310745239) * gru_0_out_t1_59 + (-0.50830715894699097) * gru_0_out_t1_60 + (-0.37233486771583557) * gru_0_out_t1_61 + (-0.10278254747390747) * gru_0_out_t1_62 + (2.2968344688415527) * gru_0_out_t1_63 + (0.1279274970293045) * gru_1_fwd_t0_h_0 + (-0.36156019568443298) * gru_1_fwd_t0_h_1 + (-0.57325929403305054) * gru_1_fwd_t0_h_2 + (0.57127010822296143) * gru_1_fwd_t0_h_3 + (-0.36992895603179932) * gru_1_fwd_t0_h_4 + (-0.99652540683746338) * gru_1_fwd_t0_h_5 + (0.97806090116500854) * gru_1_fwd_t0_h_6 + (0.11585577577352524) * gru_1_fwd_t0_h_7 + (-0.45205506682395935) * gru_1_fwd_t0_h_8 + (-0.092385701835155487) * gru_1_fwd_t0_h_9 + (-0.052569180727005005) * gru_1_fwd_t0_h_10 + (-0.0064573776908218861) * gru_1_fwd_t0_h_11 + (0.14360027015209198) * gru_1_fwd_t0_h_12 + (-1.5671166181564331) * gru_1_fwd_t0_h_13 + (-0.0099725499749183655) * gru_1_fwd_t0_h_14 + (-0.047282777726650238) * gru_1_fwd_t0_h_15 + (-0.40574735403060913) * gru_1_fwd_t0_h_16 + (0.15778286755084991) * gru_1_fwd_t0_h_17 + (0.30046087503433228) * gru_1_fwd_t0_h_18 + (-0.71401423215866089) * gru_1_fwd_t0_h_19 + (-0.092171594500541687) * gru_1_fwd_t0_h_20 + (-0.33916765451431274) * gru_1_fwd_t0_h_21 + (-0.14947962760925293) * gru_1_fwd_t0_h_22 + (-0.071506120264530182) * gru_1_fwd_t0_h_23 + (-1.7893922328948975) * gru_1_fwd_t0_h_24 + (1.0787578821182251) * gru_1_fwd_t0_h_25 + (0.54126131534576416) * gru_1_fwd_t0_h_26 + (0.026489097625017166) * gru_1_fwd_t0_h_27 + (0.44872143864631653) * gru_1_fwd_t0_h_28 + (-0.069654397666454315) * gru_1_fwd_t0_h_29 + (-1.3622226715087891) * gru_1_fwd_t0_h_30 + (-0.11501754820346832) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((0.098901771008968353) + (0.26790449023246765) * gru_0_out_t1_0 + (0.66023933887481689) * gru_0_out_t1_1 + (-0.49097895622253418) * gru_0_out_t1_2 + (0.83575057983398438) * gru_0_out_t1_3 + (0.25618106126785278) * gru_0_out_t1_4 + (-0.34730884432792664) * gru_0_out_t1_5 + (0.076646372675895691) * gru_0_out_t1_6 + (-1.8044203519821167) * gru_0_out_t1_7 + (0.48304712772369385) * gru_0_out_t1_8 + (1.0323642492294312) * gru_0_out_t1_9 + (0.27785715460777283) * gru_0_out_t1_10 + (0.25535884499549866) * gru_0_out_t1_11 + (-0.47621080279350281) * gru_0_out_t1_12 + (-0.71382826566696167) * gru_0_out_t1_13 + (-0.033862117677927017) * gru_0_out_t1_14 + (-0.31509429216384888) * gru_0_out_t1_15 + (-0.12258738279342651) * gru_0_out_t1_16 + (-0.065539933741092682) * gru_0_out_t1_17 + (0.38164776563644409) * gru_0_out_t1_18 + (0.89014643430709839) * gru_0_out_t1_19 + (-0.40559121966362) * gru_0_out_t1_20 + (-0.12672297656536102) * gru_0_out_t1_21 + (-1.4290814399719238) * gru_0_out_t1_22 + (-0.81405472755432129) * gru_0_out_t1_23 + (1.0293149948120117) * gru_0_out_t1_24 + (0.44364061951637268) * gru_0_out_t1_25 + (-0.20541177690029144) * gru_0_out_t1_26 + (0.26095238327980042) * gru_0_out_t1_27 + (2.0532352924346924) * gru_0_out_t1_28 + (0.93070262670516968) * gru_0_out_t1_29 + (0.63277274370193481) * gru_0_out_t1_30 + (1.2211294174194336) * gru_0_out_t1_31 + (1.8795474767684937) * gru_0_out_t1_32 + (0.33055835962295532) * gru_0_out_t1_33 + (0.1517450362443924) * gru_0_out_t1_34 + (-0.31990328431129456) * gru_0_out_t1_35 + (0.096573047339916229) * gru_0_out_t1_36 + (0.17963609099388123) * gru_0_out_t1_37 + (0.01677272655069828) * gru_0_out_t1_38 + (-0.35066628456115723) * gru_0_out_t1_39 + (0.15757070481777191) * gru_0_out_t1_40 + (-1.1609734296798706) * gru_0_out_t1_41 + (-0.71084761619567871) * gru_0_out_t1_42 + (-0.46621230244636536) * gru_0_out_t1_43 + (-0.12567982077598572) * gru_0_out_t1_44 + (-0.33459195494651794) * gru_0_out_t1_45 + (0.34160834550857544) * gru_0_out_t1_46 + (-0.38255295157432556) * gru_0_out_t1_47 + (0.32127940654754639) * gru_0_out_t1_48 + (-0.50376880168914795) * gru_0_out_t1_49 + (0.48926115036010742) * gru_0_out_t1_50 + (-0.4084513783454895) * gru_0_out_t1_51 + (0.34690967202186584) * gru_0_out_t1_52 + (0.035803288221359253) * gru_0_out_t1_53 + (-0.35029610991477966) * gru_0_out_t1_54 + (0.31896334886550903) * gru_0_out_t1_55 + (0.31267881393432617) * gru_0_out_t1_56 + (-0.001831499976105988) * gru_0_out_t1_57 + (0.30812576413154602) * gru_0_out_t1_58 + (0.61868494749069214) * gru_0_out_t1_59 + (0.24542374908924103) * gru_0_out_t1_60 + (-0.24312825500965118) * gru_0_out_t1_61 + (-0.15853442251682281) * gru_0_out_t1_62 + (-0.4452798068523407) * gru_0_out_t1_63 + (-0.97681337594985962) * gru_1_fwd_t0_h_0 + (0.08331763744354248) * gru_1_fwd_t0_h_1 + (-0.27465251088142395) * gru_1_fwd_t0_h_2 + (0.069623149931430817) * gru_1_fwd_t0_h_3 + (0.20878979563713074) * gru_1_fwd_t0_h_4 + (0.0073037166148424149) * gru_1_fwd_t0_h_5 + (0.28755375742912292) * gru_1_fwd_t0_h_6 + (-0.77620100975036621) * gru_1_fwd_t0_h_7 + (0.46741592884063721) * gru_1_fwd_t0_h_8 + (0.11321624368429184) * gru_1_fwd_t0_h_9 + (-0.25531557202339172) * gru_1_fwd_t0_h_10 + (-0.95224869251251221) * gru_1_fwd_t0_h_11 + (1.214138388633728) * gru_1_fwd_t0_h_12 + (-0.06232534721493721) * gru_1_fwd_t0_h_13 + (-0.42823770642280579) * gru_1_fwd_t0_h_14 + (-0.62786555290222168) * gru_1_fwd_t0_h_15 + (0.29051324725151062) * gru_1_fwd_t0_h_16 + (0.5285419225692749) * gru_1_fwd_t0_h_17 + (0.48163169622421265) * gru_1_fwd_t0_h_18 + (0.36232021450996399) * gru_1_fwd_t0_h_19 + (-0.80483353137969971) * gru_1_fwd_t0_h_20 + (2.0563983917236328) * gru_1_fwd_t0_h_21 + (0.26855066418647766) * gru_1_fwd_t0_h_22 + (1.0019446611404419) * gru_1_fwd_t0_h_23 + (0.46915468573570251) * gru_1_fwd_t0_h_24 + (-0.58661240339279175) * gru_1_fwd_t0_h_25 + (-0.18930664658546448) * gru_1_fwd_t0_h_26 + (-0.34527099132537842) * gru_1_fwd_t0_h_27 + (0.65793842077255249) * gru_1_fwd_t0_h_28 + (-0.23503805696964264) * gru_1_fwd_t0_h_29 + (0.46234336495399475) * gru_1_fwd_t0_h_30 + (-0.49330401420593262) * gru_1_fwd_t0_h_31);
    gate_n = tanh((0.035159725695848465) + (-0.08853517472743988) * gru_0_out_t1_0 + (0.28788402676582336) * gru_0_out_t1_1 + (-0.54823362827301025) * gru_0_out_t1_2 + (-0.0042568342760205269) * gru_0_out_t1_3 + (0.19225247204303741) * gru_0_out_t1_4 + (0.11134367436170578) * gru_0_out_t1_5 + (0.21037399768829346) * gru_0_out_t1_6 + (-0.15053296089172363) * gru_0_out_t1_7 + (-0.40025916695594788) * gru_0_out_t1_8 + (-0.025375574827194214) * gru_0_out_t1_9 + (-0.12294541299343109) * gru_0_out_t1_10 + (-0.12273577600717545) * gru_0_out_t1_11 + (0.04265211895108223) * gru_0_out_t1_12 + (-0.26186558604240417) * gru_0_out_t1_13 + (0.17058643698692322) * gru_0_out_t1_14 + (-0.027253648266196251) * gru_0_out_t1_15 + (0.59505236148834229) * gru_0_out_t1_16 + (-0.1141689345240593) * gru_0_out_t1_17 + (-0.15626473724842072) * gru_0_out_t1_18 + (-0.17445825040340424) * gru_0_out_t1_19 + (0.10242993384599686) * gru_0_out_t1_20 + (0.052345592528581619) * gru_0_out_t1_21 + (0.081754356622695923) * gru_0_out_t1_22 + (0.34917214512825012) * gru_0_out_t1_23 + (-0.050582218915224075) * gru_0_out_t1_24 + (-0.25408637523651123) * gru_0_out_t1_25 + (0.069133155047893524) * gru_0_out_t1_26 + (-0.12887786328792572) * gru_0_out_t1_27 + (-1.4698892831802368) * gru_0_out_t1_28 + (-0.77784442901611328) * gru_0_out_t1_29 + (0.29932042956352234) * gru_0_out_t1_30 + (0.25389385223388672) * gru_0_out_t1_31 + (-0.011390303261578083) * gru_0_out_t1_32 + (0.0060517392121255398) * gru_0_out_t1_33 + (0.093926019966602325) * gru_0_out_t1_34 + (0.4721972644329071) * gru_0_out_t1_35 + (-0.11033742874860764) * gru_0_out_t1_36 + (-0.23404668271541595) * gru_0_out_t1_37 + (-0.1707637757062912) * gru_0_out_t1_38 + (-1.0134559869766235) * gru_0_out_t1_39 + (-0.029952997341752052) * gru_0_out_t1_40 + (0.040784019976854324) * gru_0_out_t1_41 + (-0.25285729765892029) * gru_0_out_t1_42 + (-0.13345231115818024) * gru_0_out_t1_43 + (-0.028507119044661522) * gru_0_out_t1_44 + (0.4731193482875824) * gru_0_out_t1_45 + (-0.21453763544559479) * gru_0_out_t1_46 + (0.30017560720443726) * gru_0_out_t1_47 + (0.96943986415863037) * gru_0_out_t1_48 + (-0.11195682734251022) * gru_0_out_t1_49 + (-0.55412352085113525) * gru_0_out_t1_50 + (-0.21212081611156464) * gru_0_out_t1_51 + (0.19174441695213318) * gru_0_out_t1_52 + (-0.18461023271083832) * gru_0_out_t1_53 + (0.058927111327648163) * gru_0_out_t1_54 + (0.15701396763324738) * gru_0_out_t1_55 + (-0.12456706166267395) * gru_0_out_t1_56 + (-0.14607350528240204) * gru_0_out_t1_57 + (0.32731017470359802) * gru_0_out_t1_58 + (0.42114987969398499) * gru_0_out_t1_59 + (0.014675414189696312) * gru_0_out_t1_60 + (-0.052481375634670258) * gru_0_out_t1_61 + (-0.12645533680915833) * gru_0_out_t1_62 + (1.7810565233230591) * gru_0_out_t1_63 + gate_r * ((-0.2310643196105957) + (-0.10161932557821274) * gru_1_fwd_t0_h_0 + (-0.027378702536225319) * gru_1_fwd_t0_h_1 + (-0.026164045557379723) * gru_1_fwd_t0_h_2 + (-0.25556400418281555) * gru_1_fwd_t0_h_3 + (-0.19964107871055603) * gru_1_fwd_t0_h_4 + (0.21500395238399506) * gru_1_fwd_t0_h_5 + (0.31625452637672424) * gru_1_fwd_t0_h_6 + (-0.24881403148174286) * gru_1_fwd_t0_h_7 + (0.29941552877426147) * gru_1_fwd_t0_h_8 + (-0.094522550702095032) * gru_1_fwd_t0_h_9 + (0.19519755244255066) * gru_1_fwd_t0_h_10 + (0.11414958536624908) * gru_1_fwd_t0_h_11 + (-0.16130149364471436) * gru_1_fwd_t0_h_12 + (-0.3815155029296875) * gru_1_fwd_t0_h_13 + (0.35557779669761658) * gru_1_fwd_t0_h_14 + (-0.11919749528169632) * gru_1_fwd_t0_h_15 + (-0.0083007412031292915) * gru_1_fwd_t0_h_16 + (0.073021858930587769) * gru_1_fwd_t0_h_17 + (-0.0067197885364294052) * gru_1_fwd_t0_h_18 + (0.24978102743625641) * gru_1_fwd_t0_h_19 + (-0.13269484043121338) * gru_1_fwd_t0_h_20 + (0.071465209126472473) * gru_1_fwd_t0_h_21 + (-0.15624240040779114) * gru_1_fwd_t0_h_22 + (-1.1506456136703491) * gru_1_fwd_t0_h_23 + (0.24524341523647308) * gru_1_fwd_t0_h_24 + (-0.1749148964881897) * gru_1_fwd_t0_h_25 + (-0.24097849428653717) * gru_1_fwd_t0_h_26 + (-0.25703004002571106) * gru_1_fwd_t0_h_27 + (-0.14647114276885986) * gru_1_fwd_t0_h_28 + (0.16564995050430298) * gru_1_fwd_t0_h_29 + (0.17593143880367279) * gru_1_fwd_t0_h_30 + (0.26184177398681641) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_26 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_26;
    // h=27
    gate_r = sigmoid((-0.46266156435012817) + (-0.17690213024616241) * gru_0_out_t1_0 + (0.39805281162261963) * gru_0_out_t1_1 + (0.48003080487251282) * gru_0_out_t1_2 + (0.78808289766311646) * gru_0_out_t1_3 + (0.17656855285167694) * gru_0_out_t1_4 + (0.37412503361701965) * gru_0_out_t1_5 + (-1.5806025266647339) * gru_0_out_t1_6 + (-0.90156131982803345) * gru_0_out_t1_7 + (0.052514322102069855) * gru_0_out_t1_8 + (-0.14406579732894897) * gru_0_out_t1_9 + (-0.092430122196674347) * gru_0_out_t1_10 + (1.3271166086196899) * gru_0_out_t1_11 + (-0.19042648375034332) * gru_0_out_t1_12 + (-0.4084133505821228) * gru_0_out_t1_13 + (-0.19637815654277802) * gru_0_out_t1_14 + (0.60568296909332275) * gru_0_out_t1_15 + (0.025304369628429413) * gru_0_out_t1_16 + (0.16182741522789001) * gru_0_out_t1_17 + (-0.01197005994617939) * gru_0_out_t1_18 + (-0.86063051223754883) * gru_0_out_t1_19 + (0.035169310867786407) * gru_0_out_t1_20 + (0.40657484531402588) * gru_0_out_t1_21 + (0.81035816669464111) * gru_0_out_t1_22 + (0.15718436241149902) * gru_0_out_t1_23 + (-3.3010518550872803) * gru_0_out_t1_24 + (0.086790688335895538) * gru_0_out_t1_25 + (1.0286291837692261) * gru_0_out_t1_26 + (0.17655761539936066) * gru_0_out_t1_27 + (-1.5627838373184204) * gru_0_out_t1_28 + (0.099544249475002289) * gru_0_out_t1_29 + (-0.2321852445602417) * gru_0_out_t1_30 + (2.1300156116485596) * gru_0_out_t1_31 + (-0.041468128561973572) * gru_0_out_t1_32 + (1.6231603622436523) * gru_0_out_t1_33 + (1.196184515953064) * gru_0_out_t1_34 + (-0.17761018872261047) * gru_0_out_t1_35 + (-1.3216122388839722) * gru_0_out_t1_36 + (0.95802593231201172) * gru_0_out_t1_37 + (-0.16500398516654968) * gru_0_out_t1_38 + (-1.7530776262283325) * gru_0_out_t1_39 + (0.094662830233573914) * gru_0_out_t1_40 + (-0.035025123506784439) * gru_0_out_t1_41 + (0.31252974271774292) * gru_0_out_t1_42 + (1.7129338979721069) * gru_0_out_t1_43 + (0.48306536674499512) * gru_0_out_t1_44 + (-0.039640277624130249) * gru_0_out_t1_45 + (2.3545219898223877) * gru_0_out_t1_46 + (0.080370105803012848) * gru_0_out_t1_47 + (-0.65957075357437134) * gru_0_out_t1_48 + (0.32162865996360779) * gru_0_out_t1_49 + (0.2682584822177887) * gru_0_out_t1_50 + (-0.176847904920578) * gru_0_out_t1_51 + (-2.2430248260498047) * gru_0_out_t1_52 + (0.79624253511428833) * gru_0_out_t1_53 + (0.31350612640380859) * gru_0_out_t1_54 + (-0.4660300612449646) * gru_0_out_t1_55 + (-0.92167216539382935) * gru_0_out_t1_56 + (0.41907140612602234) * gru_0_out_t1_57 + (0.44410884380340576) * gru_0_out_t1_58 + (0.69895142316818237) * gru_0_out_t1_59 + (-0.18372361361980438) * gru_0_out_t1_60 + (0.042234990745782852) * gru_0_out_t1_61 + (-1.2581833600997925) * gru_0_out_t1_62 + (0.30793109536170959) * gru_0_out_t1_63 + (0.69012761116027832) * gru_1_fwd_t0_h_0 + (1.9290456771850586) * gru_1_fwd_t0_h_1 + (-0.58328062295913696) * gru_1_fwd_t0_h_2 + (0.48346406221389771) * gru_1_fwd_t0_h_3 + (-0.78185242414474487) * gru_1_fwd_t0_h_4 + (0.85304969549179077) * gru_1_fwd_t0_h_5 + (0.27101030945777893) * gru_1_fwd_t0_h_6 + (-0.81157982349395752) * gru_1_fwd_t0_h_7 + (-1.2876484394073486) * gru_1_fwd_t0_h_8 + (0.22055685520172119) * gru_1_fwd_t0_h_9 + (0.19453853368759155) * gru_1_fwd_t0_h_10 + (0.69804090261459351) * gru_1_fwd_t0_h_11 + (0.43181443214416504) * gru_1_fwd_t0_h_12 + (0.40058153867721558) * gru_1_fwd_t0_h_13 + (0.44322815537452698) * gru_1_fwd_t0_h_14 + (0.62534636259078979) * gru_1_fwd_t0_h_15 + (0.041804123669862747) * gru_1_fwd_t0_h_16 + (0.46044901013374329) * gru_1_fwd_t0_h_17 + (0.32727187871932983) * gru_1_fwd_t0_h_18 + (-0.20609748363494873) * gru_1_fwd_t0_h_19 + (-0.36359140276908875) * gru_1_fwd_t0_h_20 + (0.75188511610031128) * gru_1_fwd_t0_h_21 + (1.0623284578323364) * gru_1_fwd_t0_h_22 + (0.95388895273208618) * gru_1_fwd_t0_h_23 + (0.77921456098556519) * gru_1_fwd_t0_h_24 + (0.32610294222831726) * gru_1_fwd_t0_h_25 + (1.0090687274932861) * gru_1_fwd_t0_h_26 + (-1.240517258644104) * gru_1_fwd_t0_h_27 + (0.8376879096031189) * gru_1_fwd_t0_h_28 + (0.7643926739692688) * gru_1_fwd_t0_h_29 + (-1.9757161140441895) * gru_1_fwd_t0_h_30 + (0.91344583034515381) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((1.3229556083679199) + (-0.19408118724822998) * gru_0_out_t1_0 + (-0.23358795046806335) * gru_0_out_t1_1 + (0.98805457353591919) * gru_0_out_t1_2 + (-0.64171534776687622) * gru_0_out_t1_3 + (0.34609121084213257) * gru_0_out_t1_4 + (0.019168959930539131) * gru_0_out_t1_5 + (-0.24356620013713837) * gru_0_out_t1_6 + (-1.2493016719818115) * gru_0_out_t1_7 + (-0.29067152738571167) * gru_0_out_t1_8 + (-0.52916741371154785) * gru_0_out_t1_9 + (-0.87251752614974976) * gru_0_out_t1_10 + (-0.35165524482727051) * gru_0_out_t1_11 + (-0.096616163849830627) * gru_0_out_t1_12 + (-0.40826353430747986) * gru_0_out_t1_13 + (0.21357770264148712) * gru_0_out_t1_14 + (0.17562766373157501) * gru_0_out_t1_15 + (0.2310110479593277) * gru_0_out_t1_16 + (0.15968644618988037) * gru_0_out_t1_17 + (-0.30910789966583252) * gru_0_out_t1_18 + (-1.1662306785583496) * gru_0_out_t1_19 + (1.4947967529296875) * gru_0_out_t1_20 + (0.1501757949590683) * gru_0_out_t1_21 + (-0.36502715945243835) * gru_0_out_t1_22 + (0.17250221967697144) * gru_0_out_t1_23 + (0.13504825532436371) * gru_0_out_t1_24 + (-0.59695678949356079) * gru_0_out_t1_25 + (-0.069472193717956543) * gru_0_out_t1_26 + (0.33949404954910278) * gru_0_out_t1_27 + (-1.2997053861618042) * gru_0_out_t1_28 + (-0.11241608858108521) * gru_0_out_t1_29 + (0.39656755328178406) * gru_0_out_t1_30 + (-0.27382257580757141) * gru_0_out_t1_31 + (-0.0060353772714734077) * gru_0_out_t1_32 + (0.30710777640342712) * gru_0_out_t1_33 + (0.17229078710079193) * gru_0_out_t1_34 + (0.71598315238952637) * gru_0_out_t1_35 + (0.054784055799245834) * gru_0_out_t1_36 + (0.31369408965110779) * gru_0_out_t1_37 + (-0.40285336971282959) * gru_0_out_t1_38 + (0.225486159324646) * gru_0_out_t1_39 + (0.0068082367070019245) * gru_0_out_t1_40 + (-0.038092441856861115) * gru_0_out_t1_41 + (-0.17348015308380127) * gru_0_out_t1_42 + (-0.029206864535808563) * gru_0_out_t1_43 + (0.18822723627090454) * gru_0_out_t1_44 + (0.24751554429531097) * gru_0_out_t1_45 + (0.16960126161575317) * gru_0_out_t1_46 + (-0.53373128175735474) * gru_0_out_t1_47 + (0.011361001990735531) * gru_0_out_t1_48 + (-0.19353409111499786) * gru_0_out_t1_49 + (0.51860243082046509) * gru_0_out_t1_50 + (0.026689315214753151) * gru_0_out_t1_51 + (0.67123115062713623) * gru_0_out_t1_52 + (0.61337155103683472) * gru_0_out_t1_53 + (-0.043040905147790909) * gru_0_out_t1_54 + (-0.97380971908569336) * gru_0_out_t1_55 + (0.017116930335760117) * gru_0_out_t1_56 + (-0.38505706191062927) * gru_0_out_t1_57 + (1.0475902557373047) * gru_0_out_t1_58 + (0.07731589674949646) * gru_0_out_t1_59 + (0.0769672691822052) * gru_0_out_t1_60 + (-0.12370793521404266) * gru_0_out_t1_61 + (0.22392010688781738) * gru_0_out_t1_62 + (-0.4176185131072998) * gru_0_out_t1_63 + (0.05029924213886261) * gru_1_fwd_t0_h_0 + (-0.042512658983469009) * gru_1_fwd_t0_h_1 + (-0.13258562982082367) * gru_1_fwd_t0_h_2 + (0.048657514154911041) * gru_1_fwd_t0_h_3 + (-0.48304593563079834) * gru_1_fwd_t0_h_4 + (0.4075295627117157) * gru_1_fwd_t0_h_5 + (-0.81183981895446777) * gru_1_fwd_t0_h_6 + (-0.12810757756233215) * gru_1_fwd_t0_h_7 + (-0.0090620918199419975) * gru_1_fwd_t0_h_8 + (0.14675474166870117) * gru_1_fwd_t0_h_9 + (0.2826198935508728) * gru_1_fwd_t0_h_10 + (0.47382363677024841) * gru_1_fwd_t0_h_11 + (0.18025462329387665) * gru_1_fwd_t0_h_12 + (-0.21279884874820709) * gru_1_fwd_t0_h_13 + (0.068469859659671783) * gru_1_fwd_t0_h_14 + (-0.48510155081748962) * gru_1_fwd_t0_h_15 + (-0.74551665782928467) * gru_1_fwd_t0_h_16 + (0.41722646355628967) * gru_1_fwd_t0_h_17 + (0.58349162340164185) * gru_1_fwd_t0_h_18 + (-0.33853861689567566) * gru_1_fwd_t0_h_19 + (-0.24335719645023346) * gru_1_fwd_t0_h_20 + (-0.18778686225414276) * gru_1_fwd_t0_h_21 + (0.074099011719226837) * gru_1_fwd_t0_h_22 + (0.15932762622833252) * gru_1_fwd_t0_h_23 + (0.056651704013347626) * gru_1_fwd_t0_h_24 + (0.25060722231864929) * gru_1_fwd_t0_h_25 + (-0.20705272257328033) * gru_1_fwd_t0_h_26 + (-0.31949368119239807) * gru_1_fwd_t0_h_27 + (0.8193366527557373) * gru_1_fwd_t0_h_28 + (0.41072604060173035) * gru_1_fwd_t0_h_29 + (-0.10766115784645081) * gru_1_fwd_t0_h_30 + (-0.076130211353302002) * gru_1_fwd_t0_h_31);
    gate_n = tanh((-0.10986202955245972) + (-0.15132446587085724) * gru_0_out_t1_0 + (-0.047645311802625656) * gru_0_out_t1_1 + (0.022800343111157417) * gru_0_out_t1_2 + (0.72179222106933594) * gru_0_out_t1_3 + (0.018053233623504639) * gru_0_out_t1_4 + (-0.0079949526116251945) * gru_0_out_t1_5 + (-0.44103798270225525) * gru_0_out_t1_6 + (-0.81276571750640869) * gru_0_out_t1_7 + (-0.24211443960666656) * gru_0_out_t1_8 + (0.059833303093910217) * gru_0_out_t1_9 + (-0.3750927746295929) * gru_0_out_t1_10 + (-0.042615491896867752) * gru_0_out_t1_11 + (0.28127750754356384) * gru_0_out_t1_12 + (0.0056372336111962795) * gru_0_out_t1_13 + (-0.086078844964504242) * gru_0_out_t1_14 + (-0.04189179465174675) * gru_0_out_t1_15 + (0.084578096866607666) * gru_0_out_t1_16 + (0.028473369777202606) * gru_0_out_t1_17 + (-0.063915744423866272) * gru_0_out_t1_18 + (-1.7903996706008911) * gru_0_out_t1_19 + (-0.11881640553474426) * gru_0_out_t1_20 + (-0.2240329384803772) * gru_0_out_t1_21 + (0.078823000192642212) * gru_0_out_t1_22 + (0.093560591340065002) * gru_0_out_t1_23 + (-0.24129828810691833) * gru_0_out_t1_24 + (0.033049155026674271) * gru_0_out_t1_25 + (0.01011956762522459) * gru_0_out_t1_26 + (0.13075383007526398) * gru_0_out_t1_27 + (-0.30526226758956909) * gru_0_out_t1_28 + (-0.42008984088897705) * gru_0_out_t1_29 + (-0.55150467157363892) * gru_0_out_t1_30 + (0.12012997269630432) * gru_0_out_t1_31 + (-0.14246127009391785) * gru_0_out_t1_32 + (0.39198222756385803) * gru_0_out_t1_33 + (0.46505078673362732) * gru_0_out_t1_34 + (0.12762421369552612) * gru_0_out_t1_35 + (-0.17087139189243317) * gru_0_out_t1_36 + (-0.067461922764778137) * gru_0_out_t1_37 + (-0.21715927124023438) * gru_0_out_t1_38 + (0.37669804692268372) * gru_0_out_t1_39 + (-0.0057161059230566025) * gru_0_out_t1_40 + (0.054626982659101486) * gru_0_out_t1_41 + (-0.13482645153999329) * gru_0_out_t1_42 + (0.34352749586105347) * gru_0_out_t1_43 + (0.14716720581054688) * gru_0_out_t1_44 + (-0.14493536949157715) * gru_0_out_t1_45 + (-0.47443497180938721) * gru_0_out_t1_46 + (-0.2263568639755249) * gru_0_out_t1_47 + (-0.49783539772033691) * gru_0_out_t1_48 + (0.40575695037841797) * gru_0_out_t1_49 + (-0.07882419228553772) * gru_0_out_t1_50 + (-0.037815365940332413) * gru_0_out_t1_51 + (-0.23600991070270538) * gru_0_out_t1_52 + (0.11244021356105804) * gru_0_out_t1_53 + (0.050635199993848801) * gru_0_out_t1_54 + (-0.57346516847610474) * gru_0_out_t1_55 + (-0.17085875570774078) * gru_0_out_t1_56 + (0.49295917153358459) * gru_0_out_t1_57 + (-0.38841795921325684) * gru_0_out_t1_58 + (-0.4260963499546051) * gru_0_out_t1_59 + (-0.25148192048072815) * gru_0_out_t1_60 + (-0.062053903937339783) * gru_0_out_t1_61 + (-0.17309589684009552) * gru_0_out_t1_62 + (-1.2660020589828491) * gru_0_out_t1_63 + gate_r * ((0.20784817636013031) + (-0.11957739293575287) * gru_1_fwd_t0_h_0 + (0.41642230749130249) * gru_1_fwd_t0_h_1 + (0.10992847383022308) * gru_1_fwd_t0_h_2 + (0.114470474421978) * gru_1_fwd_t0_h_3 + (0.00046876363921910524) * gru_1_fwd_t0_h_4 + (-0.63266223669052124) * gru_1_fwd_t0_h_5 + (-1.7140777111053467) * gru_1_fwd_t0_h_6 + (0.1877790242433548) * gru_1_fwd_t0_h_7 + (-0.72462975978851318) * gru_1_fwd_t0_h_8 + (-0.18423940241336823) * gru_1_fwd_t0_h_9 + (0.59281313419342041) * gru_1_fwd_t0_h_10 + (0.0074567529372870922) * gru_1_fwd_t0_h_11 + (0.090893454849720001) * gru_1_fwd_t0_h_12 + (0.064232304692268372) * gru_1_fwd_t0_h_13 + (0.082251675426959991) * gru_1_fwd_t0_h_14 + (-0.22943024337291718) * gru_1_fwd_t0_h_15 + (0.25550812482833862) * gru_1_fwd_t0_h_16 + (0.21975533664226532) * gru_1_fwd_t0_h_17 + (-0.54472231864929199) * gru_1_fwd_t0_h_18 + (0.1911674439907074) * gru_1_fwd_t0_h_19 + (-0.16192390024662018) * gru_1_fwd_t0_h_20 + (0.059335801750421524) * gru_1_fwd_t0_h_21 + (0.66550922393798828) * gru_1_fwd_t0_h_22 + (-0.48722758889198303) * gru_1_fwd_t0_h_23 + (0.10165116190910339) * gru_1_fwd_t0_h_24 + (-0.57978683710098267) * gru_1_fwd_t0_h_25 + (0.84031236171722412) * gru_1_fwd_t0_h_26 + (-0.46686133742332458) * gru_1_fwd_t0_h_27 + (0.52492588758468628) * gru_1_fwd_t0_h_28 + (-0.011396618559956551) * gru_1_fwd_t0_h_29 + (-0.089386850595474243) * gru_1_fwd_t0_h_30 + (0.58417230844497681) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_27 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_27;
    // h=28
    gate_r = sigmoid((-0.11330907791852951) + (0.23868207633495331) * gru_0_out_t1_0 + (-0.26589274406433105) * gru_0_out_t1_1 + (0.22211344540119171) * gru_0_out_t1_2 + (-0.22721266746520996) * gru_0_out_t1_3 + (0.51347047090530396) * gru_0_out_t1_4 + (0.094098299741744995) * gru_0_out_t1_5 + (-0.26612523198127747) * gru_0_out_t1_6 + (2.07944655418396) * gru_0_out_t1_7 + (-0.11185628920793533) * gru_0_out_t1_8 + (-0.70029062032699585) * gru_0_out_t1_9 + (0.26492491364479065) * gru_0_out_t1_10 + (-0.96662825345993042) * gru_0_out_t1_11 + (-0.021238695830106735) * gru_0_out_t1_12 + (0.029995609074831009) * gru_0_out_t1_13 + (-0.20772404968738556) * gru_0_out_t1_14 + (0.14736655354499817) * gru_0_out_t1_15 + (0.17589056491851807) * gru_0_out_t1_16 + (-0.094975575804710388) * gru_0_out_t1_17 + (-0.10728712379932404) * gru_0_out_t1_18 + (0.6890215277671814) * gru_0_out_t1_19 + (1.6729998588562012) * gru_0_out_t1_20 + (0.042248018085956573) * gru_0_out_t1_21 + (-0.009382772259414196) * gru_0_out_t1_22 + (-1.2302887439727783) * gru_0_out_t1_23 + (0.73327797651290894) * gru_0_out_t1_24 + (0.3207356333732605) * gru_0_out_t1_25 + (2.1189708709716797) * gru_0_out_t1_26 + (0.24689359962940216) * gru_0_out_t1_27 + (-2.3345799446105957) * gru_0_out_t1_28 + (-1.0443856716156006) * gru_0_out_t1_29 + (-0.084836609661579132) * gru_0_out_t1_30 + (-1.2881007194519043) * gru_0_out_t1_31 + (0.0077554001472890377) * gru_0_out_t1_32 + (-0.15084411203861237) * gru_0_out_t1_33 + (-0.50253176689147949) * gru_0_out_t1_34 + (0.13887390494346619) * gru_0_out_t1_35 + (-0.18549858033657074) * gru_0_out_t1_36 + (0.042670011520385742) * gru_0_out_t1_37 + (0.31364706158638) * gru_0_out_t1_38 + (0.54703521728515625) * gru_0_out_t1_39 + (0.92722576856613159) * gru_0_out_t1_40 + (0.33524727821350098) * gru_0_out_t1_41 + (1.5436555147171021) * gru_0_out_t1_42 + (-0.2408667653799057) * gru_0_out_t1_43 + (-0.129362553358078) * gru_0_out_t1_44 + (-0.30828237533569336) * gru_0_out_t1_45 + (0.71437788009643555) * gru_0_out_t1_46 + (-0.3641757071018219) * gru_0_out_t1_47 + (0.20061153173446655) * gru_0_out_t1_48 + (-0.39720180630683899) * gru_0_out_t1_49 + (-0.41693547368049622) * gru_0_out_t1_50 + (-0.39698934555053711) * gru_0_out_t1_51 + (-0.34782266616821289) * gru_0_out_t1_52 + (-0.397462397813797) * gru_0_out_t1_53 + (-0.33320078253746033) * gru_0_out_t1_54 + (-0.61713320016860962) * gru_0_out_t1_55 + (0.25206875801086426) * gru_0_out_t1_56 + (0.2800675630569458) * gru_0_out_t1_57 + (0.63394159078598022) * gru_0_out_t1_58 + (0.86329883337020874) * gru_0_out_t1_59 + (-0.5461503267288208) * gru_0_out_t1_60 + (-0.77278047800064087) * gru_0_out_t1_61 + (-1.6426070928573608) * gru_0_out_t1_62 + (-1.1830781698226929) * gru_0_out_t1_63 + (-0.19762478768825531) * gru_1_fwd_t0_h_0 + (0.39954051375389099) * gru_1_fwd_t0_h_1 + (0.064608506858348846) * gru_1_fwd_t0_h_2 + (-0.52282851934432983) * gru_1_fwd_t0_h_3 + (-0.64223223924636841) * gru_1_fwd_t0_h_4 + (0.1589525043964386) * gru_1_fwd_t0_h_5 + (-1.1951804161071777) * gru_1_fwd_t0_h_6 + (0.73369759321212769) * gru_1_fwd_t0_h_7 + (0.23770622909069061) * gru_1_fwd_t0_h_8 + (0.66960102319717407) * gru_1_fwd_t0_h_9 + (0.51748830080032349) * gru_1_fwd_t0_h_10 + (-0.17856761813163757) * gru_1_fwd_t0_h_11 + (0.017382381483912468) * gru_1_fwd_t0_h_12 + (0.59949177503585815) * gru_1_fwd_t0_h_13 + (-0.7694929838180542) * gru_1_fwd_t0_h_14 + (-0.84058630466461182) * gru_1_fwd_t0_h_15 + (-0.25160661339759827) * gru_1_fwd_t0_h_16 + (-0.026627423241734505) * gru_1_fwd_t0_h_17 + (-0.89583492279052734) * gru_1_fwd_t0_h_18 + (-0.39361593127250671) * gru_1_fwd_t0_h_19 + (0.16620483994483948) * gru_1_fwd_t0_h_20 + (-0.038880672305822372) * gru_1_fwd_t0_h_21 + (-0.41281166672706604) * gru_1_fwd_t0_h_22 + (-0.57736748456954956) * gru_1_fwd_t0_h_23 + (-1.1113115549087524) * gru_1_fwd_t0_h_24 + (1.2116637229919434) * gru_1_fwd_t0_h_25 + (0.86436039209365845) * gru_1_fwd_t0_h_26 + (-2.1153652667999268) * gru_1_fwd_t0_h_27 + (0.40905645489692688) * gru_1_fwd_t0_h_28 + (0.45748615264892578) * gru_1_fwd_t0_h_29 + (-0.59583783149719238) * gru_1_fwd_t0_h_30 + (-0.44737356901168823) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((1.0137003660202026) + (0.096069946885108948) * gru_0_out_t1_0 + (0.60274285078048706) * gru_0_out_t1_1 + (1.8841409683227539) * gru_0_out_t1_2 + (-0.36468514800071716) * gru_0_out_t1_3 + (-0.11091623455286026) * gru_0_out_t1_4 + (0.17133083939552307) * gru_0_out_t1_5 + (-0.74669456481933594) * gru_0_out_t1_6 + (-1.0042018890380859) * gru_0_out_t1_7 + (0.46870109438896179) * gru_0_out_t1_8 + (0.86777263879776001) * gru_0_out_t1_9 + (-2.325650691986084) * gru_0_out_t1_10 + (-0.13318872451782227) * gru_0_out_t1_11 + (0.1803363561630249) * gru_0_out_t1_12 + (-0.01500435546040535) * gru_0_out_t1_13 + (0.22377978265285492) * gru_0_out_t1_14 + (-0.48864454030990601) * gru_0_out_t1_15 + (0.0064848419278860092) * gru_0_out_t1_16 + (0.26269811391830444) * gru_0_out_t1_17 + (0.088999420404434204) * gru_0_out_t1_18 + (-1.1525503396987915) * gru_0_out_t1_19 + (0.15682427585124969) * gru_0_out_t1_20 + (-0.17340855300426483) * gru_0_out_t1_21 + (-0.3393481969833374) * gru_0_out_t1_22 + (-0.10375408828258514) * gru_0_out_t1_23 + (-2.332902193069458) * gru_0_out_t1_24 + (-0.90679287910461426) * gru_0_out_t1_25 + (-0.050443381071090698) * gru_0_out_t1_26 + (0.94321978092193604) * gru_0_out_t1_27 + (-0.053961370140314102) * gru_0_out_t1_28 + (0.72054827213287354) * gru_0_out_t1_29 + (1.5476299524307251) * gru_0_out_t1_30 + (1.6552830934524536) * gru_0_out_t1_31 + (0.36996898055076599) * gru_0_out_t1_32 + (-0.56176078319549561) * gru_0_out_t1_33 + (-0.24438998103141785) * gru_0_out_t1_34 + (-0.66791278123855591) * gru_0_out_t1_35 + (-0.13870760798454285) * gru_0_out_t1_36 + (-0.04323713481426239) * gru_0_out_t1_37 + (0.50320303440093994) * gru_0_out_t1_38 + (0.23860694468021393) * gru_0_out_t1_39 + (0.083128005266189575) * gru_0_out_t1_40 + (-0.20730403065681458) * gru_0_out_t1_41 + (0.064789183437824249) * gru_0_out_t1_42 + (-0.33715721964836121) * gru_0_out_t1_43 + (0.029271423816680908) * gru_0_out_t1_44 + (-0.03444691002368927) * gru_0_out_t1_45 + (0.022111659869551659) * gru_0_out_t1_46 + (0.00010886295785894617) * gru_0_out_t1_47 + (-0.33459678292274475) * gru_0_out_t1_48 + (0.28829923272132874) * gru_0_out_t1_49 + (0.12606702744960785) * gru_0_out_t1_50 + (-0.2200017124414444) * gru_0_out_t1_51 + (0.1866936981678009) * gru_0_out_t1_52 + (0.057327117770910263) * gru_0_out_t1_53 + (-0.054931327700614929) * gru_0_out_t1_54 + (-0.19174535572528839) * gru_0_out_t1_55 + (0.002056170254945755) * gru_0_out_t1_56 + (-0.28556126356124878) * gru_0_out_t1_57 + (-0.41446033120155334) * gru_0_out_t1_58 + (0.21847237646579742) * gru_0_out_t1_59 + (0.079293161630630493) * gru_0_out_t1_60 + (0.08750731498003006) * gru_0_out_t1_61 + (1.6067353487014771) * gru_0_out_t1_62 + (-0.40200385451316833) * gru_0_out_t1_63 + (0.24674060940742493) * gru_1_fwd_t0_h_0 + (-0.0011159152491018176) * gru_1_fwd_t0_h_1 + (-0.025198619812726974) * gru_1_fwd_t0_h_2 + (0.0063190450891852379) * gru_1_fwd_t0_h_3 + (0.18125554919242859) * gru_1_fwd_t0_h_4 + (0.15080668032169342) * gru_1_fwd_t0_h_5 + (0.034605208784341812) * gru_1_fwd_t0_h_6 + (0.31796035170555115) * gru_1_fwd_t0_h_7 + (0.18267208337783813) * gru_1_fwd_t0_h_8 + (-0.047706462442874908) * gru_1_fwd_t0_h_9 + (0.26399099826812744) * gru_1_fwd_t0_h_10 + (0.9424889087677002) * gru_1_fwd_t0_h_11 + (-0.085302866995334625) * gru_1_fwd_t0_h_12 + (-0.051999066025018692) * gru_1_fwd_t0_h_13 + (-0.046016760170459747) * gru_1_fwd_t0_h_14 + (-0.071490518748760223) * gru_1_fwd_t0_h_15 + (-0.21830558776855469) * gru_1_fwd_t0_h_16 + (-0.13019084930419922) * gru_1_fwd_t0_h_17 + (0.55442208051681519) * gru_1_fwd_t0_h_18 + (-0.1526714563369751) * gru_1_fwd_t0_h_19 + (-0.051631193608045578) * gru_1_fwd_t0_h_20 + (0.05695328488945961) * gru_1_fwd_t0_h_21 + (0.2037513256072998) * gru_1_fwd_t0_h_22 + (-0.27845042943954468) * gru_1_fwd_t0_h_23 + (0.4123711884021759) * gru_1_fwd_t0_h_24 + (-0.24829399585723877) * gru_1_fwd_t0_h_25 + (0.3626922070980072) * gru_1_fwd_t0_h_26 + (0.0037178769707679749) * gru_1_fwd_t0_h_27 + (1.0910708904266357) * gru_1_fwd_t0_h_28 + (0.099506832659244537) * gru_1_fwd_t0_h_29 + (0.096690841019153595) * gru_1_fwd_t0_h_30 + (-0.013727192766964436) * gru_1_fwd_t0_h_31);
    gate_n = tanh((0.011667217127978802) + (-0.17605970799922943) * gru_0_out_t1_0 + (-0.28558093309402466) * gru_0_out_t1_1 + (-0.82366365194320679) * gru_0_out_t1_2 + (-1.3276199102401733) * gru_0_out_t1_3 + (1.5996085405349731) * gru_0_out_t1_4 + (0.14893645048141479) * gru_0_out_t1_5 + (-0.51614552736282349) * gru_0_out_t1_6 + (0.28483825922012329) * gru_0_out_t1_7 + (0.40029403567314148) * gru_0_out_t1_8 + (-0.72730797529220581) * gru_0_out_t1_9 + (0.60510170459747314) * gru_0_out_t1_10 + (-0.23110891878604889) * gru_0_out_t1_11 + (0.16136851906776428) * gru_0_out_t1_12 + (0.55385923385620117) * gru_0_out_t1_13 + (0.14843088388442993) * gru_0_out_t1_14 + (0.042584475129842758) * gru_0_out_t1_15 + (-0.022276997566223145) * gru_0_out_t1_16 + (-0.24395942687988281) * gru_0_out_t1_17 + (-0.082054078578948975) * gru_0_out_t1_18 + (-0.12776866555213928) * gru_0_out_t1_19 + (-0.69251143932342529) * gru_0_out_t1_20 + (-0.48548012971878052) * gru_0_out_t1_21 + (-0.4664052426815033) * gru_0_out_t1_22 + (-0.43287709355354309) * gru_0_out_t1_23 + (-0.62426561117172241) * gru_0_out_t1_24 + (0.28704565763473511) * gru_0_out_t1_25 + (0.52302896976470947) * gru_0_out_t1_26 + (-0.51696532964706421) * gru_0_out_t1_27 + (1.5256439447402954) * gru_0_out_t1_28 + (0.70288169384002686) * gru_0_out_t1_29 + (0.46908754110336304) * gru_0_out_t1_30 + (-2.6174004077911377) * gru_0_out_t1_31 + (0.28437396883964539) * gru_0_out_t1_32 + (-0.21844868361949921) * gru_0_out_t1_33 + (0.19128407537937164) * gru_0_out_t1_34 + (-0.54660451412200928) * gru_0_out_t1_35 + (0.013573847711086273) * gru_0_out_t1_36 + (-0.48077425360679626) * gru_0_out_t1_37 + (-0.054843436926603317) * gru_0_out_t1_38 + (0.45447456836700439) * gru_0_out_t1_39 + (-0.1343790739774704) * gru_0_out_t1_40 + (0.006156042218208313) * gru_0_out_t1_41 + (-0.31759673357009888) * gru_0_out_t1_42 + (0.31766647100448608) * gru_0_out_t1_43 + (-0.71415853500366211) * gru_0_out_t1_44 + (-0.62088453769683838) * gru_0_out_t1_45 + (-0.13849695026874542) * gru_0_out_t1_46 + (-0.21280704438686371) * gru_0_out_t1_47 + (0.062639042735099792) * gru_0_out_t1_48 + (0.014612744562327862) * gru_0_out_t1_49 + (0.02870761975646019) * gru_0_out_t1_50 + (-0.0040994440205395222) * gru_0_out_t1_51 + (0.11520720273256302) * gru_0_out_t1_52 + (-0.010840080678462982) * gru_0_out_t1_53 + (-0.048147425055503845) * gru_0_out_t1_54 + (0.5135035514831543) * gru_0_out_t1_55 + (-0.046957951039075851) * gru_0_out_t1_56 + (0.10739531368017197) * gru_0_out_t1_57 + (0.0012379726395010948) * gru_0_out_t1_58 + (-0.010854272171854973) * gru_0_out_t1_59 + (-0.31454750895500183) * gru_0_out_t1_60 + (-0.1097334697842598) * gru_0_out_t1_61 + (-1.3330061435699463) * gru_0_out_t1_62 + (-0.48009693622589111) * gru_0_out_t1_63 + gate_r * ((0.53222149610519409) + (-0.19964157044887543) * gru_1_fwd_t0_h_0 + (-0.64266508817672729) * gru_1_fwd_t0_h_1 + (0.77700501680374146) * gru_1_fwd_t0_h_2 + (-0.11378323286771774) * gru_1_fwd_t0_h_3 + (0.0045714420266449451) * gru_1_fwd_t0_h_4 + (-0.083188816905021667) * gru_1_fwd_t0_h_5 + (-1.7983860969543457) * gru_1_fwd_t0_h_6 + (-0.13725081086158752) * gru_1_fwd_t0_h_7 + (0.0013769841752946377) * gru_1_fwd_t0_h_8 + (0.53469586372375488) * gru_1_fwd_t0_h_9 + (-1.5929825305938721) * gru_1_fwd_t0_h_10 + (0.84426432847976685) * gru_1_fwd_t0_h_11 + (0.0093040848150849342) * gru_1_fwd_t0_h_12 + (-0.069953300058841705) * gru_1_fwd_t0_h_13 + (0.2974412739276886) * gru_1_fwd_t0_h_14 + (0.53654813766479492) * gru_1_fwd_t0_h_15 + (0.38515326380729675) * gru_1_fwd_t0_h_16 + (-0.29968741536140442) * gru_1_fwd_t0_h_17 + (-0.47595643997192383) * gru_1_fwd_t0_h_18 + (-0.27855798602104187) * gru_1_fwd_t0_h_19 + (0.46855705976486206) * gru_1_fwd_t0_h_20 + (-0.50183564424514771) * gru_1_fwd_t0_h_21 + (-0.32827281951904297) * gru_1_fwd_t0_h_22 + (0.37400898337364197) * gru_1_fwd_t0_h_23 + (0.91426616907119751) * gru_1_fwd_t0_h_24 + (-0.19293954968452454) * gru_1_fwd_t0_h_25 + (-0.54872512817382812) * gru_1_fwd_t0_h_26 + (0.39695465564727783) * gru_1_fwd_t0_h_27 + (-0.93786215782165527) * gru_1_fwd_t0_h_28 + (0.75340127944946289) * gru_1_fwd_t0_h_29 + (0.63832324743270874) * gru_1_fwd_t0_h_30 + (-0.8941267728805542) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_28 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_28;
    // h=29
    gate_r = sigmoid((-0.92251473665237427) + (-0.39038658142089844) * gru_0_out_t1_0 + (0.18780107796192169) * gru_0_out_t1_1 + (-1.0979119539260864) * gru_0_out_t1_2 + (-0.60150808095932007) * gru_0_out_t1_3 + (-0.14528946578502655) * gru_0_out_t1_4 + (-0.90606784820556641) * gru_0_out_t1_5 + (1.3516972064971924) * gru_0_out_t1_6 + (-0.89922827482223511) * gru_0_out_t1_7 + (0.41642627120018005) * gru_0_out_t1_8 + (-2.7407538890838623) * gru_0_out_t1_9 + (0.65814995765686035) * gru_0_out_t1_10 + (0.087023518979549408) * gru_0_out_t1_11 + (0.14722952246665955) * gru_0_out_t1_12 + (-0.4251905083656311) * gru_0_out_t1_13 + (-0.46483990550041199) * gru_0_out_t1_14 + (0.20667056739330292) * gru_0_out_t1_15 + (0.050824549049139023) * gru_0_out_t1_16 + (-0.25552272796630859) * gru_0_out_t1_17 + (-0.23700647056102753) * gru_0_out_t1_18 + (0.23406417667865753) * gru_0_out_t1_19 + (-2.9941120147705078) * gru_0_out_t1_20 + (-0.44341227412223816) * gru_0_out_t1_21 + (2.0404627323150635) * gru_0_out_t1_22 + (-0.4838111400604248) * gru_0_out_t1_23 + (-0.84234941005706787) * gru_0_out_t1_24 + (1.0689977407455444) * gru_0_out_t1_25 + (0.68949627876281738) * gru_0_out_t1_26 + (0.49937337636947632) * gru_0_out_t1_27 + (-1.271941065788269) * gru_0_out_t1_28 + (-0.82917135953903198) * gru_0_out_t1_29 + (-0.67583984136581421) * gru_0_out_t1_30 + (0.60815346240997314) * gru_0_out_t1_31 + (-0.22063110768795013) * gru_0_out_t1_32 + (0.32702028751373291) * gru_0_out_t1_33 + (0.29341697692871094) * gru_0_out_t1_34 + (-1.2571684122085571) * gru_0_out_t1_35 + (-0.16803900897502899) * gru_0_out_t1_36 + (0.073361046612262726) * gru_0_out_t1_37 + (0.36117705702781677) * gru_0_out_t1_38 + (0.61497890949249268) * gru_0_out_t1_39 + (-2.3874959945678711) * gru_0_out_t1_40 + (0.11008328199386597) * gru_0_out_t1_41 + (-0.89313274621963501) * gru_0_out_t1_42 + (-0.055917855352163315) * gru_0_out_t1_43 + (-1.0683904886245728) * gru_0_out_t1_44 + (-1.0985851287841797) * gru_0_out_t1_45 + (-0.0056257913820445538) * gru_0_out_t1_46 + (0.95078510046005249) * gru_0_out_t1_47 + (-0.22642657160758972) * gru_0_out_t1_48 + (0.40927204489707947) * gru_0_out_t1_49 + (-1.3455471992492676) * gru_0_out_t1_50 + (-0.37723469734191895) * gru_0_out_t1_51 + (-0.12355297058820724) * gru_0_out_t1_52 + (0.29326564073562622) * gru_0_out_t1_53 + (0.2992006242275238) * gru_0_out_t1_54 + (0.7466089129447937) * gru_0_out_t1_55 + (0.051136508584022522) * gru_0_out_t1_56 + (0.40840333700180054) * gru_0_out_t1_57 + (-0.078412361443042755) * gru_0_out_t1_58 + (-0.57041716575622559) * gru_0_out_t1_59 + (-0.1657002866268158) * gru_0_out_t1_60 + (0.17158176004886627) * gru_0_out_t1_61 + (-0.18634362518787384) * gru_0_out_t1_62 + (0.025293445214629173) * gru_0_out_t1_63 + (-1.0929297208786011) * gru_1_fwd_t0_h_0 + (0.70284289121627808) * gru_1_fwd_t0_h_1 + (-0.18219971656799316) * gru_1_fwd_t0_h_2 + (0.48118415474891663) * gru_1_fwd_t0_h_3 + (-0.25667822360992432) * gru_1_fwd_t0_h_4 + (0.30920293927192688) * gru_1_fwd_t0_h_5 + (-0.37201675772666931) * gru_1_fwd_t0_h_6 + (-1.4938733577728271) * gru_1_fwd_t0_h_7 + (-0.25639298558235168) * gru_1_fwd_t0_h_8 + (-0.61872786283493042) * gru_1_fwd_t0_h_9 + (-0.040455549955368042) * gru_1_fwd_t0_h_10 + (0.69775509834289551) * gru_1_fwd_t0_h_11 + (-0.91314244270324707) * gru_1_fwd_t0_h_12 + (0.37844234704971313) * gru_1_fwd_t0_h_13 + (-0.38517078757286072) * gru_1_fwd_t0_h_14 + (-0.17661190032958984) * gru_1_fwd_t0_h_15 + (-0.65481746196746826) * gru_1_fwd_t0_h_16 + (0.44163432717323303) * gru_1_fwd_t0_h_17 + (-0.87098026275634766) * gru_1_fwd_t0_h_18 + (0.29194188117980957) * gru_1_fwd_t0_h_19 + (-0.88437032699584961) * gru_1_fwd_t0_h_20 + (-0.14314882457256317) * gru_1_fwd_t0_h_21 + (0.77341514825820923) * gru_1_fwd_t0_h_22 + (1.8835701942443848) * gru_1_fwd_t0_h_23 + (-0.0038290293887257576) * gru_1_fwd_t0_h_24 + (-0.087611503899097443) * gru_1_fwd_t0_h_25 + (-0.1818520575761795) * gru_1_fwd_t0_h_26 + (-0.384307861328125) * gru_1_fwd_t0_h_27 + (1.2861114740371704) * gru_1_fwd_t0_h_28 + (-0.32839804887771606) * gru_1_fwd_t0_h_29 + (-0.88660091161727905) * gru_1_fwd_t0_h_30 + (-0.80877888202667236) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((-0.18232904374599457) + (-0.26437678933143616) * gru_0_out_t1_0 + (-0.4286353588104248) * gru_0_out_t1_1 + (-0.12445326149463654) * gru_0_out_t1_2 + (-0.27898070216178894) * gru_0_out_t1_3 + (-0.67298007011413574) * gru_0_out_t1_4 + (0.10678032785654068) * gru_0_out_t1_5 + (-0.13382937014102936) * gru_0_out_t1_6 + (0.86131185293197632) * gru_0_out_t1_7 + (0.22485291957855225) * gru_0_out_t1_8 + (0.13595423102378845) * gru_0_out_t1_9 + (-0.3052753210067749) * gru_0_out_t1_10 + (-0.20924863219261169) * gru_0_out_t1_11 + (0.30744278430938721) * gru_0_out_t1_12 + (0.061156276613473892) * gru_0_out_t1_13 + (0.48276069760322571) * gru_0_out_t1_14 + (0.025003233924508095) * gru_0_out_t1_15 + (-0.047980852425098419) * gru_0_out_t1_16 + (-0.030386634171009064) * gru_0_out_t1_17 + (-0.19038741290569305) * gru_0_out_t1_18 + (0.84015893936157227) * gru_0_out_t1_19 + (-0.93565154075622559) * gru_0_out_t1_20 + (-0.38451692461967468) * gru_0_out_t1_21 + (0.25221136212348938) * gru_0_out_t1_22 + (0.32603296637535095) * gru_0_out_t1_23 + (-0.019660614430904388) * gru_0_out_t1_24 + (-0.17786833643913269) * gru_0_out_t1_25 + (0.3067183792591095) * gru_0_out_t1_26 + (0.06872229278087616) * gru_0_out_t1_27 + (-0.10167368501424789) * gru_0_out_t1_28 + (-1.7044744491577148) * gru_0_out_t1_29 + (0.024157552048563957) * gru_0_out_t1_30 + (0.34286314249038696) * gru_0_out_t1_31 + (-0.10277240723371506) * gru_0_out_t1_32 + (0.0061269998550415039) * gru_0_out_t1_33 + (-0.038921181112527847) * gru_0_out_t1_34 + (0.20917965471744537) * gru_0_out_t1_35 + (0.16311877965927124) * gru_0_out_t1_36 + (-0.10550557821989059) * gru_0_out_t1_37 + (-0.4192451536655426) * gru_0_out_t1_38 + (-0.29392677545547485) * gru_0_out_t1_39 + (-0.24233916401863098) * gru_0_out_t1_40 + (0.25208958983421326) * gru_0_out_t1_41 + (0.10305343568325043) * gru_0_out_t1_42 + (0.62102681398391724) * gru_0_out_t1_43 + (-0.092553615570068359) * gru_0_out_t1_44 + (0.2716405987739563) * gru_0_out_t1_45 + (-0.64507049322128296) * gru_0_out_t1_46 + (0.12457276880741119) * gru_0_out_t1_47 + (-0.43000948429107666) * gru_0_out_t1_48 + (0.4840741753578186) * gru_0_out_t1_49 + (-0.14294683933258057) * gru_0_out_t1_50 + (0.12674605846405029) * gru_0_out_t1_51 + (-0.14768955111503601) * gru_0_out_t1_52 + (0.3890531063079834) * gru_0_out_t1_53 + (0.10121145099401474) * gru_0_out_t1_54 + (-0.090991459786891937) * gru_0_out_t1_55 + (-0.10262981802225113) * gru_0_out_t1_56 + (0.55476874113082886) * gru_0_out_t1_57 + (-0.29845055937767029) * gru_0_out_t1_58 + (-0.73720848560333252) * gru_0_out_t1_59 + (-0.44876658916473389) * gru_0_out_t1_60 + (-0.035825416445732117) * gru_0_out_t1_61 + (0.27086958289146423) * gru_0_out_t1_62 + (-0.71472722291946411) * gru_0_out_t1_63 + (0.057411674410104752) * gru_1_fwd_t0_h_0 + (-0.15579858422279358) * gru_1_fwd_t0_h_1 + (-0.6229933500289917) * gru_1_fwd_t0_h_2 + (-0.20059424638748169) * gru_1_fwd_t0_h_3 + (-0.38399079442024231) * gru_1_fwd_t0_h_4 + (-0.060798134654760361) * gru_1_fwd_t0_h_5 + (0.14114730060100555) * gru_1_fwd_t0_h_6 + (-0.30177551507949829) * gru_1_fwd_t0_h_7 + (-0.52773034572601318) * gru_1_fwd_t0_h_8 + (-0.18064978718757629) * gru_1_fwd_t0_h_9 + (0.47161322832107544) * gru_1_fwd_t0_h_10 + (0.089969314634799957) * gru_1_fwd_t0_h_11 + (0.086202919483184814) * gru_1_fwd_t0_h_12 + (0.015513378195464611) * gru_1_fwd_t0_h_13 + (0.12318819761276245) * gru_1_fwd_t0_h_14 + (-0.1859833300113678) * gru_1_fwd_t0_h_15 + (-0.53603875637054443) * gru_1_fwd_t0_h_16 + (0.11749225854873657) * gru_1_fwd_t0_h_17 + (0.00500113470479846) * gru_1_fwd_t0_h_18 + (-0.041099566966295242) * gru_1_fwd_t0_h_19 + (0.11230854690074921) * gru_1_fwd_t0_h_20 + (-0.25465580821037292) * gru_1_fwd_t0_h_21 + (0.41686552762985229) * gru_1_fwd_t0_h_22 + (0.34239977598190308) * gru_1_fwd_t0_h_23 + (-0.16125604510307312) * gru_1_fwd_t0_h_24 + (0.20833046734333038) * gru_1_fwd_t0_h_25 + (-0.54144781827926636) * gru_1_fwd_t0_h_26 + (-0.08436419814825058) * gru_1_fwd_t0_h_27 + (0.35974821448326111) * gru_1_fwd_t0_h_28 + (0.12576025724411011) * gru_1_fwd_t0_h_29 + (-0.11114911735057831) * gru_1_fwd_t0_h_30 + (0.12313659489154816) * gru_1_fwd_t0_h_31);
    gate_n = tanh((0.12120528519153595) + (0.28564846515655518) * gru_0_out_t1_0 + (0.22857376933097839) * gru_0_out_t1_1 + (0.17756438255310059) * gru_0_out_t1_2 + (-0.073568843305110931) * gru_0_out_t1_3 + (-0.33869859576225281) * gru_0_out_t1_4 + (0.21034930646419525) * gru_0_out_t1_5 + (0.72564953565597534) * gru_0_out_t1_6 + (0.9947088360786438) * gru_0_out_t1_7 + (-0.40192848443984985) * gru_0_out_t1_8 + (0.64239752292633057) * gru_0_out_t1_9 + (-0.24684731662273407) * gru_0_out_t1_10 + (-0.1534239798784256) * gru_0_out_t1_11 + (-0.0077988333068788052) * gru_0_out_t1_12 + (-0.2785874605178833) * gru_0_out_t1_13 + (0.19792993366718292) * gru_0_out_t1_14 + (-0.054874520748853683) * gru_0_out_t1_15 + (-0.37053728103637695) * gru_0_out_t1_16 + (0.13209408521652222) * gru_0_out_t1_17 + (0.050557289272546768) * gru_0_out_t1_18 + (0.57551783323287964) * gru_0_out_t1_19 + (-0.051689870655536652) * gru_0_out_t1_20 + (-0.69426029920578003) * gru_0_out_t1_21 + (0.10245537012815475) * gru_0_out_t1_22 + (-0.011866878718137741) * gru_0_out_t1_23 + (0.05868472158908844) * gru_0_out_t1_24 + (-0.046631984412670135) * gru_0_out_t1_25 + (0.17341381311416626) * gru_0_out_t1_26 + (0.15153449773788452) * gru_0_out_t1_27 + (0.16346319019794464) * gru_0_out_t1_28 + (0.94332766532897949) * gru_0_out_t1_29 + (0.10900005698204041) * gru_0_out_t1_30 + (0.88893681764602661) * gru_0_out_t1_31 + (-0.069288603961467743) * gru_0_out_t1_32 + (-0.03596058115363121) * gru_0_out_t1_33 + (-0.11243406683206558) * gru_0_out_t1_34 + (0.39156016707420349) * gru_0_out_t1_35 + (0.17132367193698883) * gru_0_out_t1_36 + (0.24726103246212006) * gru_0_out_t1_37 + (0.047508165240287781) * gru_0_out_t1_38 + (-0.33634099364280701) * gru_0_out_t1_39 + (-1.1995304822921753) * gru_0_out_t1_40 + (-0.31652563810348511) * gru_0_out_t1_41 + (-0.15060724318027496) * gru_0_out_t1_42 + (0.47918146848678589) * gru_0_out_t1_43 + (1.3099504709243774) * gru_0_out_t1_44 + (0.62214607000350952) * gru_0_out_t1_45 + (-0.082700416445732117) * gru_0_out_t1_46 + (0.22489620745182037) * gru_0_out_t1_47 + (0.37489819526672363) * gru_0_out_t1_48 + (-0.16318130493164062) * gru_0_out_t1_49 + (-0.032881557941436768) * gru_0_out_t1_50 + (0.090284258127212524) * gru_0_out_t1_51 + (0.22930942475795746) * gru_0_out_t1_52 + (0.3191530704498291) * gru_0_out_t1_53 + (0.29595097899436951) * gru_0_out_t1_54 + (-0.161802738904953) * gru_0_out_t1_55 + (0.0040839491412043571) * gru_0_out_t1_56 + (-0.17017653584480286) * gru_0_out_t1_57 + (-0.22138632833957672) * gru_0_out_t1_58 + (0.075147949159145355) * gru_0_out_t1_59 + (0.032837070524692535) * gru_0_out_t1_60 + (0.092099487781524658) * gru_0_out_t1_61 + (0.75731873512268066) * gru_0_out_t1_62 + (-0.05792517215013504) * gru_0_out_t1_63 + gate_r * ((0.27020663022994995) + (0.42967358231544495) * gru_1_fwd_t0_h_0 + (0.051386225968599319) * gru_1_fwd_t0_h_1 + (0.030685152858495712) * gru_1_fwd_t0_h_2 + (0.15159566700458527) * gru_1_fwd_t0_h_3 + (-0.027563313022255898) * gru_1_fwd_t0_h_4 + (0.36346542835235596) * gru_1_fwd_t0_h_5 + (-0.48427659273147583) * gru_1_fwd_t0_h_6 + (0.25328773260116577) * gru_1_fwd_t0_h_7 + (-0.34390914440155029) * gru_1_fwd_t0_h_8 + (-0.13072216510772705) * gru_1_fwd_t0_h_9 + (0.39448630809783936) * gru_1_fwd_t0_h_10 + (-0.32216966152191162) * gru_1_fwd_t0_h_11 + (0.48105406761169434) * gru_1_fwd_t0_h_12 + (-0.16890552639961243) * gru_1_fwd_t0_h_13 + (-0.38706314563751221) * gru_1_fwd_t0_h_14 + (0.065970517694950104) * gru_1_fwd_t0_h_15 + (-0.74366933107376099) * gru_1_fwd_t0_h_16 + (0.94575279951095581) * gru_1_fwd_t0_h_17 + (0.24756017327308655) * gru_1_fwd_t0_h_18 + (-0.10361628234386444) * gru_1_fwd_t0_h_19 + (-0.057735707610845566) * gru_1_fwd_t0_h_20 + (-0.094727985560894012) * gru_1_fwd_t0_h_21 + (0.34846204519271851) * gru_1_fwd_t0_h_22 + (0.76291912794113159) * gru_1_fwd_t0_h_23 + (-0.076669603586196899) * gru_1_fwd_t0_h_24 + (-1.1638548374176025) * gru_1_fwd_t0_h_25 + (-0.069115489721298218) * gru_1_fwd_t0_h_26 + (-0.80495637655258179) * gru_1_fwd_t0_h_27 + (-0.38515543937683105) * gru_1_fwd_t0_h_28 + (-0.24010039865970612) * gru_1_fwd_t0_h_29 + (1.1315605640411377) * gru_1_fwd_t0_h_30 + (-0.83713710308074951) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_29 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_29;
    // h=30
    gate_r = sigmoid((-0.87800562381744385) + (-0.41584101319313049) * gru_0_out_t1_0 + (0.59360259771347046) * gru_0_out_t1_1 + (-2.2012012004852295) * gru_0_out_t1_2 + (1.5722604990005493) * gru_0_out_t1_3 + (-0.25129833817481995) * gru_0_out_t1_4 + (-0.85926437377929688) * gru_0_out_t1_5 + (0.64337301254272461) * gru_0_out_t1_6 + (-1.6870865821838379) * gru_0_out_t1_7 + (0.76307642459869385) * gru_0_out_t1_8 + (4.9361882209777832) * gru_0_out_t1_9 + (1.5827140808105469) * gru_0_out_t1_10 + (0.080501250922679901) * gru_0_out_t1_11 + (-0.79519248008728027) * gru_0_out_t1_12 + (-0.62619203329086304) * gru_0_out_t1_13 + (0.18324898183345795) * gru_0_out_t1_14 + (-0.12463359534740448) * gru_0_out_t1_15 + (0.18113318085670471) * gru_0_out_t1_16 + (0.013808397576212883) * gru_0_out_t1_17 + (1.13974928855896) * gru_0_out_t1_18 + (-0.44139990210533142) * gru_0_out_t1_19 + (-2.1949512958526611) * gru_0_out_t1_20 + (0.69584202766418457) * gru_0_out_t1_21 + (-0.28655910491943359) * gru_0_out_t1_22 + (0.71894443035125732) * gru_0_out_t1_23 + (0.51268464326858521) * gru_0_out_t1_24 + (0.62979280948638916) * gru_0_out_t1_25 + (-0.10160199552774429) * gru_0_out_t1_26 + (1.2147579193115234) * gru_0_out_t1_27 + (2.3889882564544678) * gru_0_out_t1_28 + (-2.6312212944030762) * gru_0_out_t1_29 + (-0.68045198917388916) * gru_0_out_t1_30 + (1.4183875322341919) * gru_0_out_t1_31 + (-0.31072995066642761) * gru_0_out_t1_32 + (0.041240468621253967) * gru_0_out_t1_33 + (-0.44501224160194397) * gru_0_out_t1_34 + (0.13489139080047607) * gru_0_out_t1_35 + (-0.3802039623260498) * gru_0_out_t1_36 + (0.44867396354675293) * gru_0_out_t1_37 + (-0.13104119896888733) * gru_0_out_t1_38 + (-0.38637632131576538) * gru_0_out_t1_39 + (3.0194530487060547) * gru_0_out_t1_40 + (-0.31058061122894287) * gru_0_out_t1_41 + (-0.37162059545516968) * gru_0_out_t1_42 + (0.25503495335578918) * gru_0_out_t1_43 + (-0.67699432373046875) * gru_0_out_t1_44 + (-2.6132040023803711) * gru_0_out_t1_45 + (-4.2873120307922363) * gru_0_out_t1_46 + (0.43747135996818542) * gru_0_out_t1_47 + (-0.055046122521162033) * gru_0_out_t1_48 + (-0.24431082606315613) * gru_0_out_t1_49 + (-0.20195411145687103) * gru_0_out_t1_50 + (-0.27531734108924866) * gru_0_out_t1_51 + (-0.1162588819861412) * gru_0_out_t1_52 + (0.043718867003917694) * gru_0_out_t1_53 + (1.123220682144165) * gru_0_out_t1_54 + (-0.48221501708030701) * gru_0_out_t1_55 + (-2.667670726776123) * gru_0_out_t1_56 + (-0.2941209077835083) * gru_0_out_t1_57 + (0.55179321765899658) * gru_0_out_t1_58 + (-4.1740527153015137) * gru_0_out_t1_59 + (0.85722410678863525) * gru_0_out_t1_60 + (0.86690986156463623) * gru_0_out_t1_61 + (0.11539726704359055) * gru_0_out_t1_62 + (-0.96707421541213989) * gru_0_out_t1_63 + (-0.61436599493026733) * gru_1_fwd_t0_h_0 + (0.44080919027328491) * gru_1_fwd_t0_h_1 + (-0.48235085606575012) * gru_1_fwd_t0_h_2 + (-0.49386709928512573) * gru_1_fwd_t0_h_3 + (-1.1748334169387817) * gru_1_fwd_t0_h_4 + (1.4584587812423706) * gru_1_fwd_t0_h_5 + (0.38690704107284546) * gru_1_fwd_t0_h_6 + (-0.45707559585571289) * gru_1_fwd_t0_h_7 + (-0.17846176028251648) * gru_1_fwd_t0_h_8 + (-0.21318328380584717) * gru_1_fwd_t0_h_9 + (-0.61539387702941895) * gru_1_fwd_t0_h_10 + (-0.40382620692253113) * gru_1_fwd_t0_h_11 + (-0.20002022385597229) * gru_1_fwd_t0_h_12 + (2.8420925140380859) * gru_1_fwd_t0_h_13 + (0.20315040647983551) * gru_1_fwd_t0_h_14 + (-1.2480728626251221) * gru_1_fwd_t0_h_15 + (0.10917195677757263) * gru_1_fwd_t0_h_16 + (0.11197753995656967) * gru_1_fwd_t0_h_17 + (0.31522572040557861) * gru_1_fwd_t0_h_18 + (-0.69235688447952271) * gru_1_fwd_t0_h_19 + (-0.065415553748607635) * gru_1_fwd_t0_h_20 + (0.077324323356151581) * gru_1_fwd_t0_h_21 + (-0.12152609974145889) * gru_1_fwd_t0_h_22 + (0.80269205570220947) * gru_1_fwd_t0_h_23 + (-3.3419895172119141) * gru_1_fwd_t0_h_24 + (0.16012333333492279) * gru_1_fwd_t0_h_25 + (1.0432395935058594) * gru_1_fwd_t0_h_26 + (-1.8395140171051025) * gru_1_fwd_t0_h_27 + (-0.5039067268371582) * gru_1_fwd_t0_h_28 + (0.55184352397918701) * gru_1_fwd_t0_h_29 + (-0.55008184909820557) * gru_1_fwd_t0_h_30 + (0.36071956157684326) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((0.81773966550827026) + (0.17128559947013855) * gru_0_out_t1_0 + (-0.51793885231018066) * gru_0_out_t1_1 + (0.51331305503845215) * gru_0_out_t1_2 + (-0.44945234060287476) * gru_0_out_t1_3 + (0.13168874382972717) * gru_0_out_t1_4 + (0.016976071521639824) * gru_0_out_t1_5 + (1.5168601274490356) * gru_0_out_t1_6 + (-0.71693128347396851) * gru_0_out_t1_7 + (0.15520215034484863) * gru_0_out_t1_8 + (-0.64068073034286499) * gru_0_out_t1_9 + (-0.66163694858551025) * gru_0_out_t1_10 + (0.49458721280097961) * gru_0_out_t1_11 + (0.018319370225071907) * gru_0_out_t1_12 + (0.17013433575630188) * gru_0_out_t1_13 + (0.37342756986618042) * gru_0_out_t1_14 + (-0.02631581574678421) * gru_0_out_t1_15 + (-0.10172482579946518) * gru_0_out_t1_16 + (-0.43277004361152649) * gru_0_out_t1_17 + (-0.14652739465236664) * gru_0_out_t1_18 + (-0.44512426853179932) * gru_0_out_t1_19 + (0.13564082980155945) * gru_0_out_t1_20 + (-0.78439807891845703) * gru_0_out_t1_21 + (-0.015992544591426849) * gru_0_out_t1_22 + (-0.55673116445541382) * gru_0_out_t1_23 + (-0.49685096740722656) * gru_0_out_t1_24 + (-0.25559842586517334) * gru_0_out_t1_25 + (0.025627493858337402) * gru_0_out_t1_26 + (0.076091594994068146) * gru_0_out_t1_27 + (-0.25891414284706116) * gru_0_out_t1_28 + (0.13967178761959076) * gru_0_out_t1_29 + (0.1750156432390213) * gru_0_out_t1_30 + (0.051146168261766434) * gru_0_out_t1_31 + (-0.66478806734085083) * gru_0_out_t1_32 + (-0.055683236569166183) * gru_0_out_t1_33 + (0.16161510348320007) * gru_0_out_t1_34 + (0.34235835075378418) * gru_0_out_t1_35 + (-0.37824755907058716) * gru_0_out_t1_36 + (0.058202415704727173) * gru_0_out_t1_37 + (-0.18683938682079315) * gru_0_out_t1_38 + (-0.22148546576499939) * gru_0_out_t1_39 + (2.8642311096191406) * gru_0_out_t1_40 + (0.051959097385406494) * gru_0_out_t1_41 + (0.049915306270122528) * gru_0_out_t1_42 + (-0.239407017827034) * gru_0_out_t1_43 + (0.27826902270317078) * gru_0_out_t1_44 + (0.085136577486991882) * gru_0_out_t1_45 + (-0.041466694325208664) * gru_0_out_t1_46 + (-0.1715027391910553) * gru_0_out_t1_47 + (-0.18039460480213165) * gru_0_out_t1_48 + (-0.19996148347854614) * gru_0_out_t1_49 + (-0.35861837863922119) * gru_0_out_t1_50 + (0.024664273485541344) * gru_0_out_t1_51 + (0.29042401909828186) * gru_0_out_t1_52 + (0.25259080529212952) * gru_0_out_t1_53 + (0.21901717782020569) * gru_0_out_t1_54 + (0.35172504186630249) * gru_0_out_t1_55 + (0.21156875789165497) * gru_0_out_t1_56 + (-0.5028001070022583) * gru_0_out_t1_57 + (0.17370127141475677) * gru_0_out_t1_58 + (-0.15604369342327118) * gru_0_out_t1_59 + (0.3632272481918335) * gru_0_out_t1_60 + (0.5702512264251709) * gru_0_out_t1_61 + (-0.28417560458183289) * gru_0_out_t1_62 + (0.22897376120090485) * gru_0_out_t1_63 + (0.39468196034431458) * gru_1_fwd_t0_h_0 + (-0.14721629023551941) * gru_1_fwd_t0_h_1 + (-0.14268027245998383) * gru_1_fwd_t0_h_2 + (0.5336032509803772) * gru_1_fwd_t0_h_3 + (0.061225499957799911) * gru_1_fwd_t0_h_4 + (0.11972998827695847) * gru_1_fwd_t0_h_5 + (0.44489341974258423) * gru_1_fwd_t0_h_6 + (-0.20280379056930542) * gru_1_fwd_t0_h_7 + (0.031419336795806885) * gru_1_fwd_t0_h_8 + (0.25528791546821594) * gru_1_fwd_t0_h_9 + (0.67770892381668091) * gru_1_fwd_t0_h_10 + (1.595887303352356) * gru_1_fwd_t0_h_11 + (0.15991699695587158) * gru_1_fwd_t0_h_12 + (0.43232199549674988) * gru_1_fwd_t0_h_13 + (-0.16868048906326294) * gru_1_fwd_t0_h_14 + (0.30507537722587585) * gru_1_fwd_t0_h_15 + (-0.15547291934490204) * gru_1_fwd_t0_h_16 + (-0.11896631121635437) * gru_1_fwd_t0_h_17 + (0.12108030170202255) * gru_1_fwd_t0_h_18 + (-0.29632341861724854) * gru_1_fwd_t0_h_19 + (0.22881783545017242) * gru_1_fwd_t0_h_20 + (0.024817664176225662) * gru_1_fwd_t0_h_21 + (-0.92640131711959839) * gru_1_fwd_t0_h_22 + (-0.10434645414352417) * gru_1_fwd_t0_h_23 + (-0.32338699698448181) * gru_1_fwd_t0_h_24 + (1.0961728096008301) * gru_1_fwd_t0_h_25 + (0.24012205004692078) * gru_1_fwd_t0_h_26 + (-0.56309175491333008) * gru_1_fwd_t0_h_27 + (-0.38263919949531555) * gru_1_fwd_t0_h_28 + (0.29432976245880127) * gru_1_fwd_t0_h_29 + (-0.5445786714553833) * gru_1_fwd_t0_h_30 + (-0.02663467638194561) * gru_1_fwd_t0_h_31);
    gate_n = tanh((0.17851637303829193) + (0.14289499819278717) * gru_0_out_t1_0 + (0.16936215758323669) * gru_0_out_t1_1 + (0.50309932231903076) * gru_0_out_t1_2 + (-0.18246500194072723) * gru_0_out_t1_3 + (0.10168271511793137) * gru_0_out_t1_4 + (0.54029220342636108) * gru_0_out_t1_5 + (-1.9932767152786255) * gru_0_out_t1_6 + (-0.36201292276382446) * gru_0_out_t1_7 + (0.25891381502151489) * gru_0_out_t1_8 + (1.9638186693191528) * gru_0_out_t1_9 + (-0.36765179038047791) * gru_0_out_t1_10 + (0.0019499900517985225) * gru_0_out_t1_11 + (0.056114867329597473) * gru_0_out_t1_12 + (-0.58612453937530518) * gru_0_out_t1_13 + (-0.18934787809848785) * gru_0_out_t1_14 + (-0.020162424072623253) * gru_0_out_t1_15 + (0.050897553563117981) * gru_0_out_t1_16 + (0.067513041198253632) * gru_0_out_t1_17 + (0.073611602187156677) * gru_0_out_t1_18 + (-1.5869557857513428) * gru_0_out_t1_19 + (2.5913383960723877) * gru_0_out_t1_20 + (-0.033429812639951706) * gru_0_out_t1_21 + (-0.28313186764717102) * gru_0_out_t1_22 + (-0.047054562717676163) * gru_0_out_t1_23 + (-0.52044552564620972) * gru_0_out_t1_24 + (-0.42122718691825867) * gru_0_out_t1_25 + (0.0084508629515767097) * gru_0_out_t1_26 + (0.24854691326618195) * gru_0_out_t1_27 + (-0.97305792570114136) * gru_0_out_t1_28 + (0.52897018194198608) * gru_0_out_t1_29 + (0.11280126124620438) * gru_0_out_t1_30 + (0.31845730543136597) * gru_0_out_t1_31 + (0.16383849084377289) * gru_0_out_t1_32 + (-0.18815319240093231) * gru_0_out_t1_33 + (0.19882600009441376) * gru_0_out_t1_34 + (0.67761373519897461) * gru_0_out_t1_35 + (0.15303881466388702) * gru_0_out_t1_36 + (0.45678576827049255) * gru_0_out_t1_37 + (-0.073499426245689392) * gru_0_out_t1_38 + (1.6164712905883789) * gru_0_out_t1_39 + (-0.9342275857925415) * gru_0_out_t1_40 + (-0.10331630706787109) * gru_0_out_t1_41 + (0.579814612865448) * gru_0_out_t1_42 + (-0.19202439486980438) * gru_0_out_t1_43 + (-0.13954652845859528) * gru_0_out_t1_44 + (0.13703949749469757) * gru_0_out_t1_45 + (0.74812281131744385) * gru_0_out_t1_46 + (0.21106395125389099) * gru_0_out_t1_47 + (-0.19199571013450623) * gru_0_out_t1_48 + (0.082236967980861664) * gru_0_out_t1_49 + (-0.17156831920146942) * gru_0_out_t1_50 + (-0.12784421443939209) * gru_0_out_t1_51 + (-0.21391257643699646) * gru_0_out_t1_52 + (-0.21236398816108704) * gru_0_out_t1_53 + (0.011413926258683205) * gru_0_out_t1_54 + (-0.42029207944869995) * gru_0_out_t1_55 + (0.24968110024929047) * gru_0_out_t1_56 + (-0.27038609981536865) * gru_0_out_t1_57 + (0.12691529095172882) * gru_0_out_t1_58 + (0.20633998513221741) * gru_0_out_t1_59 + (0.097483158111572266) * gru_0_out_t1_60 + (0.19520801305770874) * gru_0_out_t1_61 + (1.0024480819702148) * gru_0_out_t1_62 + (-0.53255677223205566) * gru_0_out_t1_63 + gate_r * ((-0.35194575786590576) + (-0.45696541666984558) * gru_1_fwd_t0_h_0 + (-0.65750789642333984) * gru_1_fwd_t0_h_1 + (0.23430661857128143) * gru_1_fwd_t0_h_2 + (-0.0047439867630600929) * gru_1_fwd_t0_h_3 + (-0.0060073747299611568) * gru_1_fwd_t0_h_4 + (-0.68213802576065063) * gru_1_fwd_t0_h_5 + (-0.41535043716430664) * gru_1_fwd_t0_h_6 + (0.015719737857580185) * gru_1_fwd_t0_h_7 + (-0.030802538618445396) * gru_1_fwd_t0_h_8 + (-0.040794104337692261) * gru_1_fwd_t0_h_9 + (-0.07798420637845993) * gru_1_fwd_t0_h_10 + (0.15590459108352661) * gru_1_fwd_t0_h_11 + (0.16182461380958557) * gru_1_fwd_t0_h_12 + (-0.32864117622375488) * gru_1_fwd_t0_h_13 + (0.15254636108875275) * gru_1_fwd_t0_h_14 + (0.49963536858558655) * gru_1_fwd_t0_h_15 + (-0.069818541407585144) * gru_1_fwd_t0_h_16 + (0.19067126512527466) * gru_1_fwd_t0_h_17 + (0.96171349287033081) * gru_1_fwd_t0_h_18 + (0.21743594110012054) * gru_1_fwd_t0_h_19 + (-0.17560100555419922) * gru_1_fwd_t0_h_20 + (0.068666264414787292) * gru_1_fwd_t0_h_21 + (0.4168703556060791) * gru_1_fwd_t0_h_22 + (-0.72557055950164795) * gru_1_fwd_t0_h_23 + (-0.86604911088943481) * gru_1_fwd_t0_h_24 + (-0.86029863357543945) * gru_1_fwd_t0_h_25 + (1.7546672821044922) * gru_1_fwd_t0_h_26 + (0.16154970228672028) * gru_1_fwd_t0_h_27 + (-0.13596808910369873) * gru_1_fwd_t0_h_28 + (0.032455042004585266) * gru_1_fwd_t0_h_29 + (-1.4149153232574463) * gru_1_fwd_t0_h_30 + (0.62882614135742188) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_30 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_30;
    // h=31
    gate_r = sigmoid((0.20967334508895874) + (-0.29990220069885254) * gru_0_out_t1_0 + (0.19239795207977295) * gru_0_out_t1_1 + (-0.26743611693382263) * gru_0_out_t1_2 + (-0.62649214267730713) * gru_0_out_t1_3 + (0.68589323759078979) * gru_0_out_t1_4 + (-0.014664245769381523) * gru_0_out_t1_5 + (-0.31357425451278687) * gru_0_out_t1_6 + (-0.10155487805604935) * gru_0_out_t1_7 + (-0.04959607869386673) * gru_0_out_t1_8 + (0.63405925035476685) * gru_0_out_t1_9 + (-0.30301511287689209) * gru_0_out_t1_10 + (0.35798567533493042) * gru_0_out_t1_11 + (-0.27502909302711487) * gru_0_out_t1_12 + (0.11775603145360947) * gru_0_out_t1_13 + (-0.15030418336391449) * gru_0_out_t1_14 + (0.12721797823905945) * gru_0_out_t1_15 + (0.48690655827522278) * gru_0_out_t1_16 + (-0.15891537070274353) * gru_0_out_t1_17 + (0.083171702921390533) * gru_0_out_t1_18 + (-1.9511686563491821) * gru_0_out_t1_19 + (0.49278438091278076) * gru_0_out_t1_20 + (0.09223068505525589) * gru_0_out_t1_21 + (-0.48359030485153198) * gru_0_out_t1_22 + (0.34708014130592346) * gru_0_out_t1_23 + (-0.30659160017967224) * gru_0_out_t1_24 + (-0.30823656916618347) * gru_0_out_t1_25 + (-0.39882442355155945) * gru_0_out_t1_26 + (9.6815827419050038e-05) * gru_0_out_t1_27 + (-0.42601487040519714) * gru_0_out_t1_28 + (-0.90354841947555542) * gru_0_out_t1_29 + (0.1208379715681076) * gru_0_out_t1_30 + (-0.77041679620742798) * gru_0_out_t1_31 + (0.93809503316879272) * gru_0_out_t1_32 + (0.16229765117168427) * gru_0_out_t1_33 + (0.31941649317741394) * gru_0_out_t1_34 + (-0.045119088143110275) * gru_0_out_t1_35 + (0.19085857272148132) * gru_0_out_t1_36 + (-0.086860403418540955) * gru_0_out_t1_37 + (0.027238396927714348) * gru_0_out_t1_38 + (0.49798467755317688) * gru_0_out_t1_39 + (-0.64532971382141113) * gru_0_out_t1_40 + (-0.083294875919818878) * gru_0_out_t1_41 + (0.20426000654697418) * gru_0_out_t1_42 + (-0.45308166742324829) * gru_0_out_t1_43 + (-0.0034623797982931137) * gru_0_out_t1_44 + (-0.1962042897939682) * gru_0_out_t1_45 + (0.31427952647209167) * gru_0_out_t1_46 + (-0.80603957176208496) * gru_0_out_t1_47 + (0.58460253477096558) * gru_0_out_t1_48 + (-0.21770013868808746) * gru_0_out_t1_49 + (-0.42251354455947876) * gru_0_out_t1_50 + (-0.35352548956871033) * gru_0_out_t1_51 + (-0.53871268033981323) * gru_0_out_t1_52 + (0.71781891584396362) * gru_0_out_t1_53 + (-2.6819026470184326) * gru_0_out_t1_54 + (-0.51425379514694214) * gru_0_out_t1_55 + (-0.13675147294998169) * gru_0_out_t1_56 + (-0.43949040770530701) * gru_0_out_t1_57 + (0.28085276484489441) * gru_0_out_t1_58 + (0.77072542905807495) * gru_0_out_t1_59 + (-0.49132651090621948) * gru_0_out_t1_60 + (0.3653409481048584) * gru_0_out_t1_61 + (0.75576895475387573) * gru_0_out_t1_62 + (-0.1192517951130867) * gru_0_out_t1_63 + (-0.1809026300907135) * gru_1_fwd_t0_h_0 + (-0.033703815191984177) * gru_1_fwd_t0_h_1 + (-0.00951346755027771) * gru_1_fwd_t0_h_2 + (-0.17121396958827972) * gru_1_fwd_t0_h_3 + (-0.74436593055725098) * gru_1_fwd_t0_h_4 + (1.3062326908111572) * gru_1_fwd_t0_h_5 + (-1.1980996131896973) * gru_1_fwd_t0_h_6 + (-0.51400047540664673) * gru_1_fwd_t0_h_7 + (0.10013008862733841) * gru_1_fwd_t0_h_8 + (0.090408407151699066) * gru_1_fwd_t0_h_9 + (0.21418322622776031) * gru_1_fwd_t0_h_10 + (0.069714032113552094) * gru_1_fwd_t0_h_11 + (-0.21528147161006927) * gru_1_fwd_t0_h_12 + (0.6108701229095459) * gru_1_fwd_t0_h_13 + (-0.40365278720855713) * gru_1_fwd_t0_h_14 + (-0.067411042749881744) * gru_1_fwd_t0_h_15 + (0.45934364199638367) * gru_1_fwd_t0_h_16 + (0.027161072939634323) * gru_1_fwd_t0_h_17 + (-0.16385954618453979) * gru_1_fwd_t0_h_18 + (-0.0067514772526919842) * gru_1_fwd_t0_h_19 + (0.32362991571426392) * gru_1_fwd_t0_h_20 + (0.18444579839706421) * gru_1_fwd_t0_h_21 + (0.096423111855983734) * gru_1_fwd_t0_h_22 + (1.1873027086257935) * gru_1_fwd_t0_h_23 + (0.46057096123695374) * gru_1_fwd_t0_h_24 + (0.10534723848104477) * gru_1_fwd_t0_h_25 + (-0.46146708726882935) * gru_1_fwd_t0_h_26 + (0.1269262433052063) * gru_1_fwd_t0_h_27 + (-0.12155076116323471) * gru_1_fwd_t0_h_28 + (-0.06298595666885376) * gru_1_fwd_t0_h_29 + (-0.0802726149559021) * gru_1_fwd_t0_h_30 + (0.17798225581645966) * gru_1_fwd_t0_h_31);
    gate_z = sigmoid((-1.5708490610122681) + (-0.52364081144332886) * gru_0_out_t1_0 + (-0.24127785861492157) * gru_0_out_t1_1 + (-1.9255368709564209) * gru_0_out_t1_2 + (-0.29298657178878784) * gru_0_out_t1_3 + (-0.12863631546497345) * gru_0_out_t1_4 + (0.26886558532714844) * gru_0_out_t1_5 + (-0.11590530723333359) * gru_0_out_t1_6 + (1.6646939516067505) * gru_0_out_t1_7 + (0.79181891679763794) * gru_0_out_t1_8 + (-0.77106618881225586) * gru_0_out_t1_9 + (2.0734095573425293) * gru_0_out_t1_10 + (0.10390692949295044) * gru_0_out_t1_11 + (-0.30964061617851257) * gru_0_out_t1_12 + (-0.034910280257463455) * gru_0_out_t1_13 + (-0.16313086450099945) * gru_0_out_t1_14 + (-0.69061791896820068) * gru_0_out_t1_15 + (0.28230005502700806) * gru_0_out_t1_16 + (-0.74474287033081055) * gru_0_out_t1_17 + (0.25261691212654114) * gru_0_out_t1_18 + (2.325453519821167) * gru_0_out_t1_19 + (-1.9211370944976807) * gru_0_out_t1_20 + (0.45446920394897461) * gru_0_out_t1_21 + (0.40475079417228699) * gru_0_out_t1_22 + (-0.2659313976764679) * gru_0_out_t1_23 + (1.3477935791015625) * gru_0_out_t1_24 + (0.14540131390094757) * gru_0_out_t1_25 + (0.0052851513028144836) * gru_0_out_t1_26 + (-0.49886664748191833) * gru_0_out_t1_27 + (0.83104908466339111) * gru_0_out_t1_28 + (0.026456732302904129) * gru_0_out_t1_29 + (-0.64608162641525269) * gru_0_out_t1_30 + (-1.1802588701248169) * gru_0_out_t1_31 + (-0.37865176796913147) * gru_0_out_t1_32 + (0.11485591530799866) * gru_0_out_t1_33 + (0.2439369261264801) * gru_0_out_t1_34 + (-0.75955909490585327) * gru_0_out_t1_35 + (0.26272538304328918) * gru_0_out_t1_36 + (0.13270311057567596) * gru_0_out_t1_37 + (0.30327385663986206) * gru_0_out_t1_38 + (0.28111365437507629) * gru_0_out_t1_39 + (-2.9819467067718506) * gru_0_out_t1_40 + (-0.22869941592216492) * gru_0_out_t1_41 + (0.51670557260513306) * gru_0_out_t1_42 + (0.13505245745182037) * gru_0_out_t1_43 + (-0.31707146763801575) * gru_0_out_t1_44 + (-0.39577195048332214) * gru_0_out_t1_45 + (0.18859279155731201) * gru_0_out_t1_46 + (0.55429625511169434) * gru_0_out_t1_47 + (-0.13784430921077728) * gru_0_out_t1_48 + (-0.0028403862379491329) * gru_0_out_t1_49 + (-0.80398917198181152) * gru_0_out_t1_50 + (-0.13821184635162354) * gru_0_out_t1_51 + (-0.035888116806745529) * gru_0_out_t1_52 + (-0.99573326110839844) * gru_0_out_t1_53 + (0.29413333535194397) * gru_0_out_t1_54 + (0.14233855903148651) * gru_0_out_t1_55 + (-0.83636701107025146) * gru_0_out_t1_56 + (-0.023530829697847366) * gru_0_out_t1_57 + (-0.41732168197631836) * gru_0_out_t1_58 + (-0.21330302953720093) * gru_0_out_t1_59 + (0.8921431303024292) * gru_0_out_t1_60 + (-0.87944042682647705) * gru_0_out_t1_61 + (-0.39166903495788574) * gru_0_out_t1_62 + (0.58020478487014771) * gru_0_out_t1_63 + (-0.57574981451034546) * gru_1_fwd_t0_h_0 + (1.6215771436691284) * gru_1_fwd_t0_h_1 + (-0.34320369362831116) * gru_1_fwd_t0_h_2 + (-0.49578666687011719) * gru_1_fwd_t0_h_3 + (0.27507570385932922) * gru_1_fwd_t0_h_4 + (-1.1861916780471802) * gru_1_fwd_t0_h_5 + (0.17442318797111511) * gru_1_fwd_t0_h_6 + (0.49565953016281128) * gru_1_fwd_t0_h_7 + (0.30514419078826904) * gru_1_fwd_t0_h_8 + (0.68545526266098022) * gru_1_fwd_t0_h_9 + (-0.015728786587715149) * gru_1_fwd_t0_h_10 + (2.0072088241577148) * gru_1_fwd_t0_h_11 + (-0.083062402904033661) * gru_1_fwd_t0_h_12 + (0.39044469594955444) * gru_1_fwd_t0_h_13 + (0.23526749014854431) * gru_1_fwd_t0_h_14 + (-0.086912460625171661) * gru_1_fwd_t0_h_15 + (0.19192121922969818) * gru_1_fwd_t0_h_16 + (0.74911558628082275) * gru_1_fwd_t0_h_17 + (-0.14681941270828247) * gru_1_fwd_t0_h_18 + (0.3123525083065033) * gru_1_fwd_t0_h_19 + (0.19948874413967133) * gru_1_fwd_t0_h_20 + (-0.27458778023719788) * gru_1_fwd_t0_h_21 + (-0.46526089310646057) * gru_1_fwd_t0_h_22 + (1.14471435546875) * gru_1_fwd_t0_h_23 + (-0.58947557210922241) * gru_1_fwd_t0_h_24 + (-0.35406193137168884) * gru_1_fwd_t0_h_25 + (-1.3951840400695801) * gru_1_fwd_t0_h_26 + (0.57051306962966919) * gru_1_fwd_t0_h_27 + (0.084670968353748322) * gru_1_fwd_t0_h_28 + (0.42024078965187073) * gru_1_fwd_t0_h_29 + (-0.37332999706268311) * gru_1_fwd_t0_h_30 + (0.042901366949081421) * gru_1_fwd_t0_h_31);
    gate_n = tanh((-0.027732593938708305) + (-0.14300656318664551) * gru_0_out_t1_0 + (-0.08473842591047287) * gru_0_out_t1_1 + (0.21244299411773682) * gru_0_out_t1_2 + (-0.080064944922924042) * gru_0_out_t1_3 + (-0.28786370158195496) * gru_0_out_t1_4 + (0.094129391014575958) * gru_0_out_t1_5 + (-0.036121316254138947) * gru_0_out_t1_6 + (-0.22730052471160889) * gru_0_out_t1_7 + (-0.16333964467048645) * gru_0_out_t1_8 + (-0.45304316282272339) * gru_0_out_t1_9 + (-0.072136290371417999) * gru_0_out_t1_10 + (0.35763850808143616) * gru_0_out_t1_11 + (-0.0019672720227390528) * gru_0_out_t1_12 + (-0.027877481654286385) * gru_0_out_t1_13 + (-0.31174606084823608) * gru_0_out_t1_14 + (0.10973086953163147) * gru_0_out_t1_15 + (-0.021004060283303261) * gru_0_out_t1_16 + (0.15650467574596405) * gru_0_out_t1_17 + (-0.058733168989419937) * gru_0_out_t1_18 + (-0.54861831665039062) * gru_0_out_t1_19 + (-0.33014219999313354) * gru_0_out_t1_20 + (0.18220792710781097) * gru_0_out_t1_21 + (0.11679074913263321) * gru_0_out_t1_22 + (-0.35005933046340942) * gru_0_out_t1_23 + (-0.14914911985397339) * gru_0_out_t1_24 + (-0.76734685897827148) * gru_0_out_t1_25 + (0.051192678511142731) * gru_0_out_t1_26 + (0.10329507291316986) * gru_0_out_t1_27 + (-0.10266322642564774) * gru_0_out_t1_28 + (0.77014082670211792) * gru_0_out_t1_29 + (-1.0773215293884277) * gru_0_out_t1_30 + (0.1286233514547348) * gru_0_out_t1_31 + (0.26050376892089844) * gru_0_out_t1_32 + (-0.53916555643081665) * gru_0_out_t1_33 + (0.2894720733165741) * gru_0_out_t1_34 + (-0.47400009632110596) * gru_0_out_t1_35 + (-0.091160140931606293) * gru_0_out_t1_36 + (0.069460429251194) * gru_0_out_t1_37 + (-0.15595392882823944) * gru_0_out_t1_38 + (-0.0018634696025401354) * gru_0_out_t1_39 + (-0.061337418854236603) * gru_0_out_t1_40 + (0.05213320255279541) * gru_0_out_t1_41 + (-0.42697620391845703) * gru_0_out_t1_42 + (0.28156614303588867) * gru_0_out_t1_43 + (0.042865462601184845) * gru_0_out_t1_44 + (-0.16251970827579498) * gru_0_out_t1_45 + (-0.35042855143547058) * gru_0_out_t1_46 + (-0.54185616970062256) * gru_0_out_t1_47 + (-0.21947178244590759) * gru_0_out_t1_48 + (0.38353753089904785) * gru_0_out_t1_49 + (0.0043533858843147755) * gru_0_out_t1_50 + (0.32753312587738037) * gru_0_out_t1_51 + (-0.29348239302635193) * gru_0_out_t1_52 + (0.50983858108520508) * gru_0_out_t1_53 + (0.080752424895763397) * gru_0_out_t1_54 + (0.072130724787712097) * gru_0_out_t1_55 + (-0.13460832834243774) * gru_0_out_t1_56 + (0.36010941863059998) * gru_0_out_t1_57 + (-0.074413403868675232) * gru_0_out_t1_58 + (-0.12156960368156433) * gru_0_out_t1_59 + (0.004703400656580925) * gru_0_out_t1_60 + (0.11808716505765915) * gru_0_out_t1_61 + (-0.6021302342414856) * gru_0_out_t1_62 + (-0.91609400510787964) * gru_0_out_t1_63 + gate_r * ((0.12262941151857376) + (0.057252276688814163) * gru_1_fwd_t0_h_0 + (0.039879586547613144) * gru_1_fwd_t0_h_1 + (0.018536834046244621) * gru_1_fwd_t0_h_2 + (0.64742529392242432) * gru_1_fwd_t0_h_3 + (-0.18314000964164734) * gru_1_fwd_t0_h_4 + (-0.37682139873504639) * gru_1_fwd_t0_h_5 + (-0.30979776382446289) * gru_1_fwd_t0_h_6 + (0.23698128759860992) * gru_1_fwd_t0_h_7 + (-0.091686457395553589) * gru_1_fwd_t0_h_8 + (0.040832266211509705) * gru_1_fwd_t0_h_9 + (-0.25267067551612854) * gru_1_fwd_t0_h_10 + (0.086815588176250458) * gru_1_fwd_t0_h_11 + (-0.0096743907779455185) * gru_1_fwd_t0_h_12 + (0.058526713401079178) * gru_1_fwd_t0_h_13 + (-0.17420612275600433) * gru_1_fwd_t0_h_14 + (-0.03177221491932869) * gru_1_fwd_t0_h_15 + (0.051403425633907318) * gru_1_fwd_t0_h_16 + (-0.093971900641918182) * gru_1_fwd_t0_h_17 + (0.043977741152048111) * gru_1_fwd_t0_h_18 + (-0.29037961363792419) * gru_1_fwd_t0_h_19 + (-0.33840790390968323) * gru_1_fwd_t0_h_20 + (0.13710835576057434) * gru_1_fwd_t0_h_21 + (-0.085579767823219299) * gru_1_fwd_t0_h_22 + (0.057670138776302338) * gru_1_fwd_t0_h_23 + (0.097161531448364258) * gru_1_fwd_t0_h_24 + (-0.083818145096302032) * gru_1_fwd_t0_h_25 + (0.015383318997919559) * gru_1_fwd_t0_h_26 + (0.031158596277236938) * gru_1_fwd_t0_h_27 + (-0.16118171811103821) * gru_1_fwd_t0_h_28 + (-0.14433081448078156) * gru_1_fwd_t0_h_29 + (-0.07113974541425705) * gru_1_fwd_t0_h_30 + (-0.47427299618721008) * gru_1_fwd_t0_h_31));
    gru_1_fwd_t1_h_31 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t0_h_31;

    // FW step t=2
    // h=0
    gate_r = sigmoid((0.92290431261062622) + (1.1045633554458618) * gru_0_out_t2_0 + (-0.2133268415927887) * gru_0_out_t2_1 + (0.16065214574337006) * gru_0_out_t2_2 + (-0.71245211362838745) * gru_0_out_t2_3 + (0.028422756120562553) * gru_0_out_t2_4 + (0.64177036285400391) * gru_0_out_t2_5 + (0.47260215878486633) * gru_0_out_t2_6 + (0.22205697000026703) * gru_0_out_t2_7 + (-0.20081166923046112) * gru_0_out_t2_8 + (-0.17624849081039429) * gru_0_out_t2_9 + (-0.30159914493560791) * gru_0_out_t2_10 + (0.58505105972290039) * gru_0_out_t2_11 + (-0.18798148632049561) * gru_0_out_t2_12 + (0.39401087164878845) * gru_0_out_t2_13 + (-0.27783262729644775) * gru_0_out_t2_14 + (-1.3736021518707275) * gru_0_out_t2_15 + (-0.33441537618637085) * gru_0_out_t2_16 + (-0.097843743860721588) * gru_0_out_t2_17 + (-0.78705054521560669) * gru_0_out_t2_18 + (-0.60388648509979248) * gru_0_out_t2_19 + (-0.10964680463075638) * gru_0_out_t2_20 + (-0.21744340658187866) * gru_0_out_t2_21 + (0.10899338126182556) * gru_0_out_t2_22 + (-0.0017179554561153054) * gru_0_out_t2_23 + (-0.65444493293762207) * gru_0_out_t2_24 + (0.81407082080841064) * gru_0_out_t2_25 + (-2.3913583755493164) * gru_0_out_t2_26 + (-0.59948593378067017) * gru_0_out_t2_27 + (1.8486552238464355) * gru_0_out_t2_28 + (0.73820418119430542) * gru_0_out_t2_29 + (0.91148179769515991) * gru_0_out_t2_30 + (0.42830204963684082) * gru_0_out_t2_31 + (1.0923470258712769) * gru_0_out_t2_32 + (0.055961038917303085) * gru_0_out_t2_33 + (-0.36855596303939819) * gru_0_out_t2_34 + (0.040452901273965836) * gru_0_out_t2_35 + (0.0073131341487169266) * gru_0_out_t2_36 + (0.67468506097793579) * gru_0_out_t2_37 + (0.19488053023815155) * gru_0_out_t2_38 + (-0.34015029668807983) * gru_0_out_t2_39 + (-0.26154735684394836) * gru_0_out_t2_40 + (0.063074536621570587) * gru_0_out_t2_41 + (1.6201909780502319) * gru_0_out_t2_42 + (0.046380024403333664) * gru_0_out_t2_43 + (0.028809642419219017) * gru_0_out_t2_44 + (0.35925427079200745) * gru_0_out_t2_45 + (0.15697577595710754) * gru_0_out_t2_46 + (-1.3027632236480713) * gru_0_out_t2_47 + (-0.31852549314498901) * gru_0_out_t2_48 + (0.60700899362564087) * gru_0_out_t2_49 + (0.76091420650482178) * gru_0_out_t2_50 + (0.61767661571502686) * gru_0_out_t2_51 + (0.46616986393928528) * gru_0_out_t2_52 + (-0.69698280096054077) * gru_0_out_t2_53 + (0.25682902336120605) * gru_0_out_t2_54 + (-0.28471586108207703) * gru_0_out_t2_55 + (-0.44065222144126892) * gru_0_out_t2_56 + (-0.13848119974136353) * gru_0_out_t2_57 + (0.45502963662147522) * gru_0_out_t2_58 + (-1.7845675945281982) * gru_0_out_t2_59 + (0.68821680545806885) * gru_0_out_t2_60 + (0.80427300930023193) * gru_0_out_t2_61 + (-0.13378022611141205) * gru_0_out_t2_62 + (-0.37236344814300537) * gru_0_out_t2_63 + (-0.00048765793326310813) * gru_1_fwd_t1_h_0 + (0.24798299372196198) * gru_1_fwd_t1_h_1 + (-1.4829704761505127) * gru_1_fwd_t1_h_2 + (-0.27702322602272034) * gru_1_fwd_t1_h_3 + (-0.30148932337760925) * gru_1_fwd_t1_h_4 + (-1.8370332717895508) * gru_1_fwd_t1_h_5 + (-0.25477135181427002) * gru_1_fwd_t1_h_6 + (-0.24636177718639374) * gru_1_fwd_t1_h_7 + (0.12837120890617371) * gru_1_fwd_t1_h_8 + (-0.50453227758407593) * gru_1_fwd_t1_h_9 + (1.1101263761520386) * gru_1_fwd_t1_h_10 + (0.52118134498596191) * gru_1_fwd_t1_h_11 + (0.026840934529900551) * gru_1_fwd_t1_h_12 + (3.8707935810089111) * gru_1_fwd_t1_h_13 + (0.35285216569900513) * gru_1_fwd_t1_h_14 + (-0.6153988242149353) * gru_1_fwd_t1_h_15 + (-0.33351758122444153) * gru_1_fwd_t1_h_16 + (-0.30710908770561218) * gru_1_fwd_t1_h_17 + (0.047760602086782455) * gru_1_fwd_t1_h_18 + (0.22839462757110596) * gru_1_fwd_t1_h_19 + (-0.11993524432182312) * gru_1_fwd_t1_h_20 + (-3.3679022789001465) * gru_1_fwd_t1_h_21 + (0.88687258958816528) * gru_1_fwd_t1_h_22 + (-1.2424252033233643) * gru_1_fwd_t1_h_23 + (-1.3703998327255249) * gru_1_fwd_t1_h_24 + (1.3479937314987183) * gru_1_fwd_t1_h_25 + (-0.10286874324083328) * gru_1_fwd_t1_h_26 + (-1.7251091003417969) * gru_1_fwd_t1_h_27 + (1.530382513999939) * gru_1_fwd_t1_h_28 + (-0.067557595670223236) * gru_1_fwd_t1_h_29 + (-0.89855557680130005) * gru_1_fwd_t1_h_30 + (-0.44321313500404358) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((-0.27335548400878906) + (-0.00046041858149692416) * gru_0_out_t2_0 + (0.43551507592201233) * gru_0_out_t2_1 + (0.94652295112609863) * gru_0_out_t2_2 + (0.1180119588971138) * gru_0_out_t2_3 + (0.14282757043838501) * gru_0_out_t2_4 + (-0.22018459439277649) * gru_0_out_t2_5 + (-2.3974709510803223) * gru_0_out_t2_6 + (-1.3863810300827026) * gru_0_out_t2_7 + (0.23445062339305878) * gru_0_out_t2_8 + (-0.88761204481124878) * gru_0_out_t2_9 + (-1.0330084562301636) * gru_0_out_t2_10 + (0.251618891954422) * gru_0_out_t2_11 + (-0.12074483186006546) * gru_0_out_t2_12 + (-0.47108533978462219) * gru_0_out_t2_13 + (-0.011014214716851711) * gru_0_out_t2_14 + (-0.47825214266777039) * gru_0_out_t2_15 + (-0.10082999616861343) * gru_0_out_t2_16 + (-0.013769764453172684) * gru_0_out_t2_17 + (0.29466140270233154) * gru_0_out_t2_18 + (1.2545264959335327) * gru_0_out_t2_19 + (1.2807070016860962) * gru_0_out_t2_20 + (0.54824626445770264) * gru_0_out_t2_21 + (-0.74261903762817383) * gru_0_out_t2_22 + (0.062540128827095032) * gru_0_out_t2_23 + (-0.99730771780014038) * gru_0_out_t2_24 + (-0.030268354341387749) * gru_0_out_t2_25 + (-0.3203997015953064) * gru_0_out_t2_26 + (0.058124862611293793) * gru_0_out_t2_27 + (-1.9487055540084839) * gru_0_out_t2_28 + (-0.88585937023162842) * gru_0_out_t2_29 + (-0.22884136438369751) * gru_0_out_t2_30 + (2.0555384159088135) * gru_0_out_t2_31 + (0.25203666090965271) * gru_0_out_t2_32 + (0.36211672425270081) * gru_0_out_t2_33 + (-0.019749920815229416) * gru_0_out_t2_34 + (-0.16771245002746582) * gru_0_out_t2_35 + (0.10268975049257278) * gru_0_out_t2_36 + (0.16552738845348358) * gru_0_out_t2_37 + (0.10133104771375656) * gru_0_out_t2_38 + (-0.46199256181716919) * gru_0_out_t2_39 + (-0.94136816263198853) * gru_0_out_t2_40 + (0.046523485332727432) * gru_0_out_t2_41 + (-0.22029867768287659) * gru_0_out_t2_42 + (-0.071930713951587677) * gru_0_out_t2_43 + (-0.37160280346870422) * gru_0_out_t2_44 + (-0.39402055740356445) * gru_0_out_t2_45 + (0.012129510752856731) * gru_0_out_t2_46 + (0.14445243775844574) * gru_0_out_t2_47 + (-0.27260789275169373) * gru_0_out_t2_48 + (0.02906295470893383) * gru_0_out_t2_49 + (0.10711795836687088) * gru_0_out_t2_50 + (-0.31713837385177612) * gru_0_out_t2_51 + (-1.1477912664413452) * gru_0_out_t2_52 + (0.1162782683968544) * gru_0_out_t2_53 + (0.14245930314064026) * gru_0_out_t2_54 + (-0.13650105893611908) * gru_0_out_t2_55 + (-0.59119206666946411) * gru_0_out_t2_56 + (0.05715169757604599) * gru_0_out_t2_57 + (-0.34857755899429321) * gru_0_out_t2_58 + (0.80447930097579956) * gru_0_out_t2_59 + (0.34121733903884888) * gru_0_out_t2_60 + (0.044497359544038773) * gru_0_out_t2_61 + (0.082599639892578125) * gru_0_out_t2_62 + (-0.022663665935397148) * gru_0_out_t2_63 + (0.59845834970474243) * gru_1_fwd_t1_h_0 + (0.10520035773515701) * gru_1_fwd_t1_h_1 + (0.43809822201728821) * gru_1_fwd_t1_h_2 + (-0.1119224801659584) * gru_1_fwd_t1_h_3 + (0.24366055428981781) * gru_1_fwd_t1_h_4 + (-0.40749627351760864) * gru_1_fwd_t1_h_5 + (0.54930263757705688) * gru_1_fwd_t1_h_6 + (0.13647782802581787) * gru_1_fwd_t1_h_7 + (-0.64403241872787476) * gru_1_fwd_t1_h_8 + (-0.0049235285259783268) * gru_1_fwd_t1_h_9 + (0.38345205783843994) * gru_1_fwd_t1_h_10 + (0.39155158400535583) * gru_1_fwd_t1_h_11 + (0.0020860668737441301) * gru_1_fwd_t1_h_12 + (-0.0020011740271002054) * gru_1_fwd_t1_h_13 + (-0.32731983065605164) * gru_1_fwd_t1_h_14 + (-0.4094979465007782) * gru_1_fwd_t1_h_15 + (-0.60733562707901001) * gru_1_fwd_t1_h_16 + (0.40310630202293396) * gru_1_fwd_t1_h_17 + (0.49988049268722534) * gru_1_fwd_t1_h_18 + (0.1411546915769577) * gru_1_fwd_t1_h_19 + (-0.024866815656423569) * gru_1_fwd_t1_h_20 + (-0.032584246248006821) * gru_1_fwd_t1_h_21 + (0.087761864066123962) * gru_1_fwd_t1_h_22 + (-0.61184912919998169) * gru_1_fwd_t1_h_23 + (0.52182173728942871) * gru_1_fwd_t1_h_24 + (-0.025960085913538933) * gru_1_fwd_t1_h_25 + (-0.94178479909896851) * gru_1_fwd_t1_h_26 + (0.083306267857551575) * gru_1_fwd_t1_h_27 + (-0.57796961069107056) * gru_1_fwd_t1_h_28 + (-0.10754292458295822) * gru_1_fwd_t1_h_29 + (-0.23659531772136688) * gru_1_fwd_t1_h_30 + (0.93608367443084717) * gru_1_fwd_t1_h_31);
    gate_n = tanh((0.39123314619064331) + (0.19431978464126587) * gru_0_out_t2_0 + (-0.094584077596664429) * gru_0_out_t2_1 + (-0.29768466949462891) * gru_0_out_t2_2 + (-0.17392189800739288) * gru_0_out_t2_3 + (-0.21688064932823181) * gru_0_out_t2_4 + (0.32321906089782715) * gru_0_out_t2_5 + (-0.057221703231334686) * gru_0_out_t2_6 + (0.72595876455307007) * gru_0_out_t2_7 + (-0.26018118858337402) * gru_0_out_t2_8 + (0.28782129287719727) * gru_0_out_t2_9 + (-0.18370382487773895) * gru_0_out_t2_10 + (0.42337909340858459) * gru_0_out_t2_11 + (0.29480314254760742) * gru_0_out_t2_12 + (0.42220473289489746) * gru_0_out_t2_13 + (0.31645354628562927) * gru_0_out_t2_14 + (-0.12026351690292358) * gru_0_out_t2_15 + (-0.43513089418411255) * gru_0_out_t2_16 + (0.018173309043049812) * gru_0_out_t2_17 + (-0.040478266775608063) * gru_0_out_t2_18 + (-0.73264682292938232) * gru_0_out_t2_19 + (0.86033284664154053) * gru_0_out_t2_20 + (-0.12448019534349442) * gru_0_out_t2_21 + (1.000995397567749) * gru_0_out_t2_22 + (-0.21363067626953125) * gru_0_out_t2_23 + (-0.46598666906356812) * gru_0_out_t2_24 + (0.72014552354812622) * gru_0_out_t2_25 + (0.36778035759925842) * gru_0_out_t2_26 + (-0.50406694412231445) * gru_0_out_t2_27 + (-0.22420403361320496) * gru_0_out_t2_28 + (1.7060513496398926) * gru_0_out_t2_29 + (-1.2512500286102295) * gru_0_out_t2_30 + (-0.14651638269424438) * gru_0_out_t2_31 + (0.43895930051803589) * gru_0_out_t2_32 + (-0.0083406064659357071) * gru_0_out_t2_33 + (0.0010850004618987441) * gru_0_out_t2_34 + (0.021359767764806747) * gru_0_out_t2_35 + (0.070249602198600769) * gru_0_out_t2_36 + (-0.14353889226913452) * gru_0_out_t2_37 + (-0.30067735910415649) * gru_0_out_t2_38 + (0.6437874436378479) * gru_0_out_t2_39 + (0.58158755302429199) * gru_0_out_t2_40 + (1.3402148485183716) * gru_0_out_t2_41 + (0.24423687160015106) * gru_0_out_t2_42 + (0.43864667415618896) * gru_0_out_t2_43 + (0.070067480206489563) * gru_0_out_t2_44 + (-0.018586527556180954) * gru_0_out_t2_45 + (-0.67168509960174561) * gru_0_out_t2_46 + (-0.54887920618057251) * gru_0_out_t2_47 + (-0.29294431209564209) * gru_0_out_t2_48 + (0.34526950120925903) * gru_0_out_t2_49 + (0.26750260591506958) * gru_0_out_t2_50 + (0.96596884727478027) * gru_0_out_t2_51 + (0.16313986480236053) * gru_0_out_t2_52 + (0.17978483438491821) * gru_0_out_t2_53 + (-0.057877454906702042) * gru_0_out_t2_54 + (0.40616804361343384) * gru_0_out_t2_55 + (0.32692444324493408) * gru_0_out_t2_56 + (-0.18161624670028687) * gru_0_out_t2_57 + (-0.34009513258934021) * gru_0_out_t2_58 + (-0.24120001494884491) * gru_0_out_t2_59 + (-0.026615869253873825) * gru_0_out_t2_60 + (-0.074203573167324066) * gru_0_out_t2_61 + (-0.18763545155525208) * gru_0_out_t2_62 + (0.047078210860490799) * gru_0_out_t2_63 + gate_r * ((0.77060091495513916) + (0.42461302876472473) * gru_1_fwd_t1_h_0 + (0.18143285810947418) * gru_1_fwd_t1_h_1 + (-0.91265267133712769) * gru_1_fwd_t1_h_2 + (0.40925326943397522) * gru_1_fwd_t1_h_3 + (-0.44925269484519958) * gru_1_fwd_t1_h_4 + (0.38997045159339905) * gru_1_fwd_t1_h_5 + (-0.2331024706363678) * gru_1_fwd_t1_h_6 + (0.11838461458683014) * gru_1_fwd_t1_h_7 + (0.0263181421905756) * gru_1_fwd_t1_h_8 + (-0.16184759140014648) * gru_1_fwd_t1_h_9 + (-0.51561945676803589) * gru_1_fwd_t1_h_10 + (0.29407331347465515) * gru_1_fwd_t1_h_11 + (-0.055916938930749893) * gru_1_fwd_t1_h_12 + (0.43786811828613281) * gru_1_fwd_t1_h_13 + (0.20499828457832336) * gru_1_fwd_t1_h_14 + (-0.59562605619430542) * gru_1_fwd_t1_h_15 + (0.25508835911750793) * gru_1_fwd_t1_h_16 + (-0.2044098824262619) * gru_1_fwd_t1_h_17 + (-0.27653482556343079) * gru_1_fwd_t1_h_18 + (-0.50880205631256104) * gru_1_fwd_t1_h_19 + (-0.12128182500600815) * gru_1_fwd_t1_h_20 + (0.016028698533773422) * gru_1_fwd_t1_h_21 + (-0.017189545556902885) * gru_1_fwd_t1_h_22 + (-0.57745462656021118) * gru_1_fwd_t1_h_23 + (0.76263958215713501) * gru_1_fwd_t1_h_24 + (0.35228434205055237) * gru_1_fwd_t1_h_25 + (-0.15006327629089355) * gru_1_fwd_t1_h_26 + (-0.28062298893928528) * gru_1_fwd_t1_h_27 + (-0.34732541441917419) * gru_1_fwd_t1_h_28 + (-0.19124829769134521) * gru_1_fwd_t1_h_29 + (0.71982651948928833) * gru_1_fwd_t1_h_30 + (0.40859660506248474) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_0 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_0;
    // h=1
    gate_r = sigmoid((-0.70027840137481689) + (-0.22518432140350342) * gru_0_out_t2_0 + (0.32357168197631836) * gru_0_out_t2_1 + (0.30564495921134949) * gru_0_out_t2_2 + (-0.63086026906967163) * gru_0_out_t2_3 + (0.58409696817398071) * gru_0_out_t2_4 + (0.57274794578552246) * gru_0_out_t2_5 + (0.25124314427375793) * gru_0_out_t2_6 + (0.64587557315826416) * gru_0_out_t2_7 + (-0.40239343047142029) * gru_0_out_t2_8 + (0.25151556730270386) * gru_0_out_t2_9 + (1.5982394218444824) * gru_0_out_t2_10 + (0.66593581438064575) * gru_0_out_t2_11 + (-0.32349550724029541) * gru_0_out_t2_12 + (-0.12820850312709808) * gru_0_out_t2_13 + (-0.36099353432655334) * gru_0_out_t2_14 + (0.25929465889930725) * gru_0_out_t2_15 + (0.12030039727687836) * gru_0_out_t2_16 + (0.22822485864162445) * gru_0_out_t2_17 + (0.054334599524736404) * gru_0_out_t2_18 + (2.6427233219146729) * gru_0_out_t2_19 + (-1.4475501775741577) * gru_0_out_t2_20 + (0.19445428252220154) * gru_0_out_t2_21 + (2.3294155597686768) * gru_0_out_t2_22 + (-2.6403250694274902) * gru_0_out_t2_23 + (-2.2446932792663574) * gru_0_out_t2_24 + (0.72280663251876831) * gru_0_out_t2_25 + (-0.20329819619655609) * gru_0_out_t2_26 + (0.20219039916992188) * gru_0_out_t2_27 + (2.3565177917480469) * gru_0_out_t2_28 + (-0.2438591867685318) * gru_0_out_t2_29 + (-0.071536637842655182) * gru_0_out_t2_30 + (0.36003473401069641) * gru_0_out_t2_31 + (-1.2745753526687622) * gru_0_out_t2_32 + (0.24907796084880829) * gru_0_out_t2_33 + (-0.079657025635242462) * gru_0_out_t2_34 + (-0.92214673757553101) * gru_0_out_t2_35 + (-0.074366927146911621) * gru_0_out_t2_36 + (0.2038496732711792) * gru_0_out_t2_37 + (-0.44677823781967163) * gru_0_out_t2_38 + (1.6425158977508545) * gru_0_out_t2_39 + (3.0641646385192871) * gru_0_out_t2_40 + (-0.31896516680717468) * gru_0_out_t2_41 + (-0.27639520168304443) * gru_0_out_t2_42 + (0.1147574782371521) * gru_0_out_t2_43 + (-0.67748105525970459) * gru_0_out_t2_44 + (-0.12257138639688492) * gru_0_out_t2_45 + (0.58410447835922241) * gru_0_out_t2_46 + (0.53325343132019043) * gru_0_out_t2_47 + (-0.34689542651176453) * gru_0_out_t2_48 + (0.16989219188690186) * gru_0_out_t2_49 + (-0.49173128604888916) * gru_0_out_t2_50 + (0.07084096223115921) * gru_0_out_t2_51 + (0.15906542539596558) * gru_0_out_t2_52 + (-0.43373334407806396) * gru_0_out_t2_53 + (-0.09531690925359726) * gru_0_out_t2_54 + (0.061522968113422394) * gru_0_out_t2_55 + (-0.99706399440765381) * gru_0_out_t2_56 + (0.24552071094512939) * gru_0_out_t2_57 + (0.31430783867835999) * gru_0_out_t2_58 + (1.1770200729370117) * gru_0_out_t2_59 + (0.15546554327011108) * gru_0_out_t2_60 + (0.42079305648803711) * gru_0_out_t2_61 + (0.084392338991165161) * gru_0_out_t2_62 + (1.4237250089645386) * gru_0_out_t2_63 + (0.058108419179916382) * gru_1_fwd_t1_h_0 + (2.329561710357666) * gru_1_fwd_t1_h_1 + (-0.4964754581451416) * gru_1_fwd_t1_h_2 + (0.004796614870429039) * gru_1_fwd_t1_h_3 + (0.039509762078523636) * gru_1_fwd_t1_h_4 + (-0.7541351318359375) * gru_1_fwd_t1_h_5 + (1.010418176651001) * gru_1_fwd_t1_h_6 + (0.041833624243736267) * gru_1_fwd_t1_h_7 + (0.27651998400688171) * gru_1_fwd_t1_h_8 + (-0.19521725177764893) * gru_1_fwd_t1_h_9 + (1.2542259693145752) * gru_1_fwd_t1_h_10 + (0.2245793491601944) * gru_1_fwd_t1_h_11 + (-0.16257482767105103) * gru_1_fwd_t1_h_12 + (-0.89612340927124023) * gru_1_fwd_t1_h_13 + (-0.32158979773521423) * gru_1_fwd_t1_h_14 + (0.35263463854789734) * gru_1_fwd_t1_h_15 + (-0.38517656922340393) * gru_1_fwd_t1_h_16 + (-0.47764173150062561) * gru_1_fwd_t1_h_17 + (-0.086551561951637268) * gru_1_fwd_t1_h_18 + (-0.029328173026442528) * gru_1_fwd_t1_h_19 + (0.61516267061233521) * gru_1_fwd_t1_h_20 + (-1.3558006286621094) * gru_1_fwd_t1_h_21 + (0.12057483941316605) * gru_1_fwd_t1_h_22 + (-0.12082312256097794) * gru_1_fwd_t1_h_23 + (-1.3003363609313965) * gru_1_fwd_t1_h_24 + (0.4505336582660675) * gru_1_fwd_t1_h_25 + (-0.092312216758728027) * gru_1_fwd_t1_h_26 + (-0.51790159940719604) * gru_1_fwd_t1_h_27 + (1.3366760015487671) * gru_1_fwd_t1_h_28 + (0.37273317575454712) * gru_1_fwd_t1_h_29 + (-0.14862322807312012) * gru_1_fwd_t1_h_30 + (-1.1412676572799683) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((0.77038103342056274) + (0.24489060044288635) * gru_0_out_t2_0 + (-0.1775362640619278) * gru_0_out_t2_1 + (-0.37783050537109375) * gru_0_out_t2_2 + (-0.38833865523338318) * gru_0_out_t2_3 + (-0.093411169946193695) * gru_0_out_t2_4 + (1.2640342712402344) * gru_0_out_t2_5 + (0.20033217966556549) * gru_0_out_t2_6 + (0.069999195635318756) * gru_0_out_t2_7 + (0.064550995826721191) * gru_0_out_t2_8 + (1.2897717952728271) * gru_0_out_t2_9 + (-0.2548738420009613) * gru_0_out_t2_10 + (0.15947367250919342) * gru_0_out_t2_11 + (-0.42596033215522766) * gru_0_out_t2_12 + (0.1495421975851059) * gru_0_out_t2_13 + (0.084553822875022888) * gru_0_out_t2_14 + (-0.19631852209568024) * gru_0_out_t2_15 + (-0.085384920239448547) * gru_0_out_t2_16 + (0.12335345149040222) * gru_0_out_t2_17 + (-0.17779096961021423) * gru_0_out_t2_18 + (1.7875295877456665) * gru_0_out_t2_19 + (1.335243821144104) * gru_0_out_t2_20 + (0.58255654573440552) * gru_0_out_t2_21 + (1.0564762353897095) * gru_0_out_t2_22 + (-1.8371857404708862) * gru_0_out_t2_23 + (-0.10871656239032745) * gru_0_out_t2_24 + (-0.53597110509872437) * gru_0_out_t2_25 + (0.49144580960273743) * gru_0_out_t2_26 + (0.11390985548496246) * gru_0_out_t2_27 + (-1.1074849367141724) * gru_0_out_t2_28 + (-0.33506655693054199) * gru_0_out_t2_29 + (-0.30577602982521057) * gru_0_out_t2_30 + (1.5806097984313965) * gru_0_out_t2_31 + (0.19845192134380341) * gru_0_out_t2_32 + (-0.075386941432952881) * gru_0_out_t2_33 + (0.31186938285827637) * gru_0_out_t2_34 + (-0.093937434256076813) * gru_0_out_t2_35 + (0.12441937625408173) * gru_0_out_t2_36 + (-0.055479031056165695) * gru_0_out_t2_37 + (-0.4609297513961792) * gru_0_out_t2_38 + (-0.58919060230255127) * gru_0_out_t2_39 + (-0.50504618883132935) * gru_0_out_t2_40 + (-0.09708838164806366) * gru_0_out_t2_41 + (0.041393309831619263) * gru_0_out_t2_42 + (-0.4121364951133728) * gru_0_out_t2_43 + (-0.068712681531906128) * gru_0_out_t2_44 + (0.16381558775901794) * gru_0_out_t2_45 + (-0.0022179705556482077) * gru_0_out_t2_46 + (-0.14360980689525604) * gru_0_out_t2_47 + (0.10215239971876144) * gru_0_out_t2_48 + (-0.37685057520866394) * gru_0_out_t2_49 + (-0.070414081215858459) * gru_0_out_t2_50 + (-0.23371732234954834) * gru_0_out_t2_51 + (0.023022051900625229) * gru_0_out_t2_52 + (-0.031785439699888229) * gru_0_out_t2_53 + (-0.041236378252506256) * gru_0_out_t2_54 + (-0.10513702034950256) * gru_0_out_t2_55 + (-0.54306071996688843) * gru_0_out_t2_56 + (0.5017625093460083) * gru_0_out_t2_57 + (-0.14962303638458252) * gru_0_out_t2_58 + (-0.10072103887796402) * gru_0_out_t2_59 + (0.51168918609619141) * gru_0_out_t2_60 + (0.6920282244682312) * gru_0_out_t2_61 + (0.56562042236328125) * gru_0_out_t2_62 + (-0.22053413093090057) * gru_0_out_t2_63 + (0.25045657157897949) * gru_1_fwd_t1_h_0 + (-0.68272709846496582) * gru_1_fwd_t1_h_1 + (0.18206489086151123) * gru_1_fwd_t1_h_2 + (0.17762936651706696) * gru_1_fwd_t1_h_3 + (-0.10855237394571304) * gru_1_fwd_t1_h_4 + (-0.22970998287200928) * gru_1_fwd_t1_h_5 + (-0.20943531394004822) * gru_1_fwd_t1_h_6 + (-0.49372997879981995) * gru_1_fwd_t1_h_7 + (-0.14463967084884644) * gru_1_fwd_t1_h_8 + (-0.40174612402915955) * gru_1_fwd_t1_h_9 + (-0.28369486331939697) * gru_1_fwd_t1_h_10 + (0.11884106695652008) * gru_1_fwd_t1_h_11 + (-0.52869689464569092) * gru_1_fwd_t1_h_12 + (0.49349504709243774) * gru_1_fwd_t1_h_13 + (-0.22442436218261719) * gru_1_fwd_t1_h_14 + (1.0436092615127563) * gru_1_fwd_t1_h_15 + (-0.015210593119263649) * gru_1_fwd_t1_h_16 + (-0.011611516587436199) * gru_1_fwd_t1_h_17 + (0.52721792459487915) * gru_1_fwd_t1_h_18 + (0.14505510032176971) * gru_1_fwd_t1_h_19 + (0.63044530153274536) * gru_1_fwd_t1_h_20 + (0.11244993656873703) * gru_1_fwd_t1_h_21 + (1.5537668466567993) * gru_1_fwd_t1_h_22 + (0.55670106410980225) * gru_1_fwd_t1_h_23 + (1.1856895685195923) * gru_1_fwd_t1_h_24 + (0.12388496845960617) * gru_1_fwd_t1_h_25 + (-1.6448471546173096) * gru_1_fwd_t1_h_26 + (0.10663823038339615) * gru_1_fwd_t1_h_27 + (-0.062473852187395096) * gru_1_fwd_t1_h_28 + (0.10443691909313202) * gru_1_fwd_t1_h_29 + (1.1368736028671265) * gru_1_fwd_t1_h_30 + (0.42028522491455078) * gru_1_fwd_t1_h_31);
    gate_n = tanh((-0.2812190055847168) + (-0.18501707911491394) * gru_0_out_t2_0 + (-0.12492191046476364) * gru_0_out_t2_1 + (-0.48282048106193542) * gru_0_out_t2_2 + (0.4266129732131958) * gru_0_out_t2_3 + (0.18430374562740326) * gru_0_out_t2_4 + (-0.73433548212051392) * gru_0_out_t2_5 + (-0.73631113767623901) * gru_0_out_t2_6 + (-0.64574515819549561) * gru_0_out_t2_7 + (-0.38297629356384277) * gru_0_out_t2_8 + (0.45512565970420837) * gru_0_out_t2_9 + (-0.3071475625038147) * gru_0_out_t2_10 + (0.25616437196731567) * gru_0_out_t2_11 + (0.15791207551956177) * gru_0_out_t2_12 + (-0.09859156608581543) * gru_0_out_t2_13 + (-0.27521419525146484) * gru_0_out_t2_14 + (-0.1988920122385025) * gru_0_out_t2_15 + (0.21824513375759125) * gru_0_out_t2_16 + (-0.58295124769210815) * gru_0_out_t2_17 + (-0.63808280229568481) * gru_0_out_t2_18 + (-0.48877549171447754) * gru_0_out_t2_19 + (-0.35894477367401123) * gru_0_out_t2_20 + (0.060637902468442917) * gru_0_out_t2_21 + (0.025833399966359138) * gru_0_out_t2_22 + (0.89378505945205688) * gru_0_out_t2_23 + (0.41567882895469666) * gru_0_out_t2_24 + (-0.037401217967271805) * gru_0_out_t2_25 + (-0.50687336921691895) * gru_0_out_t2_26 + (-0.29360011219978333) * gru_0_out_t2_27 + (-0.99672520160675049) * gru_0_out_t2_28 + (0.32957702875137329) * gru_0_out_t2_29 + (0.39973968267440796) * gru_0_out_t2_30 + (0.56766992807388306) * gru_0_out_t2_31 + (-0.68671309947967529) * gru_0_out_t2_32 + (0.27257674932479858) * gru_0_out_t2_33 + (-0.047621805220842361) * gru_0_out_t2_34 + (-0.21050484478473663) * gru_0_out_t2_35 + (-0.16854815185070038) * gru_0_out_t2_36 + (0.028602557256817818) * gru_0_out_t2_37 + (0.11757426708936691) * gru_0_out_t2_38 + (0.60293668508529663) * gru_0_out_t2_39 + (-2.2362842559814453) * gru_0_out_t2_40 + (-0.52057498693466187) * gru_0_out_t2_41 + (1.4618779420852661) * gru_0_out_t2_42 + (-0.15928164124488831) * gru_0_out_t2_43 + (-0.48020997643470764) * gru_0_out_t2_44 + (-0.044084653258323669) * gru_0_out_t2_45 + (0.021879546344280243) * gru_0_out_t2_46 + (0.46162819862365723) * gru_0_out_t2_47 + (-0.18061167001724243) * gru_0_out_t2_48 + (0.07562592625617981) * gru_0_out_t2_49 + (-0.20155155658721924) * gru_0_out_t2_50 + (-0.18413941562175751) * gru_0_out_t2_51 + (0.41791576147079468) * gru_0_out_t2_52 + (-0.4354800283908844) * gru_0_out_t2_53 + (0.079184018075466156) * gru_0_out_t2_54 + (0.47410595417022705) * gru_0_out_t2_55 + (0.14362338185310364) * gru_0_out_t2_56 + (0.044051371514797211) * gru_0_out_t2_57 + (0.35349231958389282) * gru_0_out_t2_58 + (-0.073036178946495056) * gru_0_out_t2_59 + (-0.51809835433959961) * gru_0_out_t2_60 + (0.0053834305144846439) * gru_0_out_t2_61 + (-0.14705432951450348) * gru_0_out_t2_62 + (0.038098700344562531) * gru_0_out_t2_63 + gate_r * ((-0.43491771817207336) + (0.22717593610286713) * gru_1_fwd_t1_h_0 + (-1.640711784362793) * gru_1_fwd_t1_h_1 + (0.058801248669624329) * gru_1_fwd_t1_h_2 + (0.084008552134037018) * gru_1_fwd_t1_h_3 + (-0.71966195106506348) * gru_1_fwd_t1_h_4 + (0.028102850541472435) * gru_1_fwd_t1_h_5 + (-0.096582122147083282) * gru_1_fwd_t1_h_6 + (-0.29804244637489319) * gru_1_fwd_t1_h_7 + (0.094979368150234222) * gru_1_fwd_t1_h_8 + (0.24360485374927521) * gru_1_fwd_t1_h_9 + (0.39811053872108459) * gru_1_fwd_t1_h_10 + (0.049434557557106018) * gru_1_fwd_t1_h_11 + (0.035434439778327942) * gru_1_fwd_t1_h_12 + (-0.3799307644367218) * gru_1_fwd_t1_h_13 + (0.34547847509384155) * gru_1_fwd_t1_h_14 + (0.054025173187255859) * gru_1_fwd_t1_h_15 + (0.13873991370201111) * gru_1_fwd_t1_h_16 + (1.0794413089752197) * gru_1_fwd_t1_h_17 + (0.63782989978790283) * gru_1_fwd_t1_h_18 + (0.22147892415523529) * gru_1_fwd_t1_h_19 + (-0.22266033291816711) * gru_1_fwd_t1_h_20 + (-0.67676997184753418) * gru_1_fwd_t1_h_21 + (0.36093652248382568) * gru_1_fwd_t1_h_22 + (0.088556684553623199) * gru_1_fwd_t1_h_23 + (-0.435273677110672) * gru_1_fwd_t1_h_24 + (-0.60251402854919434) * gru_1_fwd_t1_h_25 + (-0.28600335121154785) * gru_1_fwd_t1_h_26 + (-0.45045197010040283) * gru_1_fwd_t1_h_27 + (-0.55714583396911621) * gru_1_fwd_t1_h_28 + (-0.20893697440624237) * gru_1_fwd_t1_h_29 + (-0.26471704244613647) * gru_1_fwd_t1_h_30 + (0.056924022734165192) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_1 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_1;
    // h=2
    gate_r = sigmoid((-0.80130773782730103) + (-0.100528784096241) * gru_0_out_t2_0 + (-0.32967126369476318) * gru_0_out_t2_1 + (-1.1889894008636475) * gru_0_out_t2_2 + (0.85434794425964355) * gru_0_out_t2_3 + (-0.029109988361597061) * gru_0_out_t2_4 + (0.82351845502853394) * gru_0_out_t2_5 + (2.9602882862091064) * gru_0_out_t2_6 + (0.80660271644592285) * gru_0_out_t2_7 + (-0.5042426586151123) * gru_0_out_t2_8 + (-2.3615262508392334) * gru_0_out_t2_9 + (1.4685114622116089) * gru_0_out_t2_10 + (0.48095569014549255) * gru_0_out_t2_11 + (0.073211319744586945) * gru_0_out_t2_12 + (-0.10180370509624481) * gru_0_out_t2_13 + (-0.15948349237442017) * gru_0_out_t2_14 + (0.042096503078937531) * gru_0_out_t2_15 + (0.38725593686103821) * gru_0_out_t2_16 + (0.53839683532714844) * gru_0_out_t2_17 + (0.70709323883056641) * gru_0_out_t2_18 + (-5.3833951950073242) * gru_0_out_t2_19 + (-5.0577640533447266) * gru_0_out_t2_20 + (-1.0346024036407471) * gru_0_out_t2_21 + (0.26058155298233032) * gru_0_out_t2_22 + (-0.47588759660720825) * gru_0_out_t2_23 + (2.1275923252105713) * gru_0_out_t2_24 + (1.6826300621032715) * gru_0_out_t2_25 + (-0.23277321457862854) * gru_0_out_t2_26 + (-1.5142252445220947) * gru_0_out_t2_27 + (3.5222656726837158) * gru_0_out_t2_28 + (-1.6155205965042114) * gru_0_out_t2_29 + (-0.4348844587802887) * gru_0_out_t2_30 + (-2.3938338756561279) * gru_0_out_t2_31 + (-0.033482268452644348) * gru_0_out_t2_32 + (0.41803348064422607) * gru_0_out_t2_33 + (0.94805604219436646) * gru_0_out_t2_34 + (-0.78205990791320801) * gru_0_out_t2_35 + (0.030733497813344002) * gru_0_out_t2_36 + (-0.17461836338043213) * gru_0_out_t2_37 + (-0.0048537030816078186) * gru_0_out_t2_38 + (-0.023821575567126274) * gru_0_out_t2_39 + (-3.2332377433776855) * gru_0_out_t2_40 + (-0.11836265027523041) * gru_0_out_t2_41 + (1.0609533786773682) * gru_0_out_t2_42 + (-0.32806643843650818) * gru_0_out_t2_43 + (-0.23137618601322174) * gru_0_out_t2_44 + (-0.13767676055431366) * gru_0_out_t2_45 + (0.34608623385429382) * gru_0_out_t2_46 + (0.44703960418701172) * gru_0_out_t2_47 + (-0.52609825134277344) * gru_0_out_t2_48 + (0.36009553074836731) * gru_0_out_t2_49 + (-0.12488983571529388) * gru_0_out_t2_50 + (0.30593332648277283) * gru_0_out_t2_51 + (0.083293244242668152) * gru_0_out_t2_52 + (0.2672882080078125) * gru_0_out_t2_53 + (-0.018082955852150917) * gru_0_out_t2_54 + (0.25229889154434204) * gru_0_out_t2_55 + (0.30516588687896729) * gru_0_out_t2_56 + (0.45220145583152771) * gru_0_out_t2_57 + (0.25455430150032043) * gru_0_out_t2_58 + (0.36614274978637695) * gru_0_out_t2_59 + (0.15735766291618347) * gru_0_out_t2_60 + (-0.21402230858802795) * gru_0_out_t2_61 + (-0.90059643983840942) * gru_0_out_t2_62 + (-0.21560972929000854) * gru_0_out_t2_63 + (0.29176518321037292) * gru_1_fwd_t1_h_0 + (0.55023294687271118) * gru_1_fwd_t1_h_1 + (-1.5755831003189087) * gru_1_fwd_t1_h_2 + (0.046943303197622299) * gru_1_fwd_t1_h_3 + (-0.065060734748840332) * gru_1_fwd_t1_h_4 + (0.088999129831790924) * gru_1_fwd_t1_h_5 + (-0.26341709494590759) * gru_1_fwd_t1_h_6 + (-0.31852802634239197) * gru_1_fwd_t1_h_7 + (-0.23358933627605438) * gru_1_fwd_t1_h_8 + (0.34375259280204773) * gru_1_fwd_t1_h_9 + (0.35962417721748352) * gru_1_fwd_t1_h_10 + (2.0903744697570801) * gru_1_fwd_t1_h_11 + (0.39759913086891174) * gru_1_fwd_t1_h_12 + (-0.5481831431388855) * gru_1_fwd_t1_h_13 + (0.28141248226165771) * gru_1_fwd_t1_h_14 + (-0.6815718412399292) * gru_1_fwd_t1_h_15 + (-0.17326280474662781) * gru_1_fwd_t1_h_16 + (-0.018815051764249802) * gru_1_fwd_t1_h_17 + (-0.80207931995391846) * gru_1_fwd_t1_h_18 + (0.62671923637390137) * gru_1_fwd_t1_h_19 + (0.25782200694084167) * gru_1_fwd_t1_h_20 + (-0.027612673118710518) * gru_1_fwd_t1_h_21 + (-0.79628229141235352) * gru_1_fwd_t1_h_22 + (-0.67338544130325317) * gru_1_fwd_t1_h_23 + (0.82098954916000366) * gru_1_fwd_t1_h_24 + (0.60292512178421021) * gru_1_fwd_t1_h_25 + (0.7743074893951416) * gru_1_fwd_t1_h_26 + (-0.7444007396697998) * gru_1_fwd_t1_h_27 + (0.64619606733322144) * gru_1_fwd_t1_h_28 + (0.32141095399856567) * gru_1_fwd_t1_h_29 + (-1.056377649307251) * gru_1_fwd_t1_h_30 + (-0.42717519402503967) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((0.70974469184875488) + (-0.21757189929485321) * gru_0_out_t2_0 + (-0.67466270923614502) * gru_0_out_t2_1 + (1.2901037931442261) * gru_0_out_t2_2 + (-1.1657323837280273) * gru_0_out_t2_3 + (-0.6204988956451416) * gru_0_out_t2_4 + (0.034227278083562851) * gru_0_out_t2_5 + (0.3868427574634552) * gru_0_out_t2_6 + (-0.72424066066741943) * gru_0_out_t2_7 + (0.014449868351221085) * gru_0_out_t2_8 + (-0.8835785984992981) * gru_0_out_t2_9 + (-0.58577919006347656) * gru_0_out_t2_10 + (-0.16756491363048553) * gru_0_out_t2_11 + (0.27329421043395996) * gru_0_out_t2_12 + (0.52899229526519775) * gru_0_out_t2_13 + (0.38066896796226501) * gru_0_out_t2_14 + (0.20360586047172546) * gru_0_out_t2_15 + (-0.26299482583999634) * gru_0_out_t2_16 + (-0.30773904919624329) * gru_0_out_t2_17 + (-0.3657991886138916) * gru_0_out_t2_18 + (-1.0770071744918823) * gru_0_out_t2_19 + (0.70913469791412354) * gru_0_out_t2_20 + (-0.67965042591094971) * gru_0_out_t2_21 + (0.35090941190719604) * gru_0_out_t2_22 + (-0.1910814642906189) * gru_0_out_t2_23 + (-0.29093858599662781) * gru_0_out_t2_24 + (-0.67180091142654419) * gru_0_out_t2_25 + (-0.37334945797920227) * gru_0_out_t2_26 + (-0.18787962198257446) * gru_0_out_t2_27 + (-2.3632440567016602) * gru_0_out_t2_28 + (-0.89417010545730591) * gru_0_out_t2_29 + (-0.049014385789632797) * gru_0_out_t2_30 + (-0.62437403202056885) * gru_0_out_t2_31 + (0.13921299576759338) * gru_0_out_t2_32 + (-0.13079348206520081) * gru_0_out_t2_33 + (-0.14115071296691895) * gru_0_out_t2_34 + (0.48310491442680359) * gru_0_out_t2_35 + (0.16448287665843964) * gru_0_out_t2_36 + (-0.39815303683280945) * gru_0_out_t2_37 + (0.24357986450195312) * gru_0_out_t2_38 + (0.4730871319770813) * gru_0_out_t2_39 + (-0.31586173176765442) * gru_0_out_t2_40 + (0.43277233839035034) * gru_0_out_t2_41 + (-0.39591112732887268) * gru_0_out_t2_42 + (-0.37520736455917358) * gru_0_out_t2_43 + (-0.14738069474697113) * gru_0_out_t2_44 + (-0.061563026160001755) * gru_0_out_t2_45 + (-0.37783735990524292) * gru_0_out_t2_46 + (-0.15851083397865295) * gru_0_out_t2_47 + (-0.75639259815216064) * gru_0_out_t2_48 + (0.55528748035430908) * gru_0_out_t2_49 + (0.50796633958816528) * gru_0_out_t2_50 + (-0.0045085558667778969) * gru_0_out_t2_51 + (0.16608144342899323) * gru_0_out_t2_52 + (-0.32391816377639771) * gru_0_out_t2_53 + (-0.3456653356552124) * gru_0_out_t2_54 + (0.93299746513366699) * gru_0_out_t2_55 + (0.32286429405212402) * gru_0_out_t2_56 + (0.18077418208122253) * gru_0_out_t2_57 + (-0.15583305060863495) * gru_0_out_t2_58 + (-0.34632194042205811) * gru_0_out_t2_59 + (-0.20020826160907745) * gru_0_out_t2_60 + (-0.17262400686740875) * gru_0_out_t2_61 + (0.20702271163463593) * gru_0_out_t2_62 + (-0.17916786670684814) * gru_0_out_t2_63 + (0.041772790253162384) * gru_1_fwd_t1_h_0 + (-0.094294749200344086) * gru_1_fwd_t1_h_1 + (-0.14854806661605835) * gru_1_fwd_t1_h_2 + (0.34954366087913513) * gru_1_fwd_t1_h_3 + (0.13386538624763489) * gru_1_fwd_t1_h_4 + (0.40266287326812744) * gru_1_fwd_t1_h_5 + (-0.32935774326324463) * gru_1_fwd_t1_h_6 + (-0.13213901221752167) * gru_1_fwd_t1_h_7 + (-0.41296806931495667) * gru_1_fwd_t1_h_8 + (-0.20188750326633453) * gru_1_fwd_t1_h_9 + (0.78893965482711792) * gru_1_fwd_t1_h_10 + (0.10735327750444412) * gru_1_fwd_t1_h_11 + (0.18676812946796417) * gru_1_fwd_t1_h_12 + (-0.083891972899436951) * gru_1_fwd_t1_h_13 + (0.53801006078720093) * gru_1_fwd_t1_h_14 + (-0.47360628843307495) * gru_1_fwd_t1_h_15 + (-0.754128098487854) * gru_1_fwd_t1_h_16 + (0.18725168704986572) * gru_1_fwd_t1_h_17 + (-0.047931388020515442) * gru_1_fwd_t1_h_18 + (0.034751351922750473) * gru_1_fwd_t1_h_19 + (-0.27451694011688232) * gru_1_fwd_t1_h_20 + (0.13128581643104553) * gru_1_fwd_t1_h_21 + (-0.47335213422775269) * gru_1_fwd_t1_h_22 + (0.55677336454391479) * gru_1_fwd_t1_h_23 + (0.32298740744590759) * gru_1_fwd_t1_h_24 + (0.22443808615207672) * gru_1_fwd_t1_h_25 + (0.47897675633430481) * gru_1_fwd_t1_h_26 + (0.76062685251235962) * gru_1_fwd_t1_h_27 + (-0.30137616395950317) * gru_1_fwd_t1_h_28 + (0.8942791223526001) * gru_1_fwd_t1_h_29 + (0.38830229640007019) * gru_1_fwd_t1_h_30 + (-0.28786146640777588) * gru_1_fwd_t1_h_31);
    gate_n = tanh((-0.087131738662719727) + (0.040281638503074646) * gru_0_out_t2_0 + (-0.15501950681209564) * gru_0_out_t2_1 + (0.3018951416015625) * gru_0_out_t2_2 + (0.031743306666612625) * gru_0_out_t2_3 + (0.10615171492099762) * gru_0_out_t2_4 + (0.036074366420507431) * gru_0_out_t2_5 + (-1.1981058120727539) * gru_0_out_t2_6 + (0.022387325763702393) * gru_0_out_t2_7 + (0.44338533282279968) * gru_0_out_t2_8 + (-1.6422256231307983) * gru_0_out_t2_9 + (0.060480102896690369) * gru_0_out_t2_10 + (0.071534611284732819) * gru_0_out_t2_11 + (0.35143506526947021) * gru_0_out_t2_12 + (0.38802114129066467) * gru_0_out_t2_13 + (-0.29208230972290039) * gru_0_out_t2_14 + (0.069332800805568695) * gru_0_out_t2_15 + (-0.10089780390262604) * gru_0_out_t2_16 + (0.12890392541885376) * gru_0_out_t2_17 + (0.059282019734382629) * gru_0_out_t2_18 + (0.90338140726089478) * gru_0_out_t2_19 + (-1.6954474449157715) * gru_0_out_t2_20 + (0.067985862493515015) * gru_0_out_t2_21 + (-0.092437364161014557) * gru_0_out_t2_22 + (-0.145838662981987) * gru_0_out_t2_23 + (-0.59530025720596313) * gru_0_out_t2_24 + (-0.1259523332118988) * gru_0_out_t2_25 + (0.038953617215156555) * gru_0_out_t2_26 + (0.2040574699640274) * gru_0_out_t2_27 + (1.4365075826644897) * gru_0_out_t2_28 + (-0.69751554727554321) * gru_0_out_t2_29 + (-0.11070973426103592) * gru_0_out_t2_30 + (0.42063379287719727) * gru_0_out_t2_31 + (0.059314567595720291) * gru_0_out_t2_32 + (-0.34709888696670532) * gru_0_out_t2_33 + (0.25183001160621643) * gru_0_out_t2_34 + (-0.30905234813690186) * gru_0_out_t2_35 + (0.070733577013015747) * gru_0_out_t2_36 + (0.19110687077045441) * gru_0_out_t2_37 + (0.10854526609182358) * gru_0_out_t2_38 + (-0.027657022699713707) * gru_0_out_t2_39 + (-1.9690155982971191) * gru_0_out_t2_40 + (0.21316581964492798) * gru_0_out_t2_41 + (-0.021885743364691734) * gru_0_out_t2_42 + (-0.36006554961204529) * gru_0_out_t2_43 + (-0.068194448947906494) * gru_0_out_t2_44 + (-0.27470871806144714) * gru_0_out_t2_45 + (-0.20801557600498199) * gru_0_out_t2_46 + (-0.12202548980712891) * gru_0_out_t2_47 + (-0.72316205501556396) * gru_0_out_t2_48 + (0.31765559315681458) * gru_0_out_t2_49 + (0.13046504557132721) * gru_0_out_t2_50 + (-0.15704089403152466) * gru_0_out_t2_51 + (-0.18807622790336609) * gru_0_out_t2_52 + (0.22307142615318298) * gru_0_out_t2_53 + (0.12333199381828308) * gru_0_out_t2_54 + (0.21753798425197601) * gru_0_out_t2_55 + (-0.050385911017656326) * gru_0_out_t2_56 + (0.23111903667449951) * gru_0_out_t2_57 + (-0.15122593939304352) * gru_0_out_t2_58 + (-0.030426429584622383) * gru_0_out_t2_59 + (-0.15221656858921051) * gru_0_out_t2_60 + (-0.041052386164665222) * gru_0_out_t2_61 + (-0.41448625922203064) * gru_0_out_t2_62 + (-0.044311240315437317) * gru_0_out_t2_63 + gate_r * ((0.21654579043388367) + (-0.2179698646068573) * gru_1_fwd_t1_h_0 + (0.87882739305496216) * gru_1_fwd_t1_h_1 + (0.11962254345417023) * gru_1_fwd_t1_h_2 + (-0.39271038770675659) * gru_1_fwd_t1_h_3 + (-0.15568935871124268) * gru_1_fwd_t1_h_4 + (-0.656524658203125) * gru_1_fwd_t1_h_5 + (0.017481366172432899) * gru_1_fwd_t1_h_6 + (0.027484448626637459) * gru_1_fwd_t1_h_7 + (0.13600663840770721) * gru_1_fwd_t1_h_8 + (0.0011710341786965728) * gru_1_fwd_t1_h_9 + (-0.51135188341140747) * gru_1_fwd_t1_h_10 + (-0.56779420375823975) * gru_1_fwd_t1_h_11 + (-0.083768159151077271) * gru_1_fwd_t1_h_12 + (-0.70277339220046997) * gru_1_fwd_t1_h_13 + (0.21923577785491943) * gru_1_fwd_t1_h_14 + (-0.62161004543304443) * gru_1_fwd_t1_h_15 + (0.10882394015789032) * gru_1_fwd_t1_h_16 + (-0.017960753291845322) * gru_1_fwd_t1_h_17 + (0.71296101808547974) * gru_1_fwd_t1_h_18 + (0.37084877490997314) * gru_1_fwd_t1_h_19 + (-0.40932461619377136) * gru_1_fwd_t1_h_20 + (0.27010408043861389) * gru_1_fwd_t1_h_21 + (0.68297994136810303) * gru_1_fwd_t1_h_22 + (-0.21817669272422791) * gru_1_fwd_t1_h_23 + (-0.90504699945449829) * gru_1_fwd_t1_h_24 + (0.16259913146495819) * gru_1_fwd_t1_h_25 + (1.0815945863723755) * gru_1_fwd_t1_h_26 + (0.065328061580657959) * gru_1_fwd_t1_h_27 + (-0.32552757859230042) * gru_1_fwd_t1_h_28 + (-0.13884367048740387) * gru_1_fwd_t1_h_29 + (-0.082689903676509857) * gru_1_fwd_t1_h_30 + (0.25511392951011658) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_2 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_2;
    // h=3
    gate_r = sigmoid((-0.73512458801269531) + (-0.357526034116745) * gru_0_out_t2_0 + (0.67554879188537598) * gru_0_out_t2_1 + (-0.44719204306602478) * gru_0_out_t2_2 + (-0.51952296495437622) * gru_0_out_t2_3 + (0.34409463405609131) * gru_0_out_t2_4 + (-0.13040825724601746) * gru_0_out_t2_5 + (0.65058249235153198) * gru_0_out_t2_6 + (-1.8340790271759033) * gru_0_out_t2_7 + (0.091794818639755249) * gru_0_out_t2_8 + (0.16142657399177551) * gru_0_out_t2_9 + (0.16180258989334106) * gru_0_out_t2_10 + (0.45138552784919739) * gru_0_out_t2_11 + (-0.74758297204971313) * gru_0_out_t2_12 + (-0.20452438294887543) * gru_0_out_t2_13 + (-0.36171483993530273) * gru_0_out_t2_14 + (-0.30924093723297119) * gru_0_out_t2_15 + (0.57958841323852539) * gru_0_out_t2_16 + (0.076990723609924316) * gru_0_out_t2_17 + (-0.01787932962179184) * gru_0_out_t2_18 + (-0.83978563547134399) * gru_0_out_t2_19 + (0.24854418635368347) * gru_0_out_t2_20 + (0.49101632833480835) * gru_0_out_t2_21 + (0.64740222692489624) * gru_0_out_t2_22 + (-0.64302659034729004) * gru_0_out_t2_23 + (-0.19489207863807678) * gru_0_out_t2_24 + (0.2106207013130188) * gru_0_out_t2_25 + (0.17731291055679321) * gru_0_out_t2_26 + (-0.51566392183303833) * gru_0_out_t2_27 + (0.87024980783462524) * gru_0_out_t2_28 + (0.83537840843200684) * gru_0_out_t2_29 + (-0.332084059715271) * gru_0_out_t2_30 + (-1.938754677772522) * gru_0_out_t2_31 + (-0.89648681879043579) * gru_0_out_t2_32 + (0.13453015685081482) * gru_0_out_t2_33 + (0.13805671036243439) * gru_0_out_t2_34 + (-0.77289557456970215) * gru_0_out_t2_35 + (-0.24054610729217529) * gru_0_out_t2_36 + (0.57982468605041504) * gru_0_out_t2_37 + (-0.240960493683815) * gru_0_out_t2_38 + (-0.7718353271484375) * gru_0_out_t2_39 + (1.4746149778366089) * gru_0_out_t2_40 + (-0.71177256107330322) * gru_0_out_t2_41 + (-0.33733132481575012) * gru_0_out_t2_42 + (0.30654025077819824) * gru_0_out_t2_43 + (-0.44988304376602173) * gru_0_out_t2_44 + (-0.18161241710186005) * gru_0_out_t2_45 + (1.3798726797103882) * gru_0_out_t2_46 + (0.94931250810623169) * gru_0_out_t2_47 + (-0.43872794508934021) * gru_0_out_t2_48 + (0.30180278420448303) * gru_0_out_t2_49 + (-0.12908774614334106) * gru_0_out_t2_50 + (-0.52981925010681152) * gru_0_out_t2_51 + (-0.15786568820476532) * gru_0_out_t2_52 + (-0.019875487312674522) * gru_0_out_t2_53 + (-0.28271123766899109) * gru_0_out_t2_54 + (-0.66721123456954956) * gru_0_out_t2_55 + (0.50614374876022339) * gru_0_out_t2_56 + (0.13755032420158386) * gru_0_out_t2_57 + (0.28638118505477905) * gru_0_out_t2_58 + (1.9030090570449829) * gru_0_out_t2_59 + (-0.79395371675491333) * gru_0_out_t2_60 + (-0.81351441144943237) * gru_0_out_t2_61 + (-0.6225237250328064) * gru_0_out_t2_62 + (-0.82535439729690552) * gru_0_out_t2_63 + (-0.64333522319793701) * gru_1_fwd_t1_h_0 + (1.1893267631530762) * gru_1_fwd_t1_h_1 + (0.54559355974197388) * gru_1_fwd_t1_h_2 + (0.19615514576435089) * gru_1_fwd_t1_h_3 + (0.16730357706546783) * gru_1_fwd_t1_h_4 + (1.3560274839401245) * gru_1_fwd_t1_h_5 + (-0.56636053323745728) * gru_1_fwd_t1_h_6 + (-0.2290196567773819) * gru_1_fwd_t1_h_7 + (0.088852368295192719) * gru_1_fwd_t1_h_8 + (0.70217156410217285) * gru_1_fwd_t1_h_9 + (0.88142496347427368) * gru_1_fwd_t1_h_10 + (0.015489391982555389) * gru_1_fwd_t1_h_11 + (-0.81325554847717285) * gru_1_fwd_t1_h_12 + (0.64672607183456421) * gru_1_fwd_t1_h_13 + (0.11225621402263641) * gru_1_fwd_t1_h_14 + (-0.12179204076528549) * gru_1_fwd_t1_h_15 + (-0.091260224580764771) * gru_1_fwd_t1_h_16 + (0.6234089732170105) * gru_1_fwd_t1_h_17 + (0.82425844669342041) * gru_1_fwd_t1_h_18 + (0.2012646347284317) * gru_1_fwd_t1_h_19 + (0.65513527393341064) * gru_1_fwd_t1_h_20 + (0.90664666891098022) * gru_1_fwd_t1_h_21 + (0.35701343417167664) * gru_1_fwd_t1_h_22 + (1.3459697961807251) * gru_1_fwd_t1_h_23 + (-1.1782728433609009) * gru_1_fwd_t1_h_24 + (-0.94744575023651123) * gru_1_fwd_t1_h_25 + (1.198517918586731) * gru_1_fwd_t1_h_26 + (1.2783628702163696) * gru_1_fwd_t1_h_27 + (0.79835426807403564) * gru_1_fwd_t1_h_28 + (0.15512238442897797) * gru_1_fwd_t1_h_29 + (0.14908125996589661) * gru_1_fwd_t1_h_30 + (-0.16609637439250946) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((-1.8353067636489868) + (-0.15754492580890656) * gru_0_out_t2_0 + (0.30207481980323792) * gru_0_out_t2_1 + (-2.2664363384246826) * gru_0_out_t2_2 + (-0.019407905638217926) * gru_0_out_t2_3 + (0.63117849826812744) * gru_0_out_t2_4 + (-0.24904240667819977) * gru_0_out_t2_5 + (1.7606936693191528) * gru_0_out_t2_6 + (1.1187100410461426) * gru_0_out_t2_7 + (0.15616001188755035) * gru_0_out_t2_8 + (-1.5125036239624023) * gru_0_out_t2_9 + (1.9958353042602539) * gru_0_out_t2_10 + (-0.028851548209786415) * gru_0_out_t2_11 + (-0.15303438901901245) * gru_0_out_t2_12 + (-0.15460705757141113) * gru_0_out_t2_13 + (-0.37783780694007874) * gru_0_out_t2_14 + (-1.0934160947799683) * gru_0_out_t2_15 + (0.19842585921287537) * gru_0_out_t2_16 + (-0.25122341513633728) * gru_0_out_t2_17 + (-0.010980918072164059) * gru_0_out_t2_18 + (3.1185593605041504) * gru_0_out_t2_19 + (-2.7650105953216553) * gru_0_out_t2_20 + (0.17239220440387726) * gru_0_out_t2_21 + (0.52772951126098633) * gru_0_out_t2_22 + (-0.7548058032989502) * gru_0_out_t2_23 + (0.94506239891052246) * gru_0_out_t2_24 + (0.52375459671020508) * gru_0_out_t2_25 + (0.21681110560894012) * gru_0_out_t2_26 + (0.31961864233016968) * gru_0_out_t2_27 + (3.5876975059509277) * gru_0_out_t2_28 + (-0.085283100605010986) * gru_0_out_t2_29 + (-0.18828679621219635) * gru_0_out_t2_30 + (-1.6604968309402466) * gru_0_out_t2_31 + (-0.52896612882614136) * gru_0_out_t2_32 + (0.21481484174728394) * gru_0_out_t2_33 + (0.077013865113258362) * gru_0_out_t2_34 + (-0.24268130958080292) * gru_0_out_t2_35 + (0.21265323460102081) * gru_0_out_t2_36 + (0.3160550594329834) * gru_0_out_t2_37 + (0.16796761751174927) * gru_0_out_t2_38 + (-0.014997035264968872) * gru_0_out_t2_39 + (-1.955176830291748) * gru_0_out_t2_40 + (-0.52002197504043579) * gru_0_out_t2_41 + (0.40855857729911804) * gru_0_out_t2_42 + (0.29187250137329102) * gru_0_out_t2_43 + (0.054406225681304932) * gru_0_out_t2_44 + (-0.23163893818855286) * gru_0_out_t2_45 + (1.256862998008728) * gru_0_out_t2_46 + (1.2056849002838135) * gru_0_out_t2_47 + (0.42209005355834961) * gru_0_out_t2_48 + (-0.67930150032043457) * gru_0_out_t2_49 + (-0.28609153628349304) * gru_0_out_t2_50 + (-0.095412656664848328) * gru_0_out_t2_51 + (-0.31445175409317017) * gru_0_out_t2_52 + (-0.28022322058677673) * gru_0_out_t2_53 + (-0.1376587450504303) * gru_0_out_t2_54 + (-0.27862730622291565) * gru_0_out_t2_55 + (-0.2938227653503418) * gru_0_out_t2_56 + (-0.25614255666732788) * gru_0_out_t2_57 + (0.051509570330381393) * gru_0_out_t2_58 + (-0.19032202661037445) * gru_0_out_t2_59 + (-0.18234634399414062) * gru_0_out_t2_60 + (0.30942177772521973) * gru_0_out_t2_61 + (0.35599333047866821) * gru_0_out_t2_62 + (0.27111050486564636) * gru_0_out_t2_63 + (-0.59029406309127808) * gru_1_fwd_t1_h_0 + (0.20961220562458038) * gru_1_fwd_t1_h_1 + (-0.057232897728681564) * gru_1_fwd_t1_h_2 + (-0.079398803412914276) * gru_1_fwd_t1_h_3 + (0.25706571340560913) * gru_1_fwd_t1_h_4 + (-0.14894342422485352) * gru_1_fwd_t1_h_5 + (2.0308933258056641) * gru_1_fwd_t1_h_6 + (0.17321933805942535) * gru_1_fwd_t1_h_7 + (-0.082031115889549255) * gru_1_fwd_t1_h_8 + (0.23451307415962219) * gru_1_fwd_t1_h_9 + (-0.023904362693428993) * gru_1_fwd_t1_h_10 + (-1.0267410278320312) * gru_1_fwd_t1_h_11 + (0.11799507588148117) * gru_1_fwd_t1_h_12 + (0.42772859334945679) * gru_1_fwd_t1_h_13 + (-0.28218144178390503) * gru_1_fwd_t1_h_14 + (0.6514856219291687) * gru_1_fwd_t1_h_15 + (0.036383595317602158) * gru_1_fwd_t1_h_16 + (-0.42740738391876221) * gru_1_fwd_t1_h_17 + (-1.0876708030700684) * gru_1_fwd_t1_h_18 + (0.39967525005340576) * gru_1_fwd_t1_h_19 + (0.11740215867757797) * gru_1_fwd_t1_h_20 + (0.32977825403213501) * gru_1_fwd_t1_h_21 + (-1.0739549398422241) * gru_1_fwd_t1_h_22 + (-1.0864737033843994) * gru_1_fwd_t1_h_23 + (-1.0902304649353027) * gru_1_fwd_t1_h_24 + (0.10748656094074249) * gru_1_fwd_t1_h_25 + (-0.35457372665405273) * gru_1_fwd_t1_h_26 + (0.050428207963705063) * gru_1_fwd_t1_h_27 + (-0.95617491006851196) * gru_1_fwd_t1_h_28 + (0.15548554062843323) * gru_1_fwd_t1_h_29 + (-1.1366285085678101) * gru_1_fwd_t1_h_30 + (0.14440684020519257) * gru_1_fwd_t1_h_31);
    gate_n = tanh((-0.019460473209619522) + (0.058036752045154572) * gru_0_out_t2_0 + (-0.077278465032577515) * gru_0_out_t2_1 + (-0.023768827319145203) * gru_0_out_t2_2 + (0.060359776020050049) * gru_0_out_t2_3 + (-0.31083720922470093) * gru_0_out_t2_4 + (0.13566665351390839) * gru_0_out_t2_5 + (0.19531209766864777) * gru_0_out_t2_6 + (-0.094354651868343353) * gru_0_out_t2_7 + (-0.32550519704818726) * gru_0_out_t2_8 + (-0.16147997975349426) * gru_0_out_t2_9 + (0.12911885976791382) * gru_0_out_t2_10 + (-0.21707101166248322) * gru_0_out_t2_11 + (-0.068651027977466583) * gru_0_out_t2_12 + (-0.20216991007328033) * gru_0_out_t2_13 + (0.16363252699375153) * gru_0_out_t2_14 + (0.13233429193496704) * gru_0_out_t2_15 + (-0.37145382165908813) * gru_0_out_t2_16 + (-0.15195988118648529) * gru_0_out_t2_17 + (-0.051173880696296692) * gru_0_out_t2_18 + (0.13182637095451355) * gru_0_out_t2_19 + (0.51755410432815552) * gru_0_out_t2_20 + (0.039800573140382767) * gru_0_out_t2_21 + (0.15187637507915497) * gru_0_out_t2_22 + (0.082246355712413788) * gru_0_out_t2_23 + (0.0061784754507243633) * gru_0_out_t2_24 + (-0.19896300137042999) * gru_0_out_t2_25 + (0.019916824996471405) * gru_0_out_t2_26 + (0.028971770778298378) * gru_0_out_t2_27 + (0.044988717883825302) * gru_0_out_t2_28 + (-1.0935471057891846) * gru_0_out_t2_29 + (0.00042594049591571093) * gru_0_out_t2_30 + (0.11432890594005585) * gru_0_out_t2_31 + (-0.72863304615020752) * gru_0_out_t2_32 + (0.32881239056587219) * gru_0_out_t2_33 + (-0.057423565536737442) * gru_0_out_t2_34 + (0.10477486997842789) * gru_0_out_t2_35 + (0.35552844405174255) * gru_0_out_t2_36 + (-0.062632076442241669) * gru_0_out_t2_37 + (0.15565972030162811) * gru_0_out_t2_38 + (-0.2540467381477356) * gru_0_out_t2_39 + (-0.16044199466705322) * gru_0_out_t2_40 + (0.071897104382514954) * gru_0_out_t2_41 + (0.29240047931671143) * gru_0_out_t2_42 + (-0.45783588290214539) * gru_0_out_t2_43 + (0.1434982568025589) * gru_0_out_t2_44 + (0.23941473662853241) * gru_0_out_t2_45 + (0.53427451848983765) * gru_0_out_t2_46 + (0.57159596681594849) * gru_0_out_t2_47 + (0.68147528171539307) * gru_0_out_t2_48 + (-0.3302786648273468) * gru_0_out_t2_49 + (0.12386100739240646) * gru_0_out_t2_50 + (-0.0049137375317513943) * gru_0_out_t2_51 + (-0.07931353896856308) * gru_0_out_t2_52 + (-0.40543696284294128) * gru_0_out_t2_53 + (0.040823236107826233) * gru_0_out_t2_54 + (0.0067190523259341717) * gru_0_out_t2_55 + (-0.14674259722232819) * gru_0_out_t2_56 + (-0.56632232666015625) * gru_0_out_t2_57 + (-0.029335768893361092) * gru_0_out_t2_58 + (0.080396443605422974) * gru_0_out_t2_59 + (0.59750586748123169) * gru_0_out_t2_60 + (-0.058635499328374863) * gru_0_out_t2_61 + (-0.10675833374261856) * gru_0_out_t2_62 + (0.90392518043518066) * gru_0_out_t2_63 + gate_r * ((-0.09937574714422226) + (-0.14993093907833099) * gru_1_fwd_t1_h_0 + (-0.40527954697608948) * gru_1_fwd_t1_h_1 + (-0.06178535521030426) * gru_1_fwd_t1_h_2 + (-0.77626204490661621) * gru_1_fwd_t1_h_3 + (0.56327986717224121) * gru_1_fwd_t1_h_4 + (-0.4020366370677948) * gru_1_fwd_t1_h_5 + (1.127267599105835) * gru_1_fwd_t1_h_6 + (-0.1331707090139389) * gru_1_fwd_t1_h_7 + (-0.56600499153137207) * gru_1_fwd_t1_h_8 + (-0.036703258752822876) * gru_1_fwd_t1_h_9 + (-0.31750562787055969) * gru_1_fwd_t1_h_10 + (-0.040947049856185913) * gru_1_fwd_t1_h_11 + (0.084345690906047821) * gru_1_fwd_t1_h_12 + (-0.057436000555753708) * gru_1_fwd_t1_h_13 + (0.21813309192657471) * gru_1_fwd_t1_h_14 + (0.27901142835617065) * gru_1_fwd_t1_h_15 + (0.081150047481060028) * gru_1_fwd_t1_h_16 + (0.010854163207113743) * gru_1_fwd_t1_h_17 + (0.3137231171131134) * gru_1_fwd_t1_h_18 + (0.16866211593151093) * gru_1_fwd_t1_h_19 + (0.5602613091468811) * gru_1_fwd_t1_h_20 + (-0.22023557126522064) * gru_1_fwd_t1_h_21 + (0.88414239883422852) * gru_1_fwd_t1_h_22 + (0.20507168769836426) * gru_1_fwd_t1_h_23 + (0.069921717047691345) * gru_1_fwd_t1_h_24 + (-0.21442896127700806) * gru_1_fwd_t1_h_25 + (-0.95781397819519043) * gru_1_fwd_t1_h_26 + (-0.051766645163297653) * gru_1_fwd_t1_h_27 + (-0.70796561241149902) * gru_1_fwd_t1_h_28 + (0.043337740004062653) * gru_1_fwd_t1_h_29 + (0.19646921753883362) * gru_1_fwd_t1_h_30 + (0.64586198329925537) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_3 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_3;
    // h=4
    gate_r = sigmoid((-1.4422681331634521) + (-0.27375611662864685) * gru_0_out_t2_0 + (0.24410742521286011) * gru_0_out_t2_1 + (-0.43752261996269226) * gru_0_out_t2_2 + (-0.92083472013473511) * gru_0_out_t2_3 + (-0.12444613128900528) * gru_0_out_t2_4 + (-1.2203383445739746) * gru_0_out_t2_5 + (0.76218104362487793) * gru_0_out_t2_6 + (-0.43783286213874817) * gru_0_out_t2_7 + (0.36288619041442871) * gru_0_out_t2_8 + (-1.3970472812652588) * gru_0_out_t2_9 + (0.31832197308540344) * gru_0_out_t2_10 + (-0.52894264459609985) * gru_0_out_t2_11 + (-0.28515231609344482) * gru_0_out_t2_12 + (0.0014001575764268637) * gru_0_out_t2_13 + (-0.47196140885353088) * gru_0_out_t2_14 + (-0.73993802070617676) * gru_0_out_t2_15 + (0.62621933221817017) * gru_0_out_t2_16 + (0.020511632785201073) * gru_0_out_t2_17 + (-0.21477818489074707) * gru_0_out_t2_18 + (-1.4726729393005371) * gru_0_out_t2_19 + (-1.9259865283966064) * gru_0_out_t2_20 + (0.25602319836616516) * gru_0_out_t2_21 + (0.539023756980896) * gru_0_out_t2_22 + (0.72982889413833618) * gru_0_out_t2_23 + (0.018271638080477715) * gru_0_out_t2_24 + (0.68161070346832275) * gru_0_out_t2_25 + (-0.60539287328720093) * gru_0_out_t2_26 + (-0.31466445326805115) * gru_0_out_t2_27 + (0.67938953638076782) * gru_0_out_t2_28 + (-1.2889844179153442) * gru_0_out_t2_29 + (-0.62480825185775757) * gru_0_out_t2_30 + (-1.8958251476287842) * gru_0_out_t2_31 + (0.35195761919021606) * gru_0_out_t2_32 + (0.20677934587001801) * gru_0_out_t2_33 + (-0.20766238868236542) * gru_0_out_t2_34 + (0.40839910507202148) * gru_0_out_t2_35 + (0.16821984946727753) * gru_0_out_t2_36 + (-0.11672574281692505) * gru_0_out_t2_37 + (0.60776287317276001) * gru_0_out_t2_38 + (1.1185344457626343) * gru_0_out_t2_39 + (-1.1173248291015625) * gru_0_out_t2_40 + (-0.1557161808013916) * gru_0_out_t2_41 + (0.97642439603805542) * gru_0_out_t2_42 + (0.13649097084999084) * gru_0_out_t2_43 + (-0.38936805725097656) * gru_0_out_t2_44 + (-0.62431508302688599) * gru_0_out_t2_45 + (-4.3678593635559082) * gru_0_out_t2_46 + (-0.80501943826675415) * gru_0_out_t2_47 + (1.7760469913482666) * gru_0_out_t2_48 + (-1.5917617082595825) * gru_0_out_t2_49 + (0.11371275037527084) * gru_0_out_t2_50 + (0.2044689804315567) * gru_0_out_t2_51 + (-0.22166547179222107) * gru_0_out_t2_52 + (-0.070120811462402344) * gru_0_out_t2_53 + (-0.20829281210899353) * gru_0_out_t2_54 + (0.43585482239723206) * gru_0_out_t2_55 + (1.3950122594833374) * gru_0_out_t2_56 + (-2.0214014053344727) * gru_0_out_t2_57 + (-0.059395395219326019) * gru_0_out_t2_58 + (-1.793035626411438) * gru_0_out_t2_59 + (-0.80678039789199829) * gru_0_out_t2_60 + (-2.717179536819458) * gru_0_out_t2_61 + (-0.47960367798805237) * gru_0_out_t2_62 + (1.600124716758728) * gru_0_out_t2_63 + (-0.61193925142288208) * gru_1_fwd_t1_h_0 + (-0.3505936861038208) * gru_1_fwd_t1_h_1 + (0.15937276184558868) * gru_1_fwd_t1_h_2 + (2.2484340667724609) * gru_1_fwd_t1_h_3 + (-0.95490270853042603) * gru_1_fwd_t1_h_4 + (1.3619242906570435) * gru_1_fwd_t1_h_5 + (-2.2148909568786621) * gru_1_fwd_t1_h_6 + (1.2497119903564453) * gru_1_fwd_t1_h_7 + (-1.0523821115493774) * gru_1_fwd_t1_h_8 + (0.22955328226089478) * gru_1_fwd_t1_h_9 + (-0.081123672425746918) * gru_1_fwd_t1_h_10 + (0.53329497575759888) * gru_1_fwd_t1_h_11 + (0.079320304095745087) * gru_1_fwd_t1_h_12 + (0.33669334650039673) * gru_1_fwd_t1_h_13 + (1.0165618658065796) * gru_1_fwd_t1_h_14 + (-1.1049560308456421) * gru_1_fwd_t1_h_15 + (0.14952658116817474) * gru_1_fwd_t1_h_16 + (1.4894304275512695) * gru_1_fwd_t1_h_17 + (0.78309804201126099) * gru_1_fwd_t1_h_18 + (0.93624305725097656) * gru_1_fwd_t1_h_19 + (0.3058413565158844) * gru_1_fwd_t1_h_20 + (2.2931303977966309) * gru_1_fwd_t1_h_21 + (1.4813592433929443) * gru_1_fwd_t1_h_22 + (-0.74413692951202393) * gru_1_fwd_t1_h_23 + (0.13538569211959839) * gru_1_fwd_t1_h_24 + (-0.066649794578552246) * gru_1_fwd_t1_h_25 + (-0.12127398699522018) * gru_1_fwd_t1_h_26 + (0.64555788040161133) * gru_1_fwd_t1_h_27 + (-0.24703383445739746) * gru_1_fwd_t1_h_28 + (0.31485426425933838) * gru_1_fwd_t1_h_29 + (-1.6495261192321777) * gru_1_fwd_t1_h_30 + (-0.08004537969827652) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((0.59001302719116211) + (0.23560723662376404) * gru_0_out_t2_0 + (-0.26058825850486755) * gru_0_out_t2_1 + (0.3943498432636261) * gru_0_out_t2_2 + (-0.87700468301773071) * gru_0_out_t2_3 + (-0.62639904022216797) * gru_0_out_t2_4 + (-0.11864914745092392) * gru_0_out_t2_5 + (-0.37727347016334534) * gru_0_out_t2_6 + (0.60813528299331665) * gru_0_out_t2_7 + (0.2139270007610321) * gru_0_out_t2_8 + (-0.16495823860168457) * gru_0_out_t2_9 + (-0.77105021476745605) * gru_0_out_t2_10 + (-0.32063990831375122) * gru_0_out_t2_11 + (0.019660118967294693) * gru_0_out_t2_12 + (0.41306686401367188) * gru_0_out_t2_13 + (-0.048834949731826782) * gru_0_out_t2_14 + (0.38759312033653259) * gru_0_out_t2_15 + (-0.28633469343185425) * gru_0_out_t2_16 + (0.26531136035919189) * gru_0_out_t2_17 + (0.29051917791366577) * gru_0_out_t2_18 + (-0.29238685965538025) * gru_0_out_t2_19 + (1.4378200769424438) * gru_0_out_t2_20 + (0.099473536014556885) * gru_0_out_t2_21 + (0.11079002916812897) * gru_0_out_t2_22 + (0.10038530081510544) * gru_0_out_t2_23 + (-2.316525936126709) * gru_0_out_t2_24 + (-0.54126012325286865) * gru_0_out_t2_25 + (-0.35591691732406616) * gru_0_out_t2_26 + (-0.07591584324836731) * gru_0_out_t2_27 + (0.28531637787818909) * gru_0_out_t2_28 + (-0.16191679239273071) * gru_0_out_t2_29 + (0.28354868292808533) * gru_0_out_t2_30 + (-1.725298285484314) * gru_0_out_t2_31 + (-0.41497248411178589) * gru_0_out_t2_32 + (-0.081388339400291443) * gru_0_out_t2_33 + (-0.044332440942525864) * gru_0_out_t2_34 + (0.30471780896186829) * gru_0_out_t2_35 + (-0.23920774459838867) * gru_0_out_t2_36 + (-0.41799306869506836) * gru_0_out_t2_37 + (0.50715935230255127) * gru_0_out_t2_38 + (-0.35620960593223572) * gru_0_out_t2_39 + (1.5307520627975464) * gru_0_out_t2_40 + (0.29774776101112366) * gru_0_out_t2_41 + (0.22565834224224091) * gru_0_out_t2_42 + (-0.54736006259918213) * gru_0_out_t2_43 + (0.19568614661693573) * gru_0_out_t2_44 + (0.13653028011322021) * gru_0_out_t2_45 + (-0.80638694763183594) * gru_0_out_t2_46 + (-0.13429953157901764) * gru_0_out_t2_47 + (0.15989576280117035) * gru_0_out_t2_48 + (-0.11702195554971695) * gru_0_out_t2_49 + (-0.12221340835094452) * gru_0_out_t2_50 + (0.13002289831638336) * gru_0_out_t2_51 + (-0.033596735447645187) * gru_0_out_t2_52 + (0.08393501490354538) * gru_0_out_t2_53 + (-0.14500059187412262) * gru_0_out_t2_54 + (-0.12370510399341583) * gru_0_out_t2_55 + (-0.12459183484315872) * gru_0_out_t2_56 + (-0.046911153942346573) * gru_0_out_t2_57 + (-0.038734860718250275) * gru_0_out_t2_58 + (-0.037449199706315994) * gru_0_out_t2_59 + (-0.29496097564697266) * gru_0_out_t2_60 + (0.12926171720027924) * gru_0_out_t2_61 + (0.44048583507537842) * gru_0_out_t2_62 + (-0.57463055849075317) * gru_0_out_t2_63 + (0.11742450296878815) * gru_1_fwd_t1_h_0 + (-0.025189779698848724) * gru_1_fwd_t1_h_1 + (-0.23725143074989319) * gru_1_fwd_t1_h_2 + (0.27893099188804626) * gru_1_fwd_t1_h_3 + (0.38857758045196533) * gru_1_fwd_t1_h_4 + (0.27063021063804626) * gru_1_fwd_t1_h_5 + (-0.70322179794311523) * gru_1_fwd_t1_h_6 + (0.029560694471001625) * gru_1_fwd_t1_h_7 + (-0.26834848523139954) * gru_1_fwd_t1_h_8 + (0.033899709582328796) * gru_1_fwd_t1_h_9 + (0.32650229334831238) * gru_1_fwd_t1_h_10 + (0.53739285469055176) * gru_1_fwd_t1_h_11 + (-0.23903569579124451) * gru_1_fwd_t1_h_12 + (-0.1183428093791008) * gru_1_fwd_t1_h_13 + (0.046227838844060898) * gru_1_fwd_t1_h_14 + (-0.52754861116409302) * gru_1_fwd_t1_h_15 + (-0.91855895519256592) * gru_1_fwd_t1_h_16 + (0.012714356184005737) * gru_1_fwd_t1_h_17 + (1.0441761016845703) * gru_1_fwd_t1_h_18 + (0.31894755363464355) * gru_1_fwd_t1_h_19 + (-0.12153061479330063) * gru_1_fwd_t1_h_20 + (0.08566681295633316) * gru_1_fwd_t1_h_21 + (-0.60089313983917236) * gru_1_fwd_t1_h_22 + (0.17326280474662781) * gru_1_fwd_t1_h_23 + (0.38475614786148071) * gru_1_fwd_t1_h_24 + (0.80572950839996338) * gru_1_fwd_t1_h_25 + (-0.060374639928340912) * gru_1_fwd_t1_h_26 + (-0.042112987488508224) * gru_1_fwd_t1_h_27 + (-0.16986659169197083) * gru_1_fwd_t1_h_28 + (-0.03664688766002655) * gru_1_fwd_t1_h_29 + (-0.012008765712380409) * gru_1_fwd_t1_h_30 + (0.17950601875782013) * gru_1_fwd_t1_h_31);
    gate_n = tanh((-0.068054355680942535) + (0.0041871173307299614) * gru_0_out_t2_0 + (-0.098407149314880371) * gru_0_out_t2_1 + (0.13121753931045532) * gru_0_out_t2_2 + (0.90303224325180054) * gru_0_out_t2_3 + (0.0019170270534232259) * gru_0_out_t2_4 + (0.013849160633981228) * gru_0_out_t2_5 + (-0.36919021606445312) * gru_0_out_t2_6 + (-0.14646449685096741) * gru_0_out_t2_7 + (0.14578704535961151) * gru_0_out_t2_8 + (-0.1085968017578125) * gru_0_out_t2_9 + (0.0072511369362473488) * gru_0_out_t2_10 + (0.052674461156129837) * gru_0_out_t2_11 + (0.088630042970180511) * gru_0_out_t2_12 + (-0.12792904675006866) * gru_0_out_t2_13 + (-0.13745638728141785) * gru_0_out_t2_14 + (-0.00040005726623348892) * gru_0_out_t2_15 + (-0.071156099438667297) * gru_0_out_t2_16 + (-0.072927922010421753) * gru_0_out_t2_17 + (0.015789896249771118) * gru_0_out_t2_18 + (-1.0472687482833862) * gru_0_out_t2_19 + (-0.49946719408035278) * gru_0_out_t2_20 + (0.074564933776855469) * gru_0_out_t2_21 + (0.21195763349533081) * gru_0_out_t2_22 + (-0.048271737992763519) * gru_0_out_t2_23 + (0.036148607730865479) * gru_0_out_t2_24 + (-0.0019706748425960541) * gru_0_out_t2_25 + (0.013225573115050793) * gru_0_out_t2_26 + (-0.024888442829251289) * gru_0_out_t2_27 + (0.0547514408826828) * gru_0_out_t2_28 + (0.060133684426546097) * gru_0_out_t2_29 + (-0.16785284876823425) * gru_0_out_t2_30 + (-0.015186427161097527) * gru_0_out_t2_31 + (-0.093362711369991302) * gru_0_out_t2_32 + (-0.34817573428153992) * gru_0_out_t2_33 + (0.27434349060058594) * gru_0_out_t2_34 + (-0.2916070818901062) * gru_0_out_t2_35 + (0.018608894199132919) * gru_0_out_t2_36 + (-0.18916885554790497) * gru_0_out_t2_37 + (0.19322478771209717) * gru_0_out_t2_38 + (0.12639430165290833) * gru_0_out_t2_39 + (-0.060218866914510727) * gru_0_out_t2_40 + (0.40955609083175659) * gru_0_out_t2_41 + (0.025547120720148087) * gru_0_out_t2_42 + (-0.1595780998468399) * gru_0_out_t2_43 + (-0.069916218519210815) * gru_0_out_t2_44 + (-0.52636438608169556) * gru_0_out_t2_45 + (0.16426178812980652) * gru_0_out_t2_46 + (-0.40248140692710876) * gru_0_out_t2_47 + (-0.76132369041442871) * gru_0_out_t2_48 + (0.41800042986869812) * gru_0_out_t2_49 + (0.19870555400848389) * gru_0_out_t2_50 + (0.060428645461797714) * gru_0_out_t2_51 + (-0.10697674006223679) * gru_0_out_t2_52 + (0.11562179028987885) * gru_0_out_t2_53 + (-0.020539244636893272) * gru_0_out_t2_54 + (-0.19283989071846008) * gru_0_out_t2_55 + (-0.024134794250130653) * gru_0_out_t2_56 + (0.61815500259399414) * gru_0_out_t2_57 + (-0.10895395278930664) * gru_0_out_t2_58 + (-0.08258511871099472) * gru_0_out_t2_59 + (0.016292670741677284) * gru_0_out_t2_60 + (0.016228828579187393) * gru_0_out_t2_61 + (-0.12413616478443146) * gru_0_out_t2_62 + (-0.10150615125894547) * gru_0_out_t2_63 + gate_r * ((-0.28785055875778198) + (0.74399024248123169) * gru_1_fwd_t1_h_0 + (1.248096227645874) * gru_1_fwd_t1_h_1 + (0.12937775254249573) * gru_1_fwd_t1_h_2 + (0.42848518490791321) * gru_1_fwd_t1_h_3 + (-0.35536980628967285) * gru_1_fwd_t1_h_4 + (-0.039327282458543777) * gru_1_fwd_t1_h_5 + (-0.98021650314331055) * gru_1_fwd_t1_h_6 + (-0.023159254342317581) * gru_1_fwd_t1_h_7 + (-0.10295309871435165) * gru_1_fwd_t1_h_8 + (-0.27079376578330994) * gru_1_fwd_t1_h_9 + (0.071412496268749237) * gru_1_fwd_t1_h_10 + (0.067522682249546051) * gru_1_fwd_t1_h_11 + (-0.62916719913482666) * gru_1_fwd_t1_h_12 + (0.36160588264465332) * gru_1_fwd_t1_h_13 + (-0.04858764261007309) * gru_1_fwd_t1_h_14 + (0.55430710315704346) * gru_1_fwd_t1_h_15 + (-0.20459060370922089) * gru_1_fwd_t1_h_16 + (-0.34638082981109619) * gru_1_fwd_t1_h_17 + (-1.1291549205780029) * gru_1_fwd_t1_h_18 + (0.53656977415084839) * gru_1_fwd_t1_h_19 + (-0.054548032581806183) * gru_1_fwd_t1_h_20 + (-0.061572551727294922) * gru_1_fwd_t1_h_21 + (0.012600251473486423) * gru_1_fwd_t1_h_22 + (0.70672839879989624) * gru_1_fwd_t1_h_23 + (-0.7700846791267395) * gru_1_fwd_t1_h_24 + (-0.759773850440979) * gru_1_fwd_t1_h_25 + (-0.24529395997524261) * gru_1_fwd_t1_h_26 + (0.73223656415939331) * gru_1_fwd_t1_h_27 + (0.13631437718868256) * gru_1_fwd_t1_h_28 + (0.23919746279716492) * gru_1_fwd_t1_h_29 + (-0.087307937443256378) * gru_1_fwd_t1_h_30 + (-0.079783640801906586) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_4 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_4;
    // h=5
    gate_r = sigmoid((-0.057043202221393585) + (0.18797262012958527) * gru_0_out_t2_0 + (0.28308415412902832) * gru_0_out_t2_1 + (-0.21355739235877991) * gru_0_out_t2_2 + (2.091475248336792) * gru_0_out_t2_3 + (0.12331478297710419) * gru_0_out_t2_4 + (0.21646483242511749) * gru_0_out_t2_5 + (-1.8629899024963379) * gru_0_out_t2_6 + (-1.082572340965271) * gru_0_out_t2_7 + (-0.0065923244692385197) * gru_0_out_t2_8 + (-0.7293892502784729) * gru_0_out_t2_9 + (-0.13184466958045959) * gru_0_out_t2_10 + (-0.86389338970184326) * gru_0_out_t2_11 + (0.17965957522392273) * gru_0_out_t2_12 + (-0.025681382045149803) * gru_0_out_t2_13 + (-0.22114238142967224) * gru_0_out_t2_14 + (1.028028130531311) * gru_0_out_t2_15 + (-0.13112033903598785) * gru_0_out_t2_16 + (0.013181955553591251) * gru_0_out_t2_17 + (0.59214603900909424) * gru_0_out_t2_18 + (1.1786395311355591) * gru_0_out_t2_19 + (-0.60820037126541138) * gru_0_out_t2_20 + (-1.3501039743423462) * gru_0_out_t2_21 + (0.041072621941566467) * gru_0_out_t2_22 + (-0.44121775031089783) * gru_0_out_t2_23 + (1.074573278427124) * gru_0_out_t2_24 + (-0.74668580293655396) * gru_0_out_t2_25 + (-0.87575018405914307) * gru_0_out_t2_26 + (1.5087149143218994) * gru_0_out_t2_27 + (-0.052947305142879486) * gru_0_out_t2_28 + (0.53501754999160767) * gru_0_out_t2_29 + (0.051124919205904007) * gru_0_out_t2_30 + (-1.9095953702926636) * gru_0_out_t2_31 + (-1.4853159189224243) * gru_0_out_t2_32 + (-0.86919283866882324) * gru_0_out_t2_33 + (0.38184919953346252) * gru_0_out_t2_34 + (-0.046407230198383331) * gru_0_out_t2_35 + (0.46844741702079773) * gru_0_out_t2_36 + (-0.14297601580619812) * gru_0_out_t2_37 + (0.31557995080947876) * gru_0_out_t2_38 + (0.10363997519016266) * gru_0_out_t2_39 + (-1.0821423530578613) * gru_0_out_t2_40 + (0.30671858787536621) * gru_0_out_t2_41 + (0.60028499364852905) * gru_0_out_t2_42 + (-0.35706672072410583) * gru_0_out_t2_43 + (0.25152656435966492) * gru_0_out_t2_44 + (-0.26919549703598022) * gru_0_out_t2_45 + (0.70952022075653076) * gru_0_out_t2_46 + (1.4922654628753662) * gru_0_out_t2_47 + (1.3005011081695557) * gru_0_out_t2_48 + (-1.3747574090957642) * gru_0_out_t2_49 + (-0.8775641918182373) * gru_0_out_t2_50 + (0.37451869249343872) * gru_0_out_t2_51 + (0.921378493309021) * gru_0_out_t2_52 + (-0.57372337579727173) * gru_0_out_t2_53 + (0.35788729786872864) * gru_0_out_t2_54 + (0.21129196882247925) * gru_0_out_t2_55 + (1.1655713319778442) * gru_0_out_t2_56 + (-1.6424033641815186) * gru_0_out_t2_57 + (0.030115712434053421) * gru_0_out_t2_58 + (0.70173066854476929) * gru_0_out_t2_59 + (1.6362553834915161) * gru_0_out_t2_60 + (0.34777981042861938) * gru_0_out_t2_61 + (0.47537285089492798) * gru_0_out_t2_62 + (-4.8929104804992676) * gru_0_out_t2_63 + (0.55804556608200073) * gru_1_fwd_t1_h_0 + (-0.57333105802536011) * gru_1_fwd_t1_h_1 + (0.2575061023235321) * gru_1_fwd_t1_h_2 + (1.1648322343826294) * gru_1_fwd_t1_h_3 + (0.91321456432342529) * gru_1_fwd_t1_h_4 + (1.4223272800445557) * gru_1_fwd_t1_h_5 + (1.3805950880050659) * gru_1_fwd_t1_h_6 + (0.48852679133415222) * gru_1_fwd_t1_h_7 + (-0.21782365441322327) * gru_1_fwd_t1_h_8 + (-0.42837420105934143) * gru_1_fwd_t1_h_9 + (-0.35096496343612671) * gru_1_fwd_t1_h_10 + (-0.67349022626876831) * gru_1_fwd_t1_h_11 + (-0.82829773426055908) * gru_1_fwd_t1_h_12 + (-0.86320483684539795) * gru_1_fwd_t1_h_13 + (-1.9294452667236328) * gru_1_fwd_t1_h_14 + (1.0109190940856934) * gru_1_fwd_t1_h_15 + (-0.56477338075637817) * gru_1_fwd_t1_h_16 + (1.2721501588821411) * gru_1_fwd_t1_h_17 + (0.22782188653945923) * gru_1_fwd_t1_h_18 + (0.10541124641895294) * gru_1_fwd_t1_h_19 + (0.38460183143615723) * gru_1_fwd_t1_h_20 + (-1.6298205852508545) * gru_1_fwd_t1_h_21 + (1.4201456308364868) * gru_1_fwd_t1_h_22 + (-0.6712685227394104) * gru_1_fwd_t1_h_23 + (3.1911180019378662) * gru_1_fwd_t1_h_24 + (-0.61604779958724976) * gru_1_fwd_t1_h_25 + (0.51969987154006958) * gru_1_fwd_t1_h_26 + (-0.47563943266868591) * gru_1_fwd_t1_h_27 + (-1.7933487892150879) * gru_1_fwd_t1_h_28 + (-0.32064232230186462) * gru_1_fwd_t1_h_29 + (-2.001570463180542) * gru_1_fwd_t1_h_30 + (0.56133335828781128) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((0.23555031418800354) + (0.069347873330116272) * gru_0_out_t2_0 + (-0.21264001727104187) * gru_0_out_t2_1 + (-0.05217771977186203) * gru_0_out_t2_2 + (0.13457010686397552) * gru_0_out_t2_3 + (-0.41192358732223511) * gru_0_out_t2_4 + (0.71489006280899048) * gru_0_out_t2_5 + (0.6565169095993042) * gru_0_out_t2_6 + (0.40513753890991211) * gru_0_out_t2_7 + (-0.70260804891586304) * gru_0_out_t2_8 + (-0.35470759868621826) * gru_0_out_t2_9 + (-0.67988932132720947) * gru_0_out_t2_10 + (0.085471048951148987) * gru_0_out_t2_11 + (0.36433959007263184) * gru_0_out_t2_12 + (0.3187616765499115) * gru_0_out_t2_13 + (0.12957195937633514) * gru_0_out_t2_14 + (-0.12221071869134903) * gru_0_out_t2_15 + (-1.3629049062728882) * gru_0_out_t2_16 + (-0.9615064263343811) * gru_0_out_t2_17 + (0.071905016899108887) * gru_0_out_t2_18 + (1.5222327709197998) * gru_0_out_t2_19 + (-0.6446385383605957) * gru_0_out_t2_20 + (-0.55017739534378052) * gru_0_out_t2_21 + (-0.034212764352560043) * gru_0_out_t2_22 + (1.668259859085083) * gru_0_out_t2_23 + (-0.15417201817035675) * gru_0_out_t2_24 + (-0.42746806144714355) * gru_0_out_t2_25 + (0.3437458872795105) * gru_0_out_t2_26 + (0.011678125709295273) * gru_0_out_t2_27 + (-0.73926794528961182) * gru_0_out_t2_28 + (-0.27459985017776489) * gru_0_out_t2_29 + (0.069331243634223938) * gru_0_out_t2_30 + (0.049888890236616135) * gru_0_out_t2_31 + (0.29295319318771362) * gru_0_out_t2_32 + (-0.00054584146710112691) * gru_0_out_t2_33 + (0.40058159828186035) * gru_0_out_t2_34 + (-0.35964488983154297) * gru_0_out_t2_35 + (-0.18682733178138733) * gru_0_out_t2_36 + (0.29169899225234985) * gru_0_out_t2_37 + (0.031239794567227364) * gru_0_out_t2_38 + (-1.0319201946258545) * gru_0_out_t2_39 + (-1.7977628707885742) * gru_0_out_t2_40 + (0.15915238857269287) * gru_0_out_t2_41 + (-0.98198157548904419) * gru_0_out_t2_42 + (-0.17502963542938232) * gru_0_out_t2_43 + (-0.31694120168685913) * gru_0_out_t2_44 + (0.0029012071900069714) * gru_0_out_t2_45 + (-0.96748757362365723) * gru_0_out_t2_46 + (-0.15843209624290466) * gru_0_out_t2_47 + (-0.76683348417282104) * gru_0_out_t2_48 + (0.77007973194122314) * gru_0_out_t2_49 + (0.84546959400177002) * gru_0_out_t2_50 + (-0.42910373210906982) * gru_0_out_t2_51 + (0.16975733637809753) * gru_0_out_t2_52 + (0.24525733292102814) * gru_0_out_t2_53 + (-0.034420788288116455) * gru_0_out_t2_54 + (0.23905688524246216) * gru_0_out_t2_55 + (-0.94626873731613159) * gru_0_out_t2_56 + (0.36796814203262329) * gru_0_out_t2_57 + (0.40295311808586121) * gru_0_out_t2_58 + (-0.28895077109336853) * gru_0_out_t2_59 + (-0.10368962585926056) * gru_0_out_t2_60 + (0.12750457227230072) * gru_0_out_t2_61 + (0.40303006768226624) * gru_0_out_t2_62 + (-0.81972134113311768) * gru_0_out_t2_63 + (-0.025362500920891762) * gru_1_fwd_t1_h_0 + (0.068032644689083099) * gru_1_fwd_t1_h_1 + (-0.01480433251708746) * gru_1_fwd_t1_h_2 + (-0.10420854389667511) * gru_1_fwd_t1_h_3 + (0.24562780559062958) * gru_1_fwd_t1_h_4 + (-0.60891950130462646) * gru_1_fwd_t1_h_5 + (1.3492237329483032) * gru_1_fwd_t1_h_6 + (-0.0036997867282480001) * gru_1_fwd_t1_h_7 + (0.059560440480709076) * gru_1_fwd_t1_h_8 + (-0.50457698106765747) * gru_1_fwd_t1_h_9 + (-0.07717672735452652) * gru_1_fwd_t1_h_10 + (-0.1197144091129303) * gru_1_fwd_t1_h_11 + (0.57955014705657959) * gru_1_fwd_t1_h_12 + (0.05020596832036972) * gru_1_fwd_t1_h_13 + (0.19641812145709991) * gru_1_fwd_t1_h_14 + (0.053693864494562149) * gru_1_fwd_t1_h_15 + (0.12208060920238495) * gru_1_fwd_t1_h_16 + (-0.15171648561954498) * gru_1_fwd_t1_h_17 + (0.06613602489233017) * gru_1_fwd_t1_h_18 + (-0.30470776557922363) * gru_1_fwd_t1_h_19 + (-0.80731266736984253) * gru_1_fwd_t1_h_20 + (-0.3181096613407135) * gru_1_fwd_t1_h_21 + (0.086313188076019287) * gru_1_fwd_t1_h_22 + (1.4913443326950073) * gru_1_fwd_t1_h_23 + (0.68173068761825562) * gru_1_fwd_t1_h_24 + (-0.29399922490119934) * gru_1_fwd_t1_h_25 + (-1.0101847648620605) * gru_1_fwd_t1_h_26 + (0.62208986282348633) * gru_1_fwd_t1_h_27 + (0.65831947326660156) * gru_1_fwd_t1_h_28 + (-0.15380315482616425) * gru_1_fwd_t1_h_29 + (0.3716224730014801) * gru_1_fwd_t1_h_30 + (0.22753161191940308) * gru_1_fwd_t1_h_31);
    gate_n = tanh((0.031540911644697189) + (0.47233325242996216) * gru_0_out_t2_0 + (-0.21989732980728149) * gru_0_out_t2_1 + (0.64783847332000732) * gru_0_out_t2_2 + (-1.1872661113739014) * gru_0_out_t2_3 + (-0.0083560682833194733) * gru_0_out_t2_4 + (-0.31690105795860291) * gru_0_out_t2_5 + (-0.21814532577991486) * gru_0_out_t2_6 + (-0.33134752511978149) * gru_0_out_t2_7 + (-0.51764380931854248) * gru_0_out_t2_8 + (-0.32408514618873596) * gru_0_out_t2_9 + (-0.4112669825553894) * gru_0_out_t2_10 + (-0.20532055199146271) * gru_0_out_t2_11 + (0.27936142683029175) * gru_0_out_t2_12 + (0.15096130967140198) * gru_0_out_t2_13 + (0.28147155046463013) * gru_0_out_t2_14 + (-0.11228138208389282) * gru_0_out_t2_15 + (0.076494492590427399) * gru_0_out_t2_16 + (-0.1397085040807724) * gru_0_out_t2_17 + (0.10811130702495575) * gru_0_out_t2_18 + (0.72266745567321777) * gru_0_out_t2_19 + (0.08568786084651947) * gru_0_out_t2_20 + (0.90161734819412231) * gru_0_out_t2_21 + (-0.11648587137460709) * gru_0_out_t2_22 + (0.58647835254669189) * gru_0_out_t2_23 + (0.57794785499572754) * gru_0_out_t2_24 + (-0.23746533691883087) * gru_0_out_t2_25 + (-0.46843990683555603) * gru_0_out_t2_26 + (0.2963099479675293) * gru_0_out_t2_27 + (0.62426209449768066) * gru_0_out_t2_28 + (-1.4680942296981812) * gru_0_out_t2_29 + (0.30194851756095886) * gru_0_out_t2_30 + (-0.28101557493209839) * gru_0_out_t2_31 + (0.34312805533409119) * gru_0_out_t2_32 + (0.36899793148040771) * gru_0_out_t2_33 + (0.21274296939373016) * gru_0_out_t2_34 + (0.10226816684007645) * gru_0_out_t2_35 + (-0.068835332989692688) * gru_0_out_t2_36 + (0.53790748119354248) * gru_0_out_t2_37 + (-0.4020475447177887) * gru_0_out_t2_38 + (-0.72612583637237549) * gru_0_out_t2_39 + (1.4549376964569092) * gru_0_out_t2_40 + (0.40338665246963501) * gru_0_out_t2_41 + (-0.28720459342002869) * gru_0_out_t2_42 + (-0.009017283096909523) * gru_0_out_t2_43 + (-0.14693491160869598) * gru_0_out_t2_44 + (0.011098532006144524) * gru_0_out_t2_45 + (-0.47354105114936829) * gru_0_out_t2_46 + (-0.39296433329582214) * gru_0_out_t2_47 + (-0.78385835886001587) * gru_0_out_t2_48 + (1.0284069776535034) * gru_0_out_t2_49 + (0.43505874276161194) * gru_0_out_t2_50 + (0.037796374410390854) * gru_0_out_t2_51 + (-0.62444961071014404) * gru_0_out_t2_52 + (0.26258182525634766) * gru_0_out_t2_53 + (0.13055819272994995) * gru_0_out_t2_54 + (-0.03455645963549614) * gru_0_out_t2_55 + (-0.12131097167730331) * gru_0_out_t2_56 + (0.48566716909408569) * gru_0_out_t2_57 + (0.43809017539024353) * gru_0_out_t2_58 + (-0.43170493841171265) * gru_0_out_t2_59 + (-0.66450291872024536) * gru_0_out_t2_60 + (-0.58787930011749268) * gru_0_out_t2_61 + (0.38959607481956482) * gru_0_out_t2_62 + (0.186565101146698) * gru_0_out_t2_63 + gate_r * ((-0.18905466794967651) + (-0.34556218981742859) * gru_1_fwd_t1_h_0 + (-0.12713414430618286) * gru_1_fwd_t1_h_1 + (0.2378353625535965) * gru_1_fwd_t1_h_2 + (-0.28490576148033142) * gru_1_fwd_t1_h_3 + (0.068640433251857758) * gru_1_fwd_t1_h_4 + (-2.869704008102417) * gru_1_fwd_t1_h_5 + (-0.0092148398980498314) * gru_1_fwd_t1_h_6 + (0.29293087124824524) * gru_1_fwd_t1_h_7 + (-0.43051546812057495) * gru_1_fwd_t1_h_8 + (0.5777353048324585) * gru_1_fwd_t1_h_9 + (-1.0019686222076416) * gru_1_fwd_t1_h_10 + (-0.9779248833656311) * gru_1_fwd_t1_h_11 + (0.38501018285751343) * gru_1_fwd_t1_h_12 + (-2.1401140689849854) * gru_1_fwd_t1_h_13 + (0.4621255099773407) * gru_1_fwd_t1_h_14 + (-0.59556442499160767) * gru_1_fwd_t1_h_15 + (-0.062382113188505173) * gru_1_fwd_t1_h_16 + (-0.26191377639770508) * gru_1_fwd_t1_h_17 + (0.02679443359375) * gru_1_fwd_t1_h_18 + (0.76331323385238647) * gru_1_fwd_t1_h_19 + (-0.13664205372333527) * gru_1_fwd_t1_h_20 + (0.16319230198860168) * gru_1_fwd_t1_h_21 + (-1.0656106472015381) * gru_1_fwd_t1_h_22 + (-1.0251612663269043) * gru_1_fwd_t1_h_23 + (-0.56353086233139038) * gru_1_fwd_t1_h_24 + (-0.8571707010269165) * gru_1_fwd_t1_h_25 + (-0.2981719970703125) * gru_1_fwd_t1_h_26 + (0.98325508832931519) * gru_1_fwd_t1_h_27 + (-0.0082082813605666161) * gru_1_fwd_t1_h_28 + (0.32763898372650146) * gru_1_fwd_t1_h_29 + (-0.70073127746582031) * gru_1_fwd_t1_h_30 + (1.0882366895675659) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_5 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_5;
    // h=6
    gate_r = sigmoid((0.76459360122680664) + (1.1773362159729004) * gru_0_out_t2_0 + (0.39313933253288269) * gru_0_out_t2_1 + (0.39465457201004028) * gru_0_out_t2_2 + (-0.2404157817363739) * gru_0_out_t2_3 + (0.37784329056739807) * gru_0_out_t2_4 + (-0.54295438528060913) * gru_0_out_t2_5 + (-3.7129578590393066) * gru_0_out_t2_6 + (0.36527559161186218) * gru_0_out_t2_7 + (0.60277009010314941) * gru_0_out_t2_8 + (0.047048214823007584) * gru_0_out_t2_9 + (-0.19284708797931671) * gru_0_out_t2_10 + (0.71139025688171387) * gru_0_out_t2_11 + (-0.020187757909297943) * gru_0_out_t2_12 + (-0.028262145817279816) * gru_0_out_t2_13 + (0.33027124404907227) * gru_0_out_t2_14 + (-0.13226217031478882) * gru_0_out_t2_15 + (0.11620502173900604) * gru_0_out_t2_16 + (-0.43401587009429932) * gru_0_out_t2_17 + (1.1213877201080322) * gru_0_out_t2_18 + (-0.58925962448120117) * gru_0_out_t2_19 + (-1.3491681814193726) * gru_0_out_t2_20 + (1.570453405380249) * gru_0_out_t2_21 + (-0.197423055768013) * gru_0_out_t2_22 + (-1.0202078819274902) * gru_0_out_t2_23 + (-0.15360908210277557) * gru_0_out_t2_24 + (0.059443723410367966) * gru_0_out_t2_25 + (-2.4813158512115479) * gru_0_out_t2_26 + (0.59304678440093994) * gru_0_out_t2_27 + (4.5786638259887695) * gru_0_out_t2_28 + (-1.0662459135055542) * gru_0_out_t2_29 + (0.28805246949195862) * gru_0_out_t2_30 + (1.7079511880874634) * gru_0_out_t2_31 + (2.1391003131866455) * gru_0_out_t2_32 + (1.2896127700805664) * gru_0_out_t2_33 + (0.99567717313766479) * gru_0_out_t2_34 + (-0.66504991054534912) * gru_0_out_t2_35 + (-0.50416523218154907) * gru_0_out_t2_36 + (-0.75246673822402954) * gru_0_out_t2_37 + (-1.4722223281860352) * gru_0_out_t2_38 + (0.80610531568527222) * gru_0_out_t2_39 + (-0.48433557152748108) * gru_0_out_t2_40 + (-0.36106148362159729) * gru_0_out_t2_41 + (0.66410684585571289) * gru_0_out_t2_42 + (-0.84550315141677856) * gru_0_out_t2_43 + (-0.52845221757888794) * gru_0_out_t2_44 + (-0.50390523672103882) * gru_0_out_t2_45 + (0.6662369966506958) * gru_0_out_t2_46 + (-0.29274794459342957) * gru_0_out_t2_47 + (0.12070158869028091) * gru_0_out_t2_48 + (-0.22216759622097015) * gru_0_out_t2_49 + (1.5266915559768677) * gru_0_out_t2_50 + (-0.36237996816635132) * gru_0_out_t2_51 + (-1.1659976243972778) * gru_0_out_t2_52 + (1.1051411628723145) * gru_0_out_t2_53 + (-1.1196682453155518) * gru_0_out_t2_54 + (-2.3156278133392334) * gru_0_out_t2_55 + (-1.5915284156799316) * gru_0_out_t2_56 + (-0.16391031444072723) * gru_0_out_t2_57 + (0.090744130313396454) * gru_0_out_t2_58 + (-0.86603474617004395) * gru_0_out_t2_59 + (-0.33621856570243835) * gru_0_out_t2_60 + (-0.32126727700233459) * gru_0_out_t2_61 + (-0.14489290118217468) * gru_0_out_t2_62 + (-1.023180365562439) * gru_0_out_t2_63 + (-0.35406464338302612) * gru_1_fwd_t1_h_0 + (0.10377006977796555) * gru_1_fwd_t1_h_1 + (-0.46227911114692688) * gru_1_fwd_t1_h_2 + (0.043737929314374924) * gru_1_fwd_t1_h_3 + (-0.69072103500366211) * gru_1_fwd_t1_h_4 + (-0.79402053356170654) * gru_1_fwd_t1_h_5 + (0.12364730983972549) * gru_1_fwd_t1_h_6 + (-0.33901917934417725) * gru_1_fwd_t1_h_7 + (-0.84448897838592529) * gru_1_fwd_t1_h_8 + (-0.12796197831630707) * gru_1_fwd_t1_h_9 + (-0.73800200223922729) * gru_1_fwd_t1_h_10 + (-0.85017538070678711) * gru_1_fwd_t1_h_11 + (0.79029905796051025) * gru_1_fwd_t1_h_12 + (1.4431878328323364) * gru_1_fwd_t1_h_13 + (0.045060764998197556) * gru_1_fwd_t1_h_14 + (-0.1001211553812027) * gru_1_fwd_t1_h_15 + (-0.23087327182292938) * gru_1_fwd_t1_h_16 + (0.6926720142364502) * gru_1_fwd_t1_h_17 + (0.15053263306617737) * gru_1_fwd_t1_h_18 + (-0.63395339250564575) * gru_1_fwd_t1_h_19 + (-0.3751884400844574) * gru_1_fwd_t1_h_20 + (1.0023949146270752) * gru_1_fwd_t1_h_21 + (-0.33597999811172485) * gru_1_fwd_t1_h_22 + (-1.184514045715332) * gru_1_fwd_t1_h_23 + (-1.2083083391189575) * gru_1_fwd_t1_h_24 + (-0.62080013751983643) * gru_1_fwd_t1_h_25 + (1.425758957862854) * gru_1_fwd_t1_h_26 + (1.4964048862457275) * gru_1_fwd_t1_h_27 + (0.46128931641578674) * gru_1_fwd_t1_h_28 + (0.397605299949646) * gru_1_fwd_t1_h_29 + (0.072621680796146393) * gru_1_fwd_t1_h_30 + (-0.25709521770477295) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((0.94745713472366333) + (0.19952031970024109) * gru_0_out_t2_0 + (0.17115277051925659) * gru_0_out_t2_1 + (0.4304250180721283) * gru_0_out_t2_2 + (-0.26176232099533081) * gru_0_out_t2_3 + (-0.30260530114173889) * gru_0_out_t2_4 + (1.2153657674789429) * gru_0_out_t2_5 + (-0.37391456961631775) * gru_0_out_t2_6 + (-2.5791745185852051) * gru_0_out_t2_7 + (0.29358094930648804) * gru_0_out_t2_8 + (0.71169668436050415) * gru_0_out_t2_9 + (-0.85432517528533936) * gru_0_out_t2_10 + (-0.058258306235074997) * gru_0_out_t2_11 + (-0.23421435058116913) * gru_0_out_t2_12 + (0.42517215013504028) * gru_0_out_t2_13 + (0.54890978336334229) * gru_0_out_t2_14 + (-0.46774944663047791) * gru_0_out_t2_15 + (-0.35854357481002808) * gru_0_out_t2_16 + (-0.057237345725297928) * gru_0_out_t2_17 + (-0.13408350944519043) * gru_0_out_t2_18 + (3.0529742240905762) * gru_0_out_t2_19 + (0.43066772818565369) * gru_0_out_t2_20 + (-1.3330812454223633) * gru_0_out_t2_21 + (-0.067716553807258606) * gru_0_out_t2_22 + (-1.1275417804718018) * gru_0_out_t2_23 + (0.93979519605636597) * gru_0_out_t2_24 + (-0.36093160510063171) * gru_0_out_t2_25 + (0.34265822172164917) * gru_0_out_t2_26 + (0.22612686455249786) * gru_0_out_t2_27 + (0.91547143459320068) * gru_0_out_t2_28 + (-0.11821962893009186) * gru_0_out_t2_29 + (0.24353335797786713) * gru_0_out_t2_30 + (-1.9840364456176758) * gru_0_out_t2_31 + (0.63217449188232422) * gru_0_out_t2_32 + (-0.084810003638267517) * gru_0_out_t2_33 + (0.27494272589683533) * gru_0_out_t2_34 + (0.23202989995479584) * gru_0_out_t2_35 + (-0.47533267736434937) * gru_0_out_t2_36 + (-0.13814009726047516) * gru_0_out_t2_37 + (0.39985519647598267) * gru_0_out_t2_38 + (0.024828232824802399) * gru_0_out_t2_39 + (1.4525330066680908) * gru_0_out_t2_40 + (0.29987353086471558) * gru_0_out_t2_41 + (-0.87877494096755981) * gru_0_out_t2_42 + (-0.28278917074203491) * gru_0_out_t2_43 + (-0.11271701008081436) * gru_0_out_t2_44 + (0.1878521740436554) * gru_0_out_t2_45 + (-0.1574704498052597) * gru_0_out_t2_46 + (-0.86312580108642578) * gru_0_out_t2_47 + (0.11834605783224106) * gru_0_out_t2_48 + (-0.28594550490379333) * gru_0_out_t2_49 + (0.17625711858272552) * gru_0_out_t2_50 + (0.1331290602684021) * gru_0_out_t2_51 + (0.27163535356521606) * gru_0_out_t2_52 + (0.42060071229934692) * gru_0_out_t2_53 + (0.051985852420330048) * gru_0_out_t2_54 + (-0.0062213572673499584) * gru_0_out_t2_55 + (-0.29058384895324707) * gru_0_out_t2_56 + (0.37827757000923157) * gru_0_out_t2_57 + (-0.5178687572479248) * gru_0_out_t2_58 + (-0.37619715929031372) * gru_0_out_t2_59 + (0.83290857076644897) * gru_0_out_t2_60 + (0.59976065158843994) * gru_0_out_t2_61 + (0.92694211006164551) * gru_0_out_t2_62 + (-0.25257259607315063) * gru_0_out_t2_63 + (-0.074098087847232819) * gru_1_fwd_t1_h_0 + (0.9070894718170166) * gru_1_fwd_t1_h_1 + (-0.23067305982112885) * gru_1_fwd_t1_h_2 + (-0.22644951939582825) * gru_1_fwd_t1_h_3 + (0.1154889315366745) * gru_1_fwd_t1_h_4 + (0.25507375597953796) * gru_1_fwd_t1_h_5 + (1.1701107025146484) * gru_1_fwd_t1_h_6 + (0.12494388222694397) * gru_1_fwd_t1_h_7 + (-0.085724040865898132) * gru_1_fwd_t1_h_8 + (-0.21429407596588135) * gru_1_fwd_t1_h_9 + (-0.15146031975746155) * gru_1_fwd_t1_h_10 + (-0.33074977993965149) * gru_1_fwd_t1_h_11 + (-0.17205296456813812) * gru_1_fwd_t1_h_12 + (0.076486587524414062) * gru_1_fwd_t1_h_13 + (-0.25915640592575073) * gru_1_fwd_t1_h_14 + (0.14803442358970642) * gru_1_fwd_t1_h_15 + (-0.051346171647310257) * gru_1_fwd_t1_h_16 + (-0.25954914093017578) * gru_1_fwd_t1_h_17 + (1.1755720376968384) * gru_1_fwd_t1_h_18 + (0.037849143147468567) * gru_1_fwd_t1_h_19 + (-0.48502182960510254) * gru_1_fwd_t1_h_20 + (0.48684594035148621) * gru_1_fwd_t1_h_21 + (-0.28733724355697632) * gru_1_fwd_t1_h_22 + (0.39173555374145508) * gru_1_fwd_t1_h_23 + (-0.44995519518852234) * gru_1_fwd_t1_h_24 + (0.59650546312332153) * gru_1_fwd_t1_h_25 + (0.38292255997657776) * gru_1_fwd_t1_h_26 + (0.5993722677230835) * gru_1_fwd_t1_h_27 + (-0.2292734682559967) * gru_1_fwd_t1_h_28 + (0.049508798867464066) * gru_1_fwd_t1_h_29 + (0.058367151767015457) * gru_1_fwd_t1_h_30 + (0.11031682789325714) * gru_1_fwd_t1_h_31);
    gate_n = tanh((0.034714270383119583) + (-0.019149502739310265) * gru_0_out_t2_0 + (0.088414795696735382) * gru_0_out_t2_1 + (0.94903814792633057) * gru_0_out_t2_2 + (-0.13115990161895752) * gru_0_out_t2_3 + (-0.86292338371276855) * gru_0_out_t2_4 + (-0.80825477838516235) * gru_0_out_t2_5 + (-1.166118860244751) * gru_0_out_t2_6 + (-0.42149817943572998) * gru_0_out_t2_7 + (-1.3415119647979736) * gru_0_out_t2_8 + (1.7884345054626465) * gru_0_out_t2_9 + (-0.75984042882919312) * gru_0_out_t2_10 + (0.12561789155006409) * gru_0_out_t2_11 + (0.028185836970806122) * gru_0_out_t2_12 + (0.076391689479351044) * gru_0_out_t2_13 + (-0.35391291975975037) * gru_0_out_t2_14 + (0.166725754737854) * gru_0_out_t2_15 + (0.25046643614768982) * gru_0_out_t2_16 + (-0.37020948529243469) * gru_0_out_t2_17 + (0.24743372201919556) * gru_0_out_t2_18 + (-0.40501391887664795) * gru_0_out_t2_19 + (0.78868621587753296) * gru_0_out_t2_20 + (-0.84344297647476196) * gru_0_out_t2_21 + (0.18127129971981049) * gru_0_out_t2_22 + (-0.044270887970924377) * gru_0_out_t2_23 + (0.10432392358779907) * gru_0_out_t2_24 + (-0.53638482093811035) * gru_0_out_t2_25 + (-0.48161187767982483) * gru_0_out_t2_26 + (-0.12305434048175812) * gru_0_out_t2_27 + (-0.29840666055679321) * gru_0_out_t2_28 + (-0.44820886850357056) * gru_0_out_t2_29 + (-0.58027571439743042) * gru_0_out_t2_30 + (0.93065458536148071) * gru_0_out_t2_31 + (0.45623329281806946) * gru_0_out_t2_32 + (0.19596657156944275) * gru_0_out_t2_33 + (0.0019312902586534619) * gru_0_out_t2_34 + (-0.028493326157331467) * gru_0_out_t2_35 + (-0.061247147619724274) * gru_0_out_t2_36 + (0.2122550755739212) * gru_0_out_t2_37 + (-0.069103293120861053) * gru_0_out_t2_38 + (-0.26576307415962219) * gru_0_out_t2_39 + (0.10845258831977844) * gru_0_out_t2_40 + (-0.24806350469589233) * gru_0_out_t2_41 + (-1.1119474172592163) * gru_0_out_t2_42 + (0.085573233664035797) * gru_0_out_t2_43 + (-0.064497925341129303) * gru_0_out_t2_44 + (0.06120188906788826) * gru_0_out_t2_45 + (-0.096967339515686035) * gru_0_out_t2_46 + (-0.043748762458562851) * gru_0_out_t2_47 + (-0.37686190009117126) * gru_0_out_t2_48 + (0.19940827786922455) * gru_0_out_t2_49 + (0.11391185224056244) * gru_0_out_t2_50 + (0.055827073752880096) * gru_0_out_t2_51 + (0.36903059482574463) * gru_0_out_t2_52 + (-0.24178595840930939) * gru_0_out_t2_53 + (-0.021406674757599831) * gru_0_out_t2_54 + (0.18550367653369904) * gru_0_out_t2_55 + (-0.4494994580745697) * gru_0_out_t2_56 + (0.16321928799152374) * gru_0_out_t2_57 + (0.068672716617584229) * gru_0_out_t2_58 + (-0.92650926113128662) * gru_0_out_t2_59 + (0.22732079029083252) * gru_0_out_t2_60 + (-0.24381624162197113) * gru_0_out_t2_61 + (0.045012861490249634) * gru_0_out_t2_62 + (0.83052968978881836) * gru_0_out_t2_63 + gate_r * ((-0.070541158318519592) + (-0.25205060839653015) * gru_1_fwd_t1_h_0 + (0.62958312034606934) * gru_1_fwd_t1_h_1 + (-1.3222763538360596) * gru_1_fwd_t1_h_2 + (0.36704921722412109) * gru_1_fwd_t1_h_3 + (-0.23230831325054169) * gru_1_fwd_t1_h_4 + (-0.31091555953025818) * gru_1_fwd_t1_h_5 + (-1.6422512531280518) * gru_1_fwd_t1_h_6 + (0.80958515405654907) * gru_1_fwd_t1_h_7 + (0.3747066855430603) * gru_1_fwd_t1_h_8 + (0.1373283714056015) * gru_1_fwd_t1_h_9 + (0.30883616209030151) * gru_1_fwd_t1_h_10 + (-0.19474460184574127) * gru_1_fwd_t1_h_11 + (0.3768666684627533) * gru_1_fwd_t1_h_12 + (-0.064700111746788025) * gru_1_fwd_t1_h_13 + (0.47193178534507751) * gru_1_fwd_t1_h_14 + (-2.3072104454040527) * gru_1_fwd_t1_h_15 + (0.38318246603012085) * gru_1_fwd_t1_h_16 + (0.80570328235626221) * gru_1_fwd_t1_h_17 + (0.74382573366165161) * gru_1_fwd_t1_h_18 + (-0.54933947324752808) * gru_1_fwd_t1_h_19 + (-0.65048331022262573) * gru_1_fwd_t1_h_20 + (-0.63634181022644043) * gru_1_fwd_t1_h_21 + (-1.490329384803772) * gru_1_fwd_t1_h_22 + (-0.55466121435165405) * gru_1_fwd_t1_h_23 + (0.76286286115646362) * gru_1_fwd_t1_h_24 + (-0.32742288708686829) * gru_1_fwd_t1_h_25 + (-0.71702730655670166) * gru_1_fwd_t1_h_26 + (-0.075722783803939819) * gru_1_fwd_t1_h_27 + (0.49781480431556702) * gru_1_fwd_t1_h_28 + (0.42725428938865662) * gru_1_fwd_t1_h_29 + (2.055647611618042) * gru_1_fwd_t1_h_30 + (0.22875726222991943) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_6 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_6;
    // h=7
    gate_r = sigmoid((-0.57000583410263062) + (0.60143899917602539) * gru_0_out_t2_0 + (-0.34616762399673462) * gru_0_out_t2_1 + (0.43442878127098083) * gru_0_out_t2_2 + (0.018908923491835594) * gru_0_out_t2_3 + (-0.36114731431007385) * gru_0_out_t2_4 + (0.33017802238464355) * gru_0_out_t2_5 + (-1.2108395099639893) * gru_0_out_t2_6 + (-1.1105753183364868) * gru_0_out_t2_7 + (0.29367673397064209) * gru_0_out_t2_8 + (1.1485131978988647) * gru_0_out_t2_9 + (-0.23649276793003082) * gru_0_out_t2_10 + (0.99000167846679688) * gru_0_out_t2_11 + (0.020332150161266327) * gru_0_out_t2_12 + (-0.11516355723142624) * gru_0_out_t2_13 + (-1.1770225763320923) * gru_0_out_t2_14 + (0.033193498849868774) * gru_0_out_t2_15 + (0.2323954701423645) * gru_0_out_t2_16 + (0.82852435111999512) * gru_0_out_t2_17 + (-0.11102500557899475) * gru_0_out_t2_18 + (0.26872444152832031) * gru_0_out_t2_19 + (0.91837584972381592) * gru_0_out_t2_20 + (0.15690590441226959) * gru_0_out_t2_21 + (0.26445075869560242) * gru_0_out_t2_22 + (-0.32661858201026917) * gru_0_out_t2_23 + (-0.75360876321792603) * gru_0_out_t2_24 + (0.22215162217617035) * gru_0_out_t2_25 + (1.4408731460571289) * gru_0_out_t2_26 + (-0.11756745725870132) * gru_0_out_t2_27 + (1.1117973327636719) * gru_0_out_t2_28 + (-0.13249459862709045) * gru_0_out_t2_29 + (-0.53164851665496826) * gru_0_out_t2_30 + (2.2798118591308594) * gru_0_out_t2_31 + (-0.82826071977615356) * gru_0_out_t2_32 + (0.69451487064361572) * gru_0_out_t2_33 + (-0.90443098545074463) * gru_0_out_t2_34 + (0.15578649938106537) * gru_0_out_t2_35 + (1.4636470079421997) * gru_0_out_t2_36 + (-0.03979690745472908) * gru_0_out_t2_37 + (-0.61587762832641602) * gru_0_out_t2_38 + (-1.0108344554901123) * gru_0_out_t2_39 + (0.14652037620544434) * gru_0_out_t2_40 + (-0.12215832620859146) * gru_0_out_t2_41 + (-0.10543761402368546) * gru_0_out_t2_42 + (0.19575150310993195) * gru_0_out_t2_43 + (-0.20975948870182037) * gru_0_out_t2_44 + (0.013654931448400021) * gru_0_out_t2_45 + (-0.074203528463840485) * gru_0_out_t2_46 + (0.42647185921669006) * gru_0_out_t2_47 + (-0.12567035853862762) * gru_0_out_t2_48 + (-0.17135573923587799) * gru_0_out_t2_49 + (-0.057796943932771683) * gru_0_out_t2_50 + (0.5851895809173584) * gru_0_out_t2_51 + (-0.21736569702625275) * gru_0_out_t2_52 + (-0.51654022932052612) * gru_0_out_t2_53 + (0.24226561188697815) * gru_0_out_t2_54 + (-0.46034911274909973) * gru_0_out_t2_55 + (0.12739412486553192) * gru_0_out_t2_56 + (-0.083451375365257263) * gru_0_out_t2_57 + (-0.19122046232223511) * gru_0_out_t2_58 + (0.28015574812889099) * gru_0_out_t2_59 + (0.48837527632713318) * gru_0_out_t2_60 + (-0.29203051328659058) * gru_0_out_t2_61 + (0.88895028829574585) * gru_0_out_t2_62 + (0.51885038614273071) * gru_0_out_t2_63 + (0.20890574157238007) * gru_1_fwd_t1_h_0 + (1.3259862661361694) * gru_1_fwd_t1_h_1 + (-0.5246843695640564) * gru_1_fwd_t1_h_2 + (0.17627108097076416) * gru_1_fwd_t1_h_3 + (-0.17088823020458221) * gru_1_fwd_t1_h_4 + (1.027660608291626) * gru_1_fwd_t1_h_5 + (-0.1161094531416893) * gru_1_fwd_t1_h_6 + (-0.20577150583267212) * gru_1_fwd_t1_h_7 + (-0.2823159396648407) * gru_1_fwd_t1_h_8 + (0.0013251815689727664) * gru_1_fwd_t1_h_9 + (3.4515631198883057) * gru_1_fwd_t1_h_10 + (0.015421911142766476) * gru_1_fwd_t1_h_11 + (0.12974274158477783) * gru_1_fwd_t1_h_12 + (0.10253067314624786) * gru_1_fwd_t1_h_13 + (-0.35187667608261108) * gru_1_fwd_t1_h_14 + (-0.39213207364082336) * gru_1_fwd_t1_h_15 + (-0.76099658012390137) * gru_1_fwd_t1_h_16 + (1.1098989248275757) * gru_1_fwd_t1_h_17 + (0.14096450805664062) * gru_1_fwd_t1_h_18 + (-0.011313090100884438) * gru_1_fwd_t1_h_19 + (0.10299281030893326) * gru_1_fwd_t1_h_20 + (-0.44048330187797546) * gru_1_fwd_t1_h_21 + (-0.74914354085922241) * gru_1_fwd_t1_h_22 + (2.6502466201782227) * gru_1_fwd_t1_h_23 + (-1.0253069400787354) * gru_1_fwd_t1_h_24 + (1.2537201642990112) * gru_1_fwd_t1_h_25 + (0.28998634219169617) * gru_1_fwd_t1_h_26 + (-2.436570405960083) * gru_1_fwd_t1_h_27 + (0.32884305715560913) * gru_1_fwd_t1_h_28 + (0.49490135908126831) * gru_1_fwd_t1_h_29 + (0.35284796357154846) * gru_1_fwd_t1_h_30 + (-0.065326586365699768) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((-0.04587140679359436) + (-0.35687056183815002) * gru_0_out_t2_0 + (-0.28274351358413696) * gru_0_out_t2_1 + (1.1979606151580811) * gru_0_out_t2_2 + (-0.15568332374095917) * gru_0_out_t2_3 + (-0.12012603878974915) * gru_0_out_t2_4 + (-0.18984976410865784) * gru_0_out_t2_5 + (-0.4434979259967804) * gru_0_out_t2_6 + (-2.2133409976959229) * gru_0_out_t2_7 + (-0.39229437708854675) * gru_0_out_t2_8 + (0.63607794046401978) * gru_0_out_t2_9 + (-0.87499696016311646) * gru_0_out_t2_10 + (-0.032131984829902649) * gru_0_out_t2_11 + (0.64669430255889893) * gru_0_out_t2_12 + (0.30946400761604309) * gru_0_out_t2_13 + (-0.37176910042762756) * gru_0_out_t2_14 + (-0.020910557359457016) * gru_0_out_t2_15 + (-0.039968144148588181) * gru_0_out_t2_16 + (-0.14695039391517639) * gru_0_out_t2_17 + (-0.082609236240386963) * gru_0_out_t2_18 + (-0.79512906074523926) * gru_0_out_t2_19 + (-0.57077944278717041) * gru_0_out_t2_20 + (-0.27464640140533447) * gru_0_out_t2_21 + (0.37936487793922424) * gru_0_out_t2_22 + (0.36963459849357605) * gru_0_out_t2_23 + (0.37212207913398743) * gru_0_out_t2_24 + (0.47228339314460754) * gru_0_out_t2_25 + (0.34702771902084351) * gru_0_out_t2_26 + (0.41428637504577637) * gru_0_out_t2_27 + (-0.30559545755386353) * gru_0_out_t2_28 + (-0.98354828357696533) * gru_0_out_t2_29 + (0.12244810909032822) * gru_0_out_t2_30 + (-0.22895856201648712) * gru_0_out_t2_31 + (0.22479765117168427) * gru_0_out_t2_32 + (0.20986883342266083) * gru_0_out_t2_33 + (-0.34161153435707092) * gru_0_out_t2_34 + (0.40240225195884705) * gru_0_out_t2_35 + (0.40611159801483154) * gru_0_out_t2_36 + (-0.19525398313999176) * gru_0_out_t2_37 + (0.0755438432097435) * gru_0_out_t2_38 + (-0.59957772493362427) * gru_0_out_t2_39 + (-3.2859678268432617) * gru_0_out_t2_40 + (0.070327028632164001) * gru_0_out_t2_41 + (0.15265622735023499) * gru_0_out_t2_42 + (-0.028146238997578621) * gru_0_out_t2_43 + (0.022973706945776939) * gru_0_out_t2_44 + (-0.0021095494739711285) * gru_0_out_t2_45 + (0.38883876800537109) * gru_0_out_t2_46 + (-0.023833438754081726) * gru_0_out_t2_47 + (-0.085472621023654938) * gru_0_out_t2_48 + (-0.27147987484931946) * gru_0_out_t2_49 + (-0.21113298833370209) * gru_0_out_t2_50 + (-0.37891045212745667) * gru_0_out_t2_51 + (-0.42761683464050293) * gru_0_out_t2_52 + (0.39080512523651123) * gru_0_out_t2_53 + (0.32834744453430176) * gru_0_out_t2_54 + (-0.91004657745361328) * gru_0_out_t2_55 + (0.19832019507884979) * gru_0_out_t2_56 + (-0.40268641710281372) * gru_0_out_t2_57 + (0.21979790925979614) * gru_0_out_t2_58 + (-0.047154247760772705) * gru_0_out_t2_59 + (-0.0083832563832402229) * gru_0_out_t2_60 + (-0.059801533818244934) * gru_0_out_t2_61 + (0.79434633255004883) * gru_0_out_t2_62 + (1.0997198820114136) * gru_0_out_t2_63 + (0.35185918211936951) * gru_1_fwd_t1_h_0 + (0.017235325649380684) * gru_1_fwd_t1_h_1 + (0.16532060503959656) * gru_1_fwd_t1_h_2 + (-0.27811962366104126) * gru_1_fwd_t1_h_3 + (0.41657838225364685) * gru_1_fwd_t1_h_4 + (-0.77591031789779663) * gru_1_fwd_t1_h_5 + (0.68028551340103149) * gru_1_fwd_t1_h_6 + (-0.80130678415298462) * gru_1_fwd_t1_h_7 + (-0.020184420049190521) * gru_1_fwd_t1_h_8 + (-0.14579449594020844) * gru_1_fwd_t1_h_9 + (0.22321555018424988) * gru_1_fwd_t1_h_10 + (0.36593380570411682) * gru_1_fwd_t1_h_11 + (-0.55209213495254517) * gru_1_fwd_t1_h_12 + (-0.11661341041326523) * gru_1_fwd_t1_h_13 + (0.29122602939605713) * gru_1_fwd_t1_h_14 + (-0.15962731838226318) * gru_1_fwd_t1_h_15 + (-0.40360337495803833) * gru_1_fwd_t1_h_16 + (-0.12692645192146301) * gru_1_fwd_t1_h_17 + (-0.014457837678492069) * gru_1_fwd_t1_h_18 + (-0.057844143360853195) * gru_1_fwd_t1_h_19 + (0.1149938628077507) * gru_1_fwd_t1_h_20 + (0.32896265387535095) * gru_1_fwd_t1_h_21 + (-0.5943145751953125) * gru_1_fwd_t1_h_22 + (1.1632881164550781) * gru_1_fwd_t1_h_23 + (0.3828166127204895) * gru_1_fwd_t1_h_24 + (0.13662689924240112) * gru_1_fwd_t1_h_25 + (0.20607554912567139) * gru_1_fwd_t1_h_26 + (0.22043789923191071) * gru_1_fwd_t1_h_27 + (0.8160930871963501) * gru_1_fwd_t1_h_28 + (0.35373106598854065) * gru_1_fwd_t1_h_29 + (-0.47974181175231934) * gru_1_fwd_t1_h_30 + (0.16642317175865173) * gru_1_fwd_t1_h_31);
    gate_n = tanh((0.061455216258764267) + (0.0033203964121639729) * gru_0_out_t2_0 + (0.050928425043821335) * gru_0_out_t2_1 + (-0.3327631950378418) * gru_0_out_t2_2 + (0.25804194808006287) * gru_0_out_t2_3 + (-0.34847807884216309) * gru_0_out_t2_4 + (-0.050129801034927368) * gru_0_out_t2_5 + (-0.072988018393516541) * gru_0_out_t2_6 + (0.72246628999710083) * gru_0_out_t2_7 + (-0.26640212535858154) * gru_0_out_t2_8 + (0.99001336097717285) * gru_0_out_t2_9 + (0.19103866815567017) * gru_0_out_t2_10 + (-0.063968971371650696) * gru_0_out_t2_11 + (0.0034376280382275581) * gru_0_out_t2_12 + (-0.38272193074226379) * gru_0_out_t2_13 + (0.012780452147126198) * gru_0_out_t2_14 + (0.22483208775520325) * gru_0_out_t2_15 + (0.093963518738746643) * gru_0_out_t2_16 + (-0.26786479353904724) * gru_0_out_t2_17 + (0.015466516837477684) * gru_0_out_t2_18 + (-0.45537236332893372) * gru_0_out_t2_19 + (-0.93574541807174683) * gru_0_out_t2_20 + (-0.15271390974521637) * gru_0_out_t2_21 + (0.03541097417473793) * gru_0_out_t2_22 + (0.3130963146686554) * gru_0_out_t2_23 + (0.19784095883369446) * gru_0_out_t2_24 + (0.046400103718042374) * gru_0_out_t2_25 + (-0.035990145057439804) * gru_0_out_t2_26 + (0.084829442203044891) * gru_0_out_t2_27 + (1.793291449546814) * gru_0_out_t2_28 + (-0.75447118282318115) * gru_0_out_t2_29 + (-0.17484070360660553) * gru_0_out_t2_30 + (-0.078498572111129761) * gru_0_out_t2_31 + (0.31502988934516907) * gru_0_out_t2_32 + (-0.13800683617591858) * gru_0_out_t2_33 + (0.26904436945915222) * gru_0_out_t2_34 + (-0.024464933201670647) * gru_0_out_t2_35 + (0.14852137863636017) * gru_0_out_t2_36 + (0.40926384925842285) * gru_0_out_t2_37 + (-0.01457647792994976) * gru_0_out_t2_38 + (-0.049028921872377396) * gru_0_out_t2_39 + (-1.3480129241943359) * gru_0_out_t2_40 + (-0.18059089779853821) * gru_0_out_t2_41 + (0.09233517199754715) * gru_0_out_t2_42 + (-0.047973483800888062) * gru_0_out_t2_43 + (-0.023851711302995682) * gru_0_out_t2_44 + (0.072189025580883026) * gru_0_out_t2_45 + (-0.19791175425052643) * gru_0_out_t2_46 + (-0.19294600188732147) * gru_0_out_t2_47 + (-0.6197471022605896) * gru_0_out_t2_48 + (0.57739001512527466) * gru_0_out_t2_49 + (0.25707843899726868) * gru_0_out_t2_50 + (-0.054586227983236313) * gru_0_out_t2_51 + (0.12624981999397278) * gru_0_out_t2_52 + (0.15557032823562622) * gru_0_out_t2_53 + (-0.017403583973646164) * gru_0_out_t2_54 + (0.27207943797111511) * gru_0_out_t2_55 + (-0.010869130492210388) * gru_0_out_t2_56 + (0.53073924779891968) * gru_0_out_t2_57 + (-0.13076390326023102) * gru_0_out_t2_58 + (0.23003807663917542) * gru_0_out_t2_59 + (-0.23338501155376434) * gru_0_out_t2_60 + (-0.26638278365135193) * gru_0_out_t2_61 + (-0.08728974312543869) * gru_0_out_t2_62 + (-0.43671014904975891) * gru_0_out_t2_63 + gate_r * ((-0.06018500030040741) + (-0.089460760354995728) * gru_1_fwd_t1_h_0 + (0.12257453799247742) * gru_1_fwd_t1_h_1 + (0.17234437167644501) * gru_1_fwd_t1_h_2 + (-1.7898521423339844) * gru_1_fwd_t1_h_3 + (0.0025222762487828732) * gru_1_fwd_t1_h_4 + (-0.00066971714841201901) * gru_1_fwd_t1_h_5 + (-0.49670982360839844) * gru_1_fwd_t1_h_6 + (-1.0767092704772949) * gru_1_fwd_t1_h_7 + (-0.21238161623477936) * gru_1_fwd_t1_h_8 + (-0.26275479793548584) * gru_1_fwd_t1_h_9 + (-0.1706220805644989) * gru_1_fwd_t1_h_10 + (-0.077945075929164886) * gru_1_fwd_t1_h_11 + (-0.24435724318027496) * gru_1_fwd_t1_h_12 + (-0.014147616922855377) * gru_1_fwd_t1_h_13 + (0.30601140856742859) * gru_1_fwd_t1_h_14 + (-0.13647812604904175) * gru_1_fwd_t1_h_15 + (-0.096951425075531006) * gru_1_fwd_t1_h_16 + (0.83204227685928345) * gru_1_fwd_t1_h_17 + (-0.338247150182724) * gru_1_fwd_t1_h_18 + (0.21214745938777924) * gru_1_fwd_t1_h_19 + (-0.092272110283374786) * gru_1_fwd_t1_h_20 + (-0.49177426099777222) * gru_1_fwd_t1_h_21 + (0.62521463632583618) * gru_1_fwd_t1_h_22 + (-0.17303232848644257) * gru_1_fwd_t1_h_23 + (1.0641378164291382) * gru_1_fwd_t1_h_24 + (-0.11403832584619522) * gru_1_fwd_t1_h_25 + (0.44741058349609375) * gru_1_fwd_t1_h_26 + (-0.20227669179439545) * gru_1_fwd_t1_h_27 + (0.73414385318756104) * gru_1_fwd_t1_h_28 + (0.50695902109146118) * gru_1_fwd_t1_h_29 + (0.11534740030765533) * gru_1_fwd_t1_h_30 + (1.389542818069458) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_7 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_7;
    // h=8
    gate_r = sigmoid((-1.0318014621734619) + (0.17103193700313568) * gru_0_out_t2_0 + (0.52527540922164917) * gru_0_out_t2_1 + (-0.68667298555374146) * gru_0_out_t2_2 + (0.05792628601193428) * gru_0_out_t2_3 + (0.016641827300190926) * gru_0_out_t2_4 + (-0.29880091547966003) * gru_0_out_t2_5 + (1.2979668378829956) * gru_0_out_t2_6 + (-0.37169763445854187) * gru_0_out_t2_7 + (0.62186717987060547) * gru_0_out_t2_8 + (-5.0760917663574219) * gru_0_out_t2_9 + (1.7507946491241455) * gru_0_out_t2_10 + (0.13619107007980347) * gru_0_out_t2_11 + (-0.62493777275085449) * gru_0_out_t2_12 + (0.081656254827976227) * gru_0_out_t2_13 + (0.27495947480201721) * gru_0_out_t2_14 + (-0.75284045934677124) * gru_0_out_t2_15 + (0.58226627111434937) * gru_0_out_t2_16 + (0.8292233943939209) * gru_0_out_t2_17 + (0.082769982516765594) * gru_0_out_t2_18 + (-0.96307277679443359) * gru_0_out_t2_19 + (-1.4835569858551025) * gru_0_out_t2_20 + (0.4258829653263092) * gru_0_out_t2_21 + (1.8687838315963745) * gru_0_out_t2_22 + (0.18812599778175354) * gru_0_out_t2_23 + (1.8067096471786499) * gru_0_out_t2_24 + (0.48098963499069214) * gru_0_out_t2_25 + (0.66985493898391724) * gru_0_out_t2_26 + (-1.2702208757400513) * gru_0_out_t2_27 + (-0.47981390357017517) * gru_0_out_t2_28 + (-0.34997612237930298) * gru_0_out_t2_29 + (-0.48956295847892761) * gru_0_out_t2_30 + (0.68935388326644897) * gru_0_out_t2_31 + (-1.0631533861160278) * gru_0_out_t2_32 + (0.10105585306882858) * gru_0_out_t2_33 + (0.2129330188035965) * gru_0_out_t2_34 + (-0.50255215167999268) * gru_0_out_t2_35 + (-0.22911237180233002) * gru_0_out_t2_36 + (0.14020664989948273) * gru_0_out_t2_37 + (0.091257408261299133) * gru_0_out_t2_38 + (-1.4111729860305786) * gru_0_out_t2_39 + (1.4865436553955078) * gru_0_out_t2_40 + (-0.49499478936195374) * gru_0_out_t2_41 + (-0.85397326946258545) * gru_0_out_t2_42 + (-0.31279641389846802) * gru_0_out_t2_43 + (-0.79412925243377686) * gru_0_out_t2_44 + (-0.2955782413482666) * gru_0_out_t2_45 + (-1.9063620567321777) * gru_0_out_t2_46 + (1.320256233215332) * gru_0_out_t2_47 + (1.4140074253082275) * gru_0_out_t2_48 + (-1.5690916776657104) * gru_0_out_t2_49 + (-0.60699081420898438) * gru_0_out_t2_50 + (-0.089812979102134705) * gru_0_out_t2_51 + (0.17918041348457336) * gru_0_out_t2_52 + (-0.84683704376220703) * gru_0_out_t2_53 + (0.38689064979553223) * gru_0_out_t2_54 + (0.69394266605377197) * gru_0_out_t2_55 + (0.34176114201545715) * gru_0_out_t2_56 + (-1.2408504486083984) * gru_0_out_t2_57 + (0.37757673859596252) * gru_0_out_t2_58 + (0.054300688207149506) * gru_0_out_t2_59 + (1.3631730079650879) * gru_0_out_t2_60 + (-0.69682574272155762) * gru_0_out_t2_61 + (-1.1872062683105469) * gru_0_out_t2_62 + (-1.5471545457839966) * gru_0_out_t2_63 + (0.37860190868377686) * gru_1_fwd_t1_h_0 + (-0.04791974276304245) * gru_1_fwd_t1_h_1 + (-0.047778312116861343) * gru_1_fwd_t1_h_2 + (0.74641793966293335) * gru_1_fwd_t1_h_3 + (0.57086378335952759) * gru_1_fwd_t1_h_4 + (-0.33596926927566528) * gru_1_fwd_t1_h_5 + (1.7594560384750366) * gru_1_fwd_t1_h_6 + (0.26549217104911804) * gru_1_fwd_t1_h_7 + (-0.056544531136751175) * gru_1_fwd_t1_h_8 + (0.26164224743843079) * gru_1_fwd_t1_h_9 + (-0.86008936166763306) * gru_1_fwd_t1_h_10 + (0.12446083873510361) * gru_1_fwd_t1_h_11 + (-0.13339821994304657) * gru_1_fwd_t1_h_12 + (-1.3404190540313721) * gru_1_fwd_t1_h_13 + (0.072261996567249298) * gru_1_fwd_t1_h_14 + (-0.72096431255340576) * gru_1_fwd_t1_h_15 + (-0.59500092267990112) * gru_1_fwd_t1_h_16 + (0.16276605427265167) * gru_1_fwd_t1_h_17 + (0.65126800537109375) * gru_1_fwd_t1_h_18 + (0.74893105030059814) * gru_1_fwd_t1_h_19 + (0.73354709148406982) * gru_1_fwd_t1_h_20 + (1.4928306341171265) * gru_1_fwd_t1_h_21 + (1.277287483215332) * gru_1_fwd_t1_h_22 + (-1.9760726690292358) * gru_1_fwd_t1_h_23 + (-0.78865158557891846) * gru_1_fwd_t1_h_24 + (0.45857417583465576) * gru_1_fwd_t1_h_25 + (-1.366777777671814) * gru_1_fwd_t1_h_26 + (-0.49519050121307373) * gru_1_fwd_t1_h_27 + (-0.5595855712890625) * gru_1_fwd_t1_h_28 + (0.12270007282495499) * gru_1_fwd_t1_h_29 + (0.44194906949996948) * gru_1_fwd_t1_h_30 + (0.19067232310771942) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((-0.15419253706932068) + (0.085529021918773651) * gru_0_out_t2_0 + (0.043661359697580338) * gru_0_out_t2_1 + (-0.014465460553765297) * gru_0_out_t2_2 + (-0.0024183155037462711) * gru_0_out_t2_3 + (-0.28213861584663391) * gru_0_out_t2_4 + (0.26499569416046143) * gru_0_out_t2_5 + (1.2104355096817017) * gru_0_out_t2_6 + (-0.45981505513191223) * gru_0_out_t2_7 + (0.29836612939834595) * gru_0_out_t2_8 + (-0.48472622036933899) * gru_0_out_t2_9 + (0.42181247472763062) * gru_0_out_t2_10 + (0.39907562732696533) * gru_0_out_t2_11 + (0.33805418014526367) * gru_0_out_t2_12 + (0.059355918318033218) * gru_0_out_t2_13 + (-0.2656695544719696) * gru_0_out_t2_14 + (0.52614820003509521) * gru_0_out_t2_15 + (0.015267596580088139) * gru_0_out_t2_16 + (0.43621829152107239) * gru_0_out_t2_17 + (-0.23042848706245422) * gru_0_out_t2_18 + (0.74136233329772949) * gru_0_out_t2_19 + (-0.31372761726379395) * gru_0_out_t2_20 + (-0.10311326384544373) * gru_0_out_t2_21 + (0.46559607982635498) * gru_0_out_t2_22 + (-0.28704813122749329) * gru_0_out_t2_23 + (-0.048308972269296646) * gru_0_out_t2_24 + (-0.26197236776351929) * gru_0_out_t2_25 + (0.11784367263317108) * gru_0_out_t2_26 + (0.16303637623786926) * gru_0_out_t2_27 + (0.092301934957504272) * gru_0_out_t2_28 + (0.75247973203659058) * gru_0_out_t2_29 + (-0.076546832919120789) * gru_0_out_t2_30 + (0.14334911108016968) * gru_0_out_t2_31 + (-0.098112225532531738) * gru_0_out_t2_32 + (0.39604166150093079) * gru_0_out_t2_33 + (-0.039955247193574905) * gru_0_out_t2_34 + (-0.0057545732706785202) * gru_0_out_t2_35 + (-0.21618099510669708) * gru_0_out_t2_36 + (-0.047250498086214066) * gru_0_out_t2_37 + (0.15693594515323639) * gru_0_out_t2_38 + (-0.35932466387748718) * gru_0_out_t2_39 + (-2.717975378036499) * gru_0_out_t2_40 + (-0.074914731085300446) * gru_0_out_t2_41 + (-0.053719431161880493) * gru_0_out_t2_42 + (0.00019771956431213766) * gru_0_out_t2_43 + (-0.081305176019668579) * gru_0_out_t2_44 + (0.012241839431226254) * gru_0_out_t2_45 + (-0.14052689075469971) * gru_0_out_t2_46 + (0.64433598518371582) * gru_0_out_t2_47 + (0.77447652816772461) * gru_0_out_t2_48 + (-0.79187458753585815) * gru_0_out_t2_49 + (-0.081405967473983765) * gru_0_out_t2_50 + (0.30794540047645569) * gru_0_out_t2_51 + (0.50678980350494385) * gru_0_out_t2_52 + (-0.28384947776794434) * gru_0_out_t2_53 + (-0.15214481949806213) * gru_0_out_t2_54 + (0.0066971695050597191) * gru_0_out_t2_55 + (0.013690697029232979) * gru_0_out_t2_56 + (-0.47321167588233948) * gru_0_out_t2_57 + (-0.13053098320960999) * gru_0_out_t2_58 + (0.31152358651161194) * gru_0_out_t2_59 + (0.23241764307022095) * gru_0_out_t2_60 + (0.24961099028587341) * gru_0_out_t2_61 + (-0.31454387307167053) * gru_0_out_t2_62 + (0.44976800680160522) * gru_0_out_t2_63 + (0.42176848649978638) * gru_1_fwd_t1_h_0 + (0.097215160727500916) * gru_1_fwd_t1_h_1 + (0.86339884996414185) * gru_1_fwd_t1_h_2 + (0.52267980575561523) * gru_1_fwd_t1_h_3 + (0.41969725489616394) * gru_1_fwd_t1_h_4 + (0.39579147100448608) * gru_1_fwd_t1_h_5 + (0.1249847412109375) * gru_1_fwd_t1_h_6 + (0.28477737307548523) * gru_1_fwd_t1_h_7 + (-0.11269126832485199) * gru_1_fwd_t1_h_8 + (0.11992761492729187) * gru_1_fwd_t1_h_9 + (0.42772814631462097) * gru_1_fwd_t1_h_10 + (-0.45242020487785339) * gru_1_fwd_t1_h_11 + (-0.14294259250164032) * gru_1_fwd_t1_h_12 + (0.1349509209394455) * gru_1_fwd_t1_h_13 + (-0.1658235490322113) * gru_1_fwd_t1_h_14 + (-0.71256953477859497) * gru_1_fwd_t1_h_15 + (-0.55793380737304688) * gru_1_fwd_t1_h_16 + (0.23227092623710632) * gru_1_fwd_t1_h_17 + (0.30702731013298035) * gru_1_fwd_t1_h_18 + (0.10259042680263519) * gru_1_fwd_t1_h_19 + (0.17700637876987457) * gru_1_fwd_t1_h_20 + (-0.14143446087837219) * gru_1_fwd_t1_h_21 + (0.97323161363601685) * gru_1_fwd_t1_h_22 + (0.12266594171524048) * gru_1_fwd_t1_h_23 + (0.37801069021224976) * gru_1_fwd_t1_h_24 + (0.37389737367630005) * gru_1_fwd_t1_h_25 + (-1.065036416053772) * gru_1_fwd_t1_h_26 + (0.021083027124404907) * gru_1_fwd_t1_h_27 + (0.25694030523300171) * gru_1_fwd_t1_h_28 + (0.039260499179363251) * gru_1_fwd_t1_h_29 + (0.17128859460353851) * gru_1_fwd_t1_h_30 + (-0.16294483840465546) * gru_1_fwd_t1_h_31);
    gate_n = tanh((0.12486191093921661) + (-0.12840592861175537) * gru_0_out_t2_0 + (0.23356625437736511) * gru_0_out_t2_1 + (-0.20360897481441498) * gru_0_out_t2_2 + (0.099922150373458862) * gru_0_out_t2_3 + (0.19185338914394379) * gru_0_out_t2_4 + (-0.069613829255104065) * gru_0_out_t2_5 + (0.31549364328384399) * gru_0_out_t2_6 + (-0.015757499262690544) * gru_0_out_t2_7 + (0.12717291712760925) * gru_0_out_t2_8 + (-0.84123647212982178) * gru_0_out_t2_9 + (0.28988826274871826) * gru_0_out_t2_10 + (-0.096156567335128784) * gru_0_out_t2_11 + (-0.10742771625518799) * gru_0_out_t2_12 + (-0.28689020872116089) * gru_0_out_t2_13 + (0.1620694100856781) * gru_0_out_t2_14 + (-0.054068155586719513) * gru_0_out_t2_15 + (-0.23633734881877899) * gru_0_out_t2_16 + (-0.075495287775993347) * gru_0_out_t2_17 + (0.16298399865627289) * gru_0_out_t2_18 + (-0.29856309294700623) * gru_0_out_t2_19 + (-0.36737120151519775) * gru_0_out_t2_20 + (0.13657815754413605) * gru_0_out_t2_21 + (-0.027468781918287277) * gru_0_out_t2_22 + (-0.25451049208641052) * gru_0_out_t2_23 + (0.1430574506521225) * gru_0_out_t2_24 + (0.058732852339744568) * gru_0_out_t2_25 + (-0.028251504525542259) * gru_0_out_t2_26 + (0.0084161031991243362) * gru_0_out_t2_27 + (1.0031025409698486) * gru_0_out_t2_28 + (0.90340715646743774) * gru_0_out_t2_29 + (0.035828668624162674) * gru_0_out_t2_30 + (0.049659661948680878) * gru_0_out_t2_31 + (-0.045723952353000641) * gru_0_out_t2_32 + (0.33063089847564697) * gru_0_out_t2_33 + (0.42430594563484192) * gru_0_out_t2_34 + (0.32025146484375) * gru_0_out_t2_35 + (-0.096303343772888184) * gru_0_out_t2_36 + (0.11694572120904922) * gru_0_out_t2_37 + (-0.12836176156997681) * gru_0_out_t2_38 + (-0.17235228419303894) * gru_0_out_t2_39 + (0.52438759803771973) * gru_0_out_t2_40 + (-0.38399207592010498) * gru_0_out_t2_41 + (0.35322257876396179) * gru_0_out_t2_42 + (-0.1651042252779007) * gru_0_out_t2_43 + (-0.41582635045051575) * gru_0_out_t2_44 + (0.15660849213600159) * gru_0_out_t2_45 + (0.085606366395950317) * gru_0_out_t2_46 + (0.28603085875511169) * gru_0_out_t2_47 + (1.1585259437561035) * gru_0_out_t2_48 + (-0.74090248346328735) * gru_0_out_t2_49 + (-0.25757172703742981) * gru_0_out_t2_50 + (-0.046783000230789185) * gru_0_out_t2_51 + (-0.31171056628227234) * gru_0_out_t2_52 + (0.026497850194573402) * gru_0_out_t2_53 + (-0.08405023068189621) * gru_0_out_t2_54 + (-0.73044055700302124) * gru_0_out_t2_55 + (0.030051905661821365) * gru_0_out_t2_56 + (-0.73801183700561523) * gru_0_out_t2_57 + (0.23002375662326813) * gru_0_out_t2_58 + (0.2614825963973999) * gru_0_out_t2_59 + (-0.042847342789173126) * gru_0_out_t2_60 + (-0.076615087687969208) * gru_0_out_t2_61 + (0.39820367097854614) * gru_0_out_t2_62 + (-0.21564212441444397) * gru_0_out_t2_63 + gate_r * ((-0.063360646367073059) + (0.66806715726852417) * gru_1_fwd_t1_h_0 + (-0.040770228952169418) * gru_1_fwd_t1_h_1 + (0.16337694227695465) * gru_1_fwd_t1_h_2 + (0.93093931674957275) * gru_1_fwd_t1_h_3 + (0.20631159842014313) * gru_1_fwd_t1_h_4 + (0.62291252613067627) * gru_1_fwd_t1_h_5 + (-0.19053256511688232) * gru_1_fwd_t1_h_6 + (-0.5268247127532959) * gru_1_fwd_t1_h_7 + (-0.29906806349754333) * gru_1_fwd_t1_h_8 + (-0.091551288962364197) * gru_1_fwd_t1_h_9 + (0.14386411011219025) * gru_1_fwd_t1_h_10 + (0.23644822835922241) * gru_1_fwd_t1_h_11 + (0.072281919419765472) * gru_1_fwd_t1_h_12 + (0.082523159682750702) * gru_1_fwd_t1_h_13 + (-0.38892257213592529) * gru_1_fwd_t1_h_14 + (-0.057748496532440186) * gru_1_fwd_t1_h_15 + (0.41743695735931396) * gru_1_fwd_t1_h_16 + (-0.23076605796813965) * gru_1_fwd_t1_h_17 + (0.99425619840621948) * gru_1_fwd_t1_h_18 + (-0.25816673040390015) * gru_1_fwd_t1_h_19 + (0.18905363976955414) * gru_1_fwd_t1_h_20 + (-0.90328472852706909) * gru_1_fwd_t1_h_21 + (-1.2271386384963989) * gru_1_fwd_t1_h_22 + (-0.18577371537685394) * gru_1_fwd_t1_h_23 + (0.58838444948196411) * gru_1_fwd_t1_h_24 + (0.020450513809919357) * gru_1_fwd_t1_h_25 + (-1.7770217657089233) * gru_1_fwd_t1_h_26 + (-0.16580449044704437) * gru_1_fwd_t1_h_27 + (-0.078935369849205017) * gru_1_fwd_t1_h_28 + (0.017522117123007774) * gru_1_fwd_t1_h_29 + (-0.16043743491172791) * gru_1_fwd_t1_h_30 + (0.038050662726163864) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_8 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_8;
    // h=9
    gate_r = sigmoid((-0.94645965099334717) + (-0.37767168879508972) * gru_0_out_t2_0 + (-0.60130387544631958) * gru_0_out_t2_1 + (-0.30748829245567322) * gru_0_out_t2_2 + (0.50400054454803467) * gru_0_out_t2_3 + (0.070666000247001648) * gru_0_out_t2_4 + (0.45119196176528931) * gru_0_out_t2_5 + (-0.62028306722640991) * gru_0_out_t2_6 + (-3.1603825092315674) * gru_0_out_t2_7 + (0.6015620231628418) * gru_0_out_t2_8 + (1.4467819929122925) * gru_0_out_t2_9 + (-0.4039725661277771) * gru_0_out_t2_10 + (0.64779478311538696) * gru_0_out_t2_11 + (0.00029969928436912596) * gru_0_out_t2_12 + (0.14808319509029388) * gru_0_out_t2_13 + (-0.56769078969955444) * gru_0_out_t2_14 + (-0.020663321018218994) * gru_0_out_t2_15 + (0.47193342447280884) * gru_0_out_t2_16 + (-0.0019950340501964092) * gru_0_out_t2_17 + (-0.63222205638885498) * gru_0_out_t2_18 + (-1.3066798448562622) * gru_0_out_t2_19 + (-0.48553010821342468) * gru_0_out_t2_20 + (1.9235552549362183) * gru_0_out_t2_21 + (-0.39761656522750854) * gru_0_out_t2_22 + (-0.10361424088478088) * gru_0_out_t2_23 + (1.3452063798904419) * gru_0_out_t2_24 + (-0.44561168551445007) * gru_0_out_t2_25 + (-0.6650550365447998) * gru_0_out_t2_26 + (0.61186516284942627) * gru_0_out_t2_27 + (0.26047831773757935) * gru_0_out_t2_28 + (-0.69056868553161621) * gru_0_out_t2_29 + (-0.2005523145198822) * gru_0_out_t2_30 + (-2.0741555690765381) * gru_0_out_t2_31 + (-0.40851166844367981) * gru_0_out_t2_32 + (0.17037773132324219) * gru_0_out_t2_33 + (0.0012519893934950233) * gru_0_out_t2_34 + (-0.7595832347869873) * gru_0_out_t2_35 + (0.32010185718536377) * gru_0_out_t2_36 + (0.30967417359352112) * gru_0_out_t2_37 + (-0.57692348957061768) * gru_0_out_t2_38 + (2.4536533355712891) * gru_0_out_t2_39 + (-1.1175858974456787) * gru_0_out_t2_40 + (-0.31809717416763306) * gru_0_out_t2_41 + (0.2863297164440155) * gru_0_out_t2_42 + (0.72275698184967041) * gru_0_out_t2_43 + (-0.58913415670394897) * gru_0_out_t2_44 + (-0.13283896446228027) * gru_0_out_t2_45 + (-0.77560949325561523) * gru_0_out_t2_46 + (-0.45509344339370728) * gru_0_out_t2_47 + (0.40115746855735779) * gru_0_out_t2_48 + (-0.34419289231300354) * gru_0_out_t2_49 + (-1.6312298774719238) * gru_0_out_t2_50 + (0.82627946138381958) * gru_0_out_t2_51 + (-0.55929595232009888) * gru_0_out_t2_52 + (0.46777546405792236) * gru_0_out_t2_53 + (-0.45989620685577393) * gru_0_out_t2_54 + (1.4850811958312988) * gru_0_out_t2_55 + (1.0388094186782837) * gru_0_out_t2_56 + (-0.86752957105636597) * gru_0_out_t2_57 + (-0.054243341088294983) * gru_0_out_t2_58 + (-0.2816624641418457) * gru_0_out_t2_59 + (1.9588220119476318) * gru_0_out_t2_60 + (-0.39314386248588562) * gru_0_out_t2_61 + (0.38370445370674133) * gru_0_out_t2_62 + (-0.68918830156326294) * gru_0_out_t2_63 + (0.20668517053127289) * gru_1_fwd_t1_h_0 + (1.7798197269439697) * gru_1_fwd_t1_h_1 + (0.63628911972045898) * gru_1_fwd_t1_h_2 + (0.5263744592666626) * gru_1_fwd_t1_h_3 + (0.39988097548484802) * gru_1_fwd_t1_h_4 + (-0.65697884559631348) * gru_1_fwd_t1_h_5 + (1.3408036231994629) * gru_1_fwd_t1_h_6 + (0.068485952913761139) * gru_1_fwd_t1_h_7 + (0.05989537388086319) * gru_1_fwd_t1_h_8 + (0.43155354261398315) * gru_1_fwd_t1_h_9 + (1.3358449935913086) * gru_1_fwd_t1_h_10 + (0.92117005586624146) * gru_1_fwd_t1_h_11 + (-0.70772558450698853) * gru_1_fwd_t1_h_12 + (-1.1461886167526245) * gru_1_fwd_t1_h_13 + (-0.39996549487113953) * gru_1_fwd_t1_h_14 + (-0.78399527072906494) * gru_1_fwd_t1_h_15 + (-0.52949738502502441) * gru_1_fwd_t1_h_16 + (1.2273142337799072) * gru_1_fwd_t1_h_17 + (0.2045915275812149) * gru_1_fwd_t1_h_18 + (0.69062012434005737) * gru_1_fwd_t1_h_19 + (-0.048770014196634293) * gru_1_fwd_t1_h_20 + (-0.73350769281387329) * gru_1_fwd_t1_h_21 + (-0.83570456504821777) * gru_1_fwd_t1_h_22 + (0.25391936302185059) * gru_1_fwd_t1_h_23 + (-0.39571243524551392) * gru_1_fwd_t1_h_24 + (-0.80677211284637451) * gru_1_fwd_t1_h_25 + (-0.34966760873794556) * gru_1_fwd_t1_h_26 + (-1.1451519727706909) * gru_1_fwd_t1_h_27 + (0.70054179430007935) * gru_1_fwd_t1_h_28 + (0.21137988567352295) * gru_1_fwd_t1_h_29 + (-0.13838648796081543) * gru_1_fwd_t1_h_30 + (0.24890974164009094) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((-0.66700065135955811) + (-0.38161724805831909) * gru_0_out_t2_0 + (-0.34500306844711304) * gru_0_out_t2_1 + (1.5372833013534546) * gru_0_out_t2_2 + (-0.15760894119739532) * gru_0_out_t2_3 + (-0.91397339105606079) * gru_0_out_t2_4 + (0.4443410336971283) * gru_0_out_t2_5 + (-0.36054202914237976) * gru_0_out_t2_6 + (1.8857600688934326) * gru_0_out_t2_7 + (0.53792178630828857) * gru_0_out_t2_8 + (1.3212238550186157) * gru_0_out_t2_9 + (-0.83567291498184204) * gru_0_out_t2_10 + (0.99658471345901489) * gru_0_out_t2_11 + (-0.0062271589413285255) * gru_0_out_t2_12 + (0.93031620979309082) * gru_0_out_t2_13 + (-0.072808705270290375) * gru_0_out_t2_14 + (-0.15926530957221985) * gru_0_out_t2_15 + (0.8196566104888916) * gru_0_out_t2_16 + (1.0173912048339844) * gru_0_out_t2_17 + (-0.47560089826583862) * gru_0_out_t2_18 + (-0.58177363872528076) * gru_0_out_t2_19 + (0.67490804195404053) * gru_0_out_t2_20 + (0.045951947569847107) * gru_0_out_t2_21 + (0.89346456527709961) * gru_0_out_t2_22 + (-0.76285266876220703) * gru_0_out_t2_23 + (-1.1030420064926147) * gru_0_out_t2_24 + (-0.12383623421192169) * gru_0_out_t2_25 + (0.22143468260765076) * gru_0_out_t2_26 + (0.056202955543994904) * gru_0_out_t2_27 + (-1.577633261680603) * gru_0_out_t2_28 + (0.21797789633274078) * gru_0_out_t2_29 + (-0.77259856462478638) * gru_0_out_t2_30 + (-1.159978985786438) * gru_0_out_t2_31 + (0.24378253519535065) * gru_0_out_t2_32 + (-0.15147821605205536) * gru_0_out_t2_33 + (-0.42206445336341858) * gru_0_out_t2_34 + (0.021622203290462494) * gru_0_out_t2_35 + (0.24736990034580231) * gru_0_out_t2_36 + (0.43075656890869141) * gru_0_out_t2_37 + (-0.38536757230758667) * gru_0_out_t2_38 + (0.48176106810569763) * gru_0_out_t2_39 + (-1.5472872257232666) * gru_0_out_t2_40 + (-0.60113269090652466) * gru_0_out_t2_41 + (-0.56544023752212524) * gru_0_out_t2_42 + (-0.26117965579032898) * gru_0_out_t2_43 + (0.10481437295675278) * gru_0_out_t2_44 + (-0.25591829419136047) * gru_0_out_t2_45 + (-0.16429908573627472) * gru_0_out_t2_46 + (0.20478133857250214) * gru_0_out_t2_47 + (-0.54907435178756714) * gru_0_out_t2_48 + (0.52126073837280273) * gru_0_out_t2_49 + (-0.30414152145385742) * gru_0_out_t2_50 + (0.51986747980117798) * gru_0_out_t2_51 + (1.646419882774353) * gru_0_out_t2_52 + (-0.48921141028404236) * gru_0_out_t2_53 + (-0.0061088674701750278) * gru_0_out_t2_54 + (-0.57535833120346069) * gru_0_out_t2_55 + (-0.32961165904998779) * gru_0_out_t2_56 + (0.336098313331604) * gru_0_out_t2_57 + (0.31744930148124695) * gru_0_out_t2_58 + (-1.1896982192993164) * gru_0_out_t2_59 + (-0.27101922035217285) * gru_0_out_t2_60 + (-0.40266600251197815) * gru_0_out_t2_61 + (-0.37099075317382812) * gru_0_out_t2_62 + (-1.5098087787628174) * gru_0_out_t2_63 + (-1.1944037675857544) * gru_1_fwd_t1_h_0 + (-1.5708972215652466) * gru_1_fwd_t1_h_1 + (0.52894675731658936) * gru_1_fwd_t1_h_2 + (-0.45438277721405029) * gru_1_fwd_t1_h_3 + (0.053663842380046844) * gru_1_fwd_t1_h_4 + (0.81772249937057495) * gru_1_fwd_t1_h_5 + (2.2441117763519287) * gru_1_fwd_t1_h_6 + (-0.16683463752269745) * gru_1_fwd_t1_h_7 + (0.18447914719581604) * gru_1_fwd_t1_h_8 + (-1.028412938117981) * gru_1_fwd_t1_h_9 + (0.49064677953720093) * gru_1_fwd_t1_h_10 + (1.413985013961792) * gru_1_fwd_t1_h_11 + (0.10216224938631058) * gru_1_fwd_t1_h_12 + (-0.79450666904449463) * gru_1_fwd_t1_h_13 + (0.40972590446472168) * gru_1_fwd_t1_h_14 + (-1.3380692005157471) * gru_1_fwd_t1_h_15 + (0.1170661672949791) * gru_1_fwd_t1_h_16 + (-0.021696483716368675) * gru_1_fwd_t1_h_17 + (0.37090316414833069) * gru_1_fwd_t1_h_18 + (-0.10150973498821259) * gru_1_fwd_t1_h_19 + (0.62563508749008179) * gru_1_fwd_t1_h_20 + (0.85403507947921753) * gru_1_fwd_t1_h_21 + (0.75232779979705811) * gru_1_fwd_t1_h_22 + (-1.4069914817810059) * gru_1_fwd_t1_h_23 + (-0.44997569918632507) * gru_1_fwd_t1_h_24 + (0.66764593124389648) * gru_1_fwd_t1_h_25 + (2.5112583637237549) * gru_1_fwd_t1_h_26 + (-1.6828625202178955) * gru_1_fwd_t1_h_27 + (-0.084964871406555176) * gru_1_fwd_t1_h_28 + (0.0066307974047958851) * gru_1_fwd_t1_h_29 + (-1.6966719627380371) * gru_1_fwd_t1_h_30 + (-0.87377685308456421) * gru_1_fwd_t1_h_31);
    gate_n = tanh((-0.19166179001331329) + (-0.1475931853055954) * gru_0_out_t2_0 + (-0.043603528290987015) * gru_0_out_t2_1 + (-0.19319438934326172) * gru_0_out_t2_2 + (-0.72066831588745117) * gru_0_out_t2_3 + (0.047137744724750519) * gru_0_out_t2_4 + (-0.36615806818008423) * gru_0_out_t2_5 + (0.60756677389144897) * gru_0_out_t2_6 + (-0.18598364293575287) * gru_0_out_t2_7 + (-0.61573910713195801) * gru_0_out_t2_8 + (0.81677359342575073) * gru_0_out_t2_9 + (0.021376850083470345) * gru_0_out_t2_10 + (0.177054762840271) * gru_0_out_t2_11 + (0.038420021533966064) * gru_0_out_t2_12 + (0.0814032182097435) * gru_0_out_t2_13 + (0.069693498313426971) * gru_0_out_t2_14 + (-0.063873961567878723) * gru_0_out_t2_15 + (0.30770322680473328) * gru_0_out_t2_16 + (-0.039650440216064453) * gru_0_out_t2_17 + (0.13021869957447052) * gru_0_out_t2_18 + (-1.1468101739883423) * gru_0_out_t2_19 + (-0.044447552412748337) * gru_0_out_t2_20 + (1.1399340629577637) * gru_0_out_t2_21 + (0.20640449225902557) * gru_0_out_t2_22 + (-0.020363908261060715) * gru_0_out_t2_23 + (0.18933472037315369) * gru_0_out_t2_24 + (-0.16882705688476562) * gru_0_out_t2_25 + (-0.012349817901849747) * gru_0_out_t2_26 + (-0.053277842700481415) * gru_0_out_t2_27 + (-1.6943318843841553) * gru_0_out_t2_28 + (0.2465435117483139) * gru_0_out_t2_29 + (-0.18652848899364471) * gru_0_out_t2_30 + (-0.11012193560600281) * gru_0_out_t2_31 + (-1.5551866292953491) * gru_0_out_t2_32 + (0.35812732577323914) * gru_0_out_t2_33 + (-0.11011898517608643) * gru_0_out_t2_34 + (-0.04651380330324173) * gru_0_out_t2_35 + (0.1876164972782135) * gru_0_out_t2_36 + (0.37924259901046753) * gru_0_out_t2_37 + (-0.65363907814025879) * gru_0_out_t2_38 + (1.1121944189071655) * gru_0_out_t2_39 + (0.40524789690971375) * gru_0_out_t2_40 + (0.42543366551399231) * gru_0_out_t2_41 + (1.0176169872283936) * gru_0_out_t2_42 + (-0.18014049530029297) * gru_0_out_t2_43 + (0.036608070135116577) * gru_0_out_t2_44 + (0.25217828154563904) * gru_0_out_t2_45 + (0.41992047429084778) * gru_0_out_t2_46 + (0.95891588926315308) * gru_0_out_t2_47 + (-0.45769798755645752) * gru_0_out_t2_48 + (0.21317286789417267) * gru_0_out_t2_49 + (-0.87360525131225586) * gru_0_out_t2_50 + (-0.27890890836715698) * gru_0_out_t2_51 + (-0.19646281003952026) * gru_0_out_t2_52 + (-0.95297610759735107) * gru_0_out_t2_53 + (-0.020440196618437767) * gru_0_out_t2_54 + (-0.10175060480833054) * gru_0_out_t2_55 + (1.1912167072296143) * gru_0_out_t2_56 + (0.34079918265342712) * gru_0_out_t2_57 + (-0.079186975955963135) * gru_0_out_t2_58 + (0.016781831160187721) * gru_0_out_t2_59 + (-0.17286232113838196) * gru_0_out_t2_60 + (0.10521674901247025) * gru_0_out_t2_61 + (-0.33851131796836853) * gru_0_out_t2_62 + (-0.18749696016311646) * gru_0_out_t2_63 + gate_r * ((-0.081251978874206543) + (-0.15368850529193878) * gru_1_fwd_t1_h_0 + (-1.8047639131546021) * gru_1_fwd_t1_h_1 + (-0.0042087836191058159) * gru_1_fwd_t1_h_2 + (-0.030526401475071907) * gru_1_fwd_t1_h_3 + (-0.016297871246933937) * gru_1_fwd_t1_h_4 + (0.062851183116436005) * gru_1_fwd_t1_h_5 + (-1.1061030626296997) * gru_1_fwd_t1_h_6 + (-0.49983915686607361) * gru_1_fwd_t1_h_7 + (-0.52525568008422852) * gru_1_fwd_t1_h_8 + (-1.0050609111785889) * gru_1_fwd_t1_h_9 + (-0.13954250514507294) * gru_1_fwd_t1_h_10 + (1.2703524827957153) * gru_1_fwd_t1_h_11 + (0.21290716528892517) * gru_1_fwd_t1_h_12 + (-0.086320608854293823) * gru_1_fwd_t1_h_13 + (0.037695925682783127) * gru_1_fwd_t1_h_14 + (0.45950210094451904) * gru_1_fwd_t1_h_15 + (-0.0027529832441359758) * gru_1_fwd_t1_h_16 + (-0.22879727184772491) * gru_1_fwd_t1_h_17 + (-1.5622309446334839) * gru_1_fwd_t1_h_18 + (0.43045464158058167) * gru_1_fwd_t1_h_19 + (-0.3119906485080719) * gru_1_fwd_t1_h_20 + (0.35855963826179504) * gru_1_fwd_t1_h_21 + (1.493377685546875) * gru_1_fwd_t1_h_22 + (0.57454884052276611) * gru_1_fwd_t1_h_23 + (-0.30823442339897156) * gru_1_fwd_t1_h_24 + (0.69673776626586914) * gru_1_fwd_t1_h_25 + (-0.58131015300750732) * gru_1_fwd_t1_h_26 + (0.49840947985649109) * gru_1_fwd_t1_h_27 + (-0.48726347088813782) * gru_1_fwd_t1_h_28 + (0.46462139487266541) * gru_1_fwd_t1_h_29 + (-0.40623787045478821) * gru_1_fwd_t1_h_30 + (0.28150084614753723) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_9 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_9;
    // h=10
    gate_r = sigmoid((0.12700773775577545) + (0.17358303070068359) * gru_0_out_t2_0 + (-0.26609843969345093) * gru_0_out_t2_1 + (0.36362743377685547) * gru_0_out_t2_2 + (-0.75102424621582031) * gru_0_out_t2_3 + (-0.21824626624584198) * gru_0_out_t2_4 + (-0.21286508440971375) * gru_0_out_t2_5 + (0.14633294939994812) * gru_0_out_t2_6 + (-0.71246379613876343) * gru_0_out_t2_7 + (-0.14935906231403351) * gru_0_out_t2_8 + (-1.4466354846954346) * gru_0_out_t2_9 + (0.76526260375976562) * gru_0_out_t2_10 + (0.20908111333847046) * gru_0_out_t2_11 + (0.22022069990634918) * gru_0_out_t2_12 + (0.32131481170654297) * gru_0_out_t2_13 + (0.50087523460388184) * gru_0_out_t2_14 + (0.2252572774887085) * gru_0_out_t2_15 + (-0.24023653566837311) * gru_0_out_t2_16 + (-0.43617203831672668) * gru_0_out_t2_17 + (0.26085761189460754) * gru_0_out_t2_18 + (0.99853628873825073) * gru_0_out_t2_19 + (-2.7666220664978027) * gru_0_out_t2_20 + (-0.85760492086410522) * gru_0_out_t2_21 + (0.19418257474899292) * gru_0_out_t2_22 + (0.19250328838825226) * gru_0_out_t2_23 + (0.84655123949050903) * gru_0_out_t2_24 + (-0.83766090869903564) * gru_0_out_t2_25 + (-0.40124556422233582) * gru_0_out_t2_26 + (-0.088772505521774292) * gru_0_out_t2_27 + (1.5173718929290771) * gru_0_out_t2_28 + (-1.7662951946258545) * gru_0_out_t2_29 + (0.31273770332336426) * gru_0_out_t2_30 + (0.60144495964050293) * gru_0_out_t2_31 + (-0.64341467618942261) * gru_0_out_t2_32 + (0.30114325881004333) * gru_0_out_t2_33 + (-0.098148547112941742) * gru_0_out_t2_34 + (0.21873235702514648) * gru_0_out_t2_35 + (-0.30433633923530579) * gru_0_out_t2_36 + (-0.42267179489135742) * gru_0_out_t2_37 + (-0.063711665570735931) * gru_0_out_t2_38 + (-1.6213057041168213) * gru_0_out_t2_39 + (0.53398770093917847) * gru_0_out_t2_40 + (0.57139807939529419) * gru_0_out_t2_41 + (-3.5096445083618164) * gru_0_out_t2_42 + (-0.38201916217803955) * gru_0_out_t2_43 + (1.8687019348144531) * gru_0_out_t2_44 + (-1.3772214651107788) * gru_0_out_t2_45 + (1.1983013153076172) * gru_0_out_t2_46 + (-0.20972947776317596) * gru_0_out_t2_47 + (-0.90027922391891479) * gru_0_out_t2_48 + (0.929512619972229) * gru_0_out_t2_49 + (1.1029732227325439) * gru_0_out_t2_50 + (1.1995844841003418) * gru_0_out_t2_51 + (0.11682717502117157) * gru_0_out_t2_52 + (0.93772459030151367) * gru_0_out_t2_53 + (-0.13781523704528809) * gru_0_out_t2_54 + (-0.45622417330741882) * gru_0_out_t2_55 + (0.64635336399078369) * gru_0_out_t2_56 + (0.90271449089050293) * gru_0_out_t2_57 + (-0.31877997517585754) * gru_0_out_t2_58 + (0.19310647249221802) * gru_0_out_t2_59 + (-1.969291090965271) * gru_0_out_t2_60 + (-0.3645007312297821) * gru_0_out_t2_61 + (0.90881729125976562) * gru_0_out_t2_62 + (-0.65304315090179443) * gru_0_out_t2_63 + (-1.1440044641494751) * gru_1_fwd_t1_h_0 + (-1.9637002944946289) * gru_1_fwd_t1_h_1 + (-0.31731808185577393) * gru_1_fwd_t1_h_2 + (-0.09906420111656189) * gru_1_fwd_t1_h_3 + (0.041207868605852127) * gru_1_fwd_t1_h_4 + (1.3654571771621704) * gru_1_fwd_t1_h_5 + (3.715040922164917) * gru_1_fwd_t1_h_6 + (1.4021437168121338) * gru_1_fwd_t1_h_7 + (-0.48076462745666504) * gru_1_fwd_t1_h_8 + (-0.61322939395904541) * gru_1_fwd_t1_h_9 + (0.085964687168598175) * gru_1_fwd_t1_h_10 + (1.4777522087097168) * gru_1_fwd_t1_h_11 + (0.23209357261657715) * gru_1_fwd_t1_h_12 + (0.22575594484806061) * gru_1_fwd_t1_h_13 + (0.33065521717071533) * gru_1_fwd_t1_h_14 + (-0.058784693479537964) * gru_1_fwd_t1_h_15 + (-0.19925756752490997) * gru_1_fwd_t1_h_16 + (-1.5024744272232056) * gru_1_fwd_t1_h_17 + (0.26959159970283508) * gru_1_fwd_t1_h_18 + (-1.0462486743927002) * gru_1_fwd_t1_h_19 + (0.22644157707691193) * gru_1_fwd_t1_h_20 + (1.7423503398895264) * gru_1_fwd_t1_h_21 + (-1.961057186126709) * gru_1_fwd_t1_h_22 + (-0.14904862642288208) * gru_1_fwd_t1_h_23 + (1.9360533952713013) * gru_1_fwd_t1_h_24 + (0.27051091194152832) * gru_1_fwd_t1_h_25 + (-0.41600373387336731) * gru_1_fwd_t1_h_26 + (0.59028387069702148) * gru_1_fwd_t1_h_27 + (-0.2726283073425293) * gru_1_fwd_t1_h_28 + (-0.13734602928161621) * gru_1_fwd_t1_h_29 + (1.2652761936187744) * gru_1_fwd_t1_h_30 + (-0.006536286324262619) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((0.089074894785881042) + (0.28652527928352356) * gru_0_out_t2_0 + (-0.25431522727012634) * gru_0_out_t2_1 + (-0.041737962514162064) * gru_0_out_t2_2 + (0.11614954471588135) * gru_0_out_t2_3 + (-0.3236997127532959) * gru_0_out_t2_4 + (0.063692331314086914) * gru_0_out_t2_5 + (-0.30081045627593994) * gru_0_out_t2_6 + (-0.40095525979995728) * gru_0_out_t2_7 + (-0.25703710317611694) * gru_0_out_t2_8 + (-1.2480922937393188) * gru_0_out_t2_9 + (-0.10874941945075989) * gru_0_out_t2_10 + (0.07747717946767807) * gru_0_out_t2_11 + (0.12281093746423721) * gru_0_out_t2_12 + (0.058144509792327881) * gru_0_out_t2_13 + (0.15627904236316681) * gru_0_out_t2_14 + (0.054792385548353195) * gru_0_out_t2_15 + (-0.14796812832355499) * gru_0_out_t2_16 + (-0.17247948050498962) * gru_0_out_t2_17 + (0.1170186847448349) * gru_0_out_t2_18 + (-0.09236462414264679) * gru_0_out_t2_19 + (-0.23816119134426117) * gru_0_out_t2_20 + (0.027091845870018005) * gru_0_out_t2_21 + (-0.14238347113132477) * gru_0_out_t2_22 + (0.41045933961868286) * gru_0_out_t2_23 + (-0.4211374819278717) * gru_0_out_t2_24 + (-0.072476841509342194) * gru_0_out_t2_25 + (-0.12470221519470215) * gru_0_out_t2_26 + (-0.061767518520355225) * gru_0_out_t2_27 + (-0.24785824120044708) * gru_0_out_t2_28 + (-1.03104567527771) * gru_0_out_t2_29 + (0.24498403072357178) * gru_0_out_t2_30 + (1.0302283763885498) * gru_0_out_t2_31 + (-0.049551930278539658) * gru_0_out_t2_32 + (0.49970108270645142) * gru_0_out_t2_33 + (0.094694837927818298) * gru_0_out_t2_34 + (-0.19588424265384674) * gru_0_out_t2_35 + (-0.14367903769016266) * gru_0_out_t2_36 + (-0.13032403588294983) * gru_0_out_t2_37 + (-1.061585545539856) * gru_0_out_t2_38 + (-1.0908552408218384) * gru_0_out_t2_39 + (0.43587037920951843) * gru_0_out_t2_40 + (-0.13133271038532257) * gru_0_out_t2_41 + (0.33866673707962036) * gru_0_out_t2_42 + (0.016341367736458778) * gru_0_out_t2_43 + (0.16232194006443024) * gru_0_out_t2_44 + (0.13835984468460083) * gru_0_out_t2_45 + (-0.17099936306476593) * gru_0_out_t2_46 + (-0.065953195095062256) * gru_0_out_t2_47 + (-0.11085996776819229) * gru_0_out_t2_48 + (-0.2759954035282135) * gru_0_out_t2_49 + (0.19357350468635559) * gru_0_out_t2_50 + (-0.25327783823013306) * gru_0_out_t2_51 + (-0.32417362928390503) * gru_0_out_t2_52 + (0.40157565474510193) * gru_0_out_t2_53 + (-0.16152018308639526) * gru_0_out_t2_54 + (-0.44548383355140686) * gru_0_out_t2_55 + (-0.22730287909507751) * gru_0_out_t2_56 + (-0.16933351755142212) * gru_0_out_t2_57 + (-0.18453985452651978) * gru_0_out_t2_58 + (0.10117398947477341) * gru_0_out_t2_59 + (0.023496450856328011) * gru_0_out_t2_60 + (-0.22808742523193359) * gru_0_out_t2_61 + (0.21029940247535706) * gru_0_out_t2_62 + (0.17315208911895752) * gru_0_out_t2_63 + (0.2965240478515625) * gru_1_fwd_t1_h_0 + (-0.20178084075450897) * gru_1_fwd_t1_h_1 + (-0.051777306944131851) * gru_1_fwd_t1_h_2 + (-0.10357612371444702) * gru_1_fwd_t1_h_3 + (-0.14165730774402618) * gru_1_fwd_t1_h_4 + (0.07743440568447113) * gru_1_fwd_t1_h_5 + (0.16631291806697845) * gru_1_fwd_t1_h_6 + (-0.02383355051279068) * gru_1_fwd_t1_h_7 + (-0.26477259397506714) * gru_1_fwd_t1_h_8 + (0.13699209690093994) * gru_1_fwd_t1_h_9 + (0.11808501183986664) * gru_1_fwd_t1_h_10 + (0.74052715301513672) * gru_1_fwd_t1_h_11 + (-0.16494712233543396) * gru_1_fwd_t1_h_12 + (0.029972419142723083) * gru_1_fwd_t1_h_13 + (0.19153954088687897) * gru_1_fwd_t1_h_14 + (0.032786458730697632) * gru_1_fwd_t1_h_15 + (-0.84683471918106079) * gru_1_fwd_t1_h_16 + (0.14629752933979034) * gru_1_fwd_t1_h_17 + (-0.021826334297657013) * gru_1_fwd_t1_h_18 + (-0.20769557356834412) * gru_1_fwd_t1_h_19 + (0.038672834634780884) * gru_1_fwd_t1_h_20 + (0.11926355212926865) * gru_1_fwd_t1_h_21 + (-0.32599073648452759) * gru_1_fwd_t1_h_22 + (-0.14867480099201202) * gru_1_fwd_t1_h_23 + (0.094084158539772034) * gru_1_fwd_t1_h_24 + (-0.19863781332969666) * gru_1_fwd_t1_h_25 + (-0.21899881958961487) * gru_1_fwd_t1_h_26 + (-0.27401480078697205) * gru_1_fwd_t1_h_27 + (0.20926083624362946) * gru_1_fwd_t1_h_28 + (0.0846877321600914) * gru_1_fwd_t1_h_29 + (-0.017506703734397888) * gru_1_fwd_t1_h_30 + (0.17535883188247681) * gru_1_fwd_t1_h_31);
    gate_n = tanh((0.19488437473773956) + (-0.052657756954431534) * gru_0_out_t2_0 + (0.15120185911655426) * gru_0_out_t2_1 + (0.14060412347316742) * gru_0_out_t2_2 + (0.21956713497638702) * gru_0_out_t2_3 + (0.084785185754299164) * gru_0_out_t2_4 + (-0.061486579477787018) * gru_0_out_t2_5 + (0.16998031735420227) * gru_0_out_t2_6 + (-0.32821407914161682) * gru_0_out_t2_7 + (-0.028484931215643883) * gru_0_out_t2_8 + (0.34530478715896606) * gru_0_out_t2_9 + (-0.20221924781799316) * gru_0_out_t2_10 + (-0.065937303006649017) * gru_0_out_t2_11 + (-0.10354229807853699) * gru_0_out_t2_12 + (1.3687676191329956) * gru_0_out_t2_13 + (0.28743219375610352) * gru_0_out_t2_14 + (0.27312353253364563) * gru_0_out_t2_15 + (-0.45908099412918091) * gru_0_out_t2_16 + (0.18431840837001801) * gru_0_out_t2_17 + (-0.26216778159141541) * gru_0_out_t2_18 + (2.2489731311798096) * gru_0_out_t2_19 + (2.5669353008270264) * gru_0_out_t2_20 + (-0.11508894711732864) * gru_0_out_t2_21 + (-0.43968808650970459) * gru_0_out_t2_22 + (-0.32399898767471313) * gru_0_out_t2_23 + (0.27298831939697266) * gru_0_out_t2_24 + (0.014456578530371189) * gru_0_out_t2_25 + (-1.1841315031051636) * gru_0_out_t2_26 + (-0.22079342603683472) * gru_0_out_t2_27 + (0.069377534091472626) * gru_0_out_t2_28 + (1.2896852493286133) * gru_0_out_t2_29 + (0.26943624019622803) * gru_0_out_t2_30 + (-0.27889817953109741) * gru_0_out_t2_31 + (-0.1016821563243866) * gru_0_out_t2_32 + (-0.68959653377532959) * gru_0_out_t2_33 + (0.1582711935043335) * gru_0_out_t2_34 + (0.0034264123532921076) * gru_0_out_t2_35 + (-0.086463645100593567) * gru_0_out_t2_36 + (0.11953144520521164) * gru_0_out_t2_37 + (0.22763277590274811) * gru_0_out_t2_38 + (-0.51281523704528809) * gru_0_out_t2_39 + (-0.38638588786125183) * gru_0_out_t2_40 + (0.38878515362739563) * gru_0_out_t2_41 + (-0.14520342648029327) * gru_0_out_t2_42 + (0.46485069394111633) * gru_0_out_t2_43 + (0.74395233392715454) * gru_0_out_t2_44 + (0.4961492121219635) * gru_0_out_t2_45 + (0.20395191013813019) * gru_0_out_t2_46 + (-0.11550818383693695) * gru_0_out_t2_47 + (0.83430343866348267) * gru_0_out_t2_48 + (-0.71228086948394775) * gru_0_out_t2_49 + (-0.034278146922588348) * gru_0_out_t2_50 + (0.20579424500465393) * gru_0_out_t2_51 + (1.9540479183197021) * gru_0_out_t2_52 + (-0.19661983847618103) * gru_0_out_t2_53 + (-0.34038105607032776) * gru_0_out_t2_54 + (-0.033267445862293243) * gru_0_out_t2_55 + (0.092909187078475952) * gru_0_out_t2_56 + (-0.7205735445022583) * gru_0_out_t2_57 + (0.10566961020231247) * gru_0_out_t2_58 + (-0.27177765965461731) * gru_0_out_t2_59 + (0.10067002475261688) * gru_0_out_t2_60 + (0.23755109310150146) * gru_0_out_t2_61 + (0.2422492504119873) * gru_0_out_t2_62 + (0.36490479111671448) * gru_0_out_t2_63 + gate_r * ((0.22408077120780945) + (-0.50799846649169922) * gru_1_fwd_t1_h_0 + (0.093846753239631653) * gru_1_fwd_t1_h_1 + (0.018197886645793915) * gru_1_fwd_t1_h_2 + (0.24047824740409851) * gru_1_fwd_t1_h_3 + (-0.074076414108276367) * gru_1_fwd_t1_h_4 + (-0.31624314188957214) * gru_1_fwd_t1_h_5 + (-0.02993316762149334) * gru_1_fwd_t1_h_6 + (0.14553907513618469) * gru_1_fwd_t1_h_7 + (0.64286267757415771) * gru_1_fwd_t1_h_8 + (-0.086699895560741425) * gru_1_fwd_t1_h_9 + (-0.76547086238861084) * gru_1_fwd_t1_h_10 + (-0.073846086859703064) * gru_1_fwd_t1_h_11 + (0.035273835062980652) * gru_1_fwd_t1_h_12 + (0.20413921773433685) * gru_1_fwd_t1_h_13 + (-0.054604183882474899) * gru_1_fwd_t1_h_14 + (0.13936640322208405) * gru_1_fwd_t1_h_15 + (0.41853615641593933) * gru_1_fwd_t1_h_16 + (-0.35296016931533813) * gru_1_fwd_t1_h_17 + (0.19829103350639343) * gru_1_fwd_t1_h_18 + (-0.045306652784347534) * gru_1_fwd_t1_h_19 + (0.17336693406105042) * gru_1_fwd_t1_h_20 + (-0.036644186824560165) * gru_1_fwd_t1_h_21 + (-1.092327356338501) * gru_1_fwd_t1_h_22 + (0.099627509713172913) * gru_1_fwd_t1_h_23 + (-0.20665401220321655) * gru_1_fwd_t1_h_24 + (-0.55085581541061401) * gru_1_fwd_t1_h_25 + (0.48752287030220032) * gru_1_fwd_t1_h_26 + (0.37436887621879578) * gru_1_fwd_t1_h_27 + (0.0051102391444146633) * gru_1_fwd_t1_h_28 + (-0.23560836911201477) * gru_1_fwd_t1_h_29 + (-0.16638369858264923) * gru_1_fwd_t1_h_30 + (-0.12422987073659897) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_10 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_10;
    // h=11
    gate_r = sigmoid((0.033302716910839081) + (-0.28635543584823608) * gru_0_out_t2_0 + (-0.23239918053150177) * gru_0_out_t2_1 + (0.54091012477874756) * gru_0_out_t2_2 + (-0.59756612777709961) * gru_0_out_t2_3 + (-0.081293500959873199) * gru_0_out_t2_4 + (0.019877871498465538) * gru_0_out_t2_5 + (-0.16208361089229584) * gru_0_out_t2_6 + (-0.66801559925079346) * gru_0_out_t2_7 + (-0.31933513283729553) * gru_0_out_t2_8 + (-0.55270260572433472) * gru_0_out_t2_9 + (-0.39836791157722473) * gru_0_out_t2_10 + (0.27068042755126953) * gru_0_out_t2_11 + (-0.82213824987411499) * gru_0_out_t2_12 + (0.44286924600601196) * gru_0_out_t2_13 + (-0.015299736522138119) * gru_0_out_t2_14 + (-0.6165727972984314) * gru_0_out_t2_15 + (0.71953433752059937) * gru_0_out_t2_16 + (0.22901557385921478) * gru_0_out_t2_17 + (-0.47322583198547363) * gru_0_out_t2_18 + (0.94010794162750244) * gru_0_out_t2_19 + (0.56186378002166748) * gru_0_out_t2_20 + (0.70648640394210815) * gru_0_out_t2_21 + (-0.68750816583633423) * gru_0_out_t2_22 + (-0.44315192103385925) * gru_0_out_t2_23 + (-0.29926010966300964) * gru_0_out_t2_24 + (-1.3312716484069824) * gru_0_out_t2_25 + (-1.1547507047653198) * gru_0_out_t2_26 + (0.024992421269416809) * gru_0_out_t2_27 + (1.2595838308334351) * gru_0_out_t2_28 + (-0.89963328838348389) * gru_0_out_t2_29 + (0.21058157086372375) * gru_0_out_t2_30 + (-1.2203425168991089) * gru_0_out_t2_31 + (-0.20957650244235992) * gru_0_out_t2_32 + (2.1760118007659912) * gru_0_out_t2_33 + (2.6848196983337402) * gru_0_out_t2_34 + (-0.057828739285469055) * gru_0_out_t2_35 + (-2.2955818176269531) * gru_0_out_t2_36 + (0.62297064065933228) * gru_0_out_t2_37 + (-0.89184087514877319) * gru_0_out_t2_38 + (-4.6999349594116211) * gru_0_out_t2_39 + (-0.13608497381210327) * gru_0_out_t2_40 + (-0.49157243967056274) * gru_0_out_t2_41 + (1.8394234180450439) * gru_0_out_t2_42 + (-2.6908783912658691) * gru_0_out_t2_43 + (-0.5607035756111145) * gru_0_out_t2_44 + (-0.18992577493190765) * gru_0_out_t2_45 + (2.7453629970550537) * gru_0_out_t2_46 + (-0.85910165309906006) * gru_0_out_t2_47 + (-0.90858203172683716) * gru_0_out_t2_48 + (1.3891780376434326) * gru_0_out_t2_49 + (0.69292932748794556) * gru_0_out_t2_50 + (-0.75931048393249512) * gru_0_out_t2_51 + (0.52697205543518066) * gru_0_out_t2_52 + (0.91226410865783691) * gru_0_out_t2_53 + (0.45391958951950073) * gru_0_out_t2_54 + (-0.89125627279281616) * gru_0_out_t2_55 + (-0.26087802648544312) * gru_0_out_t2_56 + (1.1523919105529785) * gru_0_out_t2_57 + (1.9383988380432129) * gru_0_out_t2_58 + (-1.2010269165039062) * gru_0_out_t2_59 + (-1.2367948293685913) * gru_0_out_t2_60 + (-0.19040235877037048) * gru_0_out_t2_61 + (0.65685826539993286) * gru_0_out_t2_62 + (3.5422356128692627) * gru_0_out_t2_63 + (0.6207348108291626) * gru_1_fwd_t1_h_0 + (1.5627206563949585) * gru_1_fwd_t1_h_1 + (-0.87710291147232056) * gru_1_fwd_t1_h_2 + (-0.13322938978672028) * gru_1_fwd_t1_h_3 + (-0.39594301581382751) * gru_1_fwd_t1_h_4 + (-0.27317079901695251) * gru_1_fwd_t1_h_5 + (1.5645034313201904) * gru_1_fwd_t1_h_6 + (-0.055733989924192429) * gru_1_fwd_t1_h_7 + (-0.21847826242446899) * gru_1_fwd_t1_h_8 + (0.20007948577404022) * gru_1_fwd_t1_h_9 + (0.40410682559013367) * gru_1_fwd_t1_h_10 + (0.19638508558273315) * gru_1_fwd_t1_h_11 + (-0.37913307547569275) * gru_1_fwd_t1_h_12 + (0.87296938896179199) * gru_1_fwd_t1_h_13 + (1.2106436491012573) * gru_1_fwd_t1_h_14 + (-1.205656886100769) * gru_1_fwd_t1_h_15 + (0.10598745942115784) * gru_1_fwd_t1_h_16 + (0.38726559281349182) * gru_1_fwd_t1_h_17 + (1.800546407699585) * gru_1_fwd_t1_h_18 + (-0.44533127546310425) * gru_1_fwd_t1_h_19 + (-0.071009784936904907) * gru_1_fwd_t1_h_20 + (0.61220467090606689) * gru_1_fwd_t1_h_21 + (-0.6552654504776001) * gru_1_fwd_t1_h_22 + (-0.39513957500457764) * gru_1_fwd_t1_h_23 + (1.6948451995849609) * gru_1_fwd_t1_h_24 + (0.57188129425048828) * gru_1_fwd_t1_h_25 + (0.36580479145050049) * gru_1_fwd_t1_h_26 + (0.32879477739334106) * gru_1_fwd_t1_h_27 + (-2.4640607833862305) * gru_1_fwd_t1_h_28 + (0.55358970165252686) * gru_1_fwd_t1_h_29 + (-0.65441054105758667) * gru_1_fwd_t1_h_30 + (-0.53655606508255005) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((-0.20379742980003357) + (0.013968752697110176) * gru_0_out_t2_0 + (-0.21290013194084167) * gru_0_out_t2_1 + (0.20908439159393311) * gru_0_out_t2_2 + (-0.15829747915267944) * gru_0_out_t2_3 + (0.32499998807907104) * gru_0_out_t2_4 + (-0.04641999676823616) * gru_0_out_t2_5 + (0.11558974534273148) * gru_0_out_t2_6 + (-0.38384121656417847) * gru_0_out_t2_7 + (0.16342544555664062) * gru_0_out_t2_8 + (-0.54254913330078125) * gru_0_out_t2_9 + (-0.095170505344867706) * gru_0_out_t2_10 + (-0.16333654522895813) * gru_0_out_t2_11 + (0.25693148374557495) * gru_0_out_t2_12 + (-0.15381982922554016) * gru_0_out_t2_13 + (0.12995675206184387) * gru_0_out_t2_14 + (-0.22064907848834991) * gru_0_out_t2_15 + (-0.46597132086753845) * gru_0_out_t2_16 + (-0.042683999985456467) * gru_0_out_t2_17 + (-0.21269966661930084) * gru_0_out_t2_18 + (0.21609680354595184) * gru_0_out_t2_19 + (-1.1297218799591064) * gru_0_out_t2_20 + (-0.089636079967021942) * gru_0_out_t2_21 + (-0.086581557989120483) * gru_0_out_t2_22 + (0.27708584070205688) * gru_0_out_t2_23 + (-0.19002352654933929) * gru_0_out_t2_24 + (0.12676183879375458) * gru_0_out_t2_25 + (0.040543869137763977) * gru_0_out_t2_26 + (-0.30297890305519104) * gru_0_out_t2_27 + (-0.11503919214010239) * gru_0_out_t2_28 + (-1.2966657876968384) * gru_0_out_t2_29 + (0.60407418012619019) * gru_0_out_t2_30 + (-0.26405501365661621) * gru_0_out_t2_31 + (0.41369813680648804) * gru_0_out_t2_32 + (-0.21095253527164459) * gru_0_out_t2_33 + (-0.057434424757957458) * gru_0_out_t2_34 + (-0.10329345613718033) * gru_0_out_t2_35 + (-0.17131724953651428) * gru_0_out_t2_36 + (0.068628385663032532) * gru_0_out_t2_37 + (-0.10504987090826035) * gru_0_out_t2_38 + (-1.0016738176345825) * gru_0_out_t2_39 + (-0.19359749555587769) * gru_0_out_t2_40 + (0.11649640649557114) * gru_0_out_t2_41 + (-0.021809699013829231) * gru_0_out_t2_42 + (0.059993993490934372) * gru_0_out_t2_43 + (0.01796291209757328) * gru_0_out_t2_44 + (-0.56980448961257935) * gru_0_out_t2_45 + (0.41346755623817444) * gru_0_out_t2_46 + (-0.13531345129013062) * gru_0_out_t2_47 + (0.68953520059585571) * gru_0_out_t2_48 + (-0.50323283672332764) * gru_0_out_t2_49 + (0.062344904989004135) * gru_0_out_t2_50 + (-0.2618567943572998) * gru_0_out_t2_51 + (-0.50660324096679688) * gru_0_out_t2_52 + (0.7260773777961731) * gru_0_out_t2_53 + (0.016264235600829124) * gru_0_out_t2_54 + (-0.34674155712127686) * gru_0_out_t2_55 + (-0.039041481912136078) * gru_0_out_t2_56 + (-0.016917739063501358) * gru_0_out_t2_57 + (-0.034211605787277222) * gru_0_out_t2_58 + (0.15881523489952087) * gru_0_out_t2_59 + (-0.27533027529716492) * gru_0_out_t2_60 + (-0.035955876111984253) * gru_0_out_t2_61 + (0.27977854013442993) * gru_0_out_t2_62 + (-0.75732642412185669) * gru_0_out_t2_63 + (0.11988511681556702) * gru_1_fwd_t1_h_0 + (0.21438734233379364) * gru_1_fwd_t1_h_1 + (-0.34554588794708252) * gru_1_fwd_t1_h_2 + (-0.25799402594566345) * gru_1_fwd_t1_h_3 + (-0.21421205997467041) * gru_1_fwd_t1_h_4 + (-0.43673524260520935) * gru_1_fwd_t1_h_5 + (0.070851221680641174) * gru_1_fwd_t1_h_6 + (-0.20893017947673798) * gru_1_fwd_t1_h_7 + (0.52889615297317505) * gru_1_fwd_t1_h_8 + (-0.11886266618967056) * gru_1_fwd_t1_h_9 + (0.00052014138782396913) * gru_1_fwd_t1_h_10 + (0.17145627737045288) * gru_1_fwd_t1_h_11 + (-0.10003609955310822) * gru_1_fwd_t1_h_12 + (0.33402067422866821) * gru_1_fwd_t1_h_13 + (-0.016618423163890839) * gru_1_fwd_t1_h_14 + (-0.2808678150177002) * gru_1_fwd_t1_h_15 + (-0.18324010074138641) * gru_1_fwd_t1_h_16 + (-0.18345372378826141) * gru_1_fwd_t1_h_17 + (0.0052920323796570301) * gru_1_fwd_t1_h_18 + (-0.10627357661724091) * gru_1_fwd_t1_h_19 + (0.19878116250038147) * gru_1_fwd_t1_h_20 + (0.14588843286037445) * gru_1_fwd_t1_h_21 + (-0.17964373528957367) * gru_1_fwd_t1_h_22 + (0.043441221117973328) * gru_1_fwd_t1_h_23 + (-0.072033978998661041) * gru_1_fwd_t1_h_24 + (0.17041733860969543) * gru_1_fwd_t1_h_25 + (-0.48847076296806335) * gru_1_fwd_t1_h_26 + (-0.45040327310562134) * gru_1_fwd_t1_h_27 + (0.58871430158615112) * gru_1_fwd_t1_h_28 + (-0.033371925354003906) * gru_1_fwd_t1_h_29 + (0.44912517070770264) * gru_1_fwd_t1_h_30 + (0.50504904985427856) * gru_1_fwd_t1_h_31);
    gate_n = tanh((0.080665022134780884) + (0.19978447258472443) * gru_0_out_t2_0 + (-0.051392246037721634) * gru_0_out_t2_1 + (-0.60841953754425049) * gru_0_out_t2_2 + (-0.36995431780815125) * gru_0_out_t2_3 + (-0.17335078120231628) * gru_0_out_t2_4 + (-0.02427055686712265) * gru_0_out_t2_5 + (-0.064915843307971954) * gru_0_out_t2_6 + (0.8683314323425293) * gru_0_out_t2_7 + (-0.19286620616912842) * gru_0_out_t2_8 + (0.79015380144119263) * gru_0_out_t2_9 + (0.59770447015762329) * gru_0_out_t2_10 + (0.056691888719797134) * gru_0_out_t2_11 + (0.4323354959487915) * gru_0_out_t2_12 + (0.22853460907936096) * gru_0_out_t2_13 + (0.24816139042377472) * gru_0_out_t2_14 + (-0.012813436798751354) * gru_0_out_t2_15 + (-0.27216216921806335) * gru_0_out_t2_16 + (-0.35157012939453125) * gru_0_out_t2_17 + (0.22720478475093842) * gru_0_out_t2_18 + (-0.53477466106414795) * gru_0_out_t2_19 + (-0.33743220567703247) * gru_0_out_t2_20 + (-0.41910183429718018) * gru_0_out_t2_21 + (-0.049144204705953598) * gru_0_out_t2_22 + (0.26003286242485046) * gru_0_out_t2_23 + (-0.0037191840820014477) * gru_0_out_t2_24 + (0.017270728945732117) * gru_0_out_t2_25 + (-0.033790819346904755) * gru_0_out_t2_26 + (0.090987145900726318) * gru_0_out_t2_27 + (-0.18506820499897003) * gru_0_out_t2_28 + (1.3200169801712036) * gru_0_out_t2_29 + (0.27922892570495605) * gru_0_out_t2_30 + (-0.032327838242053986) * gru_0_out_t2_31 + (-0.19064274430274963) * gru_0_out_t2_32 + (-0.35334771871566772) * gru_0_out_t2_33 + (-0.17395184934139252) * gru_0_out_t2_34 + (0.3954910933971405) * gru_0_out_t2_35 + (0.097039744257926941) * gru_0_out_t2_36 + (-0.30992591381072998) * gru_0_out_t2_37 + (-0.1764533519744873) * gru_0_out_t2_38 + (0.64669722318649292) * gru_0_out_t2_39 + (-0.75759142637252808) * gru_0_out_t2_40 + (0.28470149636268616) * gru_0_out_t2_41 + (-0.39732015132904053) * gru_0_out_t2_42 + (0.21011818945407867) * gru_0_out_t2_43 + (-0.0048712431453168392) * gru_0_out_t2_44 + (-0.084724657237529755) * gru_0_out_t2_45 + (-0.56317687034606934) * gru_0_out_t2_46 + (0.13989385962486267) * gru_0_out_t2_47 + (0.84713870286941528) * gru_0_out_t2_48 + (-0.86353862285614014) * gru_0_out_t2_49 + (-0.25342962145805359) * gru_0_out_t2_50 + (-0.054909225553274155) * gru_0_out_t2_51 + (0.019358288496732712) * gru_0_out_t2_52 + (-0.075290083885192871) * gru_0_out_t2_53 + (-0.16349592804908752) * gru_0_out_t2_54 + (-0.07244555652141571) * gru_0_out_t2_55 + (0.029015704989433289) * gru_0_out_t2_56 + (-0.53338426351547241) * gru_0_out_t2_57 + (-0.1850084662437439) * gru_0_out_t2_58 + (0.23830389976501465) * gru_0_out_t2_59 + (0.017138885334134102) * gru_0_out_t2_60 + (0.22678205370903015) * gru_0_out_t2_61 + (0.80220997333526611) * gru_0_out_t2_62 + (0.56181514263153076) * gru_0_out_t2_63 + gate_r * ((-0.0017872564494609833) + (0.17291161417961121) * gru_1_fwd_t1_h_0 + (-0.16557939350605011) * gru_1_fwd_t1_h_1 + (0.39554813504219055) * gru_1_fwd_t1_h_2 + (0.05569954589009285) * gru_1_fwd_t1_h_3 + (0.56083321571350098) * gru_1_fwd_t1_h_4 + (0.12670880556106567) * gru_1_fwd_t1_h_5 + (0.65794306993484497) * gru_1_fwd_t1_h_6 + (-0.21976161003112793) * gru_1_fwd_t1_h_7 + (-0.004758844617754221) * gru_1_fwd_t1_h_8 + (-0.067545615136623383) * gru_1_fwd_t1_h_9 + (-0.048043191432952881) * gru_1_fwd_t1_h_10 + (-0.079190202057361603) * gru_1_fwd_t1_h_11 + (-0.12897725403308868) * gru_1_fwd_t1_h_12 + (-0.2040000706911087) * gru_1_fwd_t1_h_13 + (-0.17037667334079742) * gru_1_fwd_t1_h_14 + (0.4589570164680481) * gru_1_fwd_t1_h_15 + (-0.37608778476715088) * gru_1_fwd_t1_h_16 + (-0.15980455279350281) * gru_1_fwd_t1_h_17 + (-0.51171118021011353) * gru_1_fwd_t1_h_18 + (-0.068312458693981171) * gru_1_fwd_t1_h_19 + (0.2520260214805603) * gru_1_fwd_t1_h_20 + (-0.1185866966843605) * gru_1_fwd_t1_h_21 + (0.43436223268508911) * gru_1_fwd_t1_h_22 + (0.35940629243850708) * gru_1_fwd_t1_h_23 + (0.46475234627723694) * gru_1_fwd_t1_h_24 + (0.24857024848461151) * gru_1_fwd_t1_h_25 + (-0.29434356093406677) * gru_1_fwd_t1_h_26 + (0.38906201720237732) * gru_1_fwd_t1_h_27 + (0.94492065906524658) * gru_1_fwd_t1_h_28 + (-0.52928435802459717) * gru_1_fwd_t1_h_29 + (-0.019179090857505798) * gru_1_fwd_t1_h_30 + (0.34318211674690247) * gru_1_fwd_t1_h_31));
    gru_1_fwd_t2_h_11 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t1_h_11;
    // h=12
    gate_r = sigmoid((-0.86868244409561157) + (-0.34697121381759644) * gru_0_out_t2_0 + (0.18967863917350769) * gru_0_out_t2_1 + (0.18173842132091522) * gru_0_out_t2_2 + (0.68365049362182617) * gru_0_out_t2_3 + (0.29115530848503113) * gru_0_out_t2_4 + (0.79211574792861938) * gru_0_out_t2_5 + (-0.71262192726135254) * gru_0_out_t2_6 + (-1.224705696105957) * gru_0_out_t2_7 + (0.88752621412277222) * gru_0_out_t2_8 + (-1.7929888963699341) * gru_0_out_t2_9 + (0.82308787107467651) * gru_0_out_t2_10 + (-0.57957661151885986) * gru_0_out_t2_11 + (0.18759529292583466) * gru_0_out_t2_12 + (0.21172942221164703) * gru_0_out_t2_13 + (-0.2630234956741333) * gru_0_out_t2_14 + (1.2525253295898438) * gru_0_out_t2_15 + (0.41601258516311646) * gru_0_out_t2_16 + (0.11622653901576996) * gru_0_out_t2_17 + (0.82903885841369629) * gru_0_out_t2_18 + (2.2396926879882812) * gru_0_out_t2_19 + (-1.4957054853439331) * gru_0_out_t2_20 + (0.59828543663024902) * gru_0_out_t2_21 + (-0.20681065320968628) * gru_0_out_t2_22 + (-0.35710138082504272) * gru_0_out_t2_23 + (1.486964225769043) * gru_0_out_t2_24 + (-0.11370556056499481) * gru_0_out_t2_25 + (-1.1863374710083008) * gru_0_out_t2_26 + (0.69345349073410034) * gru_0_out_t2_27 + (-0.024042068049311638) * gru_0_out_t2_28 + (0.53577756881713867) * gru_0_out_t2_29 + (-0.1436774879693985) * gru_0_out_t2_30 + (-4.117408275604248) * gru_0_out_t2_31 + (-1.1653522253036499) * gru_0_out_t2_32 + (0.46456235647201538) * gru_0_out_t2_33 + (-0.20534321665763855) * gru_0_out_t2_34 + (0.074372768402099609) * gru_0_out_t2_35 + (-0.16653381288051605) * gru_0_out_t2_36 + (0.15804155170917511) * gru_0_out_t2_37 + (0.012111191637814045) * gru_0_out_t2_38 + (0.079909995198249817) * gru_0_out_t2_39 + (0.73227953910827637) * gru_0_out_t2_40 + (-0.10929638147354126) * gru_0_out_t2_41 + (2.1610260009765625) * gru_0_out_t2_42 + (-0.10465149581432343) * gru_0_out_t2_43 + (-0.70635092258453369) * gru_0_out_t2_44 + (-0.27271726727485657) * gru_0_out_t2_45 + (-0.29159641265869141) * gru_0_out_t2_46 + (0.26668599247932434) * gru_0_out_t2_47 + (-0.18232174217700958) * gru_0_out_t2_48 + (0.11549025774002075) * gru_0_out_t2_49 + (-0.23823173344135284) * gru_0_out_t2_50 + (0.98151767253875732) * gru_0_out_t2_51 + (-0.25662073493003845) * gru_0_out_t2_52 + (0.0031926701776683331) * gru_0_out_t2_53 + (-0.33342918753623962) * gru_0_out_t2_54 + (-0.43766987323760986) * gru_0_out_t2_55 + (0.34654012322425842) * gru_0_out_t2_56 + (0.33429506421089172) * gru_0_out_t2_57 + (0.11083298176527023) * gru_0_out_t2_58 + (0.54052650928497314) * gru_0_out_t2_59 + (0.99470537900924683) * gru_0_out_t2_60 + (0.20675328373908997) * gru_0_out_t2_61 + (1.3286465406417847) * gru_0_out_t2_62 + (0.16312959790229797) * gru_0_out_t2_63 + (0.83877450227737427) * gru_1_fwd_t1_h_0 + (-0.771950364112854) * gru_1_fwd_t1_h_1 + (1.4217849969863892) * gru_1_fwd_t1_h_2 + (-0.49594786763191223) * gru_1_fwd_t1_h_3 + (1.170246958732605) * gru_1_fwd_t1_h_4 + (-2.159583568572998) * gru_1_fwd_t1_h_5 + (1.6332790851593018) * gru_1_fwd_t1_h_6 + (-1.0809395313262939) * gru_1_fwd_t1_h_7 + (-0.0072112772613763809) * gru_1_fwd_t1_h_8 + (0.54272443056106567) * gru_1_fwd_t1_h_9 + (0.42202857136726379) * gru_1_fwd_t1_h_10 + (0.049420721828937531) * gru_1_fwd_t1_h_11 + (-0.69319993257522583) * gru_1_fwd_t1_h_12 + (0.4198453426361084) * gru_1_fwd_t1_h_13 + (-0.61358803510665894) * gru_1_fwd_t1_h_14 + (1.5061087608337402) * gru_1_fwd_t1_h_15 + (-0.62690746784210205) * gru_1_fwd_t1_h_16 + (0.28428378701210022) * gru_1_fwd_t1_h_17 + (-0.62983691692352295) * gru_1_fwd_t1_h_18 + (0.26186287403106689) * gru_1_fwd_t1_h_19 + (0.52221685647964478) * gru_1_fwd_t1_h_20 + (0.22187063097953796) * gru_1_fwd_t1_h_21 + (1.7208113670349121) * gru_1_fwd_t1_h_22 + (-0.67760801315307617) * gru_1_fwd_t1_h_23 + (2.9978196620941162) * gru_1_fwd_t1_h_24 + (0.96962970495223999) * gru_1_fwd_t1_h_25 + (-2.7868270874023438) * gru_1_fwd_t1_h_26 + (-0.30905994772911072) * gru_1_fwd_t1_h_27 + (0.91641461849212646) * gru_1_fwd_t1_h_28 + (-0.043612692505121231) * gru_1_fwd_t1_h_29 + (0.65428990125656128) * gru_1_fwd_t1_h_30 + (0.63820570707321167) * gru_1_fwd_t1_h_31);
    gate_z = sigmoid((0.36791986227035522) + (0.54722118377685547) * gru_0_out_t2_0 + (-0.20282416045665741) * gru_0_out_t2_1 + (1.3032547235488892) * gru_0_out_t2_2 + (0.68645751476287842) * gru_0_out_t2_3 + (0.036828503012657166) * gru_0_out_t2_4 + (0.54895520210266113) * gru_0_out_t2_5 + (-0.35686805844306946) * gru_0_out_t2_6 + (-0.78790438175201416) * gru_0_out_t2_7 + (0.22940470278263092) * gru_0_out_t2_8 + (1.0058671236038208) * gru_0_out_t2_9 + (-0.98197102546691895) * gru_0_out_t2_10 + (0.57148200273513794) * gru_0_out_t2_11 + (0.12222187966108322) * gru_0_out_t2_12 + (0.079848773777484894) * gru_0_out_t2_13 + (-0.11904613673686981) * gru_0_out_t2_14 + (0.68889135122299194) * gru_0_out_t2_15 + (0.38767001032829285) * gru_0_out_t2_16 + (0.52891045808792114) * gru_0_out_t2_17 + (0.31318038702011108) * gru_0_out_t2_18 + (1.8489186763763428) * gru_0_out_t2_19 + (0.036988582462072372) * gru_0_out_t2_20 + (-0.27463957667350769) * gru_0_out_t2_21 + (0.4887758195400238) * gru_0_out_t2_22 + (0.20195753872394562) * gru_0_out_t2_23 + (-1.5405286550521851) * gru_0_out_t2_24 + (-0.61348235607147217) * gru_0_out_t2_25 + (0.21648210287094116) * gru_0_out_t2_26 + (0.4908352792263031) * gru_0_out_t2_27 + (-1.0435421466827393) * gru_0_out_t2_28 + (-0.76586192846298218) * gru_0_out_t2_29 + (-0.095818772912025452) * gru_0_out_t2_30 + (1.5397857427597046) * gru_0_out_t2_31 + (-0.76097416877746582) * gru_0_out_t2_32 + (0.39889726042747498) * gru_0_out_t2_33 + (0.19591477513313293) * gru_0_out_t2_34 + (0.36992868781089783) * gru_0_out_t2_35 + (-0.26538810133934021) * gru_0_out_t2_36 + (0.24588780105113983) * gru_0_out_t2_37 + (-0.062437083572149277) * gru_0_out_t2_38 + (0.00010240373376291245) * gru_0_out_t2_39 + (-0.16742977499961853) * gru_0_out_t2_40 + (0.64715152978897095) * gru_0_out_t2_41 + (-0.65151786804199219) * gru_0_out_t2_42 + (0.21121004223823547) * gru_0_out_t2_43 + (0.55353879928588867) * gru_0_out_t2_44 + (-0.48270019888877869) * gru_0_out_t2_45 + (-0.82655638456344604) * gru_0_out_t2_46 + (0.69995546340942383) * gru_0_out_t2_47 + (1.0435880422592163) * gru_0_out_t2_48 + (-0.43678474426269531) * gru_0_out_t2_49 + (0.028196880593895912) * gru_0_out_t2_50 + (0.095496542751789093) * gru_0_out_t2_51 + (0.14613273739814758) * gru_0_out_t2_52 + (-0.14087760448455811) * gru_0_out_t2_53 + (-0.48146101832389832) * gru_0_out_t2_54 + (-1.370659351348877) * gru_0_out_t2_55 + (0.17489950358867645) * gru_0_out_t2_56 + (-0.33385688066482544) * gru_0_out_t2_57 + (0.006064197514206171) * gru_0_out_t2_58 + (0.3133578896522522) * gru_0_out_t2_59 + (0.13343943655490875) * gru_0_out_t2_60 + (-0.3690241277217865) * gru_0_out_t2_61 + (0.62344437837600708) * gru_0_out_t2_62 + (-0.38674631714820862) * gru_0_out_t2_63 + (0.72473621368408203) * gru_1_fwd_t1_h_0 + (0.8832588791847229) * gru_1_fwd_t1_h_1 + (0.26938042044639587) * gru_1_fwd_t1_h_2 + (0.32108432054519653) * gru_1_fwd_t1_h_3 + (-0.8765723705291748) * gru_1_fwd_t1_h_4 + (0.070506654679775238) * gru_1_fwd_t1_h_5 + (-0.32015314698219299) * gru_1_fwd_t1_h_6 + (-0.5157092809677124) * gru_1_fwd_t1_h_7 + (-0.27657988667488098) * gru_1_fwd_t1_h_8 + (-0.067152820527553558) * gru_1_fwd_t1_h_9 + (0.23878930509090424) * gru_1_fwd_t1_h_10 + (-0.18771460652351379) * gru_1_fwd_t1_h_11 + (0.19229017198085785) * gru_1_fwd_t1_h_12 + (-0.52206635475158691) * gru_1_fwd_t1_h_13 + (0.15198825299739838) * gru_1_fwd_t1_h_14 + (0.030645305290818214) * gru_1_fwd_t1_h_15 + (-1.519591212272644) * gru_1_fwd_t1_h_16 + (0.54415434598922729) * gru_1_fwd_t1_h_17 + (0.46411436796188354) * gru_1_fwd_t1_h_18 + (0.34408113360404968) * gru_1_fwd_t1_h_19 + (-0.16188061237335205) * gru_1_fwd_t1_h_20 + (-0.0087371654808521271) * gru_1_fwd_t1_h_21 + (0.42599338293075562) * gru_1_fwd_t1_h_22 + (-0.20831857621669769) * gru_1_fwd_t1_h_23 + (-0.18172724545001984) * gru_1_fwd_t1_h_24 + (0.17437276244163513) * gru_1_fwd_t1_h_25 + (0.32464265823364258) * gru_1_fwd_t1_h_26 + (0.088059805333614349) * gru_1_fwd_t1_h_27 + (-0.80814319849014282) * gru_1_fwd_t1_h_28 + (0.71563374996185303) * gru_1_fwd_t1_h_29 + (-0.50392669439315796) * gru_1_fwd_t1_h_30 + (0.18853190541267395) * gru_1_fwd_t1_h_31);
