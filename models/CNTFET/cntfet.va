    gate_z = sigmoid((-0.82164716720581055) + (-1.2334725856781006) * gru_1_out_t3_0 + (-2.7538251876831055) * gru_1_out_t3_1 + (0.20357942581176758) * gru_1_out_t3_2 + (-1.560415506362915) * gru_1_out_t3_3 + (2.3551571369171143) * gru_1_out_t3_4 + (-2.8150584697723389) * gru_1_out_t3_5 + (-1.8145488500595093) * gru_1_out_t3_6 + (0.071179859340190887) * gru_1_out_t3_7 + (0.89873981475830078) * gru_1_out_t3_8 + (-0.045009911060333252) * gru_1_out_t3_9 + (0.61683893203735352) * gru_1_out_t3_10 + (-0.049352876842021942) * gru_1_out_t3_11 + (-1.413280725479126) * gru_1_out_t3_12 + (0.83196967840194702) * gru_1_out_t3_13 + (0.22739879786968231) * gru_1_out_t3_14 + (-0.072252452373504639) * gru_1_out_t3_15 + (0.50008141994476318) * gru_1_out_t3_16 + (-1.2275667190551758) * gru_1_out_t3_17 + (-2.4929084777832031) * gru_1_out_t3_18 + (0.7492944598197937) * gru_1_out_t3_19 + (0.34500494599342346) * gru_1_out_t3_20 + (0.44790244102478027) * gru_1_out_t3_21 + (1.2681951522827148) * gru_1_out_t3_22 + (-0.84682971239089966) * gru_1_out_t3_23 + (-1.323762059211731) * gru_1_out_t3_24 + (0.54339367151260376) * gru_1_out_t3_25 + (0.25517365336418152) * gru_1_out_t3_26 + (-1.5069817304611206) * gru_1_out_t3_27 + (0.71935302019119263) * gru_1_out_t3_28 + (0.36218076944351196) * gru_1_out_t3_29 + (-0.79016631841659546) * gru_1_out_t3_30 + (0.43491125106811523) * gru_1_out_t3_31 + (-0.24046154320240021) * gru_1_out_t3_32 + (-0.44228559732437134) * gru_1_out_t3_33 + (0.41466489434242249) * gru_1_out_t3_34 + (1.0060116052627563) * gru_1_out_t3_35 + (-0.21110199391841888) * gru_1_out_t3_36 + (0.69292181730270386) * gru_1_out_t3_37 + (0.89084839820861816) * gru_1_out_t3_38 + (0.57069534063339233) * gru_1_out_t3_39 + (0.58204877376556396) * gru_1_out_t3_40 + (-1.0742350816726685) * gru_1_out_t3_41 + (0.29432353377342224) * gru_1_out_t3_42 + (-0.9001765251159668) * gru_1_out_t3_43 + (-1.2728835344314575) * gru_1_out_t3_44 + (-0.15802179276943207) * gru_1_out_t3_45 + (0.45991960167884827) * gru_1_out_t3_46 + (0.59648662805557251) * gru_1_out_t3_47 + (0.90296095609664917) * gru_1_out_t3_48 + (0.45400252938270569) * gru_1_out_t3_49 + (-1.7886620759963989) * gru_1_out_t3_50 + (-0.61682033538818359) * gru_1_out_t3_51 + (0.039207663387060165) * gru_1_out_t3_52 + (0.17518936097621918) * gru_1_out_t3_53 + (0.25630784034729004) * gru_1_out_t3_54 + (0.26514822244644165) * gru_1_out_t3_55 + (0.31615006923675537) * gru_1_out_t3_56 + (-0.20887178182601929) * gru_1_out_t3_57 + (-1.0626435279846191) * gru_1_out_t3_58 + (1.1821368932723999) * gru_1_out_t3_59 + (1.4549019336700439) * gru_1_out_t3_60 + (0.084335014224052429) * gru_1_out_t3_61 + (1.4574141502380371) * gru_1_out_t3_62 + (-0.81142586469650269) * gru_1_out_t3_63 + (-0.36828523874282837) * gru_2_fwd_t2_h_0 + (-0.19977021217346191) * gru_2_fwd_t2_h_1 + (-2.1694507598876953) * gru_2_fwd_t2_h_2 + (-1.0381677150726318) * gru_2_fwd_t2_h_3 + (-0.25937545299530029) * gru_2_fwd_t2_h_4 + (-0.7269018292427063) * gru_2_fwd_t2_h_5 + (-1.0571372509002686) * gru_2_fwd_t2_h_6 + (0.8297460675239563) * gru_2_fwd_t2_h_7 + (0.11684353649616241) * gru_2_fwd_t2_h_8 + (0.29048445820808411) * gru_2_fwd_t2_h_9 + (-0.052333928644657135) * gru_2_fwd_t2_h_10 + (0.89274191856384277) * gru_2_fwd_t2_h_11 + (1.6098544597625732) * gru_2_fwd_t2_h_12 + (0.1995968371629715) * gru_2_fwd_t2_h_13 + (0.95574003458023071) * gru_2_fwd_t2_h_14 + (-0.43575263023376465) * gru_2_fwd_t2_h_15 + (0.075341425836086273) * gru_2_fwd_t2_h_16 + (-0.096529796719551086) * gru_2_fwd_t2_h_17 + (-0.52554905414581299) * gru_2_fwd_t2_h_18 + (-0.64522945880889893) * gru_2_fwd_t2_h_19 + (-0.62770724296569824) * gru_2_fwd_t2_h_20 + (0.024839259684085846) * gru_2_fwd_t2_h_21 + (0.67526346445083618) * gru_2_fwd_t2_h_22 + (-0.36137554049491882) * gru_2_fwd_t2_h_23 + (0.54051011800765991) * gru_2_fwd_t2_h_24 + (-0.31883317232131958) * gru_2_fwd_t2_h_25 + (-0.2122882753610611) * gru_2_fwd_t2_h_26 + (-0.35043856501579285) * gru_2_fwd_t2_h_27 + (0.34836462140083313) * gru_2_fwd_t2_h_28 + (-1.0618116855621338) * gru_2_fwd_t2_h_29 + (-0.36367669701576233) * gru_2_fwd_t2_h_30 + (-0.06281869113445282) * gru_2_fwd_t2_h_31);
    gate_n = tanh((0.53600269556045532) + (-0.033662285655736923) * gru_1_out_t3_0 + (-0.20693092048168182) * gru_1_out_t3_1 + (-0.26044261455535889) * gru_1_out_t3_2 + (0.25264555215835571) * gru_1_out_t3_3 + (-0.72158712148666382) * gru_1_out_t3_4 + (0.28773695230484009) * gru_1_out_t3_5 + (-0.14502076804637909) * gru_1_out_t3_6 + (-0.23682978749275208) * gru_1_out_t3_7 + (0.48496085405349731) * gru_1_out_t3_8 + (-0.36784875392913818) * gru_1_out_t3_9 + (0.051263034343719482) * gru_1_out_t3_10 + (-0.28763759136199951) * gru_1_out_t3_11 + (-0.02988235279917717) * gru_1_out_t3_12 + (-0.23604519665241241) * gru_1_out_t3_13 + (0.16778093576431274) * gru_1_out_t3_14 + (-0.41178622841835022) * gru_1_out_t3_15 + (0.39377745985984802) * gru_1_out_t3_16 + (-0.48651918768882751) * gru_1_out_t3_17 + (-0.49599027633666992) * gru_1_out_t3_18 + (0.27730527520179749) * gru_1_out_t3_19 + (0.21977756917476654) * gru_1_out_t3_20 + (0.74772322177886963) * gru_1_out_t3_21 + (-0.047112643718719482) * gru_1_out_t3_22 + (-0.0012592541752383113) * gru_1_out_t3_23 + (-0.37138348817825317) * gru_1_out_t3_24 + (0.61766147613525391) * gru_1_out_t3_25 + (-0.15215064585208893) * gru_1_out_t3_26 + (-0.83764082193374634) * gru_1_out_t3_27 + (0.11536860466003418) * gru_1_out_t3_28 + (-0.42565914988517761) * gru_1_out_t3_29 + (1.2550132274627686) * gru_1_out_t3_30 + (-1.163799524307251) * gru_1_out_t3_31 + (-0.25686123967170715) * gru_1_out_t3_32 + (0.1476670503616333) * gru_1_out_t3_33 + (0.18998761475086212) * gru_1_out_t3_34 + (-0.81881076097488403) * gru_1_out_t3_35 + (1.1625007390975952) * gru_1_out_t3_36 + (-0.061339575797319412) * gru_1_out_t3_37 + (-0.20515646040439606) * gru_1_out_t3_38 + (0.082699894905090332) * gru_1_out_t3_39 + (-0.1747448742389679) * gru_1_out_t3_40 + (0.16268463432788849) * gru_1_out_t3_41 + (-0.13290446996688843) * gru_1_out_t3_42 + (-0.23566779494285583) * gru_1_out_t3_43 + (0.88437926769256592) * gru_1_out_t3_44 + (0.092521615326404572) * gru_1_out_t3_45 + (0.049046747386455536) * gru_1_out_t3_46 + (0.71454286575317383) * gru_1_out_t3_47 + (-0.94824874401092529) * gru_1_out_t3_48 + (-0.53074479103088379) * gru_1_out_t3_49 + (-0.32177591323852539) * gru_1_out_t3_50 + (-0.16073893010616302) * gru_1_out_t3_51 + (1.0069750547409058) * gru_1_out_t3_52 + (0.36182659864425659) * gru_1_out_t3_53 + (0.079621657729148865) * gru_1_out_t3_54 + (0.22041772305965424) * gru_1_out_t3_55 + (1.2269800901412964) * gru_1_out_t3_56 + (-0.51958483457565308) * gru_1_out_t3_57 + (-0.37965419888496399) * gru_1_out_t3_58 + (0.65432339906692505) * gru_1_out_t3_59 + (-0.60394465923309326) * gru_1_out_t3_60 + (0.089263610541820526) * gru_1_out_t3_61 + (-0.408343106508255) * gru_1_out_t3_62 + (-0.012028791010379791) * gru_1_out_t3_63 + gate_r * ((0.17160902917385101) + (0.015178877860307693) * gru_2_fwd_t2_h_0 + (-0.1129683256149292) * gru_2_fwd_t2_h_1 + (0.22626890242099762) * gru_2_fwd_t2_h_2 + (-0.23686867952346802) * gru_2_fwd_t2_h_3 + (0.54577010869979858) * gru_2_fwd_t2_h_4 + (-0.029007483273744583) * gru_2_fwd_t2_h_5 + (0.14668992161750793) * gru_2_fwd_t2_h_6 + (-0.57592737674713135) * gru_2_fwd_t2_h_7 + (0.30075651407241821) * gru_2_fwd_t2_h_8 + (-0.15241266787052155) * gru_2_fwd_t2_h_9 + (-0.070806652307510376) * gru_2_fwd_t2_h_10 + (0.33988717198371887) * gru_2_fwd_t2_h_11 + (-0.40884387493133545) * gru_2_fwd_t2_h_12 + (1.1097660064697266) * gru_2_fwd_t2_h_13 + (-0.34021764993667603) * gru_2_fwd_t2_h_14 + (-1.0269484519958496) * gru_2_fwd_t2_h_15 + (-0.29106289148330688) * gru_2_fwd_t2_h_16 + (0.7659609317779541) * gru_2_fwd_t2_h_17 + (-0.24252967536449432) * gru_2_fwd_t2_h_18 + (-1.0966665744781494) * gru_2_fwd_t2_h_19 + (0.13658730685710907) * gru_2_fwd_t2_h_20 + (-0.57965481281280518) * gru_2_fwd_t2_h_21 + (-1.3540983200073242) * gru_2_fwd_t2_h_22 + (0.15654216706752777) * gru_2_fwd_t2_h_23 + (-0.14535956084728241) * gru_2_fwd_t2_h_24 + (-0.070495635271072388) * gru_2_fwd_t2_h_25 + (-0.15717725455760956) * gru_2_fwd_t2_h_26 + (0.78270572423934937) * gru_2_fwd_t2_h_27 + (-0.58674913644790649) * gru_2_fwd_t2_h_28 + (-0.277759850025177) * gru_2_fwd_t2_h_29 + (0.38236969709396362) * gru_2_fwd_t2_h_30 + (0.39095303416252136) * gru_2_fwd_t2_h_31));
    gru_2_fwd_t3_h_29 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t2_h_29;
    // h=30
    gate_r = sigmoid((-0.44035369157791138) + (0.024167967960238457) * gru_1_out_t3_0 + (-0.8258674144744873) * gru_1_out_t3_1 + (-0.98564082384109497) * gru_1_out_t3_2 + (-1.5837081670761108) * gru_1_out_t3_3 + (-0.27353569865226746) * gru_1_out_t3_4 + (-0.19752717018127441) * gru_1_out_t3_5 + (2.2448680400848389) * gru_1_out_t3_6 + (-0.9630698561668396) * gru_1_out_t3_7 + (0.3129851222038269) * gru_1_out_t3_8 + (-0.34344479441642761) * gru_1_out_t3_9 + (0.40101787447929382) * gru_1_out_t3_10 + (1.1225861310958862) * gru_1_out_t3_11 + (-0.58243376016616821) * gru_1_out_t3_12 + (-0.0031694881618022919) * gru_1_out_t3_13 + (0.93787741661071777) * gru_1_out_t3_14 + (-0.035500649362802505) * gru_1_out_t3_15 + (-0.38341191411018372) * gru_1_out_t3_16 + (0.11743106693029404) * gru_1_out_t3_17 + (0.29262125492095947) * gru_1_out_t3_18 + (-0.10628173500299454) * gru_1_out_t3_19 + (-0.44335511326789856) * gru_1_out_t3_20 + (0.47778427600860596) * gru_1_out_t3_21 + (-2.4925501346588135) * gru_1_out_t3_22 + (-1.6684459447860718) * gru_1_out_t3_23 + (1.5259826183319092) * gru_1_out_t3_24 + (-0.39869615435600281) * gru_1_out_t3_25 + (0.61336630582809448) * gru_1_out_t3_26 + (0.57254672050476074) * gru_1_out_t3_27 + (0.1060413122177124) * gru_1_out_t3_28 + (0.22935403883457184) * gru_1_out_t3_29 + (-1.3452273607254028) * gru_1_out_t3_30 + (1.0452448129653931) * gru_1_out_t3_31 + (-2.0947644710540771) * gru_1_out_t3_32 + (0.24232834577560425) * gru_1_out_t3_33 + (0.61967575550079346) * gru_1_out_t3_34 + (-0.46802103519439697) * gru_1_out_t3_35 + (-0.57561463117599487) * gru_1_out_t3_36 + (0.18914981186389923) * gru_1_out_t3_37 + (0.17087818682193756) * gru_1_out_t3_38 + (0.38814887404441833) * gru_1_out_t3_39 + (-0.073206104338169098) * gru_1_out_t3_40 + (-1.1133558750152588) * gru_1_out_t3_41 + (-0.4214550256729126) * gru_1_out_t3_42 + (0.19053380191326141) * gru_1_out_t3_43 + (-2.119084358215332) * gru_1_out_t3_44 + (0.22179014980792999) * gru_1_out_t3_45 + (0.5223279595375061) * gru_1_out_t3_46 + (-0.4610435962677002) * gru_1_out_t3_47 + (-0.65312856435775757) * gru_1_out_t3_48 + (1.4900521039962769) * gru_1_out_t3_49 + (0.27943682670593262) * gru_1_out_t3_50 + (-0.25521495938301086) * gru_1_out_t3_51 + (0.2078239768743515) * gru_1_out_t3_52 + (0.021848319098353386) * gru_1_out_t3_53 + (0.48790988326072693) * gru_1_out_t3_54 + (0.40541329979896545) * gru_1_out_t3_55 + (-0.015446191653609276) * gru_1_out_t3_56 + (-0.28413406014442444) * gru_1_out_t3_57 + (-0.83820146322250366) * gru_1_out_t3_58 + (0.11239839345216751) * gru_1_out_t3_59 + (-0.879599928855896) * gru_1_out_t3_60 + (1.5482369661331177) * gru_1_out_t3_61 + (1.5754485130310059) * gru_1_out_t3_62 + (0.59093964099884033) * gru_1_out_t3_63 + (-0.3935219943523407) * gru_2_fwd_t2_h_0 + (0.13284477591514587) * gru_2_fwd_t2_h_1 + (-1.3916128873825073) * gru_2_fwd_t2_h_2 + (0.17931467294692993) * gru_2_fwd_t2_h_3 + (-0.37841880321502686) * gru_2_fwd_t2_h_4 + (1.2312648296356201) * gru_2_fwd_t2_h_5 + (-0.2754594087600708) * gru_2_fwd_t2_h_6 + (1.4253643751144409) * gru_2_fwd_t2_h_7 + (0.62578630447387695) * gru_2_fwd_t2_h_8 + (-0.54476642608642578) * gru_2_fwd_t2_h_9 + (-1.5622199773788452) * gru_2_fwd_t2_h_10 + (0.21826881170272827) * gru_2_fwd_t2_h_11 + (-1.0687199831008911) * gru_2_fwd_t2_h_12 + (4.4378399848937988) * gru_2_fwd_t2_h_13 + (-1.0483219623565674) * gru_2_fwd_t2_h_14 + (-0.6963689923286438) * gru_2_fwd_t2_h_15 + (1.5873264074325562) * gru_2_fwd_t2_h_16 + (0.99962729215621948) * gru_2_fwd_t2_h_17 + (0.35548156499862671) * gru_2_fwd_t2_h_18 + (-1.6196060180664062) * gru_2_fwd_t2_h_19 + (0.26542022824287415) * gru_2_fwd_t2_h_20 + (-0.28658351302146912) * gru_2_fwd_t2_h_21 + (0.091242328286170959) * gru_2_fwd_t2_h_22 + (-0.33687698841094971) * gru_2_fwd_t2_h_23 + (0.07562188059091568) * gru_2_fwd_t2_h_24 + (-1.4795291423797607) * gru_2_fwd_t2_h_25 + (-0.75596237182617188) * gru_2_fwd_t2_h_26 + (0.29002785682678223) * gru_2_fwd_t2_h_27 + (0.53855651617050171) * gru_2_fwd_t2_h_28 + (-0.29524856805801392) * gru_2_fwd_t2_h_29 + (1.1326829195022583) * gru_2_fwd_t2_h_30 + (-0.42534428834915161) * gru_2_fwd_t2_h_31);
    gate_z = sigmoid((0.16957060992717743) + (0.68521153926849365) * gru_1_out_t3_0 + (0.63975441455841064) * gru_1_out_t3_1 + (-0.043382421135902405) * gru_1_out_t3_2 + (-0.11764506250619888) * gru_1_out_t3_3 + (-0.39084669947624207) * gru_1_out_t3_4 + (-0.11301214993000031) * gru_1_out_t3_5 + (0.35086256265640259) * gru_1_out_t3_6 + (-0.019042354077100754) * gru_1_out_t3_7 + (0.62724733352661133) * gru_1_out_t3_8 + (-0.39756006002426147) * gru_1_out_t3_9 + (-0.11463665962219238) * gru_1_out_t3_10 + (1.0506991147994995) * gru_1_out_t3_11 + (0.17862890660762787) * gru_1_out_t3_12 + (-0.068968094885349274) * gru_1_out_t3_13 + (0.97567957639694214) * gru_1_out_t3_14 + (-0.45340803265571594) * gru_1_out_t3_15 + (-0.049146886914968491) * gru_1_out_t3_16 + (0.62139284610748291) * gru_1_out_t3_17 + (-0.96043616533279419) * gru_1_out_t3_18 + (0.42805156111717224) * gru_1_out_t3_19 + (-0.57164698839187622) * gru_1_out_t3_20 + (-0.87624019384384155) * gru_1_out_t3_21 + (-0.036074981093406677) * gru_1_out_t3_22 + (0.05675116553902626) * gru_1_out_t3_23 + (-0.19635388255119324) * gru_1_out_t3_24 + (0.400551438331604) * gru_1_out_t3_25 + (0.71323162317276001) * gru_1_out_t3_26 + (0.43404236435890198) * gru_1_out_t3_27 + (0.69310659170150757) * gru_1_out_t3_28 + (1.0429267883300781) * gru_1_out_t3_29 + (0.93611586093902588) * gru_1_out_t3_30 + (0.71720170974731445) * gru_1_out_t3_31 + (1.8045200109481812) * gru_1_out_t3_32 + (-0.04040195420384407) * gru_1_out_t3_33 + (0.095646403729915619) * gru_1_out_t3_34 + (0.10071109235286713) * gru_1_out_t3_35 + (-0.14454898238182068) * gru_1_out_t3_36 + (-0.66121721267700195) * gru_1_out_t3_37 + (-0.74663001298904419) * gru_1_out_t3_38 + (-0.72436779737472534) * gru_1_out_t3_39 + (0.1463610827922821) * gru_1_out_t3_40 + (0.36266586184501648) * gru_1_out_t3_41 + (-0.27086633443832397) * gru_1_out_t3_42 + (0.22960628569126129) * gru_1_out_t3_43 + (-1.4851381778717041) * gru_1_out_t3_44 + (-0.13107472658157349) * gru_1_out_t3_45 + (-0.063668854534626007) * gru_1_out_t3_46 + (0.61983966827392578) * gru_1_out_t3_47 + (0.56985729932785034) * gru_1_out_t3_48 + (-0.52942973375320435) * gru_1_out_t3_49 + (1.2106542587280273) * gru_1_out_t3_50 + (-0.19393642246723175) * gru_1_out_t3_51 + (-1.6284120082855225) * gru_1_out_t3_52 + (-0.6428375244140625) * gru_1_out_t3_53 + (0.23656351864337921) * gru_1_out_t3_54 + (0.054826680570840836) * gru_1_out_t3_55 + (0.2583848237991333) * gru_1_out_t3_56 + (0.004249280784279108) * gru_1_out_t3_57 + (0.12950922548770905) * gru_1_out_t3_58 + (-0.26099815964698792) * gru_1_out_t3_59 + (0.15168169140815735) * gru_1_out_t3_60 + (-0.41445213556289673) * gru_1_out_t3_61 + (-0.16883891820907593) * gru_1_out_t3_62 + (-0.045353364199399948) * gru_1_out_t3_63 + (-0.023385912179946899) * gru_2_fwd_t2_h_0 + (0.015636852011084557) * gru_2_fwd_t2_h_1 + (0.083335831761360168) * gru_2_fwd_t2_h_2 + (-0.29004862904548645) * gru_2_fwd_t2_h_3 + (-1.2749727964401245) * gru_2_fwd_t2_h_4 + (-0.5040016770362854) * gru_2_fwd_t2_h_5 + (0.82731890678405762) * gru_2_fwd_t2_h_6 + (0.074707783758640289) * gru_2_fwd_t2_h_7 + (-0.73187118768692017) * gru_2_fwd_t2_h_8 + (0.086556039750576019) * gru_2_fwd_t2_h_9 + (-0.25084775686264038) * gru_2_fwd_t2_h_10 + (0.066989786922931671) * gru_2_fwd_t2_h_11 + (-1.0159080028533936) * gru_2_fwd_t2_h_12 + (-1.2474660873413086) * gru_2_fwd_t2_h_13 + (-1.3720499277114868) * gru_2_fwd_t2_h_14 + (-0.92267012596130371) * gru_2_fwd_t2_h_15 + (0.48785772919654846) * gru_2_fwd_t2_h_16 + (0.77263873815536499) * gru_2_fwd_t2_h_17 + (-0.58710938692092896) * gru_2_fwd_t2_h_18 + (-0.27106860280036926) * gru_2_fwd_t2_h_19 + (0.033699914813041687) * gru_2_fwd_t2_h_20 + (-0.70517677068710327) * gru_2_fwd_t2_h_21 + (0.30389311909675598) * gru_2_fwd_t2_h_22 + (-1.1088865995407104) * gru_2_fwd_t2_h_23 + (0.17367810010910034) * gru_2_fwd_t2_h_24 + (-0.22469073534011841) * gru_2_fwd_t2_h_25 + (-0.1581505686044693) * gru_2_fwd_t2_h_26 + (0.70395040512084961) * gru_2_fwd_t2_h_27 + (0.2822716236114502) * gru_2_fwd_t2_h_28 + (0.65403610467910767) * gru_2_fwd_t2_h_29 + (-0.20049691200256348) * gru_2_fwd_t2_h_30 + (0.46858373284339905) * gru_2_fwd_t2_h_31);
    gate_n = tanh((0.52486979961395264) + (0.13326022028923035) * gru_1_out_t3_0 + (-0.69122284650802612) * gru_1_out_t3_1 + (0.045024283230304718) * gru_1_out_t3_2 + (-0.4646342396736145) * gru_1_out_t3_3 + (-0.16454903781414032) * gru_1_out_t3_4 + (-0.24473054707050323) * gru_1_out_t3_5 + (-1.4458540678024292) * gru_1_out_t3_6 + (0.10692502558231354) * gru_1_out_t3_7 + (0.17192833125591278) * gru_1_out_t3_8 + (-0.39141249656677246) * gru_1_out_t3_9 + (-0.31736955046653748) * gru_1_out_t3_10 + (0.054855089634656906) * gru_1_out_t3_11 + (-0.21664039790630341) * gru_1_out_t3_12 + (-0.51173639297485352) * gru_1_out_t3_13 + (-0.22270475327968597) * gru_1_out_t3_14 + (0.1295718252658844) * gru_1_out_t3_15 + (-0.054206438362598419) * gru_1_out_t3_16 + (-0.39948827028274536) * gru_1_out_t3_17 + (0.27623021602630615) * gru_1_out_t3_18 + (-0.04163031280040741) * gru_1_out_t3_19 + (0.0039417576044797897) * gru_1_out_t3_20 + (0.6087220311164856) * gru_1_out_t3_21 + (-0.5372239351272583) * gru_1_out_t3_22 + (0.13048619031906128) * gru_1_out_t3_23 + (-0.090553916990756989) * gru_1_out_t3_24 + (0.6377711296081543) * gru_1_out_t3_25 + (-0.25443464517593384) * gru_1_out_t3_26 + (0.17218777537345886) * gru_1_out_t3_27 + (0.7036052942276001) * gru_1_out_t3_28 + (-0.25545588135719299) * gru_1_out_t3_29 + (0.32286801934242249) * gru_1_out_t3_30 + (0.068418920040130615) * gru_1_out_t3_31 + (-0.29984334111213684) * gru_1_out_t3_32 + (-0.21269907057285309) * gru_1_out_t3_33 + (0.1084739938378334) * gru_1_out_t3_34 + (-0.21083046495914459) * gru_1_out_t3_35 + (0.084689244627952576) * gru_1_out_t3_36 + (-0.14771378040313721) * gru_1_out_t3_37 + (0.088944368064403534) * gru_1_out_t3_38 + (0.030534002929925919) * gru_1_out_t3_39 + (-0.28285914659500122) * gru_1_out_t3_40 + (0.80550050735473633) * gru_1_out_t3_41 + (-0.2835935652256012) * gru_1_out_t3_42 + (0.27154707908630371) * gru_1_out_t3_43 + (-0.16528113186359406) * gru_1_out_t3_44 + (0.378548264503479) * gru_1_out_t3_45 + (0.27964144945144653) * gru_1_out_t3_46 + (-0.19379061460494995) * gru_1_out_t3_47 + (0.024784984067082405) * gru_1_out_t3_48 + (-0.49999657273292542) * gru_1_out_t3_49 + (-0.20135611295700073) * gru_1_out_t3_50 + (-0.17146085202693939) * gru_1_out_t3_51 + (0.99322938919067383) * gru_1_out_t3_52 + (0.21068564057350159) * gru_1_out_t3_53 + (-0.36300823092460632) * gru_1_out_t3_54 + (-0.42267453670501709) * gru_1_out_t3_55 + (0.27367278933525085) * gru_1_out_t3_56 + (-0.23502537608146667) * gru_1_out_t3_57 + (-0.32074633240699768) * gru_1_out_t3_58 + (-0.25243321061134338) * gru_1_out_t3_59 + (0.31852170825004578) * gru_1_out_t3_60 + (-0.085823483765125275) * gru_1_out_t3_61 + (-0.36012181639671326) * gru_1_out_t3_62 + (0.17703695595264435) * gru_1_out_t3_63 + gate_r * ((0.62432503700256348) + (-0.54622387886047363) * gru_2_fwd_t2_h_0 + (0.0143956383690238) * gru_2_fwd_t2_h_1 + (-0.48127326369285583) * gru_2_fwd_t2_h_2 + (-0.98061907291412354) * gru_2_fwd_t2_h_3 + (0.24659045040607452) * gru_2_fwd_t2_h_4 + (0.28519120812416077) * gru_2_fwd_t2_h_5 + (0.82290387153625488) * gru_2_fwd_t2_h_6 + (1.4800379276275635) * gru_2_fwd_t2_h_7 + (0.019777636975049973) * gru_2_fwd_t2_h_8 + (0.038702420890331268) * gru_2_fwd_t2_h_9 + (-0.5829322338104248) * gru_2_fwd_t2_h_10 + (-0.63806122541427612) * gru_2_fwd_t2_h_11 + (0.078911803662776947) * gru_2_fwd_t2_h_12 + (1.9817041158676147) * gru_2_fwd_t2_h_13 + (0.21271245181560516) * gru_2_fwd_t2_h_14 + (-2.4314470291137695) * gru_2_fwd_t2_h_15 + (-0.15003345906734467) * gru_2_fwd_t2_h_16 + (1.0479488372802734) * gru_2_fwd_t2_h_17 + (-1.2627525329589844) * gru_2_fwd_t2_h_18 + (-0.73277151584625244) * gru_2_fwd_t2_h_19 + (-0.42971795797348022) * gru_2_fwd_t2_h_20 + (0.15684685111045837) * gru_2_fwd_t2_h_21 + (1.680208683013916) * gru_2_fwd_t2_h_22 + (-0.57441329956054688) * gru_2_fwd_t2_h_23 + (0.59284621477127075) * gru_2_fwd_t2_h_24 + (-0.10478363186120987) * gru_2_fwd_t2_h_25 + (0.23945558071136475) * gru_2_fwd_t2_h_26 + (-0.45739391446113586) * gru_2_fwd_t2_h_27 + (-0.32303869724273682) * gru_2_fwd_t2_h_28 + (0.69600081443786621) * gru_2_fwd_t2_h_29 + (0.013752790167927742) * gru_2_fwd_t2_h_30 + (0.015940375626087189) * gru_2_fwd_t2_h_31));
    gru_2_fwd_t3_h_30 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t2_h_30;
    // h=31
    gate_r = sigmoid((-1.7815263271331787) + (0.93495190143585205) * gru_1_out_t3_0 + (-0.66579174995422363) * gru_1_out_t3_1 + (0.25233682990074158) * gru_1_out_t3_2 + (0.33942285180091858) * gru_1_out_t3_3 + (-0.56580018997192383) * gru_1_out_t3_4 + (1.2268366813659668) * gru_1_out_t3_5 + (0.60791796445846558) * gru_1_out_t3_6 + (-0.41228374838829041) * gru_1_out_t3_7 + (-0.2445475161075592) * gru_1_out_t3_8 + (0.54454284906387329) * gru_1_out_t3_9 + (0.61452871561050415) * gru_1_out_t3_10 + (0.70068174600601196) * gru_1_out_t3_11 + (0.098096318542957306) * gru_1_out_t3_12 + (0.09878946840763092) * gru_1_out_t3_13 + (-2.2319633960723877) * gru_1_out_t3_14 + (-0.63675624132156372) * gru_1_out_t3_15 + (0.74540680646896362) * gru_1_out_t3_16 + (0.2517096996307373) * gru_1_out_t3_17 + (1.2801909446716309) * gru_1_out_t3_18 + (0.77994930744171143) * gru_1_out_t3_19 + (-0.46451583504676819) * gru_1_out_t3_20 + (-0.1995013952255249) * gru_1_out_t3_21 + (-0.019534481689333916) * gru_1_out_t3_22 + (-1.3630490303039551) * gru_1_out_t3_23 + (4.5795493125915527) * gru_1_out_t3_24 + (-2.8409368991851807) * gru_1_out_t3_25 + (-0.86852645874023438) * gru_1_out_t3_26 + (-0.16667218506336212) * gru_1_out_t3_27 + (-0.99098259210586548) * gru_1_out_t3_28 + (-1.0894865989685059) * gru_1_out_t3_29 + (0.1599888801574707) * gru_1_out_t3_30 + (0.62470817565917969) * gru_1_out_t3_31 + (-0.96016401052474976) * gru_1_out_t3_32 + (0.12390316277742386) * gru_1_out_t3_33 + (0.70073246955871582) * gru_1_out_t3_34 + (0.78521895408630371) * gru_1_out_t3_35 + (-0.13294096291065216) * gru_1_out_t3_36 + (-1.1217278242111206) * gru_1_out_t3_37 + (0.13850131630897522) * gru_1_out_t3_38 + (0.16159161925315857) * gru_1_out_t3_39 + (-0.4705202579498291) * gru_1_out_t3_40 + (-1.6695711612701416) * gru_1_out_t3_41 + (-0.2519201934337616) * gru_1_out_t3_42 + (-0.19717960059642792) * gru_1_out_t3_43 + (-0.34246385097503662) * gru_1_out_t3_44 + (1.0929782390594482) * gru_1_out_t3_45 + (0.24271261692047119) * gru_1_out_t3_46 + (0.045207682996988297) * gru_1_out_t3_47 + (1.6401823759078979) * gru_1_out_t3_48 + (0.50057744979858398) * gru_1_out_t3_49 + (1.0130987167358398) * gru_1_out_t3_50 + (-1.4461284875869751) * gru_1_out_t3_51 + (-1.3199162483215332) * gru_1_out_t3_52 + (-1.0809775590896606) * gru_1_out_t3_53 + (0.38492867350578308) * gru_1_out_t3_54 + (0.89188885688781738) * gru_1_out_t3_55 + (-0.31210193037986755) * gru_1_out_t3_56 + (-0.9958876371383667) * gru_1_out_t3_57 + (-0.56891167163848877) * gru_1_out_t3_58 + (0.75465011596679688) * gru_1_out_t3_59 + (-0.79101806879043579) * gru_1_out_t3_60 + (-0.63344049453735352) * gru_1_out_t3_61 + (0.23912501335144043) * gru_1_out_t3_62 + (-1.1403803825378418) * gru_1_out_t3_63 + (-0.13416846096515656) * gru_2_fwd_t2_h_0 + (1.0902590751647949) * gru_2_fwd_t2_h_1 + (-0.16053387522697449) * gru_2_fwd_t2_h_2 + (0.35016259551048279) * gru_2_fwd_t2_h_3 + (-0.047511201351881027) * gru_2_fwd_t2_h_4 + (-1.0160132646560669) * gru_2_fwd_t2_h_5 + (-0.61796939373016357) * gru_2_fwd_t2_h_6 + (-1.7435925006866455) * gru_2_fwd_t2_h_7 + (0.35965883731842041) * gru_2_fwd_t2_h_8 + (-0.37779796123504639) * gru_2_fwd_t2_h_9 + (-0.030188845470547676) * gru_2_fwd_t2_h_10 + (-1.6433360576629639) * gru_2_fwd_t2_h_11 + (0.13710600137710571) * gru_2_fwd_t2_h_12 + (0.25348621606826782) * gru_2_fwd_t2_h_13 + (-0.72212588787078857) * gru_2_fwd_t2_h_14 + (0.020930062979459763) * gru_2_fwd_t2_h_15 + (0.23549690842628479) * gru_2_fwd_t2_h_16 + (-0.11266374588012695) * gru_2_fwd_t2_h_17 + (0.48884400725364685) * gru_2_fwd_t2_h_18 + (-0.36694297194480896) * gru_2_fwd_t2_h_19 + (-0.42375323176383972) * gru_2_fwd_t2_h_20 + (0.58402436971664429) * gru_2_fwd_t2_h_21 + (-0.086680375039577484) * gru_2_fwd_t2_h_22 + (0.27744483947753906) * gru_2_fwd_t2_h_23 + (1.7531194686889648) * gru_2_fwd_t2_h_24 + (0.043129291385412216) * gru_2_fwd_t2_h_25 + (-0.50524288415908813) * gru_2_fwd_t2_h_26 + (-0.55728399753570557) * gru_2_fwd_t2_h_27 + (1.1743757724761963) * gru_2_fwd_t2_h_28 + (-0.23450116813182831) * gru_2_fwd_t2_h_29 + (0.061185576021671295) * gru_2_fwd_t2_h_30 + (-0.9152519702911377) * gru_2_fwd_t2_h_31);
    gate_z = sigmoid((0.073960877954959869) + (0.022965142503380775) * gru_1_out_t3_0 + (-0.3393574059009552) * gru_1_out_t3_1 + (0.12157067656517029) * gru_1_out_t3_2 + (0.4620462954044342) * gru_1_out_t3_3 + (0.45869520306587219) * gru_1_out_t3_4 + (0.91973221302032471) * gru_1_out_t3_5 + (-0.5472642183303833) * gru_1_out_t3_6 + (0.039492424577474594) * gru_1_out_t3_7 + (-0.63852971792221069) * gru_1_out_t3_8 + (0.068871967494487762) * gru_1_out_t3_9 + (0.037045929580926895) * gru_1_out_t3_10 + (0.1830785870552063) * gru_1_out_t3_11 + (0.16961733996868134) * gru_1_out_t3_12 + (-0.59519606828689575) * gru_1_out_t3_13 + (0.24232250452041626) * gru_1_out_t3_14 + (-0.40436595678329468) * gru_1_out_t3_15 + (-0.51465916633605957) * gru_1_out_t3_16 + (0.78125935792922974) * gru_1_out_t3_17 + (0.055725075304508209) * gru_1_out_t3_18 + (0.10132819414138794) * gru_1_out_t3_19 + (0.30891877412796021) * gru_1_out_t3_20 + (-0.46087563037872314) * gru_1_out_t3_21 + (-0.35197895765304565) * gru_1_out_t3_22 + (1.268703818321228) * gru_1_out_t3_23 + (-0.0066659804433584213) * gru_1_out_t3_24 + (0.43952679634094238) * gru_1_out_t3_25 + (-0.1649162620306015) * gru_1_out_t3_26 + (-0.22546817362308502) * gru_1_out_t3_27 + (1.4722193479537964) * gru_1_out_t3_28 + (0.46746912598609924) * gru_1_out_t3_29 + (0.20357209444046021) * gru_1_out_t3_30 + (0.0943097323179245) * gru_1_out_t3_31 + (0.90079092979431152) * gru_1_out_t3_32 + (0.25517871975898743) * gru_1_out_t3_33 + (0.28842586278915405) * gru_1_out_t3_34 + (0.085586562752723694) * gru_1_out_t3_35 + (1.409705638885498) * gru_1_out_t3_36 + (-0.39605405926704407) * gru_1_out_t3_37 + (-0.51975858211517334) * gru_1_out_t3_38 + (-0.12581613659858704) * gru_1_out_t3_39 + (0.064443409442901611) * gru_1_out_t3_40 + (0.45263960957527161) * gru_1_out_t3_41 + (0.32583802938461304) * gru_1_out_t3_42 + (0.07411918044090271) * gru_1_out_t3_43 + (0.17966918647289276) * gru_1_out_t3_44 + (1.6813132762908936) * gru_1_out_t3_45 + (-0.07357218861579895) * gru_1_out_t3_46 + (-0.31817856431007385) * gru_1_out_t3_47 + (-1.1099578142166138) * gru_1_out_t3_48 + (-0.16955159604549408) * gru_1_out_t3_49 + (0.59761464595794678) * gru_1_out_t3_50 + (0.27911141514778137) * gru_1_out_t3_51 + (-0.36855736374855042) * gru_1_out_t3_52 + (0.50394976139068604) * gru_1_out_t3_53 + (0.36515125632286072) * gru_1_out_t3_54 + (-0.62080115079879761) * gru_1_out_t3_55 + (-0.89770853519439697) * gru_1_out_t3_56 + (0.19303140044212341) * gru_1_out_t3_57 + (0.38781458139419556) * gru_1_out_t3_58 + (0.79146277904510498) * gru_1_out_t3_59 + (-0.1103486567735672) * gru_1_out_t3_60 + (-0.27907943725585938) * gru_1_out_t3_61 + (-0.28859251737594604) * gru_1_out_t3_62 + (0.42998966574668884) * gru_1_out_t3_63 + (0.51293253898620605) * gru_2_fwd_t2_h_0 + (0.20832344889640808) * gru_2_fwd_t2_h_1 + (-0.17442344129085541) * gru_2_fwd_t2_h_2 + (0.65306460857391357) * gru_2_fwd_t2_h_3 + (0.025248387828469276) * gru_2_fwd_t2_h_4 + (-0.21575532853603363) * gru_2_fwd_t2_h_5 + (-0.40106022357940674) * gru_2_fwd_t2_h_6 + (-0.33934375643730164) * gru_2_fwd_t2_h_7 + (0.091993868350982666) * gru_2_fwd_t2_h_8 + (0.66153234243392944) * gru_2_fwd_t2_h_9 + (-0.40906724333763123) * gru_2_fwd_t2_h_10 + (-0.66236144304275513) * gru_2_fwd_t2_h_11 + (-0.22621405124664307) * gru_2_fwd_t2_h_12 + (0.37215328216552734) * gru_2_fwd_t2_h_13 + (1.0961302518844604) * gru_2_fwd_t2_h_14 + (-0.51946169137954712) * gru_2_fwd_t2_h_15 + (-0.22816924750804901) * gru_2_fwd_t2_h_16 + (-0.23571974039077759) * gru_2_fwd_t2_h_17 + (0.18237952888011932) * gru_2_fwd_t2_h_18 + (0.22779101133346558) * gru_2_fwd_t2_h_19 + (0.079185329377651215) * gru_2_fwd_t2_h_20 + (0.42215007543563843) * gru_2_fwd_t2_h_21 + (-1.1483166217803955) * gru_2_fwd_t2_h_22 + (0.36676502227783203) * gru_2_fwd_t2_h_23 + (0.37121260166168213) * gru_2_fwd_t2_h_24 + (-0.17317990958690643) * gru_2_fwd_t2_h_25 + (-0.16349697113037109) * gru_2_fwd_t2_h_26 + (-0.37886777520179749) * gru_2_fwd_t2_h_27 + (-0.48091909289360046) * gru_2_fwd_t2_h_28 + (0.2656838595867157) * gru_2_fwd_t2_h_29 + (0.32997331023216248) * gru_2_fwd_t2_h_30 + (-0.45384779572486877) * gru_2_fwd_t2_h_31);
    gate_n = tanh((0.14515006542205811) + (-0.46478024125099182) * gru_1_out_t3_0 + (-0.31735977530479431) * gru_1_out_t3_1 + (0.54822379350662231) * gru_1_out_t3_2 + (-1.380972146987915) * gru_1_out_t3_3 + (0.26829645037651062) * gru_1_out_t3_4 + (-0.43174219131469727) * gru_1_out_t3_5 + (-0.27001920342445374) * gru_1_out_t3_6 + (-0.47979044914245605) * gru_1_out_t3_7 + (-0.48224502801895142) * gru_1_out_t3_8 + (-0.35427647829055786) * gru_1_out_t3_9 + (0.15184688568115234) * gru_1_out_t3_10 + (-0.66441595554351807) * gru_1_out_t3_11 + (0.084937050938606262) * gru_1_out_t3_12 + (-0.22382940351963043) * gru_1_out_t3_13 + (-0.7386244535446167) * gru_1_out_t3_14 + (-0.32236078381538391) * gru_1_out_t3_15 + (-0.1488506942987442) * gru_1_out_t3_16 + (-0.0065810992382466793) * gru_1_out_t3_17 + (-0.19610416889190674) * gru_1_out_t3_18 + (-0.092612586915493011) * gru_1_out_t3_19 + (-0.057473737746477127) * gru_1_out_t3_20 + (0.4569220244884491) * gru_1_out_t3_21 + (-0.2383745014667511) * gru_1_out_t3_22 + (1.3617632389068604) * gru_1_out_t3_23 + (1.2686463594436646) * gru_1_out_t3_24 + (-0.25959083437919617) * gru_1_out_t3_25 + (-0.56934559345245361) * gru_1_out_t3_26 + (1.0252753496170044) * gru_1_out_t3_27 + (0.055700551718473434) * gru_1_out_t3_28 + (-0.04686969518661499) * gru_1_out_t3_29 + (1.1762231588363647) * gru_1_out_t3_30 + (0.86568927764892578) * gru_1_out_t3_31 + (-0.35840871930122375) * gru_1_out_t3_32 + (0.3163820207118988) * gru_1_out_t3_33 + (-0.4542919397354126) * gru_1_out_t3_34 + (-0.89199662208557129) * gru_1_out_t3_35 + (0.22158224880695343) * gru_1_out_t3_36 + (0.87518793344497681) * gru_1_out_t3_37 + (0.68089711666107178) * gru_1_out_t3_38 + (0.46704661846160889) * gru_1_out_t3_39 + (-0.43239176273345947) * gru_1_out_t3_40 + (0.61347043514251709) * gru_1_out_t3_41 + (-0.076828286051750183) * gru_1_out_t3_42 + (0.097342781722545624) * gru_1_out_t3_43 + (-0.3828447163105011) * gru_1_out_t3_44 + (-0.86053293943405151) * gru_1_out_t3_45 + (0.18917180597782135) * gru_1_out_t3_46 + (-0.51598471403121948) * gru_1_out_t3_47 + (-0.52515906095504761) * gru_1_out_t3_48 + (0.046294055879116058) * gru_1_out_t3_49 + (-0.022440051659941673) * gru_1_out_t3_50 + (-0.98786574602127075) * gru_1_out_t3_51 + (1.6700334548950195) * gru_1_out_t3_52 + (0.17374561727046967) * gru_1_out_t3_53 + (0.76166504621505737) * gru_1_out_t3_54 + (-0.10085459053516388) * gru_1_out_t3_55 + (0.070756159722805023) * gru_1_out_t3_56 + (0.047219470143318176) * gru_1_out_t3_57 + (0.57278025150299072) * gru_1_out_t3_58 + (0.79132050275802612) * gru_1_out_t3_59 + (-0.076801992952823639) * gru_1_out_t3_60 + (0.1381484717130661) * gru_1_out_t3_61 + (-0.1935608983039856) * gru_1_out_t3_62 + (-0.027563301846385002) * gru_1_out_t3_63 + gate_r * ((0.50284063816070557) + (-0.79433190822601318) * gru_2_fwd_t2_h_0 + (-0.20582440495491028) * gru_2_fwd_t2_h_1 + (-0.41883224248886108) * gru_2_fwd_t2_h_2 + (-0.11046017706394196) * gru_2_fwd_t2_h_3 + (-0.8629906177520752) * gru_2_fwd_t2_h_4 + (0.59116244316101074) * gru_2_fwd_t2_h_5 + (0.55285352468490601) * gru_2_fwd_t2_h_6 + (-1.1003137826919556) * gru_2_fwd_t2_h_7 + (0.23536530137062073) * gru_2_fwd_t2_h_8 + (0.35608288645744324) * gru_2_fwd_t2_h_9 + (0.59509623050689697) * gru_2_fwd_t2_h_10 + (0.51954251527786255) * gru_2_fwd_t2_h_11 + (0.17577043175697327) * gru_2_fwd_t2_h_12 + (-1.846951961517334) * gru_2_fwd_t2_h_13 + (1.4056026935577393) * gru_2_fwd_t2_h_14 + (0.60929340124130249) * gru_2_fwd_t2_h_15 + (-1.0449459552764893) * gru_2_fwd_t2_h_16 + (-1.3808363676071167) * gru_2_fwd_t2_h_17 + (-0.032662931829690933) * gru_2_fwd_t2_h_18 + (0.40425264835357666) * gru_2_fwd_t2_h_19 + (-0.27160117030143738) * gru_2_fwd_t2_h_20 + (0.27450102567672729) * gru_2_fwd_t2_h_21 + (0.16376200318336487) * gru_2_fwd_t2_h_22 + (0.55628585815429688) * gru_2_fwd_t2_h_23 + (0.22213880717754364) * gru_2_fwd_t2_h_24 + (1.1184312105178833) * gru_2_fwd_t2_h_25 + (-0.34128525853157043) * gru_2_fwd_t2_h_26 + (2.1957414150238037) * gru_2_fwd_t2_h_27 + (0.19614587724208832) * gru_2_fwd_t2_h_28 + (0.26245027780532837) * gru_2_fwd_t2_h_29 + (-1.1124726533889771) * gru_2_fwd_t2_h_30 + (0.22151148319244385) * gru_2_fwd_t2_h_31));
    gru_2_fwd_t3_h_31 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t2_h_31;

    // FW step t=4
    // h=0
    gate_r = sigmoid((-0.18073664605617523) + (0.08729107677936554) * gru_1_out_t4_0 + (-0.039967507123947144) * gru_1_out_t4_1 + (-0.31522822380065918) * gru_1_out_t4_2 + (-0.69163823127746582) * gru_1_out_t4_3 + (0.19949781894683838) * gru_1_out_t4_4 + (-0.54117608070373535) * gru_1_out_t4_5 + (-1.066991925239563) * gru_1_out_t4_6 + (0.087276667356491089) * gru_1_out_t4_7 + (-0.20998075604438782) * gru_1_out_t4_8 + (0.21276704967021942) * gru_1_out_t4_9 + (0.2321389764547348) * gru_1_out_t4_10 + (0.37099918723106384) * gru_1_out_t4_11 + (-0.30260381102561951) * gru_1_out_t4_12 + (-0.75835436582565308) * gru_1_out_t4_13 + (-0.20154118537902832) * gru_1_out_t4_14 + (0.35377636551856995) * gru_1_out_t4_15 + (-0.43740832805633545) * gru_1_out_t4_16 + (0.62309902906417847) * gru_1_out_t4_17 + (0.24479377269744873) * gru_1_out_t4_18 + (0.8066563606262207) * gru_1_out_t4_19 + (-0.16237467527389526) * gru_1_out_t4_20 + (-0.37762981653213501) * gru_1_out_t4_21 + (-0.93802309036254883) * gru_1_out_t4_22 + (-1.7538044452667236) * gru_1_out_t4_23 + (-0.46073368191719055) * gru_1_out_t4_24 + (-0.37962305545806885) * gru_1_out_t4_25 + (0.67589527368545532) * gru_1_out_t4_26 + (-0.40321063995361328) * gru_1_out_t4_27 + (0.75434738397598267) * gru_1_out_t4_28 + (0.084689721465110779) * gru_1_out_t4_29 + (-1.8361772298812866) * gru_1_out_t4_30 + (-0.6105002760887146) * gru_1_out_t4_31 + (-0.94578909873962402) * gru_1_out_t4_32 + (0.87572675943374634) * gru_1_out_t4_33 + (-1.9358584880828857) * gru_1_out_t4_34 + (-0.46796771883964539) * gru_1_out_t4_35 + (-1.3884075880050659) * gru_1_out_t4_36 + (0.018412670120596886) * gru_1_out_t4_37 + (-0.29430624842643738) * gru_1_out_t4_38 + (0.47208642959594727) * gru_1_out_t4_39 + (1.1266782283782959) * gru_1_out_t4_40 + (-1.2007905244827271) * gru_1_out_t4_41 + (0.74026471376419067) * gru_1_out_t4_42 + (-1.5903787612915039) * gru_1_out_t4_43 + (-0.18990631401538849) * gru_1_out_t4_44 + (0.62702357769012451) * gru_1_out_t4_45 + (-0.69175237417221069) * gru_1_out_t4_46 + (-0.067822158336639404) * gru_1_out_t4_47 + (0.56201267242431641) * gru_1_out_t4_48 + (1.9739961624145508) * gru_1_out_t4_49 + (0.26549708843231201) * gru_1_out_t4_50 + (0.96722650527954102) * gru_1_out_t4_51 + (1.6199929714202881) * gru_1_out_t4_52 + (-0.16836661100387573) * gru_1_out_t4_53 + (0.43099343776702881) * gru_1_out_t4_54 + (1.9925323724746704) * gru_1_out_t4_55 + (-0.22745929658412933) * gru_1_out_t4_56 + (0.96157270669937134) * gru_1_out_t4_57 + (-0.096243835985660553) * gru_1_out_t4_58 + (1.6467574834823608) * gru_1_out_t4_59 + (1.2544323205947876) * gru_1_out_t4_60 + (0.075169563293457031) * gru_1_out_t4_61 + (0.23568360507488251) * gru_1_out_t4_62 + (-0.74118083715438843) * gru_1_out_t4_63 + (0.088818199932575226) * gru_2_fwd_t3_h_0 + (1.094638466835022) * gru_2_fwd_t3_h_1 + (-0.13012155890464783) * gru_2_fwd_t3_h_2 + (0.30924892425537109) * gru_2_fwd_t3_h_3 + (-0.37895485758781433) * gru_2_fwd_t3_h_4 + (0.53093409538269043) * gru_2_fwd_t3_h_5 + (0.56977301836013794) * gru_2_fwd_t3_h_6 + (-0.036516681313514709) * gru_2_fwd_t3_h_7 + (-0.19669097661972046) * gru_2_fwd_t3_h_8 + (-0.94143807888031006) * gru_2_fwd_t3_h_9 + (-0.22347277402877808) * gru_2_fwd_t3_h_10 + (0.07340317964553833) * gru_2_fwd_t3_h_11 + (0.32363760471343994) * gru_2_fwd_t3_h_12 + (-1.1764510869979858) * gru_2_fwd_t3_h_13 + (0.77649903297424316) * gru_2_fwd_t3_h_14 + (0.15454436838626862) * gru_2_fwd_t3_h_15 + (-0.48716676235198975) * gru_2_fwd_t3_h_16 + (-0.55989372730255127) * gru_2_fwd_t3_h_17 + (0.24539470672607422) * gru_2_fwd_t3_h_18 + (-0.14125901460647583) * gru_2_fwd_t3_h_19 + (0.023622725158929825) * gru_2_fwd_t3_h_20 + (0.22418442368507385) * gru_2_fwd_t3_h_21 + (0.57258903980255127) * gru_2_fwd_t3_h_22 + (-0.33674481511116028) * gru_2_fwd_t3_h_23 + (-1.0202797651290894) * gru_2_fwd_t3_h_24 + (-0.3457828164100647) * gru_2_fwd_t3_h_25 + (-0.49569505453109741) * gru_2_fwd_t3_h_26 + (-0.26454624533653259) * gru_2_fwd_t3_h_27 + (0.20253007113933563) * gru_2_fwd_t3_h_28 + (-0.62527000904083252) * gru_2_fwd_t3_h_29 + (0.67240393161773682) * gru_2_fwd_t3_h_30 + (0.16319972276687622) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-1.5950472354888916) + (-0.62472999095916748) * gru_1_out_t4_0 + (0.948569655418396) * gru_1_out_t4_1 + (-0.042311780154705048) * gru_1_out_t4_2 + (0.22679845988750458) * gru_1_out_t4_3 + (0.83300691843032837) * gru_1_out_t4_4 + (0.50348711013793945) * gru_1_out_t4_5 + (1.3434373140335083) * gru_1_out_t4_6 + (0.83106744289398193) * gru_1_out_t4_7 + (0.92984825372695923) * gru_1_out_t4_8 + (0.12885928153991699) * gru_1_out_t4_9 + (-0.048464119434356689) * gru_1_out_t4_10 + (0.47500133514404297) * gru_1_out_t4_11 + (0.4825613796710968) * gru_1_out_t4_12 + (0.31471467018127441) * gru_1_out_t4_13 + (0.48116114735603333) * gru_1_out_t4_14 + (0.6122782826423645) * gru_1_out_t4_15 + (-0.29530638456344604) * gru_1_out_t4_16 + (-0.67366528511047363) * gru_1_out_t4_17 + (-1.2825165987014771) * gru_1_out_t4_18 + (-0.061589740216732025) * gru_1_out_t4_19 + (0.55133748054504395) * gru_1_out_t4_20 + (-0.52434903383255005) * gru_1_out_t4_21 + (-0.097612567245960236) * gru_1_out_t4_22 + (0.80840730667114258) * gru_1_out_t4_23 + (-1.0388964414596558) * gru_1_out_t4_24 + (0.00016520694771315902) * gru_1_out_t4_25 + (0.32818588614463806) * gru_1_out_t4_26 + (2.0948443412780762) * gru_1_out_t4_27 + (-0.13348464667797089) * gru_1_out_t4_28 + (-0.56748682260513306) * gru_1_out_t4_29 + (-0.085060544312000275) * gru_1_out_t4_30 + (0.12882412970066071) * gru_1_out_t4_31 + (-0.2335030734539032) * gru_1_out_t4_32 + (0.15321582555770874) * gru_1_out_t4_33 + (-0.38789618015289307) * gru_1_out_t4_34 + (0.69416701793670654) * gru_1_out_t4_35 + (0.26861950755119324) * gru_1_out_t4_36 + (-0.40949362516403198) * gru_1_out_t4_37 + (-0.52702522277832031) * gru_1_out_t4_38 + (-0.20277976989746094) * gru_1_out_t4_39 + (-0.13890430331230164) * gru_1_out_t4_40 + (-0.018138354644179344) * gru_1_out_t4_41 + (0.5611148476600647) * gru_1_out_t4_42 + (0.26855477690696716) * gru_1_out_t4_43 + (-1.1389527320861816) * gru_1_out_t4_44 + (0.59090304374694824) * gru_1_out_t4_45 + (0.70569831132888794) * gru_1_out_t4_46 + (0.51646310091018677) * gru_1_out_t4_47 + (0.59123629331588745) * gru_1_out_t4_48 + (0.32796949148178101) * gru_1_out_t4_49 + (1.8620154857635498) * gru_1_out_t4_50 + (0.092217162251472473) * gru_1_out_t4_51 + (-1.0174065828323364) * gru_1_out_t4_52 + (0.001582387019880116) * gru_1_out_t4_53 + (0.58182430267333984) * gru_1_out_t4_54 + (-0.40918311476707458) * gru_1_out_t4_55 + (-1.0552144050598145) * gru_1_out_t4_56 + (0.31395998597145081) * gru_1_out_t4_57 + (0.2548229992389679) * gru_1_out_t4_58 + (-0.57632046937942505) * gru_1_out_t4_59 + (0.026836544275283813) * gru_1_out_t4_60 + (-0.59954369068145752) * gru_1_out_t4_61 + (0.71469402313232422) * gru_1_out_t4_62 + (-0.157891646027565) * gru_1_out_t4_63 + (0.27730453014373779) * gru_2_fwd_t3_h_0 + (0.60882019996643066) * gru_2_fwd_t3_h_1 + (1.5440840721130371) * gru_2_fwd_t3_h_2 + (-0.0059450631961226463) * gru_2_fwd_t3_h_3 + (-0.16491875052452087) * gru_2_fwd_t3_h_4 + (-0.65377509593963623) * gru_2_fwd_t3_h_5 + (0.24129223823547363) * gru_2_fwd_t3_h_6 + (0.55730390548706055) * gru_2_fwd_t3_h_7 + (2.5542888641357422) * gru_2_fwd_t3_h_8 + (-0.41990578174591064) * gru_2_fwd_t3_h_9 + (-0.56818395853042603) * gru_2_fwd_t3_h_10 + (0.62904196977615356) * gru_2_fwd_t3_h_11 + (-0.88263398408889771) * gru_2_fwd_t3_h_12 + (-0.6779325008392334) * gru_2_fwd_t3_h_13 + (-2.1868524551391602) * gru_2_fwd_t3_h_14 + (-0.85047048330307007) * gru_2_fwd_t3_h_15 + (0.783008873462677) * gru_2_fwd_t3_h_16 + (-0.070817939937114716) * gru_2_fwd_t3_h_17 + (0.2077171802520752) * gru_2_fwd_t3_h_18 + (-0.43569532036781311) * gru_2_fwd_t3_h_19 + (-1.3878767490386963) * gru_2_fwd_t3_h_20 + (-0.05058152973651886) * gru_2_fwd_t3_h_21 + (0.30078700184822083) * gru_2_fwd_t3_h_22 + (-0.81006371974945068) * gru_2_fwd_t3_h_23 + (-0.57657015323638916) * gru_2_fwd_t3_h_24 + (0.18272678554058075) * gru_2_fwd_t3_h_25 + (-0.92492818832397461) * gru_2_fwd_t3_h_26 + (0.49245864152908325) * gru_2_fwd_t3_h_27 + (0.87708580493927002) * gru_2_fwd_t3_h_28 + (-0.92680990695953369) * gru_2_fwd_t3_h_29 + (0.1791825145483017) * gru_2_fwd_t3_h_30 + (-0.03632717952132225) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.89056885242462158) + (-0.15531931817531586) * gru_1_out_t4_0 + (0.039451684802770615) * gru_1_out_t4_1 + (0.15706862509250641) * gru_1_out_t4_2 + (0.30771991610527039) * gru_1_out_t4_3 + (0.14815370738506317) * gru_1_out_t4_4 + (-0.017183301970362663) * gru_1_out_t4_5 + (0.28388711810112) * gru_1_out_t4_6 + (-0.18915952742099762) * gru_1_out_t4_7 + (0.27618095278739929) * gru_1_out_t4_8 + (-0.24971669912338257) * gru_1_out_t4_9 + (-0.023962071165442467) * gru_1_out_t4_10 + (-0.66587674617767334) * gru_1_out_t4_11 + (0.30822166800498962) * gru_1_out_t4_12 + (-0.2512696385383606) * gru_1_out_t4_13 + (0.14788712561130524) * gru_1_out_t4_14 + (-0.28047487139701843) * gru_1_out_t4_15 + (-0.22166067361831665) * gru_1_out_t4_16 + (0.13373740017414093) * gru_1_out_t4_17 + (0.2893318235874176) * gru_1_out_t4_18 + (0.2883179783821106) * gru_1_out_t4_19 + (-0.30510246753692627) * gru_1_out_t4_20 + (0.18500968813896179) * gru_1_out_t4_21 + (0.60036975145339966) * gru_1_out_t4_22 + (0.69969487190246582) * gru_1_out_t4_23 + (0.3425222635269165) * gru_1_out_t4_24 + (-0.23267178237438202) * gru_1_out_t4_25 + (0.081159114837646484) * gru_1_out_t4_26 + (0.61552906036376953) * gru_1_out_t4_27 + (0.34244313836097717) * gru_1_out_t4_28 + (0.51718276739120483) * gru_1_out_t4_29 + (0.19291360676288605) * gru_1_out_t4_30 + (-0.70089727640151978) * gru_1_out_t4_31 + (0.66866022348403931) * gru_1_out_t4_32 + (0.69753736257553101) * gru_1_out_t4_33 + (-0.48435235023498535) * gru_1_out_t4_34 + (0.18863131105899811) * gru_1_out_t4_35 + (-0.44330805540084839) * gru_1_out_t4_36 + (-0.0068796528503298759) * gru_1_out_t4_37 + (0.38404324650764465) * gru_1_out_t4_38 + (-0.5873112678527832) * gru_1_out_t4_39 + (0.29154515266418457) * gru_1_out_t4_40 + (-0.25640428066253662) * gru_1_out_t4_41 + (-0.067580252885818481) * gru_1_out_t4_42 + (0.4244784414768219) * gru_1_out_t4_43 + (0.033369924873113632) * gru_1_out_t4_44 + (-0.19432789087295532) * gru_1_out_t4_45 + (-0.35623317956924438) * gru_1_out_t4_46 + (1.4397494792938232) * gru_1_out_t4_47 + (-0.53303670883178711) * gru_1_out_t4_48 + (0.15586227178573608) * gru_1_out_t4_49 + (0.34602692723274231) * gru_1_out_t4_50 + (0.62279218435287476) * gru_1_out_t4_51 + (0.094537675380706787) * gru_1_out_t4_52 + (0.08416420966386795) * gru_1_out_t4_53 + (0.17593678832054138) * gru_1_out_t4_54 + (-0.32541036605834961) * gru_1_out_t4_55 + (-0.17277508974075317) * gru_1_out_t4_56 + (0.046922165900468826) * gru_1_out_t4_57 + (-0.16812768578529358) * gru_1_out_t4_58 + (0.11006074398756027) * gru_1_out_t4_59 + (0.36323520541191101) * gru_1_out_t4_60 + (-0.14941711723804474) * gru_1_out_t4_61 + (-1.2971339225769043) * gru_1_out_t4_62 + (-0.21599899232387543) * gru_1_out_t4_63 + gate_r * ((-0.24038051068782806) + (0.095700711011886597) * gru_2_fwd_t3_h_0 + (0.10315702110528946) * gru_2_fwd_t3_h_1 + (0.82359933853149414) * gru_2_fwd_t3_h_2 + (0.70102602243423462) * gru_2_fwd_t3_h_3 + (-0.31996005773544312) * gru_2_fwd_t3_h_4 + (0.36810785531997681) * gru_2_fwd_t3_h_5 + (1.7771612405776978) * gru_2_fwd_t3_h_6 + (-0.88468968868255615) * gru_2_fwd_t3_h_7 + (-0.39480048418045044) * gru_2_fwd_t3_h_8 + (0.42028746008872986) * gru_2_fwd_t3_h_9 + (0.49731108546257019) * gru_2_fwd_t3_h_10 + (0.71990782022476196) * gru_2_fwd_t3_h_11 + (0.33260184526443481) * gru_2_fwd_t3_h_12 + (0.49829551577568054) * gru_2_fwd_t3_h_13 + (0.36034685373306274) * gru_2_fwd_t3_h_14 + (-0.81136441230773926) * gru_2_fwd_t3_h_15 + (-1.1102508306503296) * gru_2_fwd_t3_h_16 + (0.12592470645904541) * gru_2_fwd_t3_h_17 + (-0.10815896093845367) * gru_2_fwd_t3_h_18 + (-0.18353399634361267) * gru_2_fwd_t3_h_19 + (-0.0060652578249573708) * gru_2_fwd_t3_h_20 + (0.28519082069396973) * gru_2_fwd_t3_h_21 + (-0.28432619571685791) * gru_2_fwd_t3_h_22 + (0.74375808238983154) * gru_2_fwd_t3_h_23 + (0.13413126766681671) * gru_2_fwd_t3_h_24 + (-0.10465598106384277) * gru_2_fwd_t3_h_25 + (1.4642574787139893) * gru_2_fwd_t3_h_26 + (1.1443719863891602) * gru_2_fwd_t3_h_27 + (0.63237649202346802) * gru_2_fwd_t3_h_28 + (0.47616952657699585) * gru_2_fwd_t3_h_29 + (0.1388184130191803) * gru_2_fwd_t3_h_30 + (0.43742325901985168) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_0 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_0;
    // h=1
    gate_r = sigmoid((-0.076955623924732208) + (2.4431288242340088) * gru_1_out_t4_0 + (1.1316577196121216) * gru_1_out_t4_1 + (-0.54076719284057617) * gru_1_out_t4_2 + (0.025410259142518044) * gru_1_out_t4_3 + (0.22690004110336304) * gru_1_out_t4_4 + (-0.16546677052974701) * gru_1_out_t4_5 + (0.88440799713134766) * gru_1_out_t4_6 + (-0.73617559671401978) * gru_1_out_t4_7 + (-0.19487325847148895) * gru_1_out_t4_8 + (-0.17700362205505371) * gru_1_out_t4_9 + (1.3849403858184814) * gru_1_out_t4_10 + (-1.1591407060623169) * gru_1_out_t4_11 + (0.45289126038551331) * gru_1_out_t4_12 + (1.1546627283096313) * gru_1_out_t4_13 + (-0.61455452442169189) * gru_1_out_t4_14 + (-1.0931040048599243) * gru_1_out_t4_15 + (-0.97985923290252686) * gru_1_out_t4_16 + (0.21307899057865143) * gru_1_out_t4_17 + (0.388753741979599) * gru_1_out_t4_18 + (0.22562903165817261) * gru_1_out_t4_19 + (-0.36337554454803467) * gru_1_out_t4_20 + (-0.27227422595024109) * gru_1_out_t4_21 + (0.26810759305953979) * gru_1_out_t4_22 + (0.41299206018447876) * gru_1_out_t4_23 + (2.8235538005828857) * gru_1_out_t4_24 + (-0.089105606079101562) * gru_1_out_t4_25 + (-0.81910771131515503) * gru_1_out_t4_26 + (-1.4307278394699097) * gru_1_out_t4_27 + (-0.076145388185977936) * gru_1_out_t4_28 + (0.13243740797042847) * gru_1_out_t4_29 + (4.5168619155883789) * gru_1_out_t4_30 + (0.12253942340612411) * gru_1_out_t4_31 + (0.08037259429693222) * gru_1_out_t4_32 + (0.49392515420913696) * gru_1_out_t4_33 + (-0.61467605829238892) * gru_1_out_t4_34 + (-0.32944786548614502) * gru_1_out_t4_35 + (-0.30708473920822144) * gru_1_out_t4_36 + (-0.63777190446853638) * gru_1_out_t4_37 + (-0.53033339977264404) * gru_1_out_t4_38 + (-0.61023086309432983) * gru_1_out_t4_39 + (-0.31139817833900452) * gru_1_out_t4_40 + (1.0876935720443726) * gru_1_out_t4_41 + (-0.15650591254234314) * gru_1_out_t4_42 + (-1.5625373125076294) * gru_1_out_t4_43 + (-0.50046622753143311) * gru_1_out_t4_44 + (-0.38554257154464722) * gru_1_out_t4_45 + (-1.7963999509811401) * gru_1_out_t4_46 + (1.2825547456741333) * gru_1_out_t4_47 + (1.1039333343505859) * gru_1_out_t4_48 + (1.5370361804962158) * gru_1_out_t4_49 + (0.327146977186203) * gru_1_out_t4_50 + (-0.38325658440589905) * gru_1_out_t4_51 + (-1.0803104639053345) * gru_1_out_t4_52 + (-0.13954035937786102) * gru_1_out_t4_53 + (0.96088105440139771) * gru_1_out_t4_54 + (-0.1835133284330368) * gru_1_out_t4_55 + (-0.54965561628341675) * gru_1_out_t4_56 + (1.8490413427352905) * gru_1_out_t4_57 + (-0.31863704323768616) * gru_1_out_t4_58 + (-0.97742187976837158) * gru_1_out_t4_59 + (0.2103441059589386) * gru_1_out_t4_60 + (0.35383233428001404) * gru_1_out_t4_61 + (1.1381590366363525) * gru_1_out_t4_62 + (0.32660749554634094) * gru_1_out_t4_63 + (-1.3508759737014771) * gru_2_fwd_t3_h_0 + (-0.54256647825241089) * gru_2_fwd_t3_h_1 + (-0.43350794911384583) * gru_2_fwd_t3_h_2 + (-0.203192338347435) * gru_2_fwd_t3_h_3 + (-0.6945459246635437) * gru_2_fwd_t3_h_4 + (0.085429064929485321) * gru_2_fwd_t3_h_5 + (-0.57190471887588501) * gru_2_fwd_t3_h_6 + (1.4209951162338257) * gru_2_fwd_t3_h_7 + (0.019424460828304291) * gru_2_fwd_t3_h_8 + (-1.1876543760299683) * gru_2_fwd_t3_h_9 + (-0.42878162860870361) * gru_2_fwd_t3_h_10 + (-1.2442457675933838) * gru_2_fwd_t3_h_11 + (-1.3667647838592529) * gru_2_fwd_t3_h_12 + (2.5085694789886475) * gru_2_fwd_t3_h_13 + (0.29383769631385803) * gru_2_fwd_t3_h_14 + (0.5544167160987854) * gru_2_fwd_t3_h_15 + (1.2740185260772705) * gru_2_fwd_t3_h_16 + (-0.90434736013412476) * gru_2_fwd_t3_h_17 + (-0.013733631931245327) * gru_2_fwd_t3_h_18 + (-0.56985694169998169) * gru_2_fwd_t3_h_19 + (-1.2101106643676758) * gru_2_fwd_t3_h_20 + (0.032370839267969131) * gru_2_fwd_t3_h_21 + (-0.21734628081321716) * gru_2_fwd_t3_h_22 + (1.5154310464859009) * gru_2_fwd_t3_h_23 + (0.70385080575942993) * gru_2_fwd_t3_h_24 + (-0.13250283896923065) * gru_2_fwd_t3_h_25 + (0.20215073227882385) * gru_2_fwd_t3_h_26 + (-0.21269203722476959) * gru_2_fwd_t3_h_27 + (-0.7328794002532959) * gru_2_fwd_t3_h_28 + (-0.39950993657112122) * gru_2_fwd_t3_h_29 + (0.51388090848922729) * gru_2_fwd_t3_h_30 + (-0.30135920643806458) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.53590685129165649) + (0.14715632796287537) * gru_1_out_t4_0 + (0.21391016244888306) * gru_1_out_t4_1 + (0.77107900381088257) * gru_1_out_t4_2 + (0.73561185598373413) * gru_1_out_t4_3 + (0.10207085311412811) * gru_1_out_t4_4 + (0.83710801601409912) * gru_1_out_t4_5 + (0.74333930015563965) * gru_1_out_t4_6 + (-0.31950879096984863) * gru_1_out_t4_7 + (0.13774976134300232) * gru_1_out_t4_8 + (0.13335037231445312) * gru_1_out_t4_9 + (0.58584427833557129) * gru_1_out_t4_10 + (-0.021422304213047028) * gru_1_out_t4_11 + (0.35624438524246216) * gru_1_out_t4_12 + (0.076298832893371582) * gru_1_out_t4_13 + (-0.33925482630729675) * gru_1_out_t4_14 + (-0.850757896900177) * gru_1_out_t4_15 + (-0.14501842856407166) * gru_1_out_t4_16 + (0.44666123390197754) * gru_1_out_t4_17 + (-0.081198997795581818) * gru_1_out_t4_18 + (-0.88346284627914429) * gru_1_out_t4_19 + (0.69240283966064453) * gru_1_out_t4_20 + (0.40099161863327026) * gru_1_out_t4_21 + (0.18156024813652039) * gru_1_out_t4_22 + (0.54490387439727783) * gru_1_out_t4_23 + (-0.38224372267723083) * gru_1_out_t4_24 + (0.28607317805290222) * gru_1_out_t4_25 + (0.11676506698131561) * gru_1_out_t4_26 + (-0.26135024428367615) * gru_1_out_t4_27 + (0.2026161402463913) * gru_1_out_t4_28 + (-0.10886173695325851) * gru_1_out_t4_29 + (0.29166752099990845) * gru_1_out_t4_30 + (-0.31435507535934448) * gru_1_out_t4_31 + (0.69946563243865967) * gru_1_out_t4_32 + (-0.16277627646923065) * gru_1_out_t4_33 + (0.16130435466766357) * gru_1_out_t4_34 + (0.39183688163757324) * gru_1_out_t4_35 + (0.50352519750595093) * gru_1_out_t4_36 + (0.00019375012197997421) * gru_1_out_t4_37 + (0.26109817624092102) * gru_1_out_t4_38 + (-0.54404157400131226) * gru_1_out_t4_39 + (-0.28784483671188354) * gru_1_out_t4_40 + (0.09760892391204834) * gru_1_out_t4_41 + (-1.2587010860443115) * gru_1_out_t4_42 + (0.088212445378303528) * gru_1_out_t4_43 + (-0.20786267518997192) * gru_1_out_t4_44 + (-0.16868837177753448) * gru_1_out_t4_45 + (0.056641094386577606) * gru_1_out_t4_46 + (0.22310295701026917) * gru_1_out_t4_47 + (0.55202269554138184) * gru_1_out_t4_48 + (-0.50012212991714478) * gru_1_out_t4_49 + (0.40228304266929626) * gru_1_out_t4_50 + (-0.10257671028375626) * gru_1_out_t4_51 + (-1.2289341688156128) * gru_1_out_t4_52 + (-0.34043803811073303) * gru_1_out_t4_53 + (-0.40920534729957581) * gru_1_out_t4_54 + (0.35138455033302307) * gru_1_out_t4_55 + (-0.34417188167572021) * gru_1_out_t4_56 + (-0.31853753328323364) * gru_1_out_t4_57 + (-0.85867571830749512) * gru_1_out_t4_58 + (-0.058695182204246521) * gru_1_out_t4_59 + (-0.42712351679801941) * gru_1_out_t4_60 + (0.20578253269195557) * gru_1_out_t4_61 + (-1.0160008668899536) * gru_1_out_t4_62 + (0.61632812023162842) * gru_1_out_t4_63 + (-0.45612519979476929) * gru_2_fwd_t3_h_0 + (-0.61595404148101807) * gru_2_fwd_t3_h_1 + (0.1236191987991333) * gru_2_fwd_t3_h_2 + (-0.62614703178405762) * gru_2_fwd_t3_h_3 + (-0.319009929895401) * gru_2_fwd_t3_h_4 + (0.60560613870620728) * gru_2_fwd_t3_h_5 + (0.24406160414218903) * gru_2_fwd_t3_h_6 + (-0.41779324412345886) * gru_2_fwd_t3_h_7 + (-0.039914235472679138) * gru_2_fwd_t3_h_8 + (-0.23962678015232086) * gru_2_fwd_t3_h_9 + (-0.68237024545669556) * gru_2_fwd_t3_h_10 + (0.98845410346984863) * gru_2_fwd_t3_h_11 + (0.99934405088424683) * gru_2_fwd_t3_h_12 + (-0.18902616202831268) * gru_2_fwd_t3_h_13 + (0.29518115520477295) * gru_2_fwd_t3_h_14 + (-0.6039959192276001) * gru_2_fwd_t3_h_15 + (0.87571382522583008) * gru_2_fwd_t3_h_16 + (0.20610842108726501) * gru_2_fwd_t3_h_17 + (-0.47920519113540649) * gru_2_fwd_t3_h_18 + (0.089688725769519806) * gru_2_fwd_t3_h_19 + (0.10564780235290527) * gru_2_fwd_t3_h_20 + (0.0438254214823246) * gru_2_fwd_t3_h_21 + (0.17404094338417053) * gru_2_fwd_t3_h_22 + (-0.88971060514450073) * gru_2_fwd_t3_h_23 + (-0.12111139297485352) * gru_2_fwd_t3_h_24 + (-0.85890656709671021) * gru_2_fwd_t3_h_25 + (0.31811162829399109) * gru_2_fwd_t3_h_26 + (0.23936004936695099) * gru_2_fwd_t3_h_27 + (0.3705776035785675) * gru_2_fwd_t3_h_28 + (-0.31276610493659973) * gru_2_fwd_t3_h_29 + (-0.24131686985492706) * gru_2_fwd_t3_h_30 + (-0.3149702250957489) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.011742221191525459) + (-0.14176911115646362) * gru_1_out_t4_0 + (-0.32628181576728821) * gru_1_out_t4_1 + (-1.2002532482147217) * gru_1_out_t4_2 + (-0.21515153348445892) * gru_1_out_t4_3 + (-0.57778006792068481) * gru_1_out_t4_4 + (-0.96125108003616333) * gru_1_out_t4_5 + (0.835152268409729) * gru_1_out_t4_6 + (-0.047028686851263046) * gru_1_out_t4_7 + (-0.010958243161439896) * gru_1_out_t4_8 + (0.20726145803928375) * gru_1_out_t4_9 + (0.75067853927612305) * gru_1_out_t4_10 + (1.3154606819152832) * gru_1_out_t4_11 + (0.20858995616436005) * gru_1_out_t4_12 + (0.12168494611978531) * gru_1_out_t4_13 + (0.30838680267333984) * gru_1_out_t4_14 + (0.19065289199352264) * gru_1_out_t4_15 + (-0.29425638914108276) * gru_1_out_t4_16 + (-0.27644914388656616) * gru_1_out_t4_17 + (-0.42754250764846802) * gru_1_out_t4_18 + (0.46680092811584473) * gru_1_out_t4_19 + (-1.0461740493774414) * gru_1_out_t4_20 + (0.44357407093048096) * gru_1_out_t4_21 + (-0.089895457029342651) * gru_1_out_t4_22 + (-0.25110772252082825) * gru_1_out_t4_23 + (-0.14323833584785461) * gru_1_out_t4_24 + (-0.48257750272750854) * gru_1_out_t4_25 + (0.021155187860131264) * gru_1_out_t4_26 + (0.96519899368286133) * gru_1_out_t4_27 + (-1.2312343120574951) * gru_1_out_t4_28 + (0.60398197174072266) * gru_1_out_t4_29 + (-0.57691210508346558) * gru_1_out_t4_30 + (0.44014143943786621) * gru_1_out_t4_31 + (-0.14584413170814514) * gru_1_out_t4_32 + (-0.046179123222827911) * gru_1_out_t4_33 + (-0.21739661693572998) * gru_1_out_t4_34 + (-0.23909564316272736) * gru_1_out_t4_35 + (-0.57102829217910767) * gru_1_out_t4_36 + (0.20808514952659607) * gru_1_out_t4_37 + (0.22012417018413544) * gru_1_out_t4_38 + (0.21457329392433167) * gru_1_out_t4_39 + (0.48854649066925049) * gru_1_out_t4_40 + (0.12744259834289551) * gru_1_out_t4_41 + (-0.66340410709381104) * gru_1_out_t4_42 + (-0.45473042130470276) * gru_1_out_t4_43 + (-0.06278594583272934) * gru_1_out_t4_44 + (-0.35481023788452148) * gru_1_out_t4_45 + (0.25191023945808411) * gru_1_out_t4_46 + (-0.68430542945861816) * gru_1_out_t4_47 + (-0.021750569343566895) * gru_1_out_t4_48 + (0.40702882409095764) * gru_1_out_t4_49 + (0.087905839085578918) * gru_1_out_t4_50 + (0.70841377973556519) * gru_1_out_t4_51 + (0.416145920753479) * gru_1_out_t4_52 + (-0.32194927334785461) * gru_1_out_t4_53 + (0.15821196138858795) * gru_1_out_t4_54 + (0.30502107739448547) * gru_1_out_t4_55 + (-0.38511806726455688) * gru_1_out_t4_56 + (0.82361406087875366) * gru_1_out_t4_57 + (-0.086883880198001862) * gru_1_out_t4_58 + (-0.0837663933634758) * gru_1_out_t4_59 + (-0.63529461622238159) * gru_1_out_t4_60 + (0.16620606184005737) * gru_1_out_t4_61 + (0.48974329233169556) * gru_1_out_t4_62 + (-0.95967322587966919) * gru_1_out_t4_63 + gate_r * ((-0.07211950421333313) + (1.2158125638961792) * gru_2_fwd_t3_h_0 + (-0.38560789823532104) * gru_2_fwd_t3_h_1 + (-0.025172006338834763) * gru_2_fwd_t3_h_2 + (-0.19302435219287872) * gru_2_fwd_t3_h_3 + (0.49191144108772278) * gru_2_fwd_t3_h_4 + (0.22902141511440277) * gru_2_fwd_t3_h_5 + (0.1293797641992569) * gru_2_fwd_t3_h_6 + (0.78500741720199585) * gru_2_fwd_t3_h_7 + (-0.12199701368808746) * gru_2_fwd_t3_h_8 + (0.79914337396621704) * gru_2_fwd_t3_h_9 + (-0.28648126125335693) * gru_2_fwd_t3_h_10 + (-0.14169812202453613) * gru_2_fwd_t3_h_11 + (-0.6954721212387085) * gru_2_fwd_t3_h_12 + (1.7411096096038818) * gru_2_fwd_t3_h_13 + (-0.82185131311416626) * gru_2_fwd_t3_h_14 + (-0.2068319171667099) * gru_2_fwd_t3_h_15 + (-0.60462749004364014) * gru_2_fwd_t3_h_16 + (-0.011700217612087727) * gru_2_fwd_t3_h_17 + (0.42085516452789307) * gru_2_fwd_t3_h_18 + (-0.67514777183532715) * gru_2_fwd_t3_h_19 + (0.15158013999462128) * gru_2_fwd_t3_h_20 + (0.079307414591312408) * gru_2_fwd_t3_h_21 + (0.49599850177764893) * gru_2_fwd_t3_h_22 + (-0.31014043092727661) * gru_2_fwd_t3_h_23 + (-0.28365045785903931) * gru_2_fwd_t3_h_24 + (-1.1350195407867432) * gru_2_fwd_t3_h_25 + (0.68674039840698242) * gru_2_fwd_t3_h_26 + (-0.74635839462280273) * gru_2_fwd_t3_h_27 + (0.20010283589363098) * gru_2_fwd_t3_h_28 + (-0.35233056545257568) * gru_2_fwd_t3_h_29 + (-0.16155551373958588) * gru_2_fwd_t3_h_30 + (-0.12580166757106781) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_1 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_1;
    // h=2
    gate_r = sigmoid((0.50211858749389648) + (0.03546181321144104) * gru_1_out_t4_0 + (0.62873119115829468) * gru_1_out_t4_1 + (-1.0873353481292725) * gru_1_out_t4_2 + (0.63914400339126587) * gru_1_out_t4_3 + (-0.93876582384109497) * gru_1_out_t4_4 + (-0.34794798493385315) * gru_1_out_t4_5 + (0.66910278797149658) * gru_1_out_t4_6 + (0.039201650768518448) * gru_1_out_t4_7 + (0.15264949202537537) * gru_1_out_t4_8 + (0.29613927006721497) * gru_1_out_t4_9 + (0.10930211097002029) * gru_1_out_t4_10 + (0.44008582830429077) * gru_1_out_t4_11 + (0.35598498582839966) * gru_1_out_t4_12 + (1.1214288473129272) * gru_1_out_t4_13 + (1.2225011587142944) * gru_1_out_t4_14 + (-0.89958316087722778) * gru_1_out_t4_15 + (-0.072695337235927582) * gru_1_out_t4_16 + (-0.12238204479217529) * gru_1_out_t4_17 + (-1.4389032125473022) * gru_1_out_t4_18 + (-0.1536562442779541) * gru_1_out_t4_19 + (-0.09212668240070343) * gru_1_out_t4_20 + (0.64947199821472168) * gru_1_out_t4_21 + (0.76614964008331299) * gru_1_out_t4_22 + (-0.62288469076156616) * gru_1_out_t4_23 + (-4.6255497932434082) * gru_1_out_t4_24 + (0.52996534109115601) * gru_1_out_t4_25 + (2.5337831974029541) * gru_1_out_t4_26 + (-0.21127556264400482) * gru_1_out_t4_27 + (0.37190786004066467) * gru_1_out_t4_28 + (0.66079443693161011) * gru_1_out_t4_29 + (-0.74088037014007568) * gru_1_out_t4_30 + (0.023888815194368362) * gru_1_out_t4_31 + (-0.21493926644325256) * gru_1_out_t4_32 + (-0.101666159927845) * gru_1_out_t4_33 + (-0.40452995896339417) * gru_1_out_t4_34 + (1.1669552326202393) * gru_1_out_t4_35 + (-0.42686870694160461) * gru_1_out_t4_36 + (-0.044576909393072128) * gru_1_out_t4_37 + (-0.039767984300851822) * gru_1_out_t4_38 + (0.44087648391723633) * gru_1_out_t4_39 + (-1.2241232395172119) * gru_1_out_t4_40 + (0.69230908155441284) * gru_1_out_t4_41 + (-0.24427288770675659) * gru_1_out_t4_42 + (-1.9307873249053955) * gru_1_out_t4_43 + (0.33678427338600159) * gru_1_out_t4_44 + (1.5299886465072632) * gru_1_out_t4_45 + (0.59511977434158325) * gru_1_out_t4_46 + (0.68475878238677979) * gru_1_out_t4_47 + (-0.41329070925712585) * gru_1_out_t4_48 + (-0.32078123092651367) * gru_1_out_t4_49 + (-3.2815837860107422) * gru_1_out_t4_50 + (0.85719376802444458) * gru_1_out_t4_51 + (-0.53820544481277466) * gru_1_out_t4_52 + (0.80256432294845581) * gru_1_out_t4_53 + (0.58206659555435181) * gru_1_out_t4_54 + (0.57309693098068237) * gru_1_out_t4_55 + (-0.67719942331314087) * gru_1_out_t4_56 + (-0.78663325309753418) * gru_1_out_t4_57 + (-0.5363471508026123) * gru_1_out_t4_58 + (-0.54640650749206543) * gru_1_out_t4_59 + (-0.90980690717697144) * gru_1_out_t4_60 + (-0.76898908615112305) * gru_1_out_t4_61 + (-2.3156499862670898) * gru_1_out_t4_62 + (-0.86252009868621826) * gru_1_out_t4_63 + (-0.32576736807823181) * gru_2_fwd_t3_h_0 + (0.089321121573448181) * gru_2_fwd_t3_h_1 + (0.1394800990819931) * gru_2_fwd_t3_h_2 + (-0.045835129916667938) * gru_2_fwd_t3_h_3 + (-0.4358803927898407) * gru_2_fwd_t3_h_4 + (0.20511496067047119) * gru_2_fwd_t3_h_5 + (-0.82479459047317505) * gru_2_fwd_t3_h_6 + (1.3063778877258301) * gru_2_fwd_t3_h_7 + (0.20850615203380585) * gru_2_fwd_t3_h_8 + (0.16005788743495941) * gru_2_fwd_t3_h_9 + (0.3215084969997406) * gru_2_fwd_t3_h_10 + (0.92962056398391724) * gru_2_fwd_t3_h_11 + (-0.10181120038032532) * gru_2_fwd_t3_h_12 + (0.026772355660796165) * gru_2_fwd_t3_h_13 + (0.74447154998779297) * gru_2_fwd_t3_h_14 + (0.12025598436594009) * gru_2_fwd_t3_h_15 + (0.7205769419670105) * gru_2_fwd_t3_h_16 + (-0.13317883014678955) * gru_2_fwd_t3_h_17 + (0.22388005256652832) * gru_2_fwd_t3_h_18 + (-0.13946898281574249) * gru_2_fwd_t3_h_19 + (-0.22497989237308502) * gru_2_fwd_t3_h_20 + (0.96134459972381592) * gru_2_fwd_t3_h_21 + (0.11944910883903503) * gru_2_fwd_t3_h_22 + (0.046886265277862549) * gru_2_fwd_t3_h_23 + (-0.073766112327575684) * gru_2_fwd_t3_h_24 + (0.371634840965271) * gru_2_fwd_t3_h_25 + (0.10542351752519608) * gru_2_fwd_t3_h_26 + (0.6023288369178772) * gru_2_fwd_t3_h_27 + (-0.45125406980514526) * gru_2_fwd_t3_h_28 + (0.24270361661911011) * gru_2_fwd_t3_h_29 + (0.57533389329910278) * gru_2_fwd_t3_h_30 + (-0.41637510061264038) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.68357980251312256) + (0.12803052365779877) * gru_1_out_t4_0 + (0.40708094835281372) * gru_1_out_t4_1 + (0.85545206069946289) * gru_1_out_t4_2 + (-1.2080405950546265) * gru_1_out_t4_3 + (0.96959924697875977) * gru_1_out_t4_4 + (-0.32866448163986206) * gru_1_out_t4_5 + (-0.23365324735641479) * gru_1_out_t4_6 + (0.13662146031856537) * gru_1_out_t4_7 + (-0.31608948111534119) * gru_1_out_t4_8 + (0.82108980417251587) * gru_1_out_t4_9 + (0.42730045318603516) * gru_1_out_t4_10 + (0.16828462481498718) * gru_1_out_t4_11 + (-0.21607854962348938) * gru_1_out_t4_12 + (0.8896600604057312) * gru_1_out_t4_13 + (-0.1087818443775177) * gru_1_out_t4_14 + (0.090991735458374023) * gru_1_out_t4_15 + (0.57311904430389404) * gru_1_out_t4_16 + (0.35667991638183594) * gru_1_out_t4_17 + (-0.016142876818776131) * gru_1_out_t4_18 + (0.62885987758636475) * gru_1_out_t4_19 + (0.18106868863105774) * gru_1_out_t4_20 + (0.83561939001083374) * gru_1_out_t4_21 + (0.55257529020309448) * gru_1_out_t4_22 + (-0.83427983522415161) * gru_1_out_t4_23 + (0.31884363293647766) * gru_1_out_t4_24 + (-0.14832493662834167) * gru_1_out_t4_25 + (-0.7495121955871582) * gru_1_out_t4_26 + (-0.93943387269973755) * gru_1_out_t4_27 + (-1.8790460824966431) * gru_1_out_t4_28 + (0.52488404512405396) * gru_1_out_t4_29 + (0.15908949077129364) * gru_1_out_t4_30 + (-0.22081409394741058) * gru_1_out_t4_31 + (0.1776355654001236) * gru_1_out_t4_32 + (0.058606185019016266) * gru_1_out_t4_33 + (0.3690791130065918) * gru_1_out_t4_34 + (0.67146778106689453) * gru_1_out_t4_35 + (0.17916281521320343) * gru_1_out_t4_36 + (1.0813432931900024) * gru_1_out_t4_37 + (0.40573602914810181) * gru_1_out_t4_38 + (0.36104458570480347) * gru_1_out_t4_39 + (0.093546964228153229) * gru_1_out_t4_40 + (0.28564289212226868) * gru_1_out_t4_41 + (0.45597571134567261) * gru_1_out_t4_42 + (-1.5643079280853271) * gru_1_out_t4_43 + (-0.94158744812011719) * gru_1_out_t4_44 + (0.41168996691703796) * gru_1_out_t4_45 + (-0.26828816533088684) * gru_1_out_t4_46 + (0.77027595043182373) * gru_1_out_t4_47 + (-1.1340701580047607) * gru_1_out_t4_48 + (0.12209813296794891) * gru_1_out_t4_49 + (-2.944129467010498) * gru_1_out_t4_50 + (0.077653594315052032) * gru_1_out_t4_51 + (-0.62413793802261353) * gru_1_out_t4_52 + (-0.036159172654151917) * gru_1_out_t4_53 + (0.75142937898635864) * gru_1_out_t4_54 + (0.84246450662612915) * gru_1_out_t4_55 + (1.1334981918334961) * gru_1_out_t4_56 + (1.1247165203094482) * gru_1_out_t4_57 + (-0.35293760895729065) * gru_1_out_t4_58 + (1.8673948049545288) * gru_1_out_t4_59 + (-1.2065820693969727) * gru_1_out_t4_60 + (-1.0828073024749756) * gru_1_out_t4_61 + (0.077044427394866943) * gru_1_out_t4_62 + (0.69414854049682617) * gru_1_out_t4_63 + (0.25001063942909241) * gru_2_fwd_t3_h_0 + (0.18169330060482025) * gru_2_fwd_t3_h_1 + (1.0296826362609863) * gru_2_fwd_t3_h_2 + (-0.10078103095293045) * gru_2_fwd_t3_h_3 + (0.03591383621096611) * gru_2_fwd_t3_h_4 + (0.27101415395736694) * gru_2_fwd_t3_h_5 + (-1.0900731086730957) * gru_2_fwd_t3_h_6 + (-0.61273229122161865) * gru_2_fwd_t3_h_7 + (-0.30283251404762268) * gru_2_fwd_t3_h_8 + (-1.0590896606445312) * gru_2_fwd_t3_h_9 + (-1.0801339149475098) * gru_2_fwd_t3_h_10 + (0.038359299302101135) * gru_2_fwd_t3_h_11 + (-0.29144105315208435) * gru_2_fwd_t3_h_12 + (-1.6795814037322998) * gru_2_fwd_t3_h_13 + (-0.027842726558446884) * gru_2_fwd_t3_h_14 + (0.88105422258377075) * gru_2_fwd_t3_h_15 + (-0.47591060400009155) * gru_2_fwd_t3_h_16 + (-0.80419111251831055) * gru_2_fwd_t3_h_17 + (-0.053347431123256683) * gru_2_fwd_t3_h_18 + (0.18758849799633026) * gru_2_fwd_t3_h_19 + (-0.39571216702461243) * gru_2_fwd_t3_h_20 + (0.013984076678752899) * gru_2_fwd_t3_h_21 + (1.1660065650939941) * gru_2_fwd_t3_h_22 + (-0.55558276176452637) * gru_2_fwd_t3_h_23 + (-0.76818519830703735) * gru_2_fwd_t3_h_24 + (0.95321542024612427) * gru_2_fwd_t3_h_25 + (-1.2576459646224976) * gru_2_fwd_t3_h_26 + (-0.1983659416437149) * gru_2_fwd_t3_h_27 + (-0.59175437688827515) * gru_2_fwd_t3_h_28 + (-0.82502609491348267) * gru_2_fwd_t3_h_29 + (-1.1409913301467896) * gru_2_fwd_t3_h_30 + (-0.28919270634651184) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.28757476806640625) + (0.71206510066986084) * gru_1_out_t4_0 + (0.4673173725605011) * gru_1_out_t4_1 + (1.4996812343597412) * gru_1_out_t4_2 + (-0.37790834903717041) * gru_1_out_t4_3 + (-0.53326547145843506) * gru_1_out_t4_4 + (-1.3791050910949707) * gru_1_out_t4_5 + (-0.47763282060623169) * gru_1_out_t4_6 + (0.02427389845252037) * gru_1_out_t4_7 + (-0.77570384740829468) * gru_1_out_t4_8 + (-0.84844398498535156) * gru_1_out_t4_9 + (0.45537346601486206) * gru_1_out_t4_10 + (-0.29301983118057251) * gru_1_out_t4_11 + (-0.64142394065856934) * gru_1_out_t4_12 + (-1.2632129192352295) * gru_1_out_t4_13 + (-0.016080928966403008) * gru_1_out_t4_14 + (-0.66520142555236816) * gru_1_out_t4_15 + (-0.063035875558853149) * gru_1_out_t4_16 + (-0.26991292834281921) * gru_1_out_t4_17 + (0.32602483034133911) * gru_1_out_t4_18 + (0.10982970893383026) * gru_1_out_t4_19 + (-0.081058278679847717) * gru_1_out_t4_20 + (1.039059042930603) * gru_1_out_t4_21 + (0.72561758756637573) * gru_1_out_t4_22 + (-0.35857740044593811) * gru_1_out_t4_23 + (-4.0297713279724121) * gru_1_out_t4_24 + (1.114376425743103) * gru_1_out_t4_25 + (0.36551475524902344) * gru_1_out_t4_26 + (0.21977202594280243) * gru_1_out_t4_27 + (-1.2989488840103149) * gru_1_out_t4_28 + (0.59169560670852661) * gru_1_out_t4_29 + (1.5650513172149658) * gru_1_out_t4_30 + (0.024198234081268311) * gru_1_out_t4_31 + (0.61719894409179688) * gru_1_out_t4_32 + (-0.10701681673526764) * gru_1_out_t4_33 + (0.6430472731590271) * gru_1_out_t4_34 + (0.19275094568729401) * gru_1_out_t4_35 + (-0.23081982135772705) * gru_1_out_t4_36 + (0.0073824040591716766) * gru_1_out_t4_37 + (-0.087166845798492432) * gru_1_out_t4_38 + (-0.037914294749498367) * gru_1_out_t4_39 + (-0.91369789838790894) * gru_1_out_t4_40 + (-0.065582066774368286) * gru_1_out_t4_41 + (0.59199666976928711) * gru_1_out_t4_42 + (-0.93468165397644043) * gru_1_out_t4_43 + (-0.35326683521270752) * gru_1_out_t4_44 + (0.23191042244434357) * gru_1_out_t4_45 + (-0.33294910192489624) * gru_1_out_t4_46 + (0.8554108738899231) * gru_1_out_t4_47 + (-0.556385338306427) * gru_1_out_t4_48 + (-0.69082391262054443) * gru_1_out_t4_49 + (-2.0151240825653076) * gru_1_out_t4_50 + (-0.92921102046966553) * gru_1_out_t4_51 + (0.28535893559455872) * gru_1_out_t4_52 + (0.74024069309234619) * gru_1_out_t4_53 + (0.097009539604187012) * gru_1_out_t4_54 + (0.1110449805855751) * gru_1_out_t4_55 + (0.028389010578393936) * gru_1_out_t4_56 + (0.73824822902679443) * gru_1_out_t4_57 + (0.32105138897895813) * gru_1_out_t4_58 + (0.61800509691238403) * gru_1_out_t4_59 + (-0.45711445808410645) * gru_1_out_t4_60 + (-0.79884850978851318) * gru_1_out_t4_61 + (0.34846755862236023) * gru_1_out_t4_62 + (-0.24910500645637512) * gru_1_out_t4_63 + gate_r * ((-1.3853403329849243) + (0.1449582427740097) * gru_2_fwd_t3_h_0 + (0.12057004868984222) * gru_2_fwd_t3_h_1 + (0.037853624671697617) * gru_2_fwd_t3_h_2 + (-0.27401146292686462) * gru_2_fwd_t3_h_3 + (0.64049631357192993) * gru_2_fwd_t3_h_4 + (-0.065479449927806854) * gru_2_fwd_t3_h_5 + (0.078844629228115082) * gru_2_fwd_t3_h_6 + (-0.020910657942295074) * gru_2_fwd_t3_h_7 + (-1.0093957185745239) * gru_2_fwd_t3_h_8 + (-0.025831965729594231) * gru_2_fwd_t3_h_9 + (0.55257034301757812) * gru_2_fwd_t3_h_10 + (0.83090007305145264) * gru_2_fwd_t3_h_11 + (-1.3455033302307129) * gru_2_fwd_t3_h_12 + (1.0527209043502808) * gru_2_fwd_t3_h_13 + (2.7315943241119385) * gru_2_fwd_t3_h_14 + (0.38420569896697998) * gru_2_fwd_t3_h_15 + (1.4012012481689453) * gru_2_fwd_t3_h_16 + (0.25963407754898071) * gru_2_fwd_t3_h_17 + (-1.4242368936538696) * gru_2_fwd_t3_h_18 + (0.77501517534255981) * gru_2_fwd_t3_h_19 + (-0.73244589567184448) * gru_2_fwd_t3_h_20 + (0.51052916049957275) * gru_2_fwd_t3_h_21 + (-0.24775084853172302) * gru_2_fwd_t3_h_22 + (0.12070351094007492) * gru_2_fwd_t3_h_23 + (0.0041561871767044067) * gru_2_fwd_t3_h_24 + (0.28257870674133301) * gru_2_fwd_t3_h_25 + (-1.1113215684890747) * gru_2_fwd_t3_h_26 + (0.20185104012489319) * gru_2_fwd_t3_h_27 + (-1.5230107307434082) * gru_2_fwd_t3_h_28 + (1.5152634382247925) * gru_2_fwd_t3_h_29 + (0.40246233344078064) * gru_2_fwd_t3_h_30 + (-0.88555550575256348) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_2 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_2;
    // h=3
    gate_r = sigmoid((0.41261222958564758) + (0.72942841053009033) * gru_1_out_t4_0 + (0.38550209999084473) * gru_1_out_t4_1 + (-0.63798558712005615) * gru_1_out_t4_2 + (-0.14824342727661133) * gru_1_out_t4_3 + (0.84214228391647339) * gru_1_out_t4_4 + (0.1656046062707901) * gru_1_out_t4_5 + (1.4234706163406372) * gru_1_out_t4_6 + (0.81613779067993164) * gru_1_out_t4_7 + (-0.97017115354537964) * gru_1_out_t4_8 + (0.6292722225189209) * gru_1_out_t4_9 + (0.52161121368408203) * gru_1_out_t4_10 + (0.22383072972297668) * gru_1_out_t4_11 + (-0.11007523536682129) * gru_1_out_t4_12 + (-0.32908898591995239) * gru_1_out_t4_13 + (1.3908857107162476) * gru_1_out_t4_14 + (-0.024728396907448769) * gru_1_out_t4_15 + (-0.79281550645828247) * gru_1_out_t4_16 + (-0.56877726316452026) * gru_1_out_t4_17 + (-1.6753993034362793) * gru_1_out_t4_18 + (-0.84166741371154785) * gru_1_out_t4_19 + (0.024605683982372284) * gru_1_out_t4_20 + (-0.95776212215423584) * gru_1_out_t4_21 + (-2.7483136653900146) * gru_1_out_t4_22 + (1.9871777296066284) * gru_1_out_t4_23 + (-2.3792378902435303) * gru_1_out_t4_24 + (0.1534494012594223) * gru_1_out_t4_25 + (-0.16596490144729614) * gru_1_out_t4_26 + (-0.77572166919708252) * gru_1_out_t4_27 + (-1.1204510927200317) * gru_1_out_t4_28 + (-0.44777011871337891) * gru_1_out_t4_29 + (2.7567574977874756) * gru_1_out_t4_30 + (-0.11186274886131287) * gru_1_out_t4_31 + (-0.46719008684158325) * gru_1_out_t4_32 + (-0.71171694993972778) * gru_1_out_t4_33 + (0.71587181091308594) * gru_1_out_t4_34 + (-0.40979489684104919) * gru_1_out_t4_35 + (-0.52391070127487183) * gru_1_out_t4_36 + (-1.7500942945480347) * gru_1_out_t4_37 + (-0.53590065240859985) * gru_1_out_t4_38 + (-0.94653069972991943) * gru_1_out_t4_39 + (-1.6560014486312866) * gru_1_out_t4_40 + (-1.602800726890564) * gru_1_out_t4_41 + (0.36195147037506104) * gru_1_out_t4_42 + (-0.94195222854614258) * gru_1_out_t4_43 + (0.24628740549087524) * gru_1_out_t4_44 + (0.099690847098827362) * gru_1_out_t4_45 + (0.78483396768569946) * gru_1_out_t4_46 + (0.33336693048477173) * gru_1_out_t4_47 + (-1.6328805685043335) * gru_1_out_t4_48 + (-0.11385563015937805) * gru_1_out_t4_49 + (-0.24276247620582581) * gru_1_out_t4_50 + (0.91271400451660156) * gru_1_out_t4_51 + (0.79640316963195801) * gru_1_out_t4_52 + (0.58678543567657471) * gru_1_out_t4_53 + (0.86790448427200317) * gru_1_out_t4_54 + (-0.4847625195980072) * gru_1_out_t4_55 + (-0.073861971497535706) * gru_1_out_t4_56 + (-0.21071159839630127) * gru_1_out_t4_57 + (0.79096812009811401) * gru_1_out_t4_58 + (-0.60564130544662476) * gru_1_out_t4_59 + (0.93330693244934082) * gru_1_out_t4_60 + (1.2217531204223633) * gru_1_out_t4_61 + (0.085313372313976288) * gru_1_out_t4_62 + (-0.27823451161384583) * gru_1_out_t4_63 + (0.9672197699546814) * gru_2_fwd_t3_h_0 + (-0.32342821359634399) * gru_2_fwd_t3_h_1 + (1.145038366317749) * gru_2_fwd_t3_h_2 + (-0.24374072253704071) * gru_2_fwd_t3_h_3 + (-0.78459775447845459) * gru_2_fwd_t3_h_4 + (0.81713712215423584) * gru_2_fwd_t3_h_5 + (0.75967931747436523) * gru_2_fwd_t3_h_6 + (-0.36437574028968811) * gru_2_fwd_t3_h_7 + (0.40257319808006287) * gru_2_fwd_t3_h_8 + (1.5965967178344727) * gru_2_fwd_t3_h_9 + (0.05847601592540741) * gru_2_fwd_t3_h_10 + (-1.1759558916091919) * gru_2_fwd_t3_h_11 + (-1.8659487962722778) * gru_2_fwd_t3_h_12 + (6.0781865119934082) * gru_2_fwd_t3_h_13 + (1.5211633443832397) * gru_2_fwd_t3_h_14 + (-0.32064956426620483) * gru_2_fwd_t3_h_15 + (-0.3402387797832489) * gru_2_fwd_t3_h_16 + (-0.20665746927261353) * gru_2_fwd_t3_h_17 + (-0.67100042104721069) * gru_2_fwd_t3_h_18 + (0.038846399635076523) * gru_2_fwd_t3_h_19 + (1.3473756313323975) * gru_2_fwd_t3_h_20 + (-1.4460225105285645) * gru_2_fwd_t3_h_21 + (-0.19600506126880646) * gru_2_fwd_t3_h_22 + (0.47635692358016968) * gru_2_fwd_t3_h_23 + (0.99520933628082275) * gru_2_fwd_t3_h_24 + (-0.15001915395259857) * gru_2_fwd_t3_h_25 + (0.85994291305541992) * gru_2_fwd_t3_h_26 + (0.4493861198425293) * gru_2_fwd_t3_h_27 + (-0.084266006946563721) * gru_2_fwd_t3_h_28 + (0.07887239009141922) * gru_2_fwd_t3_h_29 + (-0.89524686336517334) * gru_2_fwd_t3_h_30 + (0.31747564673423767) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((0.10861821472644806) + (-0.072362400591373444) * gru_1_out_t4_0 + (-0.14582943916320801) * gru_1_out_t4_1 + (-0.22234088182449341) * gru_1_out_t4_2 + (0.52766579389572144) * gru_1_out_t4_3 + (-0.29092076420783997) * gru_1_out_t4_4 + (0.22481533885002136) * gru_1_out_t4_5 + (0.18621611595153809) * gru_1_out_t4_6 + (-0.18299438059329987) * gru_1_out_t4_7 + (0.47815492749214172) * gru_1_out_t4_8 + (0.008816177025437355) * gru_1_out_t4_9 + (0.28043878078460693) * gru_1_out_t4_10 + (0.46134102344512939) * gru_1_out_t4_11 + (0.27801001071929932) * gru_1_out_t4_12 + (0.45674625039100647) * gru_1_out_t4_13 + (0.17261607944965363) * gru_1_out_t4_14 + (0.31748270988464355) * gru_1_out_t4_15 + (0.56196624040603638) * gru_1_out_t4_16 + (0.11457680910825729) * gru_1_out_t4_17 + (-0.12096874415874481) * gru_1_out_t4_18 + (-0.38423669338226318) * gru_1_out_t4_19 + (0.26074352860450745) * gru_1_out_t4_20 + (0.27436098456382751) * gru_1_out_t4_21 + (0.38730975985527039) * gru_1_out_t4_22 + (-0.31610646843910217) * gru_1_out_t4_23 + (-0.1670653223991394) * gru_1_out_t4_24 + (0.28659391403198242) * gru_1_out_t4_25 + (0.31898173689842224) * gru_1_out_t4_26 + (0.29817718267440796) * gru_1_out_t4_27 + (0.13456575572490692) * gru_1_out_t4_28 + (-0.040615741163492203) * gru_1_out_t4_29 + (-0.080182239413261414) * gru_1_out_t4_30 + (-0.35858172178268433) * gru_1_out_t4_31 + (-0.25488370656967163) * gru_1_out_t4_32 + (-0.24240991473197937) * gru_1_out_t4_33 + (0.12383075803518295) * gru_1_out_t4_34 + (-0.071949094533920288) * gru_1_out_t4_35 + (0.12261031568050385) * gru_1_out_t4_36 + (-0.66831469535827637) * gru_1_out_t4_37 + (0.13482841849327087) * gru_1_out_t4_38 + (-0.13715457916259766) * gru_1_out_t4_39 + (-0.044348180294036865) * gru_1_out_t4_40 + (0.029283713549375534) * gru_1_out_t4_41 + (0.061948411166667938) * gru_1_out_t4_42 + (-0.067897208034992218) * gru_1_out_t4_43 + (0.44317933917045593) * gru_1_out_t4_44 + (0.11477281898260117) * gru_1_out_t4_45 + (0.016164485365152359) * gru_1_out_t4_46 + (-0.083964817225933075) * gru_1_out_t4_47 + (-0.039537832140922546) * gru_1_out_t4_48 + (-0.6622546911239624) * gru_1_out_t4_49 + (-0.0093990787863731384) * gru_1_out_t4_50 + (-0.013591255992650986) * gru_1_out_t4_51 + (-0.39146813750267029) * gru_1_out_t4_52 + (0.045659981667995453) * gru_1_out_t4_53 + (0.035790111869573593) * gru_1_out_t4_54 + (0.36386647820472717) * gru_1_out_t4_55 + (0.040862035006284714) * gru_1_out_t4_56 + (0.018575785681605339) * gru_1_out_t4_57 + (-0.011885021813213825) * gru_1_out_t4_58 + (-0.066452346742153168) * gru_1_out_t4_59 + (-0.1718003898859024) * gru_1_out_t4_60 + (0.049989845603704453) * gru_1_out_t4_61 + (0.06366875022649765) * gru_1_out_t4_62 + (0.05543908104300499) * gru_1_out_t4_63 + (-0.027348259463906288) * gru_2_fwd_t3_h_0 + (0.015383780002593994) * gru_2_fwd_t3_h_1 + (-0.083505138754844666) * gru_2_fwd_t3_h_2 + (-0.62696361541748047) * gru_2_fwd_t3_h_3 + (-0.0045378315262496471) * gru_2_fwd_t3_h_4 + (-0.17401956021785736) * gru_2_fwd_t3_h_5 + (-0.068846233189105988) * gru_2_fwd_t3_h_6 + (1.3054778575897217) * gru_2_fwd_t3_h_7 + (0.20206254720687866) * gru_2_fwd_t3_h_8 + (-0.10305936634540558) * gru_2_fwd_t3_h_9 + (-0.29657679796218872) * gru_2_fwd_t3_h_10 + (0.28771412372589111) * gru_2_fwd_t3_h_11 + (-0.33240306377410889) * gru_2_fwd_t3_h_12 + (-0.81958317756652832) * gru_2_fwd_t3_h_13 + (0.39537006616592407) * gru_2_fwd_t3_h_14 + (0.025856386870145798) * gru_2_fwd_t3_h_15 + (1.6425710916519165) * gru_2_fwd_t3_h_16 + (0.17234136164188385) * gru_2_fwd_t3_h_17 + (-0.31268978118896484) * gru_2_fwd_t3_h_18 + (-0.11673153936862946) * gru_2_fwd_t3_h_19 + (-0.12755271792411804) * gru_2_fwd_t3_h_20 + (-0.208598792552948) * gru_2_fwd_t3_h_21 + (-0.10087612271308899) * gru_2_fwd_t3_h_22 + (0.032753553241491318) * gru_2_fwd_t3_h_23 + (0.10310366749763489) * gru_2_fwd_t3_h_24 + (-0.12197903543710709) * gru_2_fwd_t3_h_25 + (-0.30940842628479004) * gru_2_fwd_t3_h_26 + (-0.17729733884334564) * gru_2_fwd_t3_h_27 + (-0.059694431722164154) * gru_2_fwd_t3_h_28 + (0.049236506223678589) * gru_2_fwd_t3_h_29 + (0.3124127984046936) * gru_2_fwd_t3_h_30 + (0.1392454206943512) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.40311375260353088) + (0.16965155303478241) * gru_1_out_t4_0 + (-0.39619007706642151) * gru_1_out_t4_1 + (-0.25950157642364502) * gru_1_out_t4_2 + (-0.061753205955028534) * gru_1_out_t4_3 + (-0.49852883815765381) * gru_1_out_t4_4 + (-0.24298186600208282) * gru_1_out_t4_5 + (0.63767510652542114) * gru_1_out_t4_6 + (-0.86279875040054321) * gru_1_out_t4_7 + (-0.10701220482587814) * gru_1_out_t4_8 + (0.40588292479515076) * gru_1_out_t4_9 + (0.23909635841846466) * gru_1_out_t4_10 + (0.28834742307662964) * gru_1_out_t4_11 + (0.8522987961769104) * gru_1_out_t4_12 + (-0.7016262412071228) * gru_1_out_t4_13 + (0.39218124747276306) * gru_1_out_t4_14 + (1.1855034828186035) * gru_1_out_t4_15 + (1.1779153347015381) * gru_1_out_t4_16 + (0.35253360867500305) * gru_1_out_t4_17 + (1.0141201019287109) * gru_1_out_t4_18 + (0.174885094165802) * gru_1_out_t4_19 + (0.29363581538200378) * gru_1_out_t4_20 + (0.81994199752807617) * gru_1_out_t4_21 + (0.79149377346038818) * gru_1_out_t4_22 + (0.48218715190887451) * gru_1_out_t4_23 + (-1.1135436296463013) * gru_1_out_t4_24 + (0.20517396926879883) * gru_1_out_t4_25 + (-0.81459778547286987) * gru_1_out_t4_26 + (-0.33148488402366638) * gru_1_out_t4_27 + (1.2521886825561523) * gru_1_out_t4_28 + (0.095828570425510406) * gru_1_out_t4_29 + (-0.49771708250045776) * gru_1_out_t4_30 + (-0.81859296560287476) * gru_1_out_t4_31 + (-0.032601334154605865) * gru_1_out_t4_32 + (0.10070813447237015) * gru_1_out_t4_33 + (-0.079929709434509277) * gru_1_out_t4_34 + (0.378752201795578) * gru_1_out_t4_35 + (0.11629186570644379) * gru_1_out_t4_36 + (0.47991591691970825) * gru_1_out_t4_37 + (0.43927496671676636) * gru_1_out_t4_38 + (-0.56944125890731812) * gru_1_out_t4_39 + (-0.46402114629745483) * gru_1_out_t4_40 + (-0.31372597813606262) * gru_1_out_t4_41 + (-0.18972760438919067) * gru_1_out_t4_42 + (0.27249845862388611) * gru_1_out_t4_43 + (0.42713436484336853) * gru_1_out_t4_44 + (-0.24359169602394104) * gru_1_out_t4_45 + (-0.01479648519307375) * gru_1_out_t4_46 + (0.40999552607536316) * gru_1_out_t4_47 + (-0.71661859750747681) * gru_1_out_t4_48 + (-0.16231091320514679) * gru_1_out_t4_49 + (0.31256157159805298) * gru_1_out_t4_50 + (0.14024022221565247) * gru_1_out_t4_51 + (-0.32426643371582031) * gru_1_out_t4_52 + (-0.15458835661411285) * gru_1_out_t4_53 + (0.096960172057151794) * gru_1_out_t4_54 + (0.3034197986125946) * gru_1_out_t4_55 + (0.070376425981521606) * gru_1_out_t4_56 + (0.43235820531845093) * gru_1_out_t4_57 + (-0.50902485847473145) * gru_1_out_t4_58 + (-0.11449965089559555) * gru_1_out_t4_59 + (0.26572126150131226) * gru_1_out_t4_60 + (-0.45414629578590393) * gru_1_out_t4_61 + (-0.39853715896606445) * gru_1_out_t4_62 + (-0.33547863364219666) * gru_1_out_t4_63 + gate_r * ((-0.60734128952026367) + (0.16532061994075775) * gru_2_fwd_t3_h_0 + (0.25308889150619507) * gru_2_fwd_t3_h_1 + (-0.65999811887741089) * gru_2_fwd_t3_h_2 + (0.79756313562393188) * gru_2_fwd_t3_h_3 + (0.12843336164951324) * gru_2_fwd_t3_h_4 + (-0.094498008489608765) * gru_2_fwd_t3_h_5 + (-0.29586115479469299) * gru_2_fwd_t3_h_6 + (0.63916081190109253) * gru_2_fwd_t3_h_7 + (-0.71176010370254517) * gru_2_fwd_t3_h_8 + (0.484559565782547) * gru_2_fwd_t3_h_9 + (0.72834372520446777) * gru_2_fwd_t3_h_10 + (-0.56453293561935425) * gru_2_fwd_t3_h_11 + (0.82707369327545166) * gru_2_fwd_t3_h_12 + (1.0703163146972656) * gru_2_fwd_t3_h_13 + (0.50485455989837646) * gru_2_fwd_t3_h_14 + (-0.19369277358055115) * gru_2_fwd_t3_h_15 + (0.084084101021289825) * gru_2_fwd_t3_h_16 + (-0.49546951055526733) * gru_2_fwd_t3_h_17 + (-0.72229218482971191) * gru_2_fwd_t3_h_18 + (0.42762452363967896) * gru_2_fwd_t3_h_19 + (0.10778695344924927) * gru_2_fwd_t3_h_20 + (1.0733940601348877) * gru_2_fwd_t3_h_21 + (-0.62827354669570923) * gru_2_fwd_t3_h_22 + (0.27162215113639832) * gru_2_fwd_t3_h_23 + (-0.19957980513572693) * gru_2_fwd_t3_h_24 + (1.9227136373519897) * gru_2_fwd_t3_h_25 + (0.10290980339050293) * gru_2_fwd_t3_h_26 + (-0.061287250369787216) * gru_2_fwd_t3_h_27 + (-0.16919925808906555) * gru_2_fwd_t3_h_28 + (0.90441656112670898) * gru_2_fwd_t3_h_29 + (-0.21546296775341034) * gru_2_fwd_t3_h_30 + (0.24932350218296051) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_3 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_3;
    // h=4
    gate_r = sigmoid((1.1615561246871948) + (-0.51844322681427002) * gru_1_out_t4_0 + (-0.11482474952936172) * gru_1_out_t4_1 + (-0.79032421112060547) * gru_1_out_t4_2 + (0.35529571771621704) * gru_1_out_t4_3 + (-1.3858778476715088) * gru_1_out_t4_4 + (1.040509819984436) * gru_1_out_t4_5 + (1.1563373804092407) * gru_1_out_t4_6 + (-1.3189194202423096) * gru_1_out_t4_7 + (0.46318355202674866) * gru_1_out_t4_8 + (-0.24252569675445557) * gru_1_out_t4_9 + (0.09466148167848587) * gru_1_out_t4_10 + (-1.3704898357391357) * gru_1_out_t4_11 + (-0.6669003963470459) * gru_1_out_t4_12 + (-2.6385173797607422) * gru_1_out_t4_13 + (-0.09086880087852478) * gru_1_out_t4_14 + (1.3733655214309692) * gru_1_out_t4_15 + (0.35340481996536255) * gru_1_out_t4_16 + (-2.0000805854797363) * gru_1_out_t4_17 + (1.2164291143417358) * gru_1_out_t4_18 + (-0.005813920870423317) * gru_1_out_t4_19 + (-1.1854885816574097) * gru_1_out_t4_20 + (-0.34444290399551392) * gru_1_out_t4_21 + (2.6697027683258057) * gru_1_out_t4_22 + (-1.2855449914932251) * gru_1_out_t4_23 + (-1.6002296209335327) * gru_1_out_t4_24 + (-1.3803770542144775) * gru_1_out_t4_25 + (1.2097533941268921) * gru_1_out_t4_26 + (0.16466657817363739) * gru_1_out_t4_27 + (0.55906915664672852) * gru_1_out_t4_28 + (0.36143714189529419) * gru_1_out_t4_29 + (-0.2141263484954834) * gru_1_out_t4_30 + (-0.011483338661491871) * gru_1_out_t4_31 + (0.33926612138748169) * gru_1_out_t4_32 + (0.73889440298080444) * gru_1_out_t4_33 + (-0.051806099712848663) * gru_1_out_t4_34 + (0.95604509115219116) * gru_1_out_t4_35 + (0.89442086219787598) * gru_1_out_t4_36 + (-0.078334502875804901) * gru_1_out_t4_37 + (0.081081442534923553) * gru_1_out_t4_38 + (0.011801640503108501) * gru_1_out_t4_39 + (-1.6659096479415894) * gru_1_out_t4_40 + (0.50042414665222168) * gru_1_out_t4_41 + (-0.12676838040351868) * gru_1_out_t4_42 + (-0.32862663269042969) * gru_1_out_t4_43 + (0.31236335635185242) * gru_1_out_t4_44 + (-0.17431282997131348) * gru_1_out_t4_45 + (0.34155973792076111) * gru_1_out_t4_46 + (-0.37792819738388062) * gru_1_out_t4_47 + (1.5381574630737305) * gru_1_out_t4_48 + (1.3252875804901123) * gru_1_out_t4_49 + (-0.40328294038772583) * gru_1_out_t4_50 + (2.7833759784698486) * gru_1_out_t4_51 + (-1.1841946840286255) * gru_1_out_t4_52 + (-0.11905388534069061) * gru_1_out_t4_53 + (-0.19529622793197632) * gru_1_out_t4_54 + (1.063428521156311) * gru_1_out_t4_55 + (-0.085169576108455658) * gru_1_out_t4_56 + (0.029804887250065804) * gru_1_out_t4_57 + (-1.0386730432510376) * gru_1_out_t4_58 + (-1.6423882246017456) * gru_1_out_t4_59 + (-2.170102596282959) * gru_1_out_t4_60 + (0.21117527782917023) * gru_1_out_t4_61 + (-0.19859708845615387) * gru_1_out_t4_62 + (-0.002856808714568615) * gru_1_out_t4_63 + (-0.36469724774360657) * gru_2_fwd_t3_h_0 + (-0.10178904980421066) * gru_2_fwd_t3_h_1 + (-0.27399241924285889) * gru_2_fwd_t3_h_2 + (0.71402335166931152) * gru_2_fwd_t3_h_3 + (-0.6691887378692627) * gru_2_fwd_t3_h_4 + (-0.033493634313344955) * gru_2_fwd_t3_h_5 + (0.81946969032287598) * gru_2_fwd_t3_h_6 + (-0.54870671033859253) * gru_2_fwd_t3_h_7 + (-0.4542212188243866) * gru_2_fwd_t3_h_8 + (-0.54228681325912476) * gru_2_fwd_t3_h_9 + (-0.1637188196182251) * gru_2_fwd_t3_h_10 + (-0.12595795094966888) * gru_2_fwd_t3_h_11 + (-0.45016413927078247) * gru_2_fwd_t3_h_12 + (-2.8524534702301025) * gru_2_fwd_t3_h_13 + (1.7543692588806152) * gru_2_fwd_t3_h_14 + (-0.063703961670398712) * gru_2_fwd_t3_h_15 + (12.061202049255371) * gru_2_fwd_t3_h_16 + (-0.56153517961502075) * gru_2_fwd_t3_h_17 + (0.53322029113769531) * gru_2_fwd_t3_h_18 + (-0.6498873233795166) * gru_2_fwd_t3_h_19 + (0.68203747272491455) * gru_2_fwd_t3_h_20 + (-0.64043480157852173) * gru_2_fwd_t3_h_21 + (-0.1909102201461792) * gru_2_fwd_t3_h_22 + (0.60868477821350098) * gru_2_fwd_t3_h_23 + (0.27507948875427246) * gru_2_fwd_t3_h_24 + (-1.8141839504241943) * gru_2_fwd_t3_h_25 + (-0.091406024992465973) * gru_2_fwd_t3_h_26 + (0.15772435069084167) * gru_2_fwd_t3_h_27 + (-0.25070461630821228) * gru_2_fwd_t3_h_28 + (-0.42107275128364563) * gru_2_fwd_t3_h_29 + (0.073756292462348938) * gru_2_fwd_t3_h_30 + (-0.14107212424278259) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-1.5012381076812744) + (-0.090260140597820282) * gru_1_out_t4_0 + (-0.51019179821014404) * gru_1_out_t4_1 + (0.45153239369392395) * gru_1_out_t4_2 + (0.33191755414009094) * gru_1_out_t4_3 + (0.74110662937164307) * gru_1_out_t4_4 + (0.20983575284481049) * gru_1_out_t4_5 + (-1.1701817512512207) * gru_1_out_t4_6 + (0.87492460012435913) * gru_1_out_t4_7 + (-0.26237618923187256) * gru_1_out_t4_8 + (0.3124658465385437) * gru_1_out_t4_9 + (-0.35517290234565735) * gru_1_out_t4_10 + (-0.6383519172668457) * gru_1_out_t4_11 + (0.24760214984416962) * gru_1_out_t4_12 + (-0.686348557472229) * gru_1_out_t4_13 + (-0.19736781716346741) * gru_1_out_t4_14 + (-0.43084129691123962) * gru_1_out_t4_15 + (-0.55540889501571655) * gru_1_out_t4_16 + (0.78783559799194336) * gru_1_out_t4_17 + (0.1855214536190033) * gru_1_out_t4_18 + (0.040669701993465424) * gru_1_out_t4_19 + (0.34320768713951111) * gru_1_out_t4_20 + (-0.047083575278520584) * gru_1_out_t4_21 + (1.3501702547073364) * gru_1_out_t4_22 + (-0.021317632868885994) * gru_1_out_t4_23 + (-2.9332995414733887) * gru_1_out_t4_24 + (-0.010865963995456696) * gru_1_out_t4_25 + (0.48027893900871277) * gru_1_out_t4_26 + (-0.73094803094863892) * gru_1_out_t4_27 + (-0.61756813526153564) * gru_1_out_t4_28 + (-0.074868053197860718) * gru_1_out_t4_29 + (0.51946008205413818) * gru_1_out_t4_30 + (0.4941883385181427) * gru_1_out_t4_31 + (1.9998337030410767) * gru_1_out_t4_32 + (0.97811120748519897) * gru_1_out_t4_33 + (-0.82199478149414062) * gru_1_out_t4_34 + (-0.091997280716896057) * gru_1_out_t4_35 + (0.32988613843917847) * gru_1_out_t4_36 + (-0.61462670564651489) * gru_1_out_t4_37 + (0.6313815712928772) * gru_1_out_t4_38 + (0.033465661108493805) * gru_1_out_t4_39 + (0.15542499721050262) * gru_1_out_t4_40 + (0.055372130125761032) * gru_1_out_t4_41 + (-0.74968910217285156) * gru_1_out_t4_42 + (-0.2316993772983551) * gru_1_out_t4_43 + (-0.14244987070560455) * gru_1_out_t4_44 + (-0.44546821713447571) * gru_1_out_t4_45 + (-1.158564567565918) * gru_1_out_t4_46 + (-0.28312653303146362) * gru_1_out_t4_47 + (-0.83777326345443726) * gru_1_out_t4_48 + (0.91363400220870972) * gru_1_out_t4_49 + (1.8630989789962769) * gru_1_out_t4_50 + (-0.35776501893997192) * gru_1_out_t4_51 + (-0.50659769773483276) * gru_1_out_t4_52 + (-0.25242751836776733) * gru_1_out_t4_53 + (4.4223661422729492) * gru_1_out_t4_54 + (-0.74356538057327271) * gru_1_out_t4_55 + (-0.90062415599822998) * gru_1_out_t4_56 + (0.85552388429641724) * gru_1_out_t4_57 + (-0.053231123834848404) * gru_1_out_t4_58 + (-0.12265348434448242) * gru_1_out_t4_59 + (-0.42789122462272644) * gru_1_out_t4_60 + (-0.61891001462936401) * gru_1_out_t4_61 + (-0.071408189833164215) * gru_1_out_t4_62 + (-0.22053249180316925) * gru_1_out_t4_63 + (0.27991241216659546) * gru_2_fwd_t3_h_0 + (-0.012508866377174854) * gru_2_fwd_t3_h_1 + (-0.017478717491030693) * gru_2_fwd_t3_h_2 + (0.25145456194877625) * gru_2_fwd_t3_h_3 + (0.52940917015075684) * gru_2_fwd_t3_h_4 + (0.21370787918567657) * gru_2_fwd_t3_h_5 + (-0.13385684788227081) * gru_2_fwd_t3_h_6 + (-0.028876958414912224) * gru_2_fwd_t3_h_7 + (0.0479142926633358) * gru_2_fwd_t3_h_8 + (0.073769941926002502) * gru_2_fwd_t3_h_9 + (-0.35924038290977478) * gru_2_fwd_t3_h_10 + (-0.23718109726905823) * gru_2_fwd_t3_h_11 + (-0.14139187335968018) * gru_2_fwd_t3_h_12 + (-1.7969862222671509) * gru_2_fwd_t3_h_13 + (-0.32404220104217529) * gru_2_fwd_t3_h_14 + (-0.158366858959198) * gru_2_fwd_t3_h_15 + (0.26653921604156494) * gru_2_fwd_t3_h_16 + (-0.18255367875099182) * gru_2_fwd_t3_h_17 + (-0.075606130063533783) * gru_2_fwd_t3_h_18 + (-0.28230386972427368) * gru_2_fwd_t3_h_19 + (-0.012211176566779613) * gru_2_fwd_t3_h_20 + (0.30335429310798645) * gru_2_fwd_t3_h_21 + (-0.056657925248146057) * gru_2_fwd_t3_h_22 + (-0.37992596626281738) * gru_2_fwd_t3_h_23 + (0.21561132371425629) * gru_2_fwd_t3_h_24 + (-0.17840689420700073) * gru_2_fwd_t3_h_25 + (-0.1219310462474823) * gru_2_fwd_t3_h_26 + (-0.044708266854286194) * gru_2_fwd_t3_h_27 + (-1.8527176380157471) * gru_2_fwd_t3_h_28 + (0.069589078426361084) * gru_2_fwd_t3_h_29 + (-0.40117847919464111) * gru_2_fwd_t3_h_30 + (-0.02530067041516304) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.85538822412490845) + (0.19673387706279755) * gru_1_out_t4_0 + (0.11977367848157883) * gru_1_out_t4_1 + (0.063396431505680084) * gru_1_out_t4_2 + (-0.41546061635017395) * gru_1_out_t4_3 + (-0.15652617812156677) * gru_1_out_t4_4 + (-1.2004828453063965) * gru_1_out_t4_5 + (1.1472791433334351) * gru_1_out_t4_6 + (-0.26816442608833313) * gru_1_out_t4_7 + (0.017762506380677223) * gru_1_out_t4_8 + (-0.3614155650138855) * gru_1_out_t4_9 + (-0.047723103314638138) * gru_1_out_t4_10 + (0.42768698930740356) * gru_1_out_t4_11 + (0.2514096200466156) * gru_1_out_t4_12 + (0.42082792520523071) * gru_1_out_t4_13 + (0.09148591011762619) * gru_1_out_t4_14 + (0.30986016988754272) * gru_1_out_t4_15 + (-0.12835897505283356) * gru_1_out_t4_16 + (-0.19608929753303528) * gru_1_out_t4_17 + (0.11906805634498596) * gru_1_out_t4_18 + (0.62790709733963013) * gru_1_out_t4_19 + (0.5753358006477356) * gru_1_out_t4_20 + (0.029715133830904961) * gru_1_out_t4_21 + (0.15036506950855255) * gru_1_out_t4_22 + (-0.12864398956298828) * gru_1_out_t4_23 + (-0.62744659185409546) * gru_1_out_t4_24 + (0.29793563485145569) * gru_1_out_t4_25 + (-0.73527175188064575) * gru_1_out_t4_26 + (0.15115538239479065) * gru_1_out_t4_27 + (0.17663122713565826) * gru_1_out_t4_28 + (-0.049297083169221878) * gru_1_out_t4_29 + (0.195863276720047) * gru_1_out_t4_30 + (0.058776926249265671) * gru_1_out_t4_31 + (0.048784065991640091) * gru_1_out_t4_32 + (0.38595929741859436) * gru_1_out_t4_33 + (-0.047970928251743317) * gru_1_out_t4_34 + (0.24445968866348267) * gru_1_out_t4_35 + (-0.067700996994972229) * gru_1_out_t4_36 + (-0.01674736849963665) * gru_1_out_t4_37 + (0.037927005439996719) * gru_1_out_t4_38 + (0.35046076774597168) * gru_1_out_t4_39 + (0.37761974334716797) * gru_1_out_t4_40 + (-0.16018760204315186) * gru_1_out_t4_41 + (0.12947246432304382) * gru_1_out_t4_42 + (-0.035048563033342361) * gru_1_out_t4_43 + (-0.056990411132574081) * gru_1_out_t4_44 + (0.20321349799633026) * gru_1_out_t4_45 + (-0.07716648280620575) * gru_1_out_t4_46 + (0.087729446589946747) * gru_1_out_t4_47 + (-0.077342361211776733) * gru_1_out_t4_48 + (0.024145988747477531) * gru_1_out_t4_49 + (-0.14626742899417877) * gru_1_out_t4_50 + (0.08624953031539917) * gru_1_out_t4_51 + (0.045424610376358032) * gru_1_out_t4_52 + (-0.2783111035823822) * gru_1_out_t4_53 + (-0.038239572197198868) * gru_1_out_t4_54 + (0.21428817510604858) * gru_1_out_t4_55 + (-0.040556322783231735) * gru_1_out_t4_56 + (0.20445281267166138) * gru_1_out_t4_57 + (0.34343084692955017) * gru_1_out_t4_58 + (0.0035412514116615057) * gru_1_out_t4_59 + (0.12956574559211731) * gru_1_out_t4_60 + (-0.61528134346008301) * gru_1_out_t4_61 + (-0.012186108157038689) * gru_1_out_t4_62 + (-0.06433415412902832) * gru_1_out_t4_63 + gate_r * ((0.27616366744041443) + (0.011770623736083508) * gru_2_fwd_t3_h_0 + (0.042923323810100555) * gru_2_fwd_t3_h_1 + (0.0063887708820402622) * gru_2_fwd_t3_h_2 + (0.35108485817909241) * gru_2_fwd_t3_h_3 + (-0.47683107852935791) * gru_2_fwd_t3_h_4 + (0.18647685647010803) * gru_2_fwd_t3_h_5 + (-0.10148010402917862) * gru_2_fwd_t3_h_6 + (0.3474542498588562) * gru_2_fwd_t3_h_7 + (-0.052057892084121704) * gru_2_fwd_t3_h_8 + (-0.0098542384803295135) * gru_2_fwd_t3_h_9 + (-0.19146966934204102) * gru_2_fwd_t3_h_10 + (0.24609066545963287) * gru_2_fwd_t3_h_11 + (0.050919286906719208) * gru_2_fwd_t3_h_12 + (0.36016419529914856) * gru_2_fwd_t3_h_13 + (0.5992465615272522) * gru_2_fwd_t3_h_14 + (-0.077639885246753693) * gru_2_fwd_t3_h_15 + (-0.1047881618142128) * gru_2_fwd_t3_h_16 + (-0.4366031289100647) * gru_2_fwd_t3_h_17 + (-0.045751035213470459) * gru_2_fwd_t3_h_18 + (-0.00089490640675649047) * gru_2_fwd_t3_h_19 + (-0.15645354986190796) * gru_2_fwd_t3_h_20 + (0.030933361500501633) * gru_2_fwd_t3_h_21 + (0.010544842109084129) * gru_2_fwd_t3_h_22 + (0.095891945064067841) * gru_2_fwd_t3_h_23 + (-0.29273870587348938) * gru_2_fwd_t3_h_24 + (-0.68296325206756592) * gru_2_fwd_t3_h_25 + (-0.2034313827753067) * gru_2_fwd_t3_h_26 + (-0.03528696671128273) * gru_2_fwd_t3_h_27 + (-0.94800305366516113) * gru_2_fwd_t3_h_28 + (0.090717539191246033) * gru_2_fwd_t3_h_29 + (-0.048611707985401154) * gru_2_fwd_t3_h_30 + (0.14299571514129639) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_4 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_4;
    // h=5
    gate_r = sigmoid((-0.42992255091667175) + (0.67963588237762451) * gru_1_out_t4_0 + (-1.6832897663116455) * gru_1_out_t4_1 + (0.4866260290145874) * gru_1_out_t4_2 + (-0.465606689453125) * gru_1_out_t4_3 + (0.32731667160987854) * gru_1_out_t4_4 + (-0.21527102589607239) * gru_1_out_t4_5 + (-0.38889089226722717) * gru_1_out_t4_6 + (0.53676134347915649) * gru_1_out_t4_7 + (-0.56792247295379639) * gru_1_out_t4_8 + (-0.69941884279251099) * gru_1_out_t4_9 + (1.2024531364440918) * gru_1_out_t4_10 + (0.3083244264125824) * gru_1_out_t4_11 + (0.11429350823163986) * gru_1_out_t4_12 + (1.3619794845581055) * gru_1_out_t4_13 + (-0.45003393292427063) * gru_1_out_t4_14 + (-0.22319296002388) * gru_1_out_t4_15 + (-0.016822177916765213) * gru_1_out_t4_16 + (0.20408381521701813) * gru_1_out_t4_17 + (0.044011548161506653) * gru_1_out_t4_18 + (-0.4178009033203125) * gru_1_out_t4_19 + (0.24989792704582214) * gru_1_out_t4_20 + (-0.56839162111282349) * gru_1_out_t4_21 + (-0.470661461353302) * gru_1_out_t4_22 + (-1.4121370315551758) * gru_1_out_t4_23 + (1.1373801231384277) * gru_1_out_t4_24 + (-0.32759776711463928) * gru_1_out_t4_25 + (-1.3112614154815674) * gru_1_out_t4_26 + (-0.69000411033630371) * gru_1_out_t4_27 + (1.1643517017364502) * gru_1_out_t4_28 + (0.60771787166595459) * gru_1_out_t4_29 + (-0.92976629734039307) * gru_1_out_t4_30 + (1.9021216630935669) * gru_1_out_t4_31 + (-0.25808629393577576) * gru_1_out_t4_32 + (1.5772418975830078) * gru_1_out_t4_33 + (-0.16185177862644196) * gru_1_out_t4_34 + (-0.09121645987033844) * gru_1_out_t4_35 + (-0.23729954659938812) * gru_1_out_t4_36 + (0.49252086877822876) * gru_1_out_t4_37 + (-0.75839030742645264) * gru_1_out_t4_38 + (1.0958569049835205) * gru_1_out_t4_39 + (0.14803045988082886) * gru_1_out_t4_40 + (0.77791619300842285) * gru_1_out_t4_41 + (0.91667449474334717) * gru_1_out_t4_42 + (-0.68460291624069214) * gru_1_out_t4_43 + (0.25986561179161072) * gru_1_out_t4_44 + (2.3789253234863281) * gru_1_out_t4_45 + (-0.47316932678222656) * gru_1_out_t4_46 + (-0.69995498657226562) * gru_1_out_t4_47 + (-1.0102299451828003) * gru_1_out_t4_48 + (-1.1653497219085693) * gru_1_out_t4_49 + (-0.54118329286575317) * gru_1_out_t4_50 + (0.18025098741054535) * gru_1_out_t4_51 + (-1.6580793857574463) * gru_1_out_t4_52 + (-1.5496077537536621) * gru_1_out_t4_53 + (0.40459966659545898) * gru_1_out_t4_54 + (1.4956268072128296) * gru_1_out_t4_55 + (-1.7405233383178711) * gru_1_out_t4_56 + (1.1070117950439453) * gru_1_out_t4_57 + (0.033076286315917969) * gru_1_out_t4_58 + (1.4205800294876099) * gru_1_out_t4_59 + (-0.76700496673583984) * gru_1_out_t4_60 + (-1.4320125579833984) * gru_1_out_t4_61 + (-0.79529893398284912) * gru_1_out_t4_62 + (0.10739266872406006) * gru_1_out_t4_63 + (-0.033626139163970947) * gru_2_fwd_t3_h_0 + (0.12966135144233704) * gru_2_fwd_t3_h_1 + (0.18968124687671661) * gru_2_fwd_t3_h_2 + (-0.31786820292472839) * gru_2_fwd_t3_h_3 + (1.5156692266464233) * gru_2_fwd_t3_h_4 + (2.191875696182251) * gru_2_fwd_t3_h_5 + (-0.01402251236140728) * gru_2_fwd_t3_h_6 + (1.7294379472732544) * gru_2_fwd_t3_h_7 + (0.37500229477882385) * gru_2_fwd_t3_h_8 + (-1.2253450155258179) * gru_2_fwd_t3_h_9 + (-0.90616881847381592) * gru_2_fwd_t3_h_10 + (-0.21586433053016663) * gru_2_fwd_t3_h_11 + (-0.33127239346504211) * gru_2_fwd_t3_h_12 + (0.90300822257995605) * gru_2_fwd_t3_h_13 + (-0.14873376488685608) * gru_2_fwd_t3_h_14 + (-1.604983925819397) * gru_2_fwd_t3_h_15 + (0.062213964760303497) * gru_2_fwd_t3_h_16 + (0.14076213538646698) * gru_2_fwd_t3_h_17 + (-0.51157492399215698) * gru_2_fwd_t3_h_18 + (0.56305873394012451) * gru_2_fwd_t3_h_19 + (-0.2692837119102478) * gru_2_fwd_t3_h_20 + (-0.25147944688796997) * gru_2_fwd_t3_h_21 + (-0.41815611720085144) * gru_2_fwd_t3_h_22 + (-0.66929167509078979) * gru_2_fwd_t3_h_23 + (-0.57815474271774292) * gru_2_fwd_t3_h_24 + (-0.36220499873161316) * gru_2_fwd_t3_h_25 + (-1.0178940296173096) * gru_2_fwd_t3_h_26 + (2.0349090099334717) * gru_2_fwd_t3_h_27 + (-1.4415844678878784) * gru_2_fwd_t3_h_28 + (0.6937604546546936) * gru_2_fwd_t3_h_29 + (0.57538062334060669) * gru_2_fwd_t3_h_30 + (-0.2614300549030304) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.43059298396110535) + (-0.56319117546081543) * gru_1_out_t4_0 + (-0.21736080944538116) * gru_1_out_t4_1 + (0.010400814935564995) * gru_1_out_t4_2 + (1.0401800870895386) * gru_1_out_t4_3 + (0.34559795260429382) * gru_1_out_t4_4 + (0.45638459920883179) * gru_1_out_t4_5 + (0.98442840576171875) * gru_1_out_t4_6 + (-0.045096974819898605) * gru_1_out_t4_7 + (0.36673802137374878) * gru_1_out_t4_8 + (-0.0050246352329850197) * gru_1_out_t4_9 + (0.1920294314622879) * gru_1_out_t4_10 + (0.6155734658241272) * gru_1_out_t4_11 + (0.17660273611545563) * gru_1_out_t4_12 + (0.52284836769104004) * gru_1_out_t4_13 + (0.66303378343582153) * gru_1_out_t4_14 + (-1.0026397705078125) * gru_1_out_t4_15 + (-0.6136023998260498) * gru_1_out_t4_16 + (0.22710001468658447) * gru_1_out_t4_17 + (-0.71945619583129883) * gru_1_out_t4_18 + (-0.726185142993927) * gru_1_out_t4_19 + (0.46539214253425598) * gru_1_out_t4_20 + (0.2733309268951416) * gru_1_out_t4_21 + (0.75763916969299316) * gru_1_out_t4_22 + (0.3782271146774292) * gru_1_out_t4_23 + (0.42483130097389221) * gru_1_out_t4_24 + (0.77455621957778931) * gru_1_out_t4_25 + (-0.2756933867931366) * gru_1_out_t4_26 + (-0.15287299454212189) * gru_1_out_t4_27 + (0.7524145245552063) * gru_1_out_t4_28 + (-0.30605560541152954) * gru_1_out_t4_29 + (-0.59794425964355469) * gru_1_out_t4_30 + (-0.51937156915664673) * gru_1_out_t4_31 + (0.74451029300689697) * gru_1_out_t4_32 + (0.68875014781951904) * gru_1_out_t4_33 + (-0.30366736650466919) * gru_1_out_t4_34 + (0.10843696445226669) * gru_1_out_t4_35 + (0.4886176586151123) * gru_1_out_t4_36 + (-0.66675907373428345) * gru_1_out_t4_37 + (-0.27668344974517822) * gru_1_out_t4_38 + (-0.65460604429244995) * gru_1_out_t4_39 + (0.35061237215995789) * gru_1_out_t4_40 + (-0.061380442231893539) * gru_1_out_t4_41 + (0.14394007623195648) * gru_1_out_t4_42 + (-0.059178367257118225) * gru_1_out_t4_43 + (0.14818419516086578) * gru_1_out_t4_44 + (-0.37072604894638062) * gru_1_out_t4_45 + (0.14275464415550232) * gru_1_out_t4_46 + (0.40884333848953247) * gru_1_out_t4_47 + (-0.0069664325565099716) * gru_1_out_t4_48 + (-0.67902755737304688) * gru_1_out_t4_49 + (0.26287287473678589) * gru_1_out_t4_50 + (0.058754086494445801) * gru_1_out_t4_51 + (-0.46438431739807129) * gru_1_out_t4_52 + (-0.13688458502292633) * gru_1_out_t4_53 + (0.36525174975395203) * gru_1_out_t4_54 + (-0.52490788698196411) * gru_1_out_t4_55 + (0.37054762244224548) * gru_1_out_t4_56 + (0.036829430609941483) * gru_1_out_t4_57 + (-0.36196622252464294) * gru_1_out_t4_58 + (0.02387058362364769) * gru_1_out_t4_59 + (-0.11637367308139801) * gru_1_out_t4_60 + (-0.25493159890174866) * gru_1_out_t4_61 + (-1.101844310760498) * gru_1_out_t4_62 + (0.54478806257247925) * gru_1_out_t4_63 + (-0.87273961305618286) * gru_2_fwd_t3_h_0 + (-0.60840022563934326) * gru_2_fwd_t3_h_1 + (0.32954475283622742) * gru_2_fwd_t3_h_2 + (-0.14296112954616547) * gru_2_fwd_t3_h_3 + (-0.54665654897689819) * gru_2_fwd_t3_h_4 + (-0.5709260106086731) * gru_2_fwd_t3_h_5 + (0.52092307806015015) * gru_2_fwd_t3_h_6 + (0.15275493264198303) * gru_2_fwd_t3_h_7 + (1.4008438587188721) * gru_2_fwd_t3_h_8 + (-0.31897595524787903) * gru_2_fwd_t3_h_9 + (0.25416091084480286) * gru_2_fwd_t3_h_10 + (0.3637232780456543) * gru_2_fwd_t3_h_11 + (1.026569128036499) * gru_2_fwd_t3_h_12 + (-0.22097496688365936) * gru_2_fwd_t3_h_13 + (0.3674875795841217) * gru_2_fwd_t3_h_14 + (0.26903742551803589) * gru_2_fwd_t3_h_15 + (-0.23657694458961487) * gru_2_fwd_t3_h_16 + (0.65303868055343628) * gru_2_fwd_t3_h_17 + (-0.28463762998580933) * gru_2_fwd_t3_h_18 + (-0.89476990699768066) * gru_2_fwd_t3_h_19 + (-0.14742656052112579) * gru_2_fwd_t3_h_20 + (0.40035703778266907) * gru_2_fwd_t3_h_21 + (-0.52813494205474854) * gru_2_fwd_t3_h_22 + (-0.66770625114440918) * gru_2_fwd_t3_h_23 + (0.32263287901878357) * gru_2_fwd_t3_h_24 + (-0.36306285858154297) * gru_2_fwd_t3_h_25 + (0.70146650075912476) * gru_2_fwd_t3_h_26 + (0.79530340433120728) * gru_2_fwd_t3_h_27 + (-0.22581323981285095) * gru_2_fwd_t3_h_28 + (0.12455646693706512) * gru_2_fwd_t3_h_29 + (0.18611921370029449) * gru_2_fwd_t3_h_30 + (-0.15259365737438202) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.38997277617454529) + (0.30987763404846191) * gru_1_out_t4_0 + (-1.1875820159912109) * gru_1_out_t4_1 + (-0.90843808650970459) * gru_1_out_t4_2 + (-0.085120365023612976) * gru_1_out_t4_3 + (-0.22600211203098297) * gru_1_out_t4_4 + (0.032841295003890991) * gru_1_out_t4_5 + (0.11430556327104568) * gru_1_out_t4_6 + (0.23872591555118561) * gru_1_out_t4_7 + (0.72304600477218628) * gru_1_out_t4_8 + (-0.076739832758903503) * gru_1_out_t4_9 + (0.51064598560333252) * gru_1_out_t4_10 + (1.5105327367782593) * gru_1_out_t4_11 + (0.38314765691757202) * gru_1_out_t4_12 + (-0.66766607761383057) * gru_1_out_t4_13 + (0.99268341064453125) * gru_1_out_t4_14 + (0.41303658485412598) * gru_1_out_t4_15 + (-0.51761919260025024) * gru_1_out_t4_16 + (-0.15797455608844757) * gru_1_out_t4_17 + (0.09660552442073822) * gru_1_out_t4_18 + (0.56043291091918945) * gru_1_out_t4_19 + (-0.82565903663635254) * gru_1_out_t4_20 + (-0.92259138822555542) * gru_1_out_t4_21 + (0.70856344699859619) * gru_1_out_t4_22 + (-0.69606637954711914) * gru_1_out_t4_23 + (0.49122524261474609) * gru_1_out_t4_24 + (-0.2270774245262146) * gru_1_out_t4_25 + (0.23694086074829102) * gru_1_out_t4_26 + (-0.27720162272453308) * gru_1_out_t4_27 + (1.0943255424499512) * gru_1_out_t4_28 + (0.78282362222671509) * gru_1_out_t4_29 + (-1.136067271232605) * gru_1_out_t4_30 + (-0.10719147324562073) * gru_1_out_t4_31 + (0.030723810195922852) * gru_1_out_t4_32 + (0.072261981666088104) * gru_1_out_t4_33 + (-0.4073948860168457) * gru_1_out_t4_34 + (1.1946412324905396) * gru_1_out_t4_35 + (0.58331620693206787) * gru_1_out_t4_36 + (-0.22593428194522858) * gru_1_out_t4_37 + (-0.29051223397254944) * gru_1_out_t4_38 + (-0.18918986618518829) * gru_1_out_t4_39 + (-0.26611790060997009) * gru_1_out_t4_40 + (-0.3156568706035614) * gru_1_out_t4_41 + (0.16253079473972321) * gru_1_out_t4_42 + (-0.26033109426498413) * gru_1_out_t4_43 + (-0.62451320886611938) * gru_1_out_t4_44 + (0.220931276679039) * gru_1_out_t4_45 + (-0.045115150511264801) * gru_1_out_t4_46 + (0.51381462812423706) * gru_1_out_t4_47 + (-0.92573493719100952) * gru_1_out_t4_48 + (0.78107285499572754) * gru_1_out_t4_49 + (0.296531081199646) * gru_1_out_t4_50 + (-0.45764133334159851) * gru_1_out_t4_51 + (-0.41901159286499023) * gru_1_out_t4_52 + (-0.91993319988250732) * gru_1_out_t4_53 + (0.2944258451461792) * gru_1_out_t4_54 + (0.083768747746944427) * gru_1_out_t4_55 + (-1.2087869644165039) * gru_1_out_t4_56 + (-0.12474789470434189) * gru_1_out_t4_57 + (0.11702824383974075) * gru_1_out_t4_58 + (-0.84011894464492798) * gru_1_out_t4_59 + (0.13155271112918854) * gru_1_out_t4_60 + (0.0074300589039921761) * gru_1_out_t4_61 + (-0.63244551420211792) * gru_1_out_t4_62 + (-0.66695588827133179) * gru_1_out_t4_63 + gate_r * ((0.044182155281305313) + (0.77569860219955444) * gru_2_fwd_t3_h_0 + (0.023920956999063492) * gru_2_fwd_t3_h_1 + (-0.064282864332199097) * gru_2_fwd_t3_h_2 + (0.69085294008255005) * gru_2_fwd_t3_h_3 + (0.031718220561742783) * gru_2_fwd_t3_h_4 + (-0.3537621796131134) * gru_2_fwd_t3_h_5 + (-0.081973150372505188) * gru_2_fwd_t3_h_6 + (-0.56047612428665161) * gru_2_fwd_t3_h_7 + (0.61015480756759644) * gru_2_fwd_t3_h_8 + (0.41468220949172974) * gru_2_fwd_t3_h_9 + (0.031472168862819672) * gru_2_fwd_t3_h_10 + (-0.23239718377590179) * gru_2_fwd_t3_h_11 + (-0.53107643127441406) * gru_2_fwd_t3_h_12 + (2.4669761657714844) * gru_2_fwd_t3_h_13 + (-0.44276198744773865) * gru_2_fwd_t3_h_14 + (0.14540085196495056) * gru_2_fwd_t3_h_15 + (0.037303533405065536) * gru_2_fwd_t3_h_16 + (0.32614773511886597) * gru_2_fwd_t3_h_17 + (-0.33809471130371094) * gru_2_fwd_t3_h_18 + (-0.0083967186510562897) * gru_2_fwd_t3_h_19 + (-0.73083525896072388) * gru_2_fwd_t3_h_20 + (0.18775936961174011) * gru_2_fwd_t3_h_21 + (-0.3583320677280426) * gru_2_fwd_t3_h_22 + (0.64606738090515137) * gru_2_fwd_t3_h_23 + (0.12671183049678802) * gru_2_fwd_t3_h_24 + (0.020685303956270218) * gru_2_fwd_t3_h_25 + (-0.070350535213947296) * gru_2_fwd_t3_h_26 + (-0.14060081541538239) * gru_2_fwd_t3_h_27 + (0.34511047601699829) * gru_2_fwd_t3_h_28 + (0.0072871893644332886) * gru_2_fwd_t3_h_29 + (0.43000140786170959) * gru_2_fwd_t3_h_30 + (-0.51871424913406372) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_5 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_5;
    // h=6
    gate_r = sigmoid((0.99238145351409912) + (0.97941190004348755) * gru_1_out_t4_0 + (1.9051604270935059) * gru_1_out_t4_1 + (-0.60982710123062134) * gru_1_out_t4_2 + (0.63175636529922485) * gru_1_out_t4_3 + (-0.49296796321868896) * gru_1_out_t4_4 + (0.51251834630966187) * gru_1_out_t4_5 + (-1.0902179479598999) * gru_1_out_t4_6 + (-0.24423442780971527) * gru_1_out_t4_7 + (-1.4805543422698975) * gru_1_out_t4_8 + (-0.77883583307266235) * gru_1_out_t4_9 + (0.61803019046783447) * gru_1_out_t4_10 + (0.79252749681472778) * gru_1_out_t4_11 + (0.30760139226913452) * gru_1_out_t4_12 + (0.99963343143463135) * gru_1_out_t4_13 + (0.99913442134857178) * gru_1_out_t4_14 + (-0.12514501810073853) * gru_1_out_t4_15 + (0.24538297951221466) * gru_1_out_t4_16 + (-1.3237224817276001) * gru_1_out_t4_17 + (0.41924157738685608) * gru_1_out_t4_18 + (-0.55750066041946411) * gru_1_out_t4_19 + (-0.1436622142791748) * gru_1_out_t4_20 + (0.86449950933456421) * gru_1_out_t4_21 + (-0.42343845963478088) * gru_1_out_t4_22 + (-1.3686064481735229) * gru_1_out_t4_23 + (2.7032325267791748) * gru_1_out_t4_24 + (1.0904897451400757) * gru_1_out_t4_25 + (1.0178974866867065) * gru_1_out_t4_26 + (0.0051362873055040836) * gru_1_out_t4_27 + (-0.11446412652730942) * gru_1_out_t4_28 + (-0.12069904804229736) * gru_1_out_t4_29 + (0.97054064273834229) * gru_1_out_t4_30 + (0.53837144374847412) * gru_1_out_t4_31 + (1.0813800096511841) * gru_1_out_t4_32 + (0.58504593372344971) * gru_1_out_t4_33 + (0.2685428261756897) * gru_1_out_t4_34 + (-0.29954433441162109) * gru_1_out_t4_35 + (0.7777177095413208) * gru_1_out_t4_36 + (0.039266772568225861) * gru_1_out_t4_37 + (-0.33155432343482971) * gru_1_out_t4_38 + (-0.1743304431438446) * gru_1_out_t4_39 + (-0.1693054735660553) * gru_1_out_t4_40 + (0.29454773664474487) * gru_1_out_t4_41 + (0.66117006540298462) * gru_1_out_t4_42 + (0.39358705282211304) * gru_1_out_t4_43 + (-0.13294480741024017) * gru_1_out_t4_44 + (0.68236023187637329) * gru_1_out_t4_45 + (0.30608677864074707) * gru_1_out_t4_46 + (-0.5872156023979187) * gru_1_out_t4_47 + (-0.74446231126785278) * gru_1_out_t4_48 + (0.95984375476837158) * gru_1_out_t4_49 + (0.99742645025253296) * gru_1_out_t4_50 + (0.56305491924285889) * gru_1_out_t4_51 + (-0.060103707015514374) * gru_1_out_t4_52 + (-0.034640897065401077) * gru_1_out_t4_53 + (-1.6142456531524658) * gru_1_out_t4_54 + (0.87334632873535156) * gru_1_out_t4_55 + (-1.0147285461425781) * gru_1_out_t4_56 + (0.36967334151268005) * gru_1_out_t4_57 + (-0.56437057256698608) * gru_1_out_t4_58 + (-0.64732939004898071) * gru_1_out_t4_59 + (-2.1714291572570801) * gru_1_out_t4_60 + (-0.32412993907928467) * gru_1_out_t4_61 + (1.7252355813980103) * gru_1_out_t4_62 + (-0.036716390401124954) * gru_1_out_t4_63 + (-0.44624048471450806) * gru_2_fwd_t3_h_0 + (-0.050888001918792725) * gru_2_fwd_t3_h_1 + (0.20776711404323578) * gru_2_fwd_t3_h_2 + (-0.30832016468048096) * gru_2_fwd_t3_h_3 + (0.03141586109995842) * gru_2_fwd_t3_h_4 + (-0.35103863477706909) * gru_2_fwd_t3_h_5 + (0.51331436634063721) * gru_2_fwd_t3_h_6 + (-2.2664053440093994) * gru_2_fwd_t3_h_7 + (-0.54240494966506958) * gru_2_fwd_t3_h_8 + (-0.060877449810504913) * gru_2_fwd_t3_h_9 + (-0.48614147305488586) * gru_2_fwd_t3_h_10 + (-0.39799469709396362) * gru_2_fwd_t3_h_11 + (-1.4587270021438599) * gru_2_fwd_t3_h_12 + (0.32146787643432617) * gru_2_fwd_t3_h_13 + (-0.79560595750808716) * gru_2_fwd_t3_h_14 + (1.0340641736984253) * gru_2_fwd_t3_h_15 + (0.70297855138778687) * gru_2_fwd_t3_h_16 + (-0.14095580577850342) * gru_2_fwd_t3_h_17 + (0.31651702523231506) * gru_2_fwd_t3_h_18 + (0.58146673440933228) * gru_2_fwd_t3_h_19 + (0.67296773195266724) * gru_2_fwd_t3_h_20 + (-0.40671494603157043) * gru_2_fwd_t3_h_21 + (-0.036937329918146133) * gru_2_fwd_t3_h_22 + (-0.039286252111196518) * gru_2_fwd_t3_h_23 + (0.01503447163850069) * gru_2_fwd_t3_h_24 + (-0.25929605960845947) * gru_2_fwd_t3_h_25 + (0.52978342771530151) * gru_2_fwd_t3_h_26 + (-0.72296953201293945) * gru_2_fwd_t3_h_27 + (-0.11858854442834854) * gru_2_fwd_t3_h_28 + (0.35634669661521912) * gru_2_fwd_t3_h_29 + (0.20360457897186279) * gru_2_fwd_t3_h_30 + (-0.35696831345558167) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.15887005627155304) + (-0.72471684217453003) * gru_1_out_t4_0 + (-0.48633319139480591) * gru_1_out_t4_1 + (-0.43803763389587402) * gru_1_out_t4_2 + (0.42213571071624756) * gru_1_out_t4_3 + (0.0088470736518502235) * gru_1_out_t4_4 + (-0.16528171300888062) * gru_1_out_t4_5 + (2.2088873386383057) * gru_1_out_t4_6 + (0.2117859423160553) * gru_1_out_t4_7 + (0.23211970925331116) * gru_1_out_t4_8 + (0.34945672750473022) * gru_1_out_t4_9 + (0.063945971429347992) * gru_1_out_t4_10 + (-1.0151585340499878) * gru_1_out_t4_11 + (-0.16469350457191467) * gru_1_out_t4_12 + (-0.56130427122116089) * gru_1_out_t4_13 + (-0.1305549293756485) * gru_1_out_t4_14 + (-0.15692748129367828) * gru_1_out_t4_15 + (0.79616332054138184) * gru_1_out_t4_16 + (-0.62406086921691895) * gru_1_out_t4_17 + (-0.79074519872665405) * gru_1_out_t4_18 + (0.14874286949634552) * gru_1_out_t4_19 + (-0.24758745729923248) * gru_1_out_t4_20 + (1.0391430854797363) * gru_1_out_t4_21 + (-0.49141255021095276) * gru_1_out_t4_22 + (0.85845279693603516) * gru_1_out_t4_23 + (2.2941417694091797) * gru_1_out_t4_24 + (-0.423595130443573) * gru_1_out_t4_25 + (0.14678360521793365) * gru_1_out_t4_26 + (0.70135873556137085) * gru_1_out_t4_27 + (-0.30797651410102844) * gru_1_out_t4_28 + (-0.3422141969203949) * gru_1_out_t4_29 + (-1.2962141036987305) * gru_1_out_t4_30 + (-0.31097346544265747) * gru_1_out_t4_31 + (-0.46404397487640381) * gru_1_out_t4_32 + (-1.0470227003097534) * gru_1_out_t4_33 + (-1.0417500734329224) * gru_1_out_t4_34 + (1.5855774879455566) * gru_1_out_t4_35 + (0.018771134316921234) * gru_1_out_t4_36 + (-0.24097840487957001) * gru_1_out_t4_37 + (1.0948796272277832) * gru_1_out_t4_38 + (-1.0532113313674927) * gru_1_out_t4_39 + (1.3148645162582397) * gru_1_out_t4_40 + (-0.39999336004257202) * gru_1_out_t4_41 + (0.28015926480293274) * gru_1_out_t4_42 + (0.12160661816596985) * gru_1_out_t4_43 + (0.098121039569377899) * gru_1_out_t4_44 + (-0.12054173648357391) * gru_1_out_t4_45 + (0.0071843313053250313) * gru_1_out_t4_46 + (1.4575604200363159) * gru_1_out_t4_47 + (1.4373639822006226) * gru_1_out_t4_48 + (-0.53084522485733032) * gru_1_out_t4_49 + (-0.16599802672863007) * gru_1_out_t4_50 + (0.17999744415283203) * gru_1_out_t4_51 + (-0.10605581104755402) * gru_1_out_t4_52 + (-0.29012593626976013) * gru_1_out_t4_53 + (-0.43322914838790894) * gru_1_out_t4_54 + (0.34951236844062805) * gru_1_out_t4_55 + (-0.5737689733505249) * gru_1_out_t4_56 + (-1.0190738439559937) * gru_1_out_t4_57 + (-0.091982178390026093) * gru_1_out_t4_58 + (0.64190882444381714) * gru_1_out_t4_59 + (-0.20702961087226868) * gru_1_out_t4_60 + (-0.37210381031036377) * gru_1_out_t4_61 + (0.76966589689254761) * gru_1_out_t4_62 + (-0.86343324184417725) * gru_1_out_t4_63 + (0.48651167750358582) * gru_2_fwd_t3_h_0 + (0.1304328441619873) * gru_2_fwd_t3_h_1 + (-0.18701286613941193) * gru_2_fwd_t3_h_2 + (-0.24094516038894653) * gru_2_fwd_t3_h_3 + (0.11735676974058151) * gru_2_fwd_t3_h_4 + (0.39963105320930481) * gru_2_fwd_t3_h_5 + (-0.53097432851791382) * gru_2_fwd_t3_h_6 + (-2.703956127166748) * gru_2_fwd_t3_h_7 + (0.34628218412399292) * gru_2_fwd_t3_h_8 + (0.46044692397117615) * gru_2_fwd_t3_h_9 + (-0.25725901126861572) * gru_2_fwd_t3_h_10 + (0.30941048264503479) * gru_2_fwd_t3_h_11 + (-0.16859607398509979) * gru_2_fwd_t3_h_12 + (2.637498140335083) * gru_2_fwd_t3_h_13 + (-0.62893259525299072) * gru_2_fwd_t3_h_14 + (0.60806828737258911) * gru_2_fwd_t3_h_15 + (1.262578010559082) * gru_2_fwd_t3_h_16 + (-0.18920978903770447) * gru_2_fwd_t3_h_17 + (0.32627171277999878) * gru_2_fwd_t3_h_18 + (-0.067556843161582947) * gru_2_fwd_t3_h_19 + (-0.13036784529685974) * gru_2_fwd_t3_h_20 + (-0.19114868342876434) * gru_2_fwd_t3_h_21 + (0.2641410231590271) * gru_2_fwd_t3_h_22 + (-0.093612708151340485) * gru_2_fwd_t3_h_23 + (-0.27469667792320251) * gru_2_fwd_t3_h_24 + (-0.65518128871917725) * gru_2_fwd_t3_h_25 + (-1.1057746410369873) * gru_2_fwd_t3_h_26 + (-0.31671872735023499) * gru_2_fwd_t3_h_27 + (0.044746961444616318) * gru_2_fwd_t3_h_28 + (-0.40845954418182373) * gru_2_fwd_t3_h_29 + (-0.48822221159934998) * gru_2_fwd_t3_h_30 + (-0.22873932123184204) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.38073989748954773) + (-0.069888316094875336) * gru_1_out_t4_0 + (-0.2414863258600235) * gru_1_out_t4_1 + (-0.62227034568786621) * gru_1_out_t4_2 + (-0.7356073260307312) * gru_1_out_t4_3 + (0.088059499859809875) * gru_1_out_t4_4 + (-0.67130643129348755) * gru_1_out_t4_5 + (-0.84127843379974365) * gru_1_out_t4_6 + (-0.18782402575016022) * gru_1_out_t4_7 + (-0.19532755017280579) * gru_1_out_t4_8 + (0.17948193848133087) * gru_1_out_t4_9 + (0.13035029172897339) * gru_1_out_t4_10 + (0.37686276435852051) * gru_1_out_t4_11 + (-0.13486675918102264) * gru_1_out_t4_12 + (0.46430742740631104) * gru_1_out_t4_13 + (-0.5601038932800293) * gru_1_out_t4_14 + (0.7103990912437439) * gru_1_out_t4_15 + (-0.98155832290649414) * gru_1_out_t4_16 + (-0.30917298793792725) * gru_1_out_t4_17 + (-0.1572728157043457) * gru_1_out_t4_18 + (0.066305853426456451) * gru_1_out_t4_19 + (0.047919288277626038) * gru_1_out_t4_20 + (0.075065046548843384) * gru_1_out_t4_21 + (0.23333732783794403) * gru_1_out_t4_22 + (0.4488789439201355) * gru_1_out_t4_23 + (-0.22282376885414124) * gru_1_out_t4_24 + (-0.30130714178085327) * gru_1_out_t4_25 + (-0.014877819456160069) * gru_1_out_t4_26 + (0.14033789932727814) * gru_1_out_t4_27 + (0.10877938568592072) * gru_1_out_t4_28 + (-0.4529661238193512) * gru_1_out_t4_29 + (-0.083255298435688019) * gru_1_out_t4_30 + (0.71279716491699219) * gru_1_out_t4_31 + (0.30829378962516785) * gru_1_out_t4_32 + (0.12226396054029465) * gru_1_out_t4_33 + (-0.087489128112792969) * gru_1_out_t4_34 + (-0.075500346720218658) * gru_1_out_t4_35 + (-0.15269826352596283) * gru_1_out_t4_36 + (0.43252423405647278) * gru_1_out_t4_37 + (0.009540473110973835) * gru_1_out_t4_38 + (-0.5790170431137085) * gru_1_out_t4_39 + (0.41713187098503113) * gru_1_out_t4_40 + (-0.091455988585948944) * gru_1_out_t4_41 + (0.4325605034828186) * gru_1_out_t4_42 + (-0.57300513982772827) * gru_1_out_t4_43 + (0.22971288859844208) * gru_1_out_t4_44 + (0.12160023301839828) * gru_1_out_t4_45 + (-0.25573226809501648) * gru_1_out_t4_46 + (-0.048875294625759125) * gru_1_out_t4_47 + (-0.13737761974334717) * gru_1_out_t4_48 + (-0.23275421559810638) * gru_1_out_t4_49 + (0.19752825796604156) * gru_1_out_t4_50 + (-0.18723508715629578) * gru_1_out_t4_51 + (0.36962774395942688) * gru_1_out_t4_52 + (0.18754303455352783) * gru_1_out_t4_53 + (0.067695558071136475) * gru_1_out_t4_54 + (-0.5221942663192749) * gru_1_out_t4_55 + (0.20494328439235687) * gru_1_out_t4_56 + (-0.045121807605028152) * gru_1_out_t4_57 + (0.48538091778755188) * gru_1_out_t4_58 + (-0.084261290729045868) * gru_1_out_t4_59 + (0.19997870922088623) * gru_1_out_t4_60 + (-0.23550234735012054) * gru_1_out_t4_61 + (0.035868816077709198) * gru_1_out_t4_62 + (0.16396276652812958) * gru_1_out_t4_63 + gate_r * ((-0.28456246852874756) + (-0.19708800315856934) * gru_2_fwd_t3_h_0 + (0.259137362241745) * gru_2_fwd_t3_h_1 + (0.45911964774131775) * gru_2_fwd_t3_h_2 + (-0.26342561841011047) * gru_2_fwd_t3_h_3 + (0.1164274737238884) * gru_2_fwd_t3_h_4 + (-0.094654358923435211) * gru_2_fwd_t3_h_5 + (-0.94615960121154785) * gru_2_fwd_t3_h_6 + (-0.052205052226781845) * gru_2_fwd_t3_h_7 + (-0.75711220502853394) * gru_2_fwd_t3_h_8 + (-0.16269890964031219) * gru_2_fwd_t3_h_9 + (0.25257182121276855) * gru_2_fwd_t3_h_10 + (0.11205314099788666) * gru_2_fwd_t3_h_11 + (-0.20655660331249237) * gru_2_fwd_t3_h_12 + (0.68340027332305908) * gru_2_fwd_t3_h_13 + (0.065231144428253174) * gru_2_fwd_t3_h_14 + (-0.071259155869483948) * gru_2_fwd_t3_h_15 + (-0.067886687815189362) * gru_2_fwd_t3_h_16 + (-0.11118495464324951) * gru_2_fwd_t3_h_17 + (1.3308243751525879) * gru_2_fwd_t3_h_18 + (0.65875756740570068) * gru_2_fwd_t3_h_19 + (0.02027457021176815) * gru_2_fwd_t3_h_20 + (-0.25972822308540344) * gru_2_fwd_t3_h_21 + (0.28337550163269043) * gru_2_fwd_t3_h_22 + (0.030049571767449379) * gru_2_fwd_t3_h_23 + (-0.19526134431362152) * gru_2_fwd_t3_h_24 + (0.10961331427097321) * gru_2_fwd_t3_h_25 + (0.095570854842662811) * gru_2_fwd_t3_h_26 + (-0.2365623414516449) * gru_2_fwd_t3_h_27 + (0.23675939440727234) * gru_2_fwd_t3_h_28 + (-0.71894544363021851) * gru_2_fwd_t3_h_29 + (0.016478011384606361) * gru_2_fwd_t3_h_30 + (0.0043945726938545704) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_6 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_6;
    // h=7
    gate_r = sigmoid((-0.62197017669677734) + (0.10606128722429276) * gru_1_out_t4_0 + (2.5488266944885254) * gru_1_out_t4_1 + (-1.4843736886978149) * gru_1_out_t4_2 + (0.35048002004623413) * gru_1_out_t4_3 + (-0.4260120689868927) * gru_1_out_t4_4 + (2.2575030326843262) * gru_1_out_t4_5 + (2.2194697856903076) * gru_1_out_t4_6 + (-0.11634258925914764) * gru_1_out_t4_7 + (-0.3215067982673645) * gru_1_out_t4_8 + (-0.67384010553359985) * gru_1_out_t4_9 + (0.74993818998336792) * gru_1_out_t4_10 + (-0.59708577394485474) * gru_1_out_t4_11 + (-0.015302901156246662) * gru_1_out_t4_12 + (-0.070593178272247314) * gru_1_out_t4_13 + (0.56934881210327148) * gru_1_out_t4_14 + (-0.59768384695053101) * gru_1_out_t4_15 + (-0.44555187225341797) * gru_1_out_t4_16 + (-0.18213480710983276) * gru_1_out_t4_17 + (0.59250104427337646) * gru_1_out_t4_18 + (-0.38874515891075134) * gru_1_out_t4_19 + (-0.071320079267024994) * gru_1_out_t4_20 + (-0.82715123891830444) * gru_1_out_t4_21 + (-0.65167057514190674) * gru_1_out_t4_22 + (0.0074586817063391209) * gru_1_out_t4_23 + (-0.99457579851150513) * gru_1_out_t4_24 + (0.27512049674987793) * gru_1_out_t4_25 + (-0.65382099151611328) * gru_1_out_t4_26 + (-1.4781731367111206) * gru_1_out_t4_27 + (-0.86624646186828613) * gru_1_out_t4_28 + (-0.62023651599884033) * gru_1_out_t4_29 + (-0.84566342830657959) * gru_1_out_t4_30 + (-0.27118068933486938) * gru_1_out_t4_31 + (-1.6714849472045898) * gru_1_out_t4_32 + (-1.4434305429458618) * gru_1_out_t4_33 + (2.3194448947906494) * gru_1_out_t4_34 + (0.30631107091903687) * gru_1_out_t4_35 + (-1.2566306591033936) * gru_1_out_t4_36 + (-0.34590819478034973) * gru_1_out_t4_37 + (-0.063884533941745758) * gru_1_out_t4_38 + (-0.28741663694381714) * gru_1_out_t4_39 + (-1.0691723823547363) * gru_1_out_t4_40 + (0.42472741007804871) * gru_1_out_t4_41 + (-0.31156787276268005) * gru_1_out_t4_42 + (3.0809240341186523) * gru_1_out_t4_43 + (-0.21261155605316162) * gru_1_out_t4_44 + (0.069369584321975708) * gru_1_out_t4_45 + (0.24070744216442108) * gru_1_out_t4_46 + (-0.31690332293510437) * gru_1_out_t4_47 + (-0.89229744672775269) * gru_1_out_t4_48 + (-0.16281262040138245) * gru_1_out_t4_49 + (1.5589324235916138) * gru_1_out_t4_50 + (0.33524227142333984) * gru_1_out_t4_51 + (-0.95937418937683105) * gru_1_out_t4_52 + (-0.5072479248046875) * gru_1_out_t4_53 + (0.75587660074234009) * gru_1_out_t4_54 + (2.8644340038299561) * gru_1_out_t4_55 + (-1.1837942600250244) * gru_1_out_t4_56 + (0.5380062460899353) * gru_1_out_t4_57 + (0.98161321878433228) * gru_1_out_t4_58 + (1.2194415330886841) * gru_1_out_t4_59 + (0.98128432035446167) * gru_1_out_t4_60 + (1.7099440097808838) * gru_1_out_t4_61 + (0.045954499393701553) * gru_1_out_t4_62 + (1.4897309541702271) * gru_1_out_t4_63 + (-0.36073625087738037) * gru_2_fwd_t3_h_0 + (-0.35412415862083435) * gru_2_fwd_t3_h_1 + (-0.23972609639167786) * gru_2_fwd_t3_h_2 + (-0.35870987176895142) * gru_2_fwd_t3_h_3 + (0.95129275321960449) * gru_2_fwd_t3_h_4 + (-0.046603061258792877) * gru_2_fwd_t3_h_5 + (0.23289823532104492) * gru_2_fwd_t3_h_6 + (-1.5957812070846558) * gru_2_fwd_t3_h_7 + (-0.13413980603218079) * gru_2_fwd_t3_h_8 + (-0.24526296555995941) * gru_2_fwd_t3_h_9 + (0.26972556114196777) * gru_2_fwd_t3_h_10 + (0.50907289981842041) * gru_2_fwd_t3_h_11 + (0.58309745788574219) * gru_2_fwd_t3_h_12 + (2.0538065433502197) * gru_2_fwd_t3_h_13 + (-0.58266818523406982) * gru_2_fwd_t3_h_14 + (0.094663754105567932) * gru_2_fwd_t3_h_15 + (-1.308366060256958) * gru_2_fwd_t3_h_16 + (-1.5770746469497681) * gru_2_fwd_t3_h_17 + (-0.44375655055046082) * gru_2_fwd_t3_h_18 + (-0.071041218936443329) * gru_2_fwd_t3_h_19 + (0.83049923181533813) * gru_2_fwd_t3_h_20 + (-0.33343058824539185) * gru_2_fwd_t3_h_21 + (0.31236156821250916) * gru_2_fwd_t3_h_22 + (0.77989143133163452) * gru_2_fwd_t3_h_23 + (-0.39142554998397827) * gru_2_fwd_t3_h_24 + (-1.3632711172103882) * gru_2_fwd_t3_h_25 + (-1.4450201988220215) * gru_2_fwd_t3_h_26 + (1.5321938991546631) * gru_2_fwd_t3_h_27 + (-0.6582527756690979) * gru_2_fwd_t3_h_28 + (1.1630057096481323) * gru_2_fwd_t3_h_29 + (-0.96424120664596558) * gru_2_fwd_t3_h_30 + (-0.60886543989181519) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((0.96685171127319336) + (0.012206170707941055) * gru_1_out_t4_0 + (-1.7312475442886353) * gru_1_out_t4_1 + (0.66134369373321533) * gru_1_out_t4_2 + (0.83093476295471191) * gru_1_out_t4_3 + (-0.81004118919372559) * gru_1_out_t4_4 + (0.20667769014835358) * gru_1_out_t4_5 + (-0.32482859492301941) * gru_1_out_t4_6 + (0.086760997772216797) * gru_1_out_t4_7 + (0.82007551193237305) * gru_1_out_t4_8 + (-0.27801385521888733) * gru_1_out_t4_9 + (-0.24740634858608246) * gru_1_out_t4_10 + (-0.028964810073375702) * gru_1_out_t4_11 + (0.0013547611888498068) * gru_1_out_t4_12 + (0.45537617802619934) * gru_1_out_t4_13 + (-0.0027167184744030237) * gru_1_out_t4_14 + (-0.8789563775062561) * gru_1_out_t4_15 + (0.51275146007537842) * gru_1_out_t4_16 + (0.5159115195274353) * gru_1_out_t4_17 + (0.16361212730407715) * gru_1_out_t4_18 + (-0.54619032144546509) * gru_1_out_t4_19 + (0.052597768604755402) * gru_1_out_t4_20 + (-0.81271541118621826) * gru_1_out_t4_21 + (1.1113190650939941) * gru_1_out_t4_22 + (1.0679113864898682) * gru_1_out_t4_23 + (-1.2912274599075317) * gru_1_out_t4_24 + (0.09121336042881012) * gru_1_out_t4_25 + (-0.63428980112075806) * gru_1_out_t4_26 + (0.34954008460044861) * gru_1_out_t4_27 + (-0.03144533559679985) * gru_1_out_t4_28 + (0.27489036321640015) * gru_1_out_t4_29 + (-0.015525013208389282) * gru_1_out_t4_30 + (-0.54355871677398682) * gru_1_out_t4_31 + (-0.27052107453346252) * gru_1_out_t4_32 + (0.052014395594596863) * gru_1_out_t4_33 + (-0.31858307123184204) * gru_1_out_t4_34 + (-0.39337372779846191) * gru_1_out_t4_35 + (0.95989447832107544) * gru_1_out_t4_36 + (-0.26006212830543518) * gru_1_out_t4_37 + (0.074188292026519775) * gru_1_out_t4_38 + (0.13213072717189789) * gru_1_out_t4_39 + (-0.27316227555274963) * gru_1_out_t4_40 + (-0.21921087801456451) * gru_1_out_t4_41 + (-0.78826171159744263) * gru_1_out_t4_42 + (-0.077395103871822357) * gru_1_out_t4_43 + (0.38001447916030884) * gru_1_out_t4_44 + (-0.26316031813621521) * gru_1_out_t4_45 + (0.10834713280200958) * gru_1_out_t4_46 + (0.13354608416557312) * gru_1_out_t4_47 + (0.0061753229238092899) * gru_1_out_t4_48 + (-0.95196187496185303) * gru_1_out_t4_49 + (0.23414483666419983) * gru_1_out_t4_50 + (0.94790107011795044) * gru_1_out_t4_51 + (0.225624680519104) * gru_1_out_t4_52 + (0.96818536520004272) * gru_1_out_t4_53 + (-1.7600637674331665) * gru_1_out_t4_54 + (-0.05408448725938797) * gru_1_out_t4_55 + (0.49943855404853821) * gru_1_out_t4_56 + (-0.23487582802772522) * gru_1_out_t4_57 + (0.64191347360610962) * gru_1_out_t4_58 + (0.10321272164583206) * gru_1_out_t4_59 + (0.37663841247558594) * gru_1_out_t4_60 + (0.52203500270843506) * gru_1_out_t4_61 + (0.48036238551139832) * gru_1_out_t4_62 + (0.4523547887802124) * gru_1_out_t4_63 + (-0.27953177690505981) * gru_2_fwd_t3_h_0 + (-0.024252982810139656) * gru_2_fwd_t3_h_1 + (0.20577381551265717) * gru_2_fwd_t3_h_2 + (0.14609898626804352) * gru_2_fwd_t3_h_3 + (-0.91442257165908813) * gru_2_fwd_t3_h_4 + (-0.48775526881217957) * gru_2_fwd_t3_h_5 + (1.1002970933914185) * gru_2_fwd_t3_h_6 + (1.6937891244888306) * gru_2_fwd_t3_h_7 + (0.83799207210540771) * gru_2_fwd_t3_h_8 + (-0.43564099073410034) * gru_2_fwd_t3_h_9 + (0.3485056459903717) * gru_2_fwd_t3_h_10 + (0.71225666999816895) * gru_2_fwd_t3_h_11 + (-0.50229358673095703) * gru_2_fwd_t3_h_12 + (0.42467275261878967) * gru_2_fwd_t3_h_13 + (0.45377600193023682) * gru_2_fwd_t3_h_14 + (-0.20936855673789978) * gru_2_fwd_t3_h_15 + (0.0030628910753875971) * gru_2_fwd_t3_h_16 + (0.48093757033348083) * gru_2_fwd_t3_h_17 + (-0.86397254467010498) * gru_2_fwd_t3_h_18 + (-1.3941292762756348) * gru_2_fwd_t3_h_19 + (-0.55151879787445068) * gru_2_fwd_t3_h_20 + (0.57059425115585327) * gru_2_fwd_t3_h_21 + (-0.18845371901988983) * gru_2_fwd_t3_h_22 + (-0.66368353366851807) * gru_2_fwd_t3_h_23 + (0.22636136412620544) * gru_2_fwd_t3_h_24 + (-0.21248839795589447) * gru_2_fwd_t3_h_25 + (0.35967874526977539) * gru_2_fwd_t3_h_26 + (0.38151472806930542) * gru_2_fwd_t3_h_27 + (-0.13408888876438141) * gru_2_fwd_t3_h_28 + (0.4341454803943634) * gru_2_fwd_t3_h_29 + (0.19996272027492523) * gru_2_fwd_t3_h_30 + (-0.83987909555435181) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.16772949695587158) + (1.0952954292297363) * gru_1_out_t4_0 + (-0.6741948127746582) * gru_1_out_t4_1 + (-1.1881314516067505) * gru_1_out_t4_2 + (-0.71068853139877319) * gru_1_out_t4_3 + (0.02962360717356205) * gru_1_out_t4_4 + (1.2724641561508179) * gru_1_out_t4_5 + (0.018698837608098984) * gru_1_out_t4_6 + (-0.18740774691104889) * gru_1_out_t4_7 + (0.64471220970153809) * gru_1_out_t4_8 + (-0.75354892015457153) * gru_1_out_t4_9 + (1.4643434286117554) * gru_1_out_t4_10 + (-0.50647121667861938) * gru_1_out_t4_11 + (0.63769596815109253) * gru_1_out_t4_12 + (0.65903520584106445) * gru_1_out_t4_13 + (1.2687849998474121) * gru_1_out_t4_14 + (0.36564844846725464) * gru_1_out_t4_15 + (-0.28932645916938782) * gru_1_out_t4_16 + (0.4631996750831604) * gru_1_out_t4_17 + (-0.75679153203964233) * gru_1_out_t4_18 + (-0.40215137600898743) * gru_1_out_t4_19 + (0.60795396566390991) * gru_1_out_t4_20 + (-0.12811829149723053) * gru_1_out_t4_21 + (0.44376468658447266) * gru_1_out_t4_22 + (0.64267253875732422) * gru_1_out_t4_23 + (1.0837119817733765) * gru_1_out_t4_24 + (0.76343041658401489) * gru_1_out_t4_25 + (0.11084635555744171) * gru_1_out_t4_26 + (-1.2510532140731812) * gru_1_out_t4_27 + (0.57588160037994385) * gru_1_out_t4_28 + (0.23647917807102203) * gru_1_out_t4_29 + (-0.24430578947067261) * gru_1_out_t4_30 + (-0.3114495575428009) * gru_1_out_t4_31 + (-0.43070966005325317) * gru_1_out_t4_32 + (0.48690155148506165) * gru_1_out_t4_33 + (-0.13391916453838348) * gru_1_out_t4_34 + (1.5850821733474731) * gru_1_out_t4_35 + (-0.13425683975219727) * gru_1_out_t4_36 + (0.48748385906219482) * gru_1_out_t4_37 + (0.31754869222640991) * gru_1_out_t4_38 + (0.11707057803869247) * gru_1_out_t4_39 + (0.013748683966696262) * gru_1_out_t4_40 + (0.53161734342575073) * gru_1_out_t4_41 + (0.23816487193107605) * gru_1_out_t4_42 + (1.3095252513885498) * gru_1_out_t4_43 + (0.72958159446716309) * gru_1_out_t4_44 + (0.64956575632095337) * gru_1_out_t4_45 + (0.0056460793130099773) * gru_1_out_t4_46 + (0.94144123792648315) * gru_1_out_t4_47 + (0.6393735408782959) * gru_1_out_t4_48 + (0.77151209115982056) * gru_1_out_t4_49 + (0.66855651140213013) * gru_1_out_t4_50 + (0.0080999704077839851) * gru_1_out_t4_51 + (-1.3328602313995361) * gru_1_out_t4_52 + (-0.056517761200666428) * gru_1_out_t4_53 + (-0.31408938765525818) * gru_1_out_t4_54 + (0.12478691339492798) * gru_1_out_t4_55 + (-0.14910398423671722) * gru_1_out_t4_56 + (0.2223050445318222) * gru_1_out_t4_57 + (-0.5043831467628479) * gru_1_out_t4_58 + (-0.06169326975941658) * gru_1_out_t4_59 + (-0.62208932638168335) * gru_1_out_t4_60 + (-0.060615688562393188) * gru_1_out_t4_61 + (-0.22841568291187286) * gru_1_out_t4_62 + (-0.78983438014984131) * gru_1_out_t4_63 + gate_r * ((0.13742536306381226) + (-0.41043013334274292) * gru_2_fwd_t3_h_0 + (-0.32365095615386963) * gru_2_fwd_t3_h_1 + (-1.1935678720474243) * gru_2_fwd_t3_h_2 + (0.89561885595321655) * gru_2_fwd_t3_h_3 + (-0.64356327056884766) * gru_2_fwd_t3_h_4 + (-0.034325506538152695) * gru_2_fwd_t3_h_5 + (-0.59835809469223022) * gru_2_fwd_t3_h_6 + (-0.6275705099105835) * gru_2_fwd_t3_h_7 + (0.58135271072387695) * gru_2_fwd_t3_h_8 + (0.0085036223754286766) * gru_2_fwd_t3_h_9 + (1.2628717422485352) * gru_2_fwd_t3_h_10 + (0.14883576333522797) * gru_2_fwd_t3_h_11 + (0.23020927608013153) * gru_2_fwd_t3_h_12 + (4.1630802154541016) * gru_2_fwd_t3_h_13 + (0.18788938224315643) * gru_2_fwd_t3_h_14 + (0.031193703413009644) * gru_2_fwd_t3_h_15 + (-0.0075277900323271751) * gru_2_fwd_t3_h_16 + (-0.38778135180473328) * gru_2_fwd_t3_h_17 + (0.079115472733974457) * gru_2_fwd_t3_h_18 + (0.39717942476272583) * gru_2_fwd_t3_h_19 + (-0.24732549488544464) * gru_2_fwd_t3_h_20 + (0.86508321762084961) * gru_2_fwd_t3_h_21 + (-0.70095056295394897) * gru_2_fwd_t3_h_22 + (0.4521980881690979) * gru_2_fwd_t3_h_23 + (0.34998223185539246) * gru_2_fwd_t3_h_24 + (0.2105255126953125) * gru_2_fwd_t3_h_25 + (0.12708206474781036) * gru_2_fwd_t3_h_26 + (0.51532614231109619) * gru_2_fwd_t3_h_27 + (-0.68063819408416748) * gru_2_fwd_t3_h_28 + (0.39099329710006714) * gru_2_fwd_t3_h_29 + (0.97692841291427612) * gru_2_fwd_t3_h_30 + (-0.51387345790863037) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_7 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_7;
    // h=8
    gate_r = sigmoid((-0.53908532857894897) + (0.078634321689605713) * gru_1_out_t4_0 + (2.0536425113677979) * gru_1_out_t4_1 + (-0.96540969610214233) * gru_1_out_t4_2 + (0.30416128039360046) * gru_1_out_t4_3 + (0.60399931669235229) * gru_1_out_t4_4 + (0.058909893035888672) * gru_1_out_t4_5 + (2.5095283985137939) * gru_1_out_t4_6 + (-0.042866971343755722) * gru_1_out_t4_7 + (-0.52229130268096924) * gru_1_out_t4_8 + (1.1680225133895874) * gru_1_out_t4_9 + (-0.12274897843599319) * gru_1_out_t4_10 + (-0.36791682243347168) * gru_1_out_t4_11 + (-0.3688347339630127) * gru_1_out_t4_12 + (-1.2192187309265137) * gru_1_out_t4_13 + (0.37666884064674377) * gru_1_out_t4_14 + (-0.94372445344924927) * gru_1_out_t4_15 + (1.1495617628097534) * gru_1_out_t4_16 + (-0.56097263097763062) * gru_1_out_t4_17 + (0.82514744997024536) * gru_1_out_t4_18 + (0.69741863012313843) * gru_1_out_t4_19 + (0.10346744209527969) * gru_1_out_t4_20 + (0.35990425944328308) * gru_1_out_t4_21 + (-2.8436679840087891) * gru_1_out_t4_22 + (0.1426994651556015) * gru_1_out_t4_23 + (-0.54870116710662842) * gru_1_out_t4_24 + (-0.05660228431224823) * gru_1_out_t4_25 + (-0.22061625123023987) * gru_1_out_t4_26 + (0.88734716176986694) * gru_1_out_t4_27 + (0.33472704887390137) * gru_1_out_t4_28 + (-0.25292253494262695) * gru_1_out_t4_29 + (-1.6953027248382568) * gru_1_out_t4_30 + (1.0126359462738037) * gru_1_out_t4_31 + (-0.35613980889320374) * gru_1_out_t4_32 + (-0.89255213737487793) * gru_1_out_t4_33 + (-0.0028074497822672129) * gru_1_out_t4_34 + (0.65458059310913086) * gru_1_out_t4_35 + (0.43885055184364319) * gru_1_out_t4_36 + (0.83492010831832886) * gru_1_out_t4_37 + (-0.29144129157066345) * gru_1_out_t4_38 + (0.16315062344074249) * gru_1_out_t4_39 + (-1.8205474615097046) * gru_1_out_t4_40 + (-0.55876225233078003) * gru_1_out_t4_41 + (-0.83146709203720093) * gru_1_out_t4_42 + (-1.0345338582992554) * gru_1_out_t4_43 + (-1.076459527015686) * gru_1_out_t4_44 + (1.2964736223220825) * gru_1_out_t4_45 + (0.97564423084259033) * gru_1_out_t4_46 + (0.99439311027526855) * gru_1_out_t4_47 + (0.03395390510559082) * gru_1_out_t4_48 + (1.0589445829391479) * gru_1_out_t4_49 + (-0.057525143027305603) * gru_1_out_t4_50 + (-0.3094896674156189) * gru_1_out_t4_51 + (0.067988887429237366) * gru_1_out_t4_52 + (0.28435409069061279) * gru_1_out_t4_53 + (-1.0499585866928101) * gru_1_out_t4_54 + (1.0331951379776001) * gru_1_out_t4_55 + (-0.5763738751411438) * gru_1_out_t4_56 + (0.034764725714921951) * gru_1_out_t4_57 + (-0.25446009635925293) * gru_1_out_t4_58 + (0.15532650053501129) * gru_1_out_t4_59 + (-0.92661362886428833) * gru_1_out_t4_60 + (-0.15858826041221619) * gru_1_out_t4_61 + (2.2558729648590088) * gru_1_out_t4_62 + (-0.23864836990833282) * gru_1_out_t4_63 + (0.026940513402223587) * gru_2_fwd_t3_h_0 + (0.48038491606712341) * gru_2_fwd_t3_h_1 + (1.3037749528884888) * gru_2_fwd_t3_h_2 + (0.60068219900131226) * gru_2_fwd_t3_h_3 + (0.69249862432479858) * gru_2_fwd_t3_h_4 + (0.35417404770851135) * gru_2_fwd_t3_h_5 + (-0.55391764640808105) * gru_2_fwd_t3_h_6 + (-0.79377347230911255) * gru_2_fwd_t3_h_7 + (-0.36381715536117554) * gru_2_fwd_t3_h_8 + (0.21685345470905304) * gru_2_fwd_t3_h_9 + (-1.7822444438934326) * gru_2_fwd_t3_h_10 + (3.2312009334564209) * gru_2_fwd_t3_h_11 + (0.19899922609329224) * gru_2_fwd_t3_h_12 + (4.3420448303222656) * gru_2_fwd_t3_h_13 + (1.4492648839950562) * gru_2_fwd_t3_h_14 + (-0.015937289223074913) * gru_2_fwd_t3_h_15 + (-0.47715145349502563) * gru_2_fwd_t3_h_16 + (-0.30698463320732117) * gru_2_fwd_t3_h_17 + (-0.66810643672943115) * gru_2_fwd_t3_h_18 + (0.79098993539810181) * gru_2_fwd_t3_h_19 + (0.28947868943214417) * gru_2_fwd_t3_h_20 + (0.46036538481712341) * gru_2_fwd_t3_h_21 + (-0.31114134192466736) * gru_2_fwd_t3_h_22 + (0.30292788147926331) * gru_2_fwd_t3_h_23 + (-0.65777057409286499) * gru_2_fwd_t3_h_24 + (0.97353672981262207) * gru_2_fwd_t3_h_25 + (0.11348570883274078) * gru_2_fwd_t3_h_26 + (-3.1759755611419678) * gru_2_fwd_t3_h_27 + (-0.39714321494102478) * gru_2_fwd_t3_h_28 + (0.0018704475369304419) * gru_2_fwd_t3_h_29 + (-0.23719868063926697) * gru_2_fwd_t3_h_30 + (0.19225315749645233) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((0.30447965860366821) + (0.19288501143455505) * gru_1_out_t4_0 + (0.16414806246757507) * gru_1_out_t4_1 + (-0.30927088856697083) * gru_1_out_t4_2 + (0.085337221622467041) * gru_1_out_t4_3 + (-0.10658828914165497) * gru_1_out_t4_4 + (-0.49309277534484863) * gru_1_out_t4_5 + (0.16548995673656464) * gru_1_out_t4_6 + (0.27559152245521545) * gru_1_out_t4_7 + (0.27526000142097473) * gru_1_out_t4_8 + (0.24473078548908234) * gru_1_out_t4_9 + (0.099203504621982574) * gru_1_out_t4_10 + (1.2784748077392578) * gru_1_out_t4_11 + (1.2376636266708374) * gru_1_out_t4_12 + (-0.024852164089679718) * gru_1_out_t4_13 + (0.49689561128616333) * gru_1_out_t4_14 + (0.36183759570121765) * gru_1_out_t4_15 + (-0.3678620457649231) * gru_1_out_t4_16 + (-0.49078550934791565) * gru_1_out_t4_17 + (0.90503126382827759) * gru_1_out_t4_18 + (-0.044006705284118652) * gru_1_out_t4_19 + (-0.55865907669067383) * gru_1_out_t4_20 + (-0.27482780814170837) * gru_1_out_t4_21 + (-0.14106933772563934) * gru_1_out_t4_22 + (-0.042704034596681595) * gru_1_out_t4_23 + (0.10288488119840622) * gru_1_out_t4_24 + (0.66289716958999634) * gru_1_out_t4_25 + (0.28080996870994568) * gru_1_out_t4_26 + (-0.55461633205413818) * gru_1_out_t4_27 + (0.55825525522232056) * gru_1_out_t4_28 + (0.0084897512570023537) * gru_1_out_t4_29 + (-0.98858010768890381) * gru_1_out_t4_30 + (0.029864830896258354) * gru_1_out_t4_31 + (0.69501322507858276) * gru_1_out_t4_32 + (0.10555534064769745) * gru_1_out_t4_33 + (0.09830956906080246) * gru_1_out_t4_34 + (0.35971704125404358) * gru_1_out_t4_35 + (0.37289887666702271) * gru_1_out_t4_36 + (-0.47766527533531189) * gru_1_out_t4_37 + (-0.063151910901069641) * gru_1_out_t4_38 + (-0.92066001892089844) * gru_1_out_t4_39 + (-0.6994621753692627) * gru_1_out_t4_40 + (-0.10258133709430695) * gru_1_out_t4_41 + (-0.54435199499130249) * gru_1_out_t4_42 + (-0.22806635499000549) * gru_1_out_t4_43 + (0.15118521451950073) * gru_1_out_t4_44 + (0.66831475496292114) * gru_1_out_t4_45 + (-0.20658956468105316) * gru_1_out_t4_46 + (-0.099997662007808685) * gru_1_out_t4_47 + (1.0328670740127563) * gru_1_out_t4_48 + (-0.048194747418165207) * gru_1_out_t4_49 + (-0.63098102807998657) * gru_1_out_t4_50 + (-0.45617866516113281) * gru_1_out_t4_51 + (-0.70968443155288696) * gru_1_out_t4_52 + (-0.35214874148368835) * gru_1_out_t4_53 + (0.36654022336006165) * gru_1_out_t4_54 + (0.060495857149362564) * gru_1_out_t4_55 + (-1.1463649272918701) * gru_1_out_t4_56 + (-0.42861640453338623) * gru_1_out_t4_57 + (-0.071352899074554443) * gru_1_out_t4_58 + (0.56755810976028442) * gru_1_out_t4_59 + (1.0881471633911133) * gru_1_out_t4_60 + (-0.40841835737228394) * gru_1_out_t4_61 + (-0.11229383200407028) * gru_1_out_t4_62 + (0.06819094717502594) * gru_1_out_t4_63 + (0.54892069101333618) * gru_2_fwd_t3_h_0 + (-0.0062309917993843555) * gru_2_fwd_t3_h_1 + (-0.55433082580566406) * gru_2_fwd_t3_h_2 + (-0.33209818601608276) * gru_2_fwd_t3_h_3 + (0.25197738409042358) * gru_2_fwd_t3_h_4 + (-0.41096436977386475) * gru_2_fwd_t3_h_5 + (0.25982311367988586) * gru_2_fwd_t3_h_6 + (0.30003294348716736) * gru_2_fwd_t3_h_7 + (1.0593330860137939) * gru_2_fwd_t3_h_8 + (0.43745589256286621) * gru_2_fwd_t3_h_9 + (-1.053313136100769) * gru_2_fwd_t3_h_10 + (2.439054012298584) * gru_2_fwd_t3_h_11 + (-0.19574570655822754) * gru_2_fwd_t3_h_12 + (0.59348911046981812) * gru_2_fwd_t3_h_13 + (1.1484494209289551) * gru_2_fwd_t3_h_14 + (-0.066194474697113037) * gru_2_fwd_t3_h_15 + (-0.31473055481910706) * gru_2_fwd_t3_h_16 + (0.71727514266967773) * gru_2_fwd_t3_h_17 + (0.19533790647983551) * gru_2_fwd_t3_h_18 + (-2.7131092548370361) * gru_2_fwd_t3_h_19 + (-0.65930771827697754) * gru_2_fwd_t3_h_20 + (-0.21705372631549835) * gru_2_fwd_t3_h_21 + (-0.18876014649868011) * gru_2_fwd_t3_h_22 + (-0.55763202905654907) * gru_2_fwd_t3_h_23 + (-0.50002330541610718) * gru_2_fwd_t3_h_24 + (-0.97957837581634521) * gru_2_fwd_t3_h_25 + (-1.552807092666626) * gru_2_fwd_t3_h_26 + (-0.35977619886398315) * gru_2_fwd_t3_h_27 + (-0.13988907635211945) * gru_2_fwd_t3_h_28 + (-0.087988585233688354) * gru_2_fwd_t3_h_29 + (-0.1538427472114563) * gru_2_fwd_t3_h_30 + (-0.074332326650619507) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.055655688047409058) + (-0.016797928139567375) * gru_1_out_t4_0 + (-0.075077153742313385) * gru_1_out_t4_1 + (0.40730956196784973) * gru_1_out_t4_2 + (-1.0813908576965332) * gru_1_out_t4_3 + (0.51369673013687134) * gru_1_out_t4_4 + (-0.38735407590866089) * gru_1_out_t4_5 + (0.32982203364372253) * gru_1_out_t4_6 + (0.15628142654895782) * gru_1_out_t4_7 + (-0.12502457201480865) * gru_1_out_t4_8 + (0.27023062109947205) * gru_1_out_t4_9 + (-0.03850395604968071) * gru_1_out_t4_10 + (0.10016777366399765) * gru_1_out_t4_11 + (-0.9997870922088623) * gru_1_out_t4_12 + (0.041368529200553894) * gru_1_out_t4_13 + (0.090797379612922668) * gru_1_out_t4_14 + (-0.48800671100616455) * gru_1_out_t4_15 + (-0.15780968964099884) * gru_1_out_t4_16 + (-0.19997213780879974) * gru_1_out_t4_17 + (-0.37419059872627258) * gru_1_out_t4_18 + (0.25626039505004883) * gru_1_out_t4_19 + (0.24937050044536591) * gru_1_out_t4_20 + (-0.0050323675386607647) * gru_1_out_t4_21 + (0.087856695055961609) * gru_1_out_t4_22 + (-0.11046905070543289) * gru_1_out_t4_23 + (-0.36441168189048767) * gru_1_out_t4_24 + (-0.1878090500831604) * gru_1_out_t4_25 + (0.099239043891429901) * gru_1_out_t4_26 + (0.073255211114883423) * gru_1_out_t4_27 + (-0.027451835572719574) * gru_1_out_t4_28 + (0.14343157410621643) * gru_1_out_t4_29 + (0.045601692050695419) * gru_1_out_t4_30 + (0.11708865314722061) * gru_1_out_t4_31 + (0.13609884679317474) * gru_1_out_t4_32 + (-0.25147533416748047) * gru_1_out_t4_33 + (0.30359148979187012) * gru_1_out_t4_34 + (-0.19323043525218964) * gru_1_out_t4_35 + (0.32059803605079651) * gru_1_out_t4_36 + (0.25422936677932739) * gru_1_out_t4_37 + (-0.18780280649662018) * gru_1_out_t4_38 + (0.65962326526641846) * gru_1_out_t4_39 + (-0.2968585193157196) * gru_1_out_t4_40 + (0.11966401338577271) * gru_1_out_t4_41 + (0.44959843158721924) * gru_1_out_t4_42 + (-0.14553603529930115) * gru_1_out_t4_43 + (-0.2625100314617157) * gru_1_out_t4_44 + (0.09806554764509201) * gru_1_out_t4_45 + (-0.269957035779953) * gru_1_out_t4_46 + (0.057726453989744186) * gru_1_out_t4_47 + (-0.19046621024608612) * gru_1_out_t4_48 + (0.37847214937210083) * gru_1_out_t4_49 + (-0.065119437873363495) * gru_1_out_t4_50 + (-0.61015766859054565) * gru_1_out_t4_51 + (0.50586223602294922) * gru_1_out_t4_52 + (0.082689382135868073) * gru_1_out_t4_53 + (0.11679784953594208) * gru_1_out_t4_54 + (0.20894849300384521) * gru_1_out_t4_55 + (-0.2432241290807724) * gru_1_out_t4_56 + (-0.24553763866424561) * gru_1_out_t4_57 + (0.37193861603736877) * gru_1_out_t4_58 + (0.023829592391848564) * gru_1_out_t4_59 + (-0.39855670928955078) * gru_1_out_t4_60 + (-0.039706315845251083) * gru_1_out_t4_61 + (0.50039315223693848) * gru_1_out_t4_62 + (0.044628221541643143) * gru_1_out_t4_63 + gate_r * ((-0.39641654491424561) + (0.13409538567066193) * gru_2_fwd_t3_h_0 + (-0.45862782001495361) * gru_2_fwd_t3_h_1 + (2.4458363056182861) * gru_2_fwd_t3_h_2 + (-1.1664884090423584) * gru_2_fwd_t3_h_3 + (0.37481012940406799) * gru_2_fwd_t3_h_4 + (0.070471704006195068) * gru_2_fwd_t3_h_5 + (-0.32100805640220642) * gru_2_fwd_t3_h_6 + (0.073784589767456055) * gru_2_fwd_t3_h_7 + (0.28433564305305481) * gru_2_fwd_t3_h_8 + (-0.34056639671325684) * gru_2_fwd_t3_h_9 + (-1.2986631393432617) * gru_2_fwd_t3_h_10 + (0.20066709816455841) * gru_2_fwd_t3_h_11 + (0.6318124532699585) * gru_2_fwd_t3_h_12 + (2.4232447147369385) * gru_2_fwd_t3_h_13 + (-1.1887780427932739) * gru_2_fwd_t3_h_14 + (-1.6228204965591431) * gru_2_fwd_t3_h_15 + (-0.43651002645492554) * gru_2_fwd_t3_h_16 + (0.10820045322179794) * gru_2_fwd_t3_h_17 + (0.37112051248550415) * gru_2_fwd_t3_h_18 + (-0.69149720668792725) * gru_2_fwd_t3_h_19 + (-0.91038805246353149) * gru_2_fwd_t3_h_20 + (0.58379346132278442) * gru_2_fwd_t3_h_21 + (0.43363875150680542) * gru_2_fwd_t3_h_22 + (-0.050965584814548492) * gru_2_fwd_t3_h_23 + (-0.45891869068145752) * gru_2_fwd_t3_h_24 + (-0.24337072670459747) * gru_2_fwd_t3_h_25 + (0.41685757040977478) * gru_2_fwd_t3_h_26 + (-0.069033816456794739) * gru_2_fwd_t3_h_27 + (-0.410971999168396) * gru_2_fwd_t3_h_28 + (0.23015139997005463) * gru_2_fwd_t3_h_29 + (-0.50702732801437378) * gru_2_fwd_t3_h_30 + (0.0064546638168394566) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_8 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_8;
    // h=9
    gate_r = sigmoid((0.014598826877772808) + (-0.46345117688179016) * gru_1_out_t4_0 + (-0.48719778656959534) * gru_1_out_t4_1 + (-1.0049848556518555) * gru_1_out_t4_2 + (-0.099054776132106781) * gru_1_out_t4_3 + (0.14393486082553864) * gru_1_out_t4_4 + (-0.21178200840950012) * gru_1_out_t4_5 + (-0.31770572066307068) * gru_1_out_t4_6 + (-0.37354984879493713) * gru_1_out_t4_7 + (0.68031573295593262) * gru_1_out_t4_8 + (0.51085525751113892) * gru_1_out_t4_9 + (-0.32035186886787415) * gru_1_out_t4_10 + (0.24460971355438232) * gru_1_out_t4_11 + (0.28930282592773438) * gru_1_out_t4_12 + (1.0542950630187988) * gru_1_out_t4_13 + (-0.48809534311294556) * gru_1_out_t4_14 + (0.37523487210273743) * gru_1_out_t4_15 + (0.59806299209594727) * gru_1_out_t4_16 + (-0.79957163333892822) * gru_1_out_t4_17 + (-1.8025393486022949) * gru_1_out_t4_18 + (-1.147591233253479) * gru_1_out_t4_19 + (-1.6719909906387329) * gru_1_out_t4_20 + (0.30019605159759521) * gru_1_out_t4_21 + (0.017319349572062492) * gru_1_out_t4_22 + (-0.041806060820817947) * gru_1_out_t4_23 + (0.40679079294204712) * gru_1_out_t4_24 + (1.1455427408218384) * gru_1_out_t4_25 + (-0.13862590491771698) * gru_1_out_t4_26 + (0.053010284900665283) * gru_1_out_t4_27 + (0.87356585264205933) * gru_1_out_t4_28 + (-0.37017935514450073) * gru_1_out_t4_29 + (-0.65110969543457031) * gru_1_out_t4_30 + (-0.5382312536239624) * gru_1_out_t4_31 + (1.3739076852798462) * gru_1_out_t4_32 + (0.56226533651351929) * gru_1_out_t4_33 + (-1.1075671911239624) * gru_1_out_t4_34 + (-0.55554085969924927) * gru_1_out_t4_35 + (-2.491192102432251) * gru_1_out_t4_36 + (1.1740829944610596) * gru_1_out_t4_37 + (0.13902252912521362) * gru_1_out_t4_38 + (-0.20352411270141602) * gru_1_out_t4_39 + (0.5467524528503418) * gru_1_out_t4_40 + (-0.23037214577198029) * gru_1_out_t4_41 + (0.97516632080078125) * gru_1_out_t4_42 + (0.92362809181213379) * gru_1_out_t4_43 + (-0.023969637230038643) * gru_1_out_t4_44 + (-0.80143368244171143) * gru_1_out_t4_45 + (0.28786575794219971) * gru_1_out_t4_46 + (1.6128722429275513) * gru_1_out_t4_47 + (1.4692742824554443) * gru_1_out_t4_48 + (0.20076000690460205) * gru_1_out_t4_49 + (-0.24042515456676483) * gru_1_out_t4_50 + (0.21900592744350433) * gru_1_out_t4_51 + (-1.0475177764892578) * gru_1_out_t4_52 + (-0.41773787140846252) * gru_1_out_t4_53 + (-1.1150989532470703) * gru_1_out_t4_54 + (0.53581899404525757) * gru_1_out_t4_55 + (0.40333741903305054) * gru_1_out_t4_56 + (-0.52914345264434814) * gru_1_out_t4_57 + (-0.052777830511331558) * gru_1_out_t4_58 + (0.07998320460319519) * gru_1_out_t4_59 + (0.71382761001586914) * gru_1_out_t4_60 + (0.5724366307258606) * gru_1_out_t4_61 + (1.8979524374008179) * gru_1_out_t4_62 + (-0.080285154283046722) * gru_1_out_t4_63 + (-0.32885783910751343) * gru_2_fwd_t3_h_0 + (0.4767228364944458) * gru_2_fwd_t3_h_1 + (-0.11488062143325806) * gru_2_fwd_t3_h_2 + (0.10639192163944244) * gru_2_fwd_t3_h_3 + (-0.53675943613052368) * gru_2_fwd_t3_h_4 + (0.097016379237174988) * gru_2_fwd_t3_h_5 + (-0.79733777046203613) * gru_2_fwd_t3_h_6 + (0.32256665825843811) * gru_2_fwd_t3_h_7 + (0.50662022829055786) * gru_2_fwd_t3_h_8 + (-1.4611529111862183) * gru_2_fwd_t3_h_9 + (0.36891168355941772) * gru_2_fwd_t3_h_10 + (3.2101454734802246) * gru_2_fwd_t3_h_11 + (0.68537330627441406) * gru_2_fwd_t3_h_12 + (0.78319895267486572) * gru_2_fwd_t3_h_13 + (-2.1572709083557129) * gru_2_fwd_t3_h_14 + (-1.9544417858123779) * gru_2_fwd_t3_h_15 + (0.49347132444381714) * gru_2_fwd_t3_h_16 + (-0.45447024703025818) * gru_2_fwd_t3_h_17 + (0.90255618095397949) * gru_2_fwd_t3_h_18 + (-0.92867517471313477) * gru_2_fwd_t3_h_19 + (-0.35590499639511108) * gru_2_fwd_t3_h_20 + (0.59487617015838623) * gru_2_fwd_t3_h_21 + (0.36751475930213928) * gru_2_fwd_t3_h_22 + (-0.75873911380767822) * gru_2_fwd_t3_h_23 + (0.14063543081283569) * gru_2_fwd_t3_h_24 + (-0.79192715883255005) * gru_2_fwd_t3_h_25 + (-2.3724424839019775) * gru_2_fwd_t3_h_26 + (0.10531227290630341) * gru_2_fwd_t3_h_27 + (-0.29738086462020874) * gru_2_fwd_t3_h_28 + (-2.0685296058654785) * gru_2_fwd_t3_h_29 + (-0.43606916069984436) * gru_2_fwd_t3_h_30 + (0.99226963520050049) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.34925282001495361) + (0.21860124170780182) * gru_1_out_t4_0 + (-1.2750535011291504) * gru_1_out_t4_1 + (0.48629972338676453) * gru_1_out_t4_2 + (1.1838271617889404) * gru_1_out_t4_3 + (1.0813385248184204) * gru_1_out_t4_4 + (-0.048997972160577774) * gru_1_out_t4_5 + (0.14296154677867889) * gru_1_out_t4_6 + (0.56945502758026123) * gru_1_out_t4_7 + (-0.38403001427650452) * gru_1_out_t4_8 + (-0.0064780316315591335) * gru_1_out_t4_9 + (-1.2874466180801392) * gru_1_out_t4_10 + (-0.9462820291519165) * gru_1_out_t4_11 + (0.11361563950777054) * gru_1_out_t4_12 + (-0.78455573320388794) * gru_1_out_t4_13 + (-0.5625959038734436) * gru_1_out_t4_14 + (0.42606377601623535) * gru_1_out_t4_15 + (-0.40487810969352722) * gru_1_out_t4_16 + (-0.35480734705924988) * gru_1_out_t4_17 + (-1.1558396816253662) * gru_1_out_t4_18 + (-0.28579071164131165) * gru_1_out_t4_19 + (0.24619176983833313) * gru_1_out_t4_20 + (0.8626895546913147) * gru_1_out_t4_21 + (-0.91276955604553223) * gru_1_out_t4_22 + (1.1313618421554565) * gru_1_out_t4_23 + (1.3128281831741333) * gru_1_out_t4_24 + (0.011046985164284706) * gru_1_out_t4_25 + (0.48031297326087952) * gru_1_out_t4_26 + (0.44386860728263855) * gru_1_out_t4_27 + (-1.8145660161972046) * gru_1_out_t4_28 + (-0.93205726146697998) * gru_1_out_t4_29 + (1.4230136871337891) * gru_1_out_t4_30 + (-0.39190006256103516) * gru_1_out_t4_31 + (1.905376672744751) * gru_1_out_t4_32 + (-0.12040308117866516) * gru_1_out_t4_33 + (-0.69080924987792969) * gru_1_out_t4_34 + (-0.32722079753875732) * gru_1_out_t4_35 + (-0.51767683029174805) * gru_1_out_t4_36 + (-0.79373836517333984) * gru_1_out_t4_37 + (0.16315026581287384) * gru_1_out_t4_38 + (-1.0651921033859253) * gru_1_out_t4_39 + (0.15370947122573853) * gru_1_out_t4_40 + (0.35539710521697998) * gru_1_out_t4_41 + (0.20755097270011902) * gru_1_out_t4_42 + (0.030037375167012215) * gru_1_out_t4_43 + (-0.27422261238098145) * gru_1_out_t4_44 + (1.5664864778518677) * gru_1_out_t4_45 + (-0.54654353857040405) * gru_1_out_t4_46 + (1.3033120632171631) * gru_1_out_t4_47 + (-0.11546861380338669) * gru_1_out_t4_48 + (0.60384708642959595) * gru_1_out_t4_49 + (0.13742566108703613) * gru_1_out_t4_50 + (0.4729074239730835) * gru_1_out_t4_51 + (-1.3827089071273804) * gru_1_out_t4_52 + (-0.64250373840332031) * gru_1_out_t4_53 + (0.61232507228851318) * gru_1_out_t4_54 + (-1.3600777387619019) * gru_1_out_t4_55 + (-0.59187108278274536) * gru_1_out_t4_56 + (0.46893236041069031) * gru_1_out_t4_57 + (-0.13582022488117218) * gru_1_out_t4_58 + (0.89733457565307617) * gru_1_out_t4_59 + (-0.01153002493083477) * gru_1_out_t4_60 + (-0.60632634162902832) * gru_1_out_t4_61 + (-1.6640650033950806) * gru_1_out_t4_62 + (-0.32998523116111755) * gru_1_out_t4_63 + (-0.80792641639709473) * gru_2_fwd_t3_h_0 + (-0.50263535976409912) * gru_2_fwd_t3_h_1 + (-0.42517659068107605) * gru_2_fwd_t3_h_2 + (-0.15159732103347778) * gru_2_fwd_t3_h_3 + (-0.57034993171691895) * gru_2_fwd_t3_h_4 + (-0.19742691516876221) * gru_2_fwd_t3_h_5 + (1.124237060546875) * gru_2_fwd_t3_h_6 + (-0.75730776786804199) * gru_2_fwd_t3_h_7 + (0.57868754863739014) * gru_2_fwd_t3_h_8 + (0.18188531696796417) * gru_2_fwd_t3_h_9 + (-0.54775822162628174) * gru_2_fwd_t3_h_10 + (-1.9113316535949707) * gru_2_fwd_t3_h_11 + (0.59199994802474976) * gru_2_fwd_t3_h_12 + (1.4188146591186523) * gru_2_fwd_t3_h_13 + (-1.8044781684875488) * gru_2_fwd_t3_h_14 + (-0.47517472505569458) * gru_2_fwd_t3_h_15 + (-0.17698931694030762) * gru_2_fwd_t3_h_16 + (0.42321637272834778) * gru_2_fwd_t3_h_17 + (-0.037012536078691483) * gru_2_fwd_t3_h_18 + (0.17175258696079254) * gru_2_fwd_t3_h_19 + (-0.16989581286907196) * gru_2_fwd_t3_h_20 + (0.10872245579957962) * gru_2_fwd_t3_h_21 + (-0.11142736673355103) * gru_2_fwd_t3_h_22 + (0.13761278986930847) * gru_2_fwd_t3_h_23 + (-0.1562000960111618) * gru_2_fwd_t3_h_24 + (0.66642320156097412) * gru_2_fwd_t3_h_25 + (3.4163589477539062) * gru_2_fwd_t3_h_26 + (0.33075064420700073) * gru_2_fwd_t3_h_27 + (0.68855172395706177) * gru_2_fwd_t3_h_28 + (0.24657255411148071) * gru_2_fwd_t3_h_29 + (0.3893875777721405) * gru_2_fwd_t3_h_30 + (-0.082849413156509399) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.80344879627227783) + (-0.64380866289138794) * gru_1_out_t4_0 + (0.11013287305831909) * gru_1_out_t4_1 + (0.26833003759384155) * gru_1_out_t4_2 + (0.32167172431945801) * gru_1_out_t4_3 + (0.35860463976860046) * gru_1_out_t4_4 + (-0.055242553353309631) * gru_1_out_t4_5 + (0.21447136998176575) * gru_1_out_t4_6 + (-0.30164352059364319) * gru_1_out_t4_7 + (-0.46121618151664734) * gru_1_out_t4_8 + (0.28518933057785034) * gru_1_out_t4_9 + (0.44683313369750977) * gru_1_out_t4_10 + (-0.18195399641990662) * gru_1_out_t4_11 + (-0.17171569168567657) * gru_1_out_t4_12 + (0.39640405774116516) * gru_1_out_t4_13 + (0.092429131269454956) * gru_1_out_t4_14 + (-0.15170484781265259) * gru_1_out_t4_15 + (-0.23539412021636963) * gru_1_out_t4_16 + (0.55429273843765259) * gru_1_out_t4_17 + (-0.1483212411403656) * gru_1_out_t4_18 + (0.45779016613960266) * gru_1_out_t4_19 + (-0.27864551544189453) * gru_1_out_t4_20 + (0.33824288845062256) * gru_1_out_t4_21 + (0.11755144596099854) * gru_1_out_t4_22 + (1.0912950038909912) * gru_1_out_t4_23 + (-0.22760289907455444) * gru_1_out_t4_24 + (-0.32826676964759827) * gru_1_out_t4_25 + (0.63522970676422119) * gru_1_out_t4_26 + (1.0378645658493042) * gru_1_out_t4_27 + (0.13981203734874725) * gru_1_out_t4_28 + (0.1481294184923172) * gru_1_out_t4_29 + (0.040944594889879227) * gru_1_out_t4_30 + (-0.89607501029968262) * gru_1_out_t4_31 + (0.019776660948991776) * gru_1_out_t4_32 + (0.036020226776599884) * gru_1_out_t4_33 + (0.33428165316581726) * gru_1_out_t4_34 + (0.23375742137432098) * gru_1_out_t4_35 + (0.050345737487077713) * gru_1_out_t4_36 + (-0.37424233555793762) * gru_1_out_t4_37 + (0.24384459853172302) * gru_1_out_t4_38 + (-0.57826662063598633) * gru_1_out_t4_39 + (-0.49773132801055908) * gru_1_out_t4_40 + (-0.0046318983659148216) * gru_1_out_t4_41 + (-0.42140865325927734) * gru_1_out_t4_42 + (0.16592682898044586) * gru_1_out_t4_43 + (0.78766995668411255) * gru_1_out_t4_44 + (0.33680889010429382) * gru_1_out_t4_45 + (0.11337278783321381) * gru_1_out_t4_46 + (0.83117175102233887) * gru_1_out_t4_47 + (0.84275215864181519) * gru_1_out_t4_48 + (-1.3008768558502197) * gru_1_out_t4_49 + (1.1068893671035767) * gru_1_out_t4_50 + (0.19907830655574799) * gru_1_out_t4_51 + (-1.1841285228729248) * gru_1_out_t4_52 + (-0.39561006426811218) * gru_1_out_t4_53 + (-0.068834610283374786) * gru_1_out_t4_54 + (-0.22703126072883606) * gru_1_out_t4_55 + (-0.16854365170001984) * gru_1_out_t4_56 + (-0.66313433647155762) * gru_1_out_t4_57 + (-0.65600341558456421) * gru_1_out_t4_58 + (0.40982499718666077) * gru_1_out_t4_59 + (0.33726418018341064) * gru_1_out_t4_60 + (0.41010606288909912) * gru_1_out_t4_61 + (-0.16902558505535126) * gru_1_out_t4_62 + (-0.32097172737121582) * gru_1_out_t4_63 + gate_r * ((-0.62511301040649414) + (-0.027013102546334267) * gru_2_fwd_t3_h_0 + (0.072364933788776398) * gru_2_fwd_t3_h_1 + (0.29475697875022888) * gru_2_fwd_t3_h_2 + (0.57644504308700562) * gru_2_fwd_t3_h_3 + (-0.29929545521736145) * gru_2_fwd_t3_h_4 + (0.036553192883729935) * gru_2_fwd_t3_h_5 + (0.21080932021141052) * gru_2_fwd_t3_h_6 + (-0.63242095708847046) * gru_2_fwd_t3_h_7 + (-0.44630146026611328) * gru_2_fwd_t3_h_8 + (0.030416790395975113) * gru_2_fwd_t3_h_9 + (0.25083568692207336) * gru_2_fwd_t3_h_10 + (-0.007373463362455368) * gru_2_fwd_t3_h_11 + (1.0482891798019409) * gru_2_fwd_t3_h_12 + (2.6967511177062988) * gru_2_fwd_t3_h_13 + (-0.56389284133911133) * gru_2_fwd_t3_h_14 + (-0.50378584861755371) * gru_2_fwd_t3_h_15 + (-0.5850256085395813) * gru_2_fwd_t3_h_16 + (0.43875250220298767) * gru_2_fwd_t3_h_17 + (0.031168919056653976) * gru_2_fwd_t3_h_18 + (-0.063511274755001068) * gru_2_fwd_t3_h_19 + (-0.25883495807647705) * gru_2_fwd_t3_h_20 + (0.26889955997467041) * gru_2_fwd_t3_h_21 + (-1.7675076723098755) * gru_2_fwd_t3_h_22 + (0.81441342830657959) * gru_2_fwd_t3_h_23 + (1.4383318424224854) * gru_2_fwd_t3_h_24 + (0.38511034846305847) * gru_2_fwd_t3_h_25 + (0.93050110340118408) * gru_2_fwd_t3_h_26 + (0.49478286504745483) * gru_2_fwd_t3_h_27 + (0.11611290276050568) * gru_2_fwd_t3_h_28 + (-0.79772394895553589) * gru_2_fwd_t3_h_29 + (-0.30018484592437744) * gru_2_fwd_t3_h_30 + (-0.14054755866527557) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_9 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_9;
    // h=10
    gate_r = sigmoid((0.44536903500556946) + (-0.15248978137969971) * gru_1_out_t4_0 + (0.92094850540161133) * gru_1_out_t4_1 + (-0.98063910007476807) * gru_1_out_t4_2 + (0.5776253342628479) * gru_1_out_t4_3 + (-1.3961191177368164) * gru_1_out_t4_4 + (-0.24139736592769623) * gru_1_out_t4_5 + (-0.63182979822158813) * gru_1_out_t4_6 + (-0.35972502827644348) * gru_1_out_t4_7 + (-0.4462527334690094) * gru_1_out_t4_8 + (-0.34732300043106079) * gru_1_out_t4_9 + (-0.21891233325004578) * gru_1_out_t4_10 + (-1.2111337184906006) * gru_1_out_t4_11 + (0.31912559270858765) * gru_1_out_t4_12 + (0.93710601329803467) * gru_1_out_t4_13 + (0.18243077397346497) * gru_1_out_t4_14 + (1.1565296649932861) * gru_1_out_t4_15 + (0.15809237957000732) * gru_1_out_t4_16 + (0.6617431640625) * gru_1_out_t4_17 + (0.17017355561256409) * gru_1_out_t4_18 + (-0.27918380498886108) * gru_1_out_t4_19 + (0.12361466884613037) * gru_1_out_t4_20 + (-0.48508039116859436) * gru_1_out_t4_21 + (1.208611011505127) * gru_1_out_t4_22 + (-0.54648900032043457) * gru_1_out_t4_23 + (-1.1438624858856201) * gru_1_out_t4_24 + (0.54043018817901611) * gru_1_out_t4_25 + (-0.78726708889007568) * gru_1_out_t4_26 + (-1.315508246421814) * gru_1_out_t4_27 + (0.60852181911468506) * gru_1_out_t4_28 + (0.040603779256343842) * gru_1_out_t4_29 + (-2.5212314128875732) * gru_1_out_t4_30 + (-0.97399181127548218) * gru_1_out_t4_31 + (0.95968502759933472) * gru_1_out_t4_32 + (0.3698577880859375) * gru_1_out_t4_33 + (-0.86713564395904541) * gru_1_out_t4_34 + (0.89397609233856201) * gru_1_out_t4_35 + (-0.34393507242202759) * gru_1_out_t4_36 + (-0.34098154306411743) * gru_1_out_t4_37 + (-0.47595596313476562) * gru_1_out_t4_38 + (-0.0019806693308055401) * gru_1_out_t4_39 + (0.21634963154792786) * gru_1_out_t4_40 + (1.1169687509536743) * gru_1_out_t4_41 + (0.63790333271026611) * gru_1_out_t4_42 + (1.546076774597168) * gru_1_out_t4_43 + (-0.11709080636501312) * gru_1_out_t4_44 + (0.34887036681175232) * gru_1_out_t4_45 + (-0.92307180166244507) * gru_1_out_t4_46 + (0.73388785123825073) * gru_1_out_t4_47 + (0.35861092805862427) * gru_1_out_t4_48 + (-0.39312419295310974) * gru_1_out_t4_49 + (-1.677613377571106) * gru_1_out_t4_50 + (-1.0073592662811279) * gru_1_out_t4_51 + (-0.80260628461837769) * gru_1_out_t4_52 + (-0.14163786172866821) * gru_1_out_t4_53 + (-0.22179156541824341) * gru_1_out_t4_54 + (-0.41148746013641357) * gru_1_out_t4_55 + (-0.79305785894393921) * gru_1_out_t4_56 + (1.0043095350265503) * gru_1_out_t4_57 + (-0.23402369022369385) * gru_1_out_t4_58 + (-0.79154568910598755) * gru_1_out_t4_59 + (-1.0322027206420898) * gru_1_out_t4_60 + (-1.4576647281646729) * gru_1_out_t4_61 + (0.21463465690612793) * gru_1_out_t4_62 + (-0.36339756846427917) * gru_1_out_t4_63 + (-0.29095810651779175) * gru_2_fwd_t3_h_0 + (0.68193626403808594) * gru_2_fwd_t3_h_1 + (0.20276749134063721) * gru_2_fwd_t3_h_2 + (0.91661059856414795) * gru_2_fwd_t3_h_3 + (-0.057080287486314774) * gru_2_fwd_t3_h_4 + (-0.10744094848632812) * gru_2_fwd_t3_h_5 + (-0.16089963912963867) * gru_2_fwd_t3_h_6 + (-0.010430184192955494) * gru_2_fwd_t3_h_7 + (0.48429778218269348) * gru_2_fwd_t3_h_8 + (-0.093360967934131622) * gru_2_fwd_t3_h_9 + (-0.068475224077701569) * gru_2_fwd_t3_h_10 + (1.7199294567108154) * gru_2_fwd_t3_h_11 + (-1.3729612827301025) * gru_2_fwd_t3_h_12 + (2.5266125202178955) * gru_2_fwd_t3_h_13 + (2.3758692741394043) * gru_2_fwd_t3_h_14 + (-0.066287152469158173) * gru_2_fwd_t3_h_15 + (-1.3841222524642944) * gru_2_fwd_t3_h_16 + (-0.18619932234287262) * gru_2_fwd_t3_h_17 + (-0.74497216939926147) * gru_2_fwd_t3_h_18 + (0.42475524544715881) * gru_2_fwd_t3_h_19 + (1.042119026184082) * gru_2_fwd_t3_h_20 + (-1.1463786363601685) * gru_2_fwd_t3_h_21 + (-0.073154576122760773) * gru_2_fwd_t3_h_22 + (0.04113808274269104) * gru_2_fwd_t3_h_23 + (0.027660610154271126) * gru_2_fwd_t3_h_24 + (0.34735149145126343) * gru_2_fwd_t3_h_25 + (-0.30783972144126892) * gru_2_fwd_t3_h_26 + (0.28503379225730896) * gru_2_fwd_t3_h_27 + (-0.88032972812652588) * gru_2_fwd_t3_h_28 + (0.52263140678405762) * gru_2_fwd_t3_h_29 + (-0.61171287298202515) * gru_2_fwd_t3_h_30 + (-0.066184274852275848) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.88238400220870972) + (0.54812383651733398) * gru_1_out_t4_0 + (0.084309190511703491) * gru_1_out_t4_1 + (-0.91612529754638672) * gru_1_out_t4_2 + (0.15114417672157288) * gru_1_out_t4_3 + (-0.41414344310760498) * gru_1_out_t4_4 + (-0.54133445024490356) * gru_1_out_t4_5 + (-0.61206787824630737) * gru_1_out_t4_6 + (-0.81620889902114868) * gru_1_out_t4_7 + (-0.22451880574226379) * gru_1_out_t4_8 + (0.064619705080986023) * gru_1_out_t4_9 + (1.0050715208053589) * gru_1_out_t4_10 + (0.57450103759765625) * gru_1_out_t4_11 + (0.35685262084007263) * gru_1_out_t4_12 + (0.19002583622932434) * gru_1_out_t4_13 + (0.024446228519082069) * gru_1_out_t4_14 + (0.52690279483795166) * gru_1_out_t4_15 + (-0.31265348196029663) * gru_1_out_t4_16 + (0.33025014400482178) * gru_1_out_t4_17 + (-0.083484441041946411) * gru_1_out_t4_18 + (0.5114629864692688) * gru_1_out_t4_19 + (-1.0977698564529419) * gru_1_out_t4_20 + (-1.7362722158432007) * gru_1_out_t4_21 + (0.47086581587791443) * gru_1_out_t4_22 + (-0.74862158298492432) * gru_1_out_t4_23 + (0.064501389861106873) * gru_1_out_t4_24 + (0.28271842002868652) * gru_1_out_t4_25 + (-0.30696329474449158) * gru_1_out_t4_26 + (0.60209017992019653) * gru_1_out_t4_27 + (-0.50003504753112793) * gru_1_out_t4_28 + (0.4604681134223938) * gru_1_out_t4_29 + (0.35494977235794067) * gru_1_out_t4_30 + (-0.74329143762588501) * gru_1_out_t4_31 + (-0.4901297390460968) * gru_1_out_t4_32 + (0.0024981463793665171) * gru_1_out_t4_33 + (-0.44576945900917053) * gru_1_out_t4_34 + (0.38223811984062195) * gru_1_out_t4_35 + (-0.56463086605072021) * gru_1_out_t4_36 + (-0.09386848658323288) * gru_1_out_t4_37 + (0.3850269615650177) * gru_1_out_t4_38 + (-0.61358171701431274) * gru_1_out_t4_39 + (-0.28007173538208008) * gru_1_out_t4_40 + (0.14258691668510437) * gru_1_out_t4_41 + (0.18060921132564545) * gru_1_out_t4_42 + (-0.29128935933113098) * gru_1_out_t4_43 + (-0.81453126668930054) * gru_1_out_t4_44 + (-0.58044469356536865) * gru_1_out_t4_45 + (-0.056896299123764038) * gru_1_out_t4_46 + (1.4222674369812012) * gru_1_out_t4_47 + (0.92971593141555786) * gru_1_out_t4_48 + (0.27866071462631226) * gru_1_out_t4_49 + (-0.27328094840049744) * gru_1_out_t4_50 + (0.16380684077739716) * gru_1_out_t4_51 + (-0.45412525534629822) * gru_1_out_t4_52 + (-0.36207464337348938) * gru_1_out_t4_53 + (0.96603852510452271) * gru_1_out_t4_54 + (0.97490638494491577) * gru_1_out_t4_55 + (-0.29322290420532227) * gru_1_out_t4_56 + (0.13680242002010345) * gru_1_out_t4_57 + (-0.67447847127914429) * gru_1_out_t4_58 + (0.5320127010345459) * gru_1_out_t4_59 + (0.65005010366439819) * gru_1_out_t4_60 + (-0.1081901416182518) * gru_1_out_t4_61 + (1.9185484647750854) * gru_1_out_t4_62 + (-1.0644124746322632) * gru_1_out_t4_63 + (0.44240972399711609) * gru_2_fwd_t3_h_0 + (0.20456065237522125) * gru_2_fwd_t3_h_1 + (-0.60759347677230835) * gru_2_fwd_t3_h_2 + (-0.50734680891036987) * gru_2_fwd_t3_h_3 + (0.26795569062232971) * gru_2_fwd_t3_h_4 + (0.42981776595115662) * gru_2_fwd_t3_h_5 + (0.53505432605743408) * gru_2_fwd_t3_h_6 + (0.26717391610145569) * gru_2_fwd_t3_h_7 + (-0.55688351392745972) * gru_2_fwd_t3_h_8 + (-0.4084412157535553) * gru_2_fwd_t3_h_9 + (-0.72031271457672119) * gru_2_fwd_t3_h_10 + (0.30688285827636719) * gru_2_fwd_t3_h_11 + (-1.0795612335205078) * gru_2_fwd_t3_h_12 + (0.68189710378646851) * gru_2_fwd_t3_h_13 + (-0.70032137632369995) * gru_2_fwd_t3_h_14 + (0.9128221869468689) * gru_2_fwd_t3_h_15 + (0.13459783792495728) * gru_2_fwd_t3_h_16 + (0.4683280885219574) * gru_2_fwd_t3_h_17 + (0.19997569918632507) * gru_2_fwd_t3_h_18 + (-1.0262961387634277) * gru_2_fwd_t3_h_19 + (-0.026962146162986755) * gru_2_fwd_t3_h_20 + (-0.17534258961677551) * gru_2_fwd_t3_h_21 + (0.97022908926010132) * gru_2_fwd_t3_h_22 + (-0.38003373146057129) * gru_2_fwd_t3_h_23 + (-0.10063326358795166) * gru_2_fwd_t3_h_24 + (-0.45745974779129028) * gru_2_fwd_t3_h_25 + (-0.48271161317825317) * gru_2_fwd_t3_h_26 + (0.42112261056900024) * gru_2_fwd_t3_h_27 + (-0.35729825496673584) * gru_2_fwd_t3_h_28 + (-0.86066955327987671) * gru_2_fwd_t3_h_29 + (0.072103492915630341) * gru_2_fwd_t3_h_30 + (1.0129979848861694) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.35566678643226624) + (0.94106805324554443) * gru_1_out_t4_0 + (-0.066037826240062714) * gru_1_out_t4_1 + (0.24671831727027893) * gru_1_out_t4_2 + (0.145344078540802) * gru_1_out_t4_3 + (-0.15700626373291016) * gru_1_out_t4_4 + (0.3973090648651123) * gru_1_out_t4_5 + (-1.2051212787628174) * gru_1_out_t4_6 + (-0.11817455291748047) * gru_1_out_t4_7 + (0.54677766561508179) * gru_1_out_t4_8 + (-0.33398649096488953) * gru_1_out_t4_9 + (-0.75343042612075806) * gru_1_out_t4_10 + (-0.42171290516853333) * gru_1_out_t4_11 + (0.26459354162216187) * gru_1_out_t4_12 + (0.16092820465564728) * gru_1_out_t4_13 + (-0.42130136489868164) * gru_1_out_t4_14 + (0.14636470377445221) * gru_1_out_t4_15 + (0.5872846245765686) * gru_1_out_t4_16 + (-0.45223715901374817) * gru_1_out_t4_17 + (0.27623280882835388) * gru_1_out_t4_18 + (0.35441708564758301) * gru_1_out_t4_19 + (-0.025506824254989624) * gru_1_out_t4_20 + (0.69608736038208008) * gru_1_out_t4_21 + (-0.083216339349746704) * gru_1_out_t4_22 + (0.30782043933868408) * gru_1_out_t4_23 + (-0.18888427317142487) * gru_1_out_t4_24 + (0.54519766569137573) * gru_1_out_t4_25 + (-0.33170685172080994) * gru_1_out_t4_26 + (-0.78278219699859619) * gru_1_out_t4_27 + (0.56635093688964844) * gru_1_out_t4_28 + (0.1023222953081131) * gru_1_out_t4_29 + (0.046122174710035324) * gru_1_out_t4_30 + (-0.73408049345016479) * gru_1_out_t4_31 + (-0.065085716545581818) * gru_1_out_t4_32 + (-0.037244178354740143) * gru_1_out_t4_33 + (0.17389422655105591) * gru_1_out_t4_34 + (-0.079805254936218262) * gru_1_out_t4_35 + (0.17589746415615082) * gru_1_out_t4_36 + (0.2332797646522522) * gru_1_out_t4_37 + (0.52086710929870605) * gru_1_out_t4_38 + (0.54039144515991211) * gru_1_out_t4_39 + (-0.028402138501405716) * gru_1_out_t4_40 + (-0.68552398681640625) * gru_1_out_t4_41 + (0.20650230348110199) * gru_1_out_t4_42 + (-0.089282922446727753) * gru_1_out_t4_43 + (0.19378629326820374) * gru_1_out_t4_44 + (0.55057907104492188) * gru_1_out_t4_45 + (0.18966677784919739) * gru_1_out_t4_46 + (0.14235572516918182) * gru_1_out_t4_47 + (0.46433690190315247) * gru_1_out_t4_48 + (0.35699918866157532) * gru_1_out_t4_49 + (0.11929582059383392) * gru_1_out_t4_50 + (0.16253997385501862) * gru_1_out_t4_51 + (-0.81926834583282471) * gru_1_out_t4_52 + (0.068933933973312378) * gru_1_out_t4_53 + (-0.18813998997211456) * gru_1_out_t4_54 + (0.43585476279258728) * gru_1_out_t4_55 + (-0.097333721816539764) * gru_1_out_t4_56 + (0.019198009744286537) * gru_1_out_t4_57 + (-0.11591122299432755) * gru_1_out_t4_58 + (0.17620737850666046) * gru_1_out_t4_59 + (-0.23682054877281189) * gru_1_out_t4_60 + (-0.21652029454708099) * gru_1_out_t4_61 + (-0.68645107746124268) * gru_1_out_t4_62 + (0.014901396818459034) * gru_1_out_t4_63 + gate_r * ((0.9399944543838501) + (1.6642125844955444) * gru_2_fwd_t3_h_0 + (0.17631930112838745) * gru_2_fwd_t3_h_1 + (-3.2039175033569336) * gru_2_fwd_t3_h_2 + (-0.26798534393310547) * gru_2_fwd_t3_h_3 + (-0.68848395347595215) * gru_2_fwd_t3_h_4 + (0.00026185123715549707) * gru_2_fwd_t3_h_5 + (-0.17378658056259155) * gru_2_fwd_t3_h_6 + (-0.54994815587997437) * gru_2_fwd_t3_h_7 + (-0.76538091897964478) * gru_2_fwd_t3_h_8 + (0.6643139123916626) * gru_2_fwd_t3_h_9 + (-0.11858974397182465) * gru_2_fwd_t3_h_10 + (-0.13503888249397278) * gru_2_fwd_t3_h_11 + (0.15734441578388214) * gru_2_fwd_t3_h_12 + (-0.32153826951980591) * gru_2_fwd_t3_h_13 + (0.46621692180633545) * gru_2_fwd_t3_h_14 + (0.34445199370384216) * gru_2_fwd_t3_h_15 + (-0.27549806237220764) * gru_2_fwd_t3_h_16 + (-0.38169682025909424) * gru_2_fwd_t3_h_17 + (-0.47753524780273438) * gru_2_fwd_t3_h_18 + (-0.102455735206604) * gru_2_fwd_t3_h_19 + (1.5667098760604858) * gru_2_fwd_t3_h_20 + (0.94780755043029785) * gru_2_fwd_t3_h_21 + (-0.075364775955677032) * gru_2_fwd_t3_h_22 + (-0.083272196352481842) * gru_2_fwd_t3_h_23 + (0.24726168811321259) * gru_2_fwd_t3_h_24 + (0.201589435338974) * gru_2_fwd_t3_h_25 + (-0.21322713792324066) * gru_2_fwd_t3_h_26 + (-0.21556515991687775) * gru_2_fwd_t3_h_27 + (-0.53659486770629883) * gru_2_fwd_t3_h_28 + (-0.76937681436538696) * gru_2_fwd_t3_h_29 + (-0.27074256539344788) * gru_2_fwd_t3_h_30 + (0.12499156594276428) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_10 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_10;
    // h=11
    gate_r = sigmoid((0.71028310060501099) + (-0.83996015787124634) * gru_1_out_t4_0 + (1.5419596433639526) * gru_1_out_t4_1 + (-0.96208059787750244) * gru_1_out_t4_2 + (-0.054532419890165329) * gru_1_out_t4_3 + (-0.26417332887649536) * gru_1_out_t4_4 + (-1.5139000415802002) * gru_1_out_t4_5 + (0.18807902932167053) * gru_1_out_t4_6 + (-0.47800993919372559) * gru_1_out_t4_7 + (0.21385866403579712) * gru_1_out_t4_8 + (1.2038860321044922) * gru_1_out_t4_9 + (-0.32816877961158752) * gru_1_out_t4_10 + (-0.58010858297348022) * gru_1_out_t4_11 + (0.0021395066287368536) * gru_1_out_t4_12 + (0.56034433841705322) * gru_1_out_t4_13 + (0.95709019899368286) * gru_1_out_t4_14 + (0.20203155279159546) * gru_1_out_t4_15 + (1.0667481422424316) * gru_1_out_t4_16 + (-0.57491368055343628) * gru_1_out_t4_17 + (1.2813822031021118) * gru_1_out_t4_18 + (-0.45364183187484741) * gru_1_out_t4_19 + (-0.17162497341632843) * gru_1_out_t4_20 + (0.055248130112886429) * gru_1_out_t4_21 + (-0.21997605264186859) * gru_1_out_t4_22 + (-2.344430685043335) * gru_1_out_t4_23 + (-1.2996143102645874) * gru_1_out_t4_24 + (-0.33946925401687622) * gru_1_out_t4_25 + (-0.49170005321502686) * gru_1_out_t4_26 + (1.4311840534210205) * gru_1_out_t4_27 + (-3.148322582244873) * gru_1_out_t4_28 + (-0.69096815586090088) * gru_1_out_t4_29 + (1.2870415449142456) * gru_1_out_t4_30 + (-0.45125603675842285) * gru_1_out_t4_31 + (0.59137845039367676) * gru_1_out_t4_32 + (-0.90605807304382324) * gru_1_out_t4_33 + (-1.218586802482605) * gru_1_out_t4_34 + (0.29383832216262817) * gru_1_out_t4_35 + (-0.94658523797988892) * gru_1_out_t4_36 + (-0.27812725305557251) * gru_1_out_t4_37 + (-0.42589494585990906) * gru_1_out_t4_38 + (-0.18495330214500427) * gru_1_out_t4_39 + (-0.62374496459960938) * gru_1_out_t4_40 + (-0.15251928567886353) * gru_1_out_t4_41 + (0.12462680786848068) * gru_1_out_t4_42 + (-1.5815494060516357) * gru_1_out_t4_43 + (-0.42662155628204346) * gru_1_out_t4_44 + (-2.3648474216461182) * gru_1_out_t4_45 + (0.21347709000110626) * gru_1_out_t4_46 + (-0.97115224599838257) * gru_1_out_t4_47 + (1.8645026683807373) * gru_1_out_t4_48 + (1.5548909902572632) * gru_1_out_t4_49 + (-0.75367039442062378) * gru_1_out_t4_50 + (-0.83520799875259399) * gru_1_out_t4_51 + (1.0573383569717407) * gru_1_out_t4_52 + (0.62131202220916748) * gru_1_out_t4_53 + (-0.67312783002853394) * gru_1_out_t4_54 + (0.75321972370147705) * gru_1_out_t4_55 + (0.68122094869613647) * gru_1_out_t4_56 + (0.83286255598068237) * gru_1_out_t4_57 + (0.56078672409057617) * gru_1_out_t4_58 + (-0.27470174431800842) * gru_1_out_t4_59 + (-0.73646223545074463) * gru_1_out_t4_60 + (0.74550455808639526) * gru_1_out_t4_61 + (-0.59570944309234619) * gru_1_out_t4_62 + (0.2224527895450592) * gru_1_out_t4_63 + (-0.10018012672662735) * gru_2_fwd_t3_h_0 + (0.082496069371700287) * gru_2_fwd_t3_h_1 + (-0.55801290273666382) * gru_2_fwd_t3_h_2 + (-0.18518951535224915) * gru_2_fwd_t3_h_3 + (0.98140150308609009) * gru_2_fwd_t3_h_4 + (-0.16384933888912201) * gru_2_fwd_t3_h_5 + (0.37317624688148499) * gru_2_fwd_t3_h_6 + (-1.1740580797195435) * gru_2_fwd_t3_h_7 + (0.17656742036342621) * gru_2_fwd_t3_h_8 + (-0.72113949060440063) * gru_2_fwd_t3_h_9 + (0.17890188097953796) * gru_2_fwd_t3_h_10 + (0.31467697024345398) * gru_2_fwd_t3_h_11 + (0.66901755332946777) * gru_2_fwd_t3_h_12 + (0.66974335908889771) * gru_2_fwd_t3_h_13 + (-0.28007790446281433) * gru_2_fwd_t3_h_14 + (0.22189612686634064) * gru_2_fwd_t3_h_15 + (-0.024067692458629608) * gru_2_fwd_t3_h_16 + (0.3419310450553894) * gru_2_fwd_t3_h_17 + (-0.41443875432014465) * gru_2_fwd_t3_h_18 + (0.097341492772102356) * gru_2_fwd_t3_h_19 + (0.087937138974666595) * gru_2_fwd_t3_h_20 + (0.055752787739038467) * gru_2_fwd_t3_h_21 + (0.71824115514755249) * gru_2_fwd_t3_h_22 + (0.3033108115196228) * gru_2_fwd_t3_h_23 + (0.27449959516525269) * gru_2_fwd_t3_h_24 + (1.6739721298217773) * gru_2_fwd_t3_h_25 + (0.22533492743968964) * gru_2_fwd_t3_h_26 + (-1.576749324798584) * gru_2_fwd_t3_h_27 + (-0.051976930350065231) * gru_2_fwd_t3_h_28 + (0.26316317915916443) * gru_2_fwd_t3_h_29 + (-0.47232568264007568) * gru_2_fwd_t3_h_30 + (-1.0536329746246338) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((0.73565912246704102) + (0.26593995094299316) * gru_1_out_t4_0 + (0.28301367163658142) * gru_1_out_t4_1 + (0.2748180627822876) * gru_1_out_t4_2 + (0.12277515232563019) * gru_1_out_t4_3 + (-0.46206530928611755) * gru_1_out_t4_4 + (0.27133607864379883) * gru_1_out_t4_5 + (0.79030650854110718) * gru_1_out_t4_6 + (0.17061728239059448) * gru_1_out_t4_7 + (0.91447573900222778) * gru_1_out_t4_8 + (-0.17776878178119659) * gru_1_out_t4_9 + (-0.24259807169437408) * gru_1_out_t4_10 + (-0.26630765199661255) * gru_1_out_t4_11 + (-0.021615404635667801) * gru_1_out_t4_12 + (0.561920166015625) * gru_1_out_t4_13 + (-0.092182137072086334) * gru_1_out_t4_14 + (-0.71178197860717773) * gru_1_out_t4_15 + (0.098088458180427551) * gru_1_out_t4_16 + (0.13264790177345276) * gru_1_out_t4_17 + (0.013573003932833672) * gru_1_out_t4_18 + (-0.13946543633937836) * gru_1_out_t4_19 + (0.44717216491699219) * gru_1_out_t4_20 + (-0.087236933410167694) * gru_1_out_t4_21 + (0.24030435085296631) * gru_1_out_t4_22 + (0.02089337445795536) * gru_1_out_t4_23 + (1.2692074775695801) * gru_1_out_t4_24 + (0.074585273861885071) * gru_1_out_t4_25 + (-0.54299432039260864) * gru_1_out_t4_26 + (0.51531338691711426) * gru_1_out_t4_27 + (-0.41715079545974731) * gru_1_out_t4_28 + (0.21265485882759094) * gru_1_out_t4_29 + (-0.21530379354953766) * gru_1_out_t4_30 + (0.095630176365375519) * gru_1_out_t4_31 + (-0.18261751532554626) * gru_1_out_t4_32 + (-0.32730227708816528) * gru_1_out_t4_33 + (0.41703435778617859) * gru_1_out_t4_34 + (-0.083711452782154083) * gru_1_out_t4_35 + (0.55411499738693237) * gru_1_out_t4_36 + (0.26425608992576599) * gru_1_out_t4_37 + (0.13559646904468536) * gru_1_out_t4_38 + (0.094243183732032776) * gru_1_out_t4_39 + (0.073382675647735596) * gru_1_out_t4_40 + (-0.007708392571657896) * gru_1_out_t4_41 + (-0.18327382206916809) * gru_1_out_t4_42 + (-0.085040457546710968) * gru_1_out_t4_43 + (1.4355136156082153) * gru_1_out_t4_44 + (0.0088088121265172958) * gru_1_out_t4_45 + (0.10632161796092987) * gru_1_out_t4_46 + (-0.44252419471740723) * gru_1_out_t4_47 + (0.095471382141113281) * gru_1_out_t4_48 + (-0.59066635370254517) * gru_1_out_t4_49 + (-0.12557344138622284) * gru_1_out_t4_50 + (0.96079212427139282) * gru_1_out_t4_51 + (0.11721780151128769) * gru_1_out_t4_52 + (0.5942961573600769) * gru_1_out_t4_53 + (-0.95836359262466431) * gru_1_out_t4_54 + (0.10378184169530869) * gru_1_out_t4_55 + (-0.15621998906135559) * gru_1_out_t4_56 + (-0.11517500132322311) * gru_1_out_t4_57 + (0.098687276244163513) * gru_1_out_t4_58 + (-0.11182619631290436) * gru_1_out_t4_59 + (-0.020097123458981514) * gru_1_out_t4_60 + (0.12254822254180908) * gru_1_out_t4_61 + (-0.076486557722091675) * gru_1_out_t4_62 + (0.15851952135562897) * gru_1_out_t4_63 + (-0.63909989595413208) * gru_2_fwd_t3_h_0 + (-0.47909277677536011) * gru_2_fwd_t3_h_1 + (0.21700011193752289) * gru_2_fwd_t3_h_2 + (0.037925660610198975) * gru_2_fwd_t3_h_3 + (-0.040488783270120621) * gru_2_fwd_t3_h_4 + (-0.32309001684188843) * gru_2_fwd_t3_h_5 + (0.38326442241668701) * gru_2_fwd_t3_h_6 + (-0.36779472231864929) * gru_2_fwd_t3_h_7 + (0.5052223801612854) * gru_2_fwd_t3_h_8 + (-0.36608558893203735) * gru_2_fwd_t3_h_9 + (0.11931672692298889) * gru_2_fwd_t3_h_10 + (-0.80815988779067993) * gru_2_fwd_t3_h_11 + (0.054616343230009079) * gru_2_fwd_t3_h_12 + (-1.0017108917236328) * gru_2_fwd_t3_h_13 + (-0.18718938529491425) * gru_2_fwd_t3_h_14 + (-0.68868899345397949) * gru_2_fwd_t3_h_15 + (0.36352929472923279) * gru_2_fwd_t3_h_16 + (0.00028035946888849139) * gru_2_fwd_t3_h_17 + (-1.1796584129333496) * gru_2_fwd_t3_h_18 + (-0.98131179809570312) * gru_2_fwd_t3_h_19 + (-0.5779539942741394) * gru_2_fwd_t3_h_20 + (-0.30839940905570984) * gru_2_fwd_t3_h_21 + (-0.54980099201202393) * gru_2_fwd_t3_h_22 + (0.016979184001684189) * gru_2_fwd_t3_h_23 + (0.070916585624217987) * gru_2_fwd_t3_h_24 + (0.030718293040990829) * gru_2_fwd_t3_h_25 + (0.094246275722980499) * gru_2_fwd_t3_h_26 + (0.51536643505096436) * gru_2_fwd_t3_h_27 + (-0.67616426944732666) * gru_2_fwd_t3_h_28 + (0.26762428879737854) * gru_2_fwd_t3_h_29 + (0.76458209753036499) * gru_2_fwd_t3_h_30 + (-0.49725019931793213) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.14023476839065552) + (0.058073867112398148) * gru_1_out_t4_0 + (0.70706421136856079) * gru_1_out_t4_1 + (-0.19553154706954956) * gru_1_out_t4_2 + (0.46549299359321594) * gru_1_out_t4_3 + (0.30654379725456238) * gru_1_out_t4_4 + (0.81120693683624268) * gru_1_out_t4_5 + (0.92728346586227417) * gru_1_out_t4_6 + (-0.18344761431217194) * gru_1_out_t4_7 + (1.1044149398803711) * gru_1_out_t4_8 + (-0.13537603616714478) * gru_1_out_t4_9 + (0.34179496765136719) * gru_1_out_t4_10 + (1.5467379093170166) * gru_1_out_t4_11 + (-0.053349196910858154) * gru_1_out_t4_12 + (-0.18914373219013214) * gru_1_out_t4_13 + (1.5539519786834717) * gru_1_out_t4_14 + (0.47488477826118469) * gru_1_out_t4_15 + (-0.52079653739929199) * gru_1_out_t4_16 + (0.72775042057037354) * gru_1_out_t4_17 + (-0.16225852072238922) * gru_1_out_t4_18 + (-0.16197341680526733) * gru_1_out_t4_19 + (0.1226925328373909) * gru_1_out_t4_20 + (-0.086470738053321838) * gru_1_out_t4_21 + (0.37024402618408203) * gru_1_out_t4_22 + (-1.5784671306610107) * gru_1_out_t4_23 + (0.011948865838348866) * gru_1_out_t4_24 + (-0.1413331925868988) * gru_1_out_t4_25 + (-0.24740421772003174) * gru_1_out_t4_26 + (0.46115055680274963) * gru_1_out_t4_27 + (0.51180166006088257) * gru_1_out_t4_28 + (0.69201815128326416) * gru_1_out_t4_29 + (0.088272146880626678) * gru_1_out_t4_30 + (0.34620165824890137) * gru_1_out_t4_31 + (0.48045808076858521) * gru_1_out_t4_32 + (0.35436505079269409) * gru_1_out_t4_33 + (-0.34909811615943909) * gru_1_out_t4_34 + (1.3249396085739136) * gru_1_out_t4_35 + (0.4026930034160614) * gru_1_out_t4_36 + (0.097475104033946991) * gru_1_out_t4_37 + (-0.74467146396636963) * gru_1_out_t4_38 + (0.097402691841125488) * gru_1_out_t4_39 + (-0.43768754601478577) * gru_1_out_t4_40 + (-0.72482675313949585) * gru_1_out_t4_41 + (-0.22686120867729187) * gru_1_out_t4_42 + (-1.1801185607910156) * gru_1_out_t4_43 + (0.28824687004089355) * gru_1_out_t4_44 + (0.85371267795562744) * gru_1_out_t4_45 + (-0.017333131283521652) * gru_1_out_t4_46 + (0.66903722286224365) * gru_1_out_t4_47 + (0.44529411196708679) * gru_1_out_t4_48 + (0.048261910676956177) * gru_1_out_t4_49 + (1.0577747821807861) * gru_1_out_t4_50 + (0.12862180173397064) * gru_1_out_t4_51 + (-0.4780285656452179) * gru_1_out_t4_52 + (0.49589827656745911) * gru_1_out_t4_53 + (-0.87748497724533081) * gru_1_out_t4_54 + (-0.37231689691543579) * gru_1_out_t4_55 + (-0.69035500288009644) * gru_1_out_t4_56 + (0.48057383298873901) * gru_1_out_t4_57 + (0.54685330390930176) * gru_1_out_t4_58 + (-0.99246877431869507) * gru_1_out_t4_59 + (1.2096695899963379) * gru_1_out_t4_60 + (0.69128912687301636) * gru_1_out_t4_61 + (0.22728896141052246) * gru_1_out_t4_62 + (-0.066954329609870911) * gru_1_out_t4_63 + gate_r * ((0.33495897054672241) + (0.5618060827255249) * gru_2_fwd_t3_h_0 + (-0.48520123958587646) * gru_2_fwd_t3_h_1 + (1.0667139291763306) * gru_2_fwd_t3_h_2 + (1.3114645481109619) * gru_2_fwd_t3_h_3 + (-0.45765760540962219) * gru_2_fwd_t3_h_4 + (-0.5591920018196106) * gru_2_fwd_t3_h_5 + (-0.42411908507347107) * gru_2_fwd_t3_h_6 + (-0.80851835012435913) * gru_2_fwd_t3_h_7 + (0.63430023193359375) * gru_2_fwd_t3_h_8 + (0.3887673020362854) * gru_2_fwd_t3_h_9 + (-0.17813634872436523) * gru_2_fwd_t3_h_10 + (-1.7577896118164062) * gru_2_fwd_t3_h_11 + (-0.5420081615447998) * gru_2_fwd_t3_h_12 + (0.71897023916244507) * gru_2_fwd_t3_h_13 + (-0.083546705543994904) * gru_2_fwd_t3_h_14 + (0.67137104272842407) * gru_2_fwd_t3_h_15 + (0.60267788171768188) * gru_2_fwd_t3_h_16 + (0.35292923450469971) * gru_2_fwd_t3_h_17 + (-1.1108901500701904) * gru_2_fwd_t3_h_18 + (-0.63303524255752563) * gru_2_fwd_t3_h_19 + (-0.3836730420589447) * gru_2_fwd_t3_h_20 + (0.073852315545082092) * gru_2_fwd_t3_h_21 + (-1.0039308071136475) * gru_2_fwd_t3_h_22 + (1.212134838104248) * gru_2_fwd_t3_h_23 + (0.16915741562843323) * gru_2_fwd_t3_h_24 + (-0.42504394054412842) * gru_2_fwd_t3_h_25 + (0.0042725070379674435) * gru_2_fwd_t3_h_26 + (-0.022911757230758667) * gru_2_fwd_t3_h_27 + (-0.42583128809928894) * gru_2_fwd_t3_h_28 + (0.0015358029631897807) * gru_2_fwd_t3_h_29 + (0.42982783913612366) * gru_2_fwd_t3_h_30 + (0.3843248188495636) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_11 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_11;
    // h=12
    gate_r = sigmoid((0.16944818198680878) + (-0.12486344575881958) * gru_1_out_t4_0 + (-0.39577034115791321) * gru_1_out_t4_1 + (-0.01969623751938343) * gru_1_out_t4_2 + (-1.1788871288299561) * gru_1_out_t4_3 + (1.9825429916381836) * gru_1_out_t4_4 + (-0.56212025880813599) * gru_1_out_t4_5 + (-0.17878864705562592) * gru_1_out_t4_6 + (0.065333619713783264) * gru_1_out_t4_7 + (0.19333800673484802) * gru_1_out_t4_8 + (0.40821775794029236) * gru_1_out_t4_9 + (0.21370121836662292) * gru_1_out_t4_10 + (0.25890830159187317) * gru_1_out_t4_11 + (-1.0001566410064697) * gru_1_out_t4_12 + (-0.3463628888130188) * gru_1_out_t4_13 + (-0.8949323296546936) * gru_1_out_t4_14 + (0.018693855032324791) * gru_1_out_t4_15 + (0.6659361720085144) * gru_1_out_t4_16 + (0.21315869688987732) * gru_1_out_t4_17 + (-0.39742454886436462) * gru_1_out_t4_18 + (-0.062339514493942261) * gru_1_out_t4_19 + (-0.088531464338302612) * gru_1_out_t4_20 + (2.2655074596405029) * gru_1_out_t4_21 + (-0.040691744536161423) * gru_1_out_t4_22 + (-1.2116712331771851) * gru_1_out_t4_23 + (-2.2831156253814697) * gru_1_out_t4_24 + (-1.3653132915496826) * gru_1_out_t4_25 + (2.1884491443634033) * gru_1_out_t4_26 + (0.83096086978912354) * gru_1_out_t4_27 + (-0.7224200963973999) * gru_1_out_t4_28 + (-0.16125762462615967) * gru_1_out_t4_29 + (-2.0918986797332764) * gru_1_out_t4_30 + (-0.29180845618247986) * gru_1_out_t4_31 + (-0.45749121904373169) * gru_1_out_t4_32 + (0.064095199108123779) * gru_1_out_t4_33 + (-0.9104352593421936) * gru_1_out_t4_34 + (0.29645594954490662) * gru_1_out_t4_35 + (-0.77248489856719971) * gru_1_out_t4_36 + (0.15088008344173431) * gru_1_out_t4_37 + (0.20478323101997375) * gru_1_out_t4_38 + (0.27986016869544983) * gru_1_out_t4_39 + (-0.91094493865966797) * gru_1_out_t4_40 + (-0.84689486026763916) * gru_1_out_t4_41 + (0.24468572437763214) * gru_1_out_t4_42 + (0.41699951887130737) * gru_1_out_t4_43 + (-1.9613479375839233) * gru_1_out_t4_44 + (0.60784876346588135) * gru_1_out_t4_45 + (-0.48926475644111633) * gru_1_out_t4_46 + (-0.22175435721874237) * gru_1_out_t4_47 + (1.7299975156784058) * gru_1_out_t4_48 + (0.83812934160232544) * gru_1_out_t4_49 + (0.23894590139389038) * gru_1_out_t4_50 + (0.52884012460708618) * gru_1_out_t4_51 + (0.86915493011474609) * gru_1_out_t4_52 + (-0.84197431802749634) * gru_1_out_t4_53 + (1.1738929748535156) * gru_1_out_t4_54 + (0.81961363554000854) * gru_1_out_t4_55 + (-0.354066401720047) * gru_1_out_t4_56 + (-0.12924318015575409) * gru_1_out_t4_57 + (0.60333359241485596) * gru_1_out_t4_58 + (0.31821498274803162) * gru_1_out_t4_59 + (-1.0185444355010986) * gru_1_out_t4_60 + (-0.099782928824424744) * gru_1_out_t4_61 + (0.22052285075187683) * gru_1_out_t4_62 + (0.17596466839313507) * gru_1_out_t4_63 + (-0.25572660565376282) * gru_2_fwd_t3_h_0 + (1.2019804716110229) * gru_2_fwd_t3_h_1 + (0.85054707527160645) * gru_2_fwd_t3_h_2 + (0.061699956655502319) * gru_2_fwd_t3_h_3 + (0.17313326895236969) * gru_2_fwd_t3_h_4 + (0.69148862361907959) * gru_2_fwd_t3_h_5 + (1.1341719627380371) * gru_2_fwd_t3_h_6 + (-0.98725676536560059) * gru_2_fwd_t3_h_7 + (0.20701077580451965) * gru_2_fwd_t3_h_8 + (0.47484278678894043) * gru_2_fwd_t3_h_9 + (0.8305736780166626) * gru_2_fwd_t3_h_10 + (0.3594323992729187) * gru_2_fwd_t3_h_11 + (-0.6807485818862915) * gru_2_fwd_t3_h_12 + (2.6161301136016846) * gru_2_fwd_t3_h_13 + (-0.21721254289150238) * gru_2_fwd_t3_h_14 + (-0.0063638561405241489) * gru_2_fwd_t3_h_15 + (-0.48215869069099426) * gru_2_fwd_t3_h_16 + (-0.71669524908065796) * gru_2_fwd_t3_h_17 + (-0.51658910512924194) * gru_2_fwd_t3_h_18 + (0.10945600271224976) * gru_2_fwd_t3_h_19 + (0.95891499519348145) * gru_2_fwd_t3_h_20 + (0.87124514579772949) * gru_2_fwd_t3_h_21 + (1.1685246229171753) * gru_2_fwd_t3_h_22 + (-0.74763756990432739) * gru_2_fwd_t3_h_23 + (0.04710015282034874) * gru_2_fwd_t3_h_24 + (0.1849445104598999) * gru_2_fwd_t3_h_25 + (0.84645116329193115) * gru_2_fwd_t3_h_26 + (0.13592912256717682) * gru_2_fwd_t3_h_27 + (0.47214299440383911) * gru_2_fwd_t3_h_28 + (0.67102092504501343) * gru_2_fwd_t3_h_29 + (-0.42009952664375305) * gru_2_fwd_t3_h_30 + (-0.6394500732421875) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.57786369323730469) + (-0.60864448547363281) * gru_1_out_t4_0 + (-0.017517786473035812) * gru_1_out_t4_1 + (-0.82356137037277222) * gru_1_out_t4_2 + (-0.18064939975738525) * gru_1_out_t4_3 + (-0.22550281882286072) * gru_1_out_t4_4 + (0.069524630904197693) * gru_1_out_t4_5 + (2.1962754726409912) * gru_1_out_t4_6 + (0.15070310235023499) * gru_1_out_t4_7 + (0.014049737714231014) * gru_1_out_t4_8 + (-0.011441241018474102) * gru_1_out_t4_9 + (-1.0584559440612793) * gru_1_out_t4_10 + (-0.23150518536567688) * gru_1_out_t4_11 + (0.45249152183532715) * gru_1_out_t4_12 + (-0.10931191593408585) * gru_1_out_t4_13 + (-0.13492612540721893) * gru_1_out_t4_14 + (0.17500287294387817) * gru_1_out_t4_15 + (0.59077572822570801) * gru_1_out_t4_16 + (-0.70482563972473145) * gru_1_out_t4_17 + (-0.27810665965080261) * gru_1_out_t4_18 + (0.25267183780670166) * gru_1_out_t4_19 + (-0.38585171103477478) * gru_1_out_t4_20 + (-0.8814551830291748) * gru_1_out_t4_21 + (0.98714715242385864) * gru_1_out_t4_22 + (-0.77360385656356812) * gru_1_out_t4_23 + (-0.50132650136947632) * gru_1_out_t4_24 + (-1.0730962753295898) * gru_1_out_t4_25 + (-0.51046669483184814) * gru_1_out_t4_26 + (-0.29229408502578735) * gru_1_out_t4_27 + (-0.41826218366622925) * gru_1_out_t4_28 + (-0.62948566675186157) * gru_1_out_t4_29 + (0.20202898979187012) * gru_1_out_t4_30 + (-0.26992246508598328) * gru_1_out_t4_31 + (0.65060925483703613) * gru_1_out_t4_32 + (-0.95093011856079102) * gru_1_out_t4_33 + (0.37174814939498901) * gru_1_out_t4_34 + (-0.26865768432617188) * gru_1_out_t4_35 + (0.23131240904331207) * gru_1_out_t4_36 + (-0.41164043545722961) * gru_1_out_t4_37 + (0.15115579962730408) * gru_1_out_t4_38 + (0.094592176377773285) * gru_1_out_t4_39 + (0.84358417987823486) * gru_1_out_t4_40 + (0.33718061447143555) * gru_1_out_t4_41 + (-0.23821233212947845) * gru_1_out_t4_42 + (-0.084829315543174744) * gru_1_out_t4_43 + (0.60788112878799438) * gru_1_out_t4_44 + (-0.36908531188964844) * gru_1_out_t4_45 + (0.24948056042194366) * gru_1_out_t4_46 + (-0.82072854042053223) * gru_1_out_t4_47 + (0.3065912127494812) * gru_1_out_t4_48 + (-0.43936115503311157) * gru_1_out_t4_49 + (0.14315697550773621) * gru_1_out_t4_50 + (1.0350942611694336) * gru_1_out_t4_51 + (0.096012115478515625) * gru_1_out_t4_52 + (-0.086434409022331238) * gru_1_out_t4_53 + (-0.28666988015174866) * gru_1_out_t4_54 + (0.21033938229084015) * gru_1_out_t4_55 + (0.99119830131530762) * gru_1_out_t4_56 + (-0.45626047253608704) * gru_1_out_t4_57 + (0.01981942355632782) * gru_1_out_t4_58 + (-0.22449560463428497) * gru_1_out_t4_59 + (0.80450272560119629) * gru_1_out_t4_60 + (0.44981980323791504) * gru_1_out_t4_61 + (-0.35846447944641113) * gru_1_out_t4_62 + (-0.35080140829086304) * gru_1_out_t4_63 + (0.54588484764099121) * gru_2_fwd_t3_h_0 + (0.4416716992855072) * gru_2_fwd_t3_h_1 + (-0.43082976341247559) * gru_2_fwd_t3_h_2 + (0.56977581977844238) * gru_2_fwd_t3_h_3 + (-0.33533290028572083) * gru_2_fwd_t3_h_4 + (0.29398337006568909) * gru_2_fwd_t3_h_5 + (-0.82194060087203979) * gru_2_fwd_t3_h_6 + (-0.79270845651626587) * gru_2_fwd_t3_h_7 + (1.7548006772994995) * gru_2_fwd_t3_h_8 + (0.81114327907562256) * gru_2_fwd_t3_h_9 + (0.63005357980728149) * gru_2_fwd_t3_h_10 + (-2.0465047359466553) * gru_2_fwd_t3_h_11 + (0.11081379652023315) * gru_2_fwd_t3_h_12 + (0.10502046346664429) * gru_2_fwd_t3_h_13 + (-0.68405389785766602) * gru_2_fwd_t3_h_14 + (-0.91741210222244263) * gru_2_fwd_t3_h_15 + (-0.42131078243255615) * gru_2_fwd_t3_h_16 + (0.24130354821681976) * gru_2_fwd_t3_h_17 + (-0.48232036828994751) * gru_2_fwd_t3_h_18 + (-0.097938582301139832) * gru_2_fwd_t3_h_19 + (-0.029126737266778946) * gru_2_fwd_t3_h_20 + (0.18312962353229523) * gru_2_fwd_t3_h_21 + (0.21077732741832733) * gru_2_fwd_t3_h_22 + (-0.59926992654800415) * gru_2_fwd_t3_h_23 + (-0.28047049045562744) * gru_2_fwd_t3_h_24 + (0.31343501806259155) * gru_2_fwd_t3_h_25 + (2.0233685970306396) * gru_2_fwd_t3_h_26 + (-1.2294410467147827) * gru_2_fwd_t3_h_27 + (1.0426993370056152) * gru_2_fwd_t3_h_28 + (0.41191518306732178) * gru_2_fwd_t3_h_29 + (0.033867880702018738) * gru_2_fwd_t3_h_30 + (-0.41335961222648621) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.29970332980155945) + (-0.44496503472328186) * gru_1_out_t4_0 + (-0.0005186786875128746) * gru_1_out_t4_1 + (-0.48829889297485352) * gru_1_out_t4_2 + (-0.1639300137758255) * gru_1_out_t4_3 + (-1.1259713172912598) * gru_1_out_t4_4 + (0.22130830585956573) * gru_1_out_t4_5 + (-0.021031465381383896) * gru_1_out_t4_6 + (-0.64112013578414917) * gru_1_out_t4_7 + (-0.44724154472351074) * gru_1_out_t4_8 + (0.5440903902053833) * gru_1_out_t4_9 + (-0.1784345805644989) * gru_1_out_t4_10 + (-0.10796526074409485) * gru_1_out_t4_11 + (0.65705198049545288) * gru_1_out_t4_12 + (-0.079550959169864655) * gru_1_out_t4_13 + (0.21311438083648682) * gru_1_out_t4_14 + (0.40743371844291687) * gru_1_out_t4_15 + (0.40913146734237671) * gru_1_out_t4_16 + (-0.1480453759431839) * gru_1_out_t4_17 + (-0.42454320192337036) * gru_1_out_t4_18 + (-0.36511766910552979) * gru_1_out_t4_19 + (-0.49843883514404297) * gru_1_out_t4_20 + (-0.33435735106468201) * gru_1_out_t4_21 + (-0.56484413146972656) * gru_1_out_t4_22 + (0.15568198263645172) * gru_1_out_t4_23 + (-0.55973106622695923) * gru_1_out_t4_24 + (-0.4586336612701416) * gru_1_out_t4_25 + (0.22200039029121399) * gru_1_out_t4_26 + (-0.27939838171005249) * gru_1_out_t4_27 + (-0.38253003358840942) * gru_1_out_t4_28 + (0.013186918571591377) * gru_1_out_t4_29 + (0.54752540588378906) * gru_1_out_t4_30 + (0.065439067780971527) * gru_1_out_t4_31 + (-0.53140830993652344) * gru_1_out_t4_32 + (-0.27809426188468933) * gru_1_out_t4_33 + (-0.46909552812576294) * gru_1_out_t4_34 + (-0.019086932763457298) * gru_1_out_t4_35 + (0.3334602415561676) * gru_1_out_t4_36 + (0.2777235209941864) * gru_1_out_t4_37 + (-0.078772246837615967) * gru_1_out_t4_38 + (0.93463265895843506) * gru_1_out_t4_39 + (0.37432646751403809) * gru_1_out_t4_40 + (-0.34424552321434021) * gru_1_out_t4_41 + (0.54839217662811279) * gru_1_out_t4_42 + (0.36816906929016113) * gru_1_out_t4_43 + (-0.055137209594249725) * gru_1_out_t4_44 + (0.14570610225200653) * gru_1_out_t4_45 + (0.12467057257890701) * gru_1_out_t4_46 + (-1.2442675828933716) * gru_1_out_t4_47 + (-0.10150041431188583) * gru_1_out_t4_48 + (0.06904572993516922) * gru_1_out_t4_49 + (0.46346005797386169) * gru_1_out_t4_50 + (0.41625890135765076) * gru_1_out_t4_51 + (0.14457127451896667) * gru_1_out_t4_52 + (0.24122712016105652) * gru_1_out_t4_53 + (-0.17262168228626251) * gru_1_out_t4_54 + (0.032582052052021027) * gru_1_out_t4_55 + (0.22182133793830872) * gru_1_out_t4_56 + (-0.24559138715267181) * gru_1_out_t4_57 + (0.43298283219337463) * gru_1_out_t4_58 + (-0.82850897312164307) * gru_1_out_t4_59 + (-0.2982783317565918) * gru_1_out_t4_60 + (-0.053848475217819214) * gru_1_out_t4_61 + (-0.24340607225894928) * gru_1_out_t4_62 + (-1.0994828939437866) * gru_1_out_t4_63 + gate_r * ((-0.60516649484634399) + (0.39791816473007202) * gru_2_fwd_t3_h_0 + (0.91058450937271118) * gru_2_fwd_t3_h_1 + (-0.6445850133895874) * gru_2_fwd_t3_h_2 + (-0.84605717658996582) * gru_2_fwd_t3_h_3 + (-0.13350023329257965) * gru_2_fwd_t3_h_4 + (0.47989460825920105) * gru_2_fwd_t3_h_5 + (-1.0696731805801392) * gru_2_fwd_t3_h_6 + (0.67709583044052124) * gru_2_fwd_t3_h_7 + (-0.42948761582374573) * gru_2_fwd_t3_h_8 + (-0.46883690357208252) * gru_2_fwd_t3_h_9 + (-0.51379489898681641) * gru_2_fwd_t3_h_10 + (0.25057938694953918) * gru_2_fwd_t3_h_11 + (0.13081668317317963) * gru_2_fwd_t3_h_12 + (-0.95006686449050903) * gru_2_fwd_t3_h_13 + (-0.12156771868467331) * gru_2_fwd_t3_h_14 + (-0.21223448216915131) * gru_2_fwd_t3_h_15 + (1.399605393409729) * gru_2_fwd_t3_h_16 + (0.34337499737739563) * gru_2_fwd_t3_h_17 + (-0.79229545593261719) * gru_2_fwd_t3_h_18 + (0.083221659064292908) * gru_2_fwd_t3_h_19 + (-0.44312742352485657) * gru_2_fwd_t3_h_20 + (0.18576166033744812) * gru_2_fwd_t3_h_21 + (0.38711002469062805) * gru_2_fwd_t3_h_22 + (0.059837784618139267) * gru_2_fwd_t3_h_23 + (-0.16898141801357269) * gru_2_fwd_t3_h_24 + (-0.97928756475448608) * gru_2_fwd_t3_h_25 + (-1.397457480430603) * gru_2_fwd_t3_h_26 + (-1.6906445026397705) * gru_2_fwd_t3_h_27 + (0.078263565897941589) * gru_2_fwd_t3_h_28 + (-0.64032602310180664) * gru_2_fwd_t3_h_29 + (0.13585709035396576) * gru_2_fwd_t3_h_30 + (-0.23471814393997192) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_12 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_12;
    // h=13
    gate_r = sigmoid((0.58357876539230347) + (1.1281019449234009) * gru_1_out_t4_0 + (-4.3545136451721191) * gru_1_out_t4_1 + (-0.028746830299496651) * gru_1_out_t4_2 + (-1.4622278213500977) * gru_1_out_t4_3 + (1.0358291864395142) * gru_1_out_t4_4 + (0.085302330553531647) * gru_1_out_t4_5 + (-2.3746373653411865) * gru_1_out_t4_6 + (0.042948536574840546) * gru_1_out_t4_7 + (-0.65025204420089722) * gru_1_out_t4_8 + (0.13461531698703766) * gru_1_out_t4_9 + (1.1833635568618774) * gru_1_out_t4_10 + (-0.047106128185987473) * gru_1_out_t4_11 + (-0.65092867612838745) * gru_1_out_t4_12 + (0.71844297647476196) * gru_1_out_t4_13 + (-0.69646787643432617) * gru_1_out_t4_14 + (0.8043675422668457) * gru_1_out_t4_15 + (-0.015815131366252899) * gru_1_out_t4_16 + (-0.039989586919546127) * gru_1_out_t4_17 + (1.6538022756576538) * gru_1_out_t4_18 + (-0.46865123510360718) * gru_1_out_t4_19 + (-0.054507546126842499) * gru_1_out_t4_20 + (1.846894383430481) * gru_1_out_t4_21 + (-1.2045470476150513) * gru_1_out_t4_22 + (0.56519848108291626) * gru_1_out_t4_23 + (0.076363563537597656) * gru_1_out_t4_24 + (1.1889606714248657) * gru_1_out_t4_25 + (-0.58372193574905396) * gru_1_out_t4_26 + (-0.60534626245498657) * gru_1_out_t4_27 + (0.91214346885681152) * gru_1_out_t4_28 + (-0.31178292632102966) * gru_1_out_t4_29 + (-2.7099626064300537) * gru_1_out_t4_30 + (3.3020329475402832) * gru_1_out_t4_31 + (1.6349533796310425) * gru_1_out_t4_32 + (0.28871718049049377) * gru_1_out_t4_33 + (-0.26864612102508545) * gru_1_out_t4_34 + (-0.035945907235145569) * gru_1_out_t4_35 + (1.0172573328018188) * gru_1_out_t4_36 + (0.2415238618850708) * gru_1_out_t4_37 + (-0.63226383924484253) * gru_1_out_t4_38 + (-0.021328158676624298) * gru_1_out_t4_39 + (1.1333166360855103) * gru_1_out_t4_40 + (0.91912311315536499) * gru_1_out_t4_41 + (0.16389310359954834) * gru_1_out_t4_42 + (-0.97838801145553589) * gru_1_out_t4_43 + (-1.6217736005783081) * gru_1_out_t4_44 + (-1.0375542640686035) * gru_1_out_t4_45 + (0.34061920642852783) * gru_1_out_t4_46 + (-0.26960462331771851) * gru_1_out_t4_47 + (1.2321298122406006) * gru_1_out_t4_48 + (0.27740246057510376) * gru_1_out_t4_49 + (0.26954036951065063) * gru_1_out_t4_50 + (-1.0854111909866333) * gru_1_out_t4_51 + (0.49599489569664001) * gru_1_out_t4_52 + (-0.26682591438293457) * gru_1_out_t4_53 + (-1.1858416795730591) * gru_1_out_t4_54 + (-0.63467973470687866) * gru_1_out_t4_55 + (0.34969666600227356) * gru_1_out_t4_56 + (0.17027886211872101) * gru_1_out_t4_57 + (-0.50631201267242432) * gru_1_out_t4_58 + (0.69311511516571045) * gru_1_out_t4_59 + (-3.2410986423492432) * gru_1_out_t4_60 + (0.4111352264881134) * gru_1_out_t4_61 + (-0.76168477535247803) * gru_1_out_t4_62 + (0.64697265625) * gru_1_out_t4_63 + (0.83060789108276367) * gru_2_fwd_t3_h_0 + (0.25921750068664551) * gru_2_fwd_t3_h_1 + (0.73875969648361206) * gru_2_fwd_t3_h_2 + (1.3211265802383423) * gru_2_fwd_t3_h_3 + (1.2856224775314331) * gru_2_fwd_t3_h_4 + (-0.46125799417495728) * gru_2_fwd_t3_h_5 + (-1.5066938400268555) * gru_2_fwd_t3_h_6 + (-0.65767151117324829) * gru_2_fwd_t3_h_7 + (-0.5636742115020752) * gru_2_fwd_t3_h_8 + (1.1401147842407227) * gru_2_fwd_t3_h_9 + (0.3786957859992981) * gru_2_fwd_t3_h_10 + (-1.2498074769973755) * gru_2_fwd_t3_h_11 + (-0.025872593745589256) * gru_2_fwd_t3_h_12 + (4.8134112358093262) * gru_2_fwd_t3_h_13 + (1.0928444862365723) * gru_2_fwd_t3_h_14 + (-0.087683707475662231) * gru_2_fwd_t3_h_15 + (-0.91014271974563599) * gru_2_fwd_t3_h_16 + (-1.4284756183624268) * gru_2_fwd_t3_h_17 + (0.83949148654937744) * gru_2_fwd_t3_h_18 + (-0.12161629647016525) * gru_2_fwd_t3_h_19 + (0.12529464066028595) * gru_2_fwd_t3_h_20 + (1.4618993997573853) * gru_2_fwd_t3_h_21 + (0.6718134880065918) * gru_2_fwd_t3_h_22 + (-1.2224351167678833) * gru_2_fwd_t3_h_23 + (-0.06743224710226059) * gru_2_fwd_t3_h_24 + (-0.40240553021430969) * gru_2_fwd_t3_h_25 + (-0.71952962875366211) * gru_2_fwd_t3_h_26 + (0.245790034532547) * gru_2_fwd_t3_h_27 + (-1.5705521106719971) * gru_2_fwd_t3_h_28 + (-0.15596300363540649) * gru_2_fwd_t3_h_29 + (0.17516365647315979) * gru_2_fwd_t3_h_30 + (-0.57250577211380005) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((2.3440382480621338) + (0.7941243052482605) * gru_1_out_t4_0 + (-0.66928517818450928) * gru_1_out_t4_1 + (-0.65344846248626709) * gru_1_out_t4_2 + (0.99833381175994873) * gru_1_out_t4_3 + (0.4059087336063385) * gru_1_out_t4_4 + (0.31285414099693298) * gru_1_out_t4_5 + (0.060495432466268539) * gru_1_out_t4_6 + (0.21695375442504883) * gru_1_out_t4_7 + (-0.24969978630542755) * gru_1_out_t4_8 + (-0.20102301239967346) * gru_1_out_t4_9 + (0.67921507358551025) * gru_1_out_t4_10 + (0.86142796277999878) * gru_1_out_t4_11 + (0.024288145825266838) * gru_1_out_t4_12 + (0.61233413219451904) * gru_1_out_t4_13 + (0.63706952333450317) * gru_1_out_t4_14 + (0.57511115074157715) * gru_1_out_t4_15 + (0.61346167325973511) * gru_1_out_t4_16 + (-0.23942200839519501) * gru_1_out_t4_17 + (0.78175461292266846) * gru_1_out_t4_18 + (-1.5223969221115112) * gru_1_out_t4_19 + (-0.89622026681900024) * gru_1_out_t4_20 + (0.58509862422943115) * gru_1_out_t4_21 + (-1.9178315401077271) * gru_1_out_t4_22 + (-0.37459582090377808) * gru_1_out_t4_23 + (0.58132565021514893) * gru_1_out_t4_24 + (0.29683622717857361) * gru_1_out_t4_25 + (0.33866101503372192) * gru_1_out_t4_26 + (0.13932916522026062) * gru_1_out_t4_27 + (0.082974612712860107) * gru_1_out_t4_28 + (-0.41129359602928162) * gru_1_out_t4_29 + (-0.17147199809551239) * gru_1_out_t4_30 + (0.077110446989536285) * gru_1_out_t4_31 + (-0.0060683977790176868) * gru_1_out_t4_32 + (-0.17414176464080811) * gru_1_out_t4_33 + (-0.010814065113663673) * gru_1_out_t4_34 + (-0.074156299233436584) * gru_1_out_t4_35 + (-0.085169285535812378) * gru_1_out_t4_36 + (0.40667077898979187) * gru_1_out_t4_37 + (-0.13684412837028503) * gru_1_out_t4_38 + (-0.045399866998195648) * gru_1_out_t4_39 + (-0.075841836631298065) * gru_1_out_t4_40 + (0.35185173153877258) * gru_1_out_t4_41 + (0.074312120676040649) * gru_1_out_t4_42 + (-0.15621732175350189) * gru_1_out_t4_43 + (0.12405303865671158) * gru_1_out_t4_44 + (0.17935959994792938) * gru_1_out_t4_45 + (0.2023332267999649) * gru_1_out_t4_46 + (-0.66039204597473145) * gru_1_out_t4_47 + (-0.099667035043239594) * gru_1_out_t4_48 + (-1.0546422004699707) * gru_1_out_t4_49 + (0.4203721284866333) * gru_1_out_t4_50 + (-0.072544008493423462) * gru_1_out_t4_51 + (0.51997613906860352) * gru_1_out_t4_52 + (0.019310932606458664) * gru_1_out_t4_53 + (0.24334980547428131) * gru_1_out_t4_54 + (0.028162442147731781) * gru_1_out_t4_55 + (0.35136678814888) * gru_1_out_t4_56 + (0.0016895328881219029) * gru_1_out_t4_57 + (0.32972878217697144) * gru_1_out_t4_58 + (0.10589949786663055) * gru_1_out_t4_59 + (-0.38969123363494873) * gru_1_out_t4_60 + (0.13938790559768677) * gru_1_out_t4_61 + (0.81767535209655762) * gru_1_out_t4_62 + (0.32526087760925293) * gru_1_out_t4_63 + (-0.027058592066168785) * gru_2_fwd_t3_h_0 + (-0.23745903372764587) * gru_2_fwd_t3_h_1 + (0.15308248996734619) * gru_2_fwd_t3_h_2 + (-0.41713663935661316) * gru_2_fwd_t3_h_3 + (-0.17323347926139832) * gru_2_fwd_t3_h_4 + (-0.075153075158596039) * gru_2_fwd_t3_h_5 + (-0.25331291556358337) * gru_2_fwd_t3_h_6 + (-0.72066211700439453) * gru_2_fwd_t3_h_7 + (0.1374436616897583) * gru_2_fwd_t3_h_8 + (0.079374954104423523) * gru_2_fwd_t3_h_9 + (0.25832223892211914) * gru_2_fwd_t3_h_10 + (-0.064871504902839661) * gru_2_fwd_t3_h_11 + (-0.34475284814834595) * gru_2_fwd_t3_h_12 + (2.3374428749084473) * gru_2_fwd_t3_h_13 + (0.094867154955863953) * gru_2_fwd_t3_h_14 + (-0.18756669759750366) * gru_2_fwd_t3_h_15 + (-0.053354702889919281) * gru_2_fwd_t3_h_16 + (0.25647687911987305) * gru_2_fwd_t3_h_17 + (0.520843505859375) * gru_2_fwd_t3_h_18 + (-0.22660245001316071) * gru_2_fwd_t3_h_19 + (0.26918718218803406) * gru_2_fwd_t3_h_20 + (-0.52512210607528687) * gru_2_fwd_t3_h_21 + (0.072394095361232758) * gru_2_fwd_t3_h_22 + (-0.098293058574199677) * gru_2_fwd_t3_h_23 + (-0.092367768287658691) * gru_2_fwd_t3_h_24 + (0.053994596004486084) * gru_2_fwd_t3_h_25 + (-0.08146803081035614) * gru_2_fwd_t3_h_26 + (-0.846363365650177) * gru_2_fwd_t3_h_27 + (-0.14905130863189697) * gru_2_fwd_t3_h_28 + (-0.29852002859115601) * gru_2_fwd_t3_h_29 + (0.0086045907810330391) * gru_2_fwd_t3_h_30 + (-0.34125334024429321) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.46342349052429199) + (0.26516634225845337) * gru_1_out_t4_0 + (1.8463733196258545) * gru_1_out_t4_1 + (0.15156488120555878) * gru_1_out_t4_2 + (0.086181998252868652) * gru_1_out_t4_3 + (-1.3136317729949951) * gru_1_out_t4_4 + (0.54682731628417969) * gru_1_out_t4_5 + (-0.62087732553482056) * gru_1_out_t4_6 + (0.076718270778656006) * gru_1_out_t4_7 + (-0.48709267377853394) * gru_1_out_t4_8 + (0.21047528088092804) * gru_1_out_t4_9 + (-1.1409760713577271) * gru_1_out_t4_10 + (-0.66302108764648438) * gru_1_out_t4_11 + (0.0011276218574494123) * gru_1_out_t4_12 + (0.64898586273193359) * gru_1_out_t4_13 + (-0.05031174048781395) * gru_1_out_t4_14 + (0.058718264102935791) * gru_1_out_t4_15 + (-0.48503977060317993) * gru_1_out_t4_16 + (-1.1007044315338135) * gru_1_out_t4_17 + (-1.7090333700180054) * gru_1_out_t4_18 + (0.91622114181518555) * gru_1_out_t4_19 + (0.41768369078636169) * gru_1_out_t4_20 + (-0.84451639652252197) * gru_1_out_t4_21 + (-0.2069636732339859) * gru_1_out_t4_22 + (0.1722533255815506) * gru_1_out_t4_23 + (1.1315822601318359) * gru_1_out_t4_24 + (-1.1866620779037476) * gru_1_out_t4_25 + (-0.25504264235496521) * gru_1_out_t4_26 + (-0.72916257381439209) * gru_1_out_t4_27 + (0.58248788118362427) * gru_1_out_t4_28 + (-0.43827703595161438) * gru_1_out_t4_29 + (-0.38158699870109558) * gru_1_out_t4_30 + (-1.4783724546432495) * gru_1_out_t4_31 + (-0.43459323048591614) * gru_1_out_t4_32 + (0.031790439039468765) * gru_1_out_t4_33 + (-0.30355739593505859) * gru_1_out_t4_34 + (-0.058721300214529037) * gru_1_out_t4_35 + (-0.19545979797840118) * gru_1_out_t4_36 + (0.090653561055660248) * gru_1_out_t4_37 + (-0.1964404284954071) * gru_1_out_t4_38 + (0.16292805969715118) * gru_1_out_t4_39 + (-0.045594815164804459) * gru_1_out_t4_40 + (-0.0021998565644025803) * gru_1_out_t4_41 + (-0.030373634770512581) * gru_1_out_t4_42 + (1.853370189666748) * gru_1_out_t4_43 + (0.71527975797653198) * gru_1_out_t4_44 + (-0.066338703036308289) * gru_1_out_t4_45 + (-0.56568241119384766) * gru_1_out_t4_46 + (0.062515199184417725) * gru_1_out_t4_47 + (-0.8251081109046936) * gru_1_out_t4_48 + (0.2407473623752594) * gru_1_out_t4_49 + (-0.9809688925743103) * gru_1_out_t4_50 + (0.59228110313415527) * gru_1_out_t4_51 + (0.097626097500324249) * gru_1_out_t4_52 + (0.20746088027954102) * gru_1_out_t4_53 + (1.3023968935012817) * gru_1_out_t4_54 + (-0.049411233514547348) * gru_1_out_t4_55 + (-0.4488634467124939) * gru_1_out_t4_56 + (-0.036257930099964142) * gru_1_out_t4_57 + (-0.18765246868133545) * gru_1_out_t4_58 + (-0.17007966339588165) * gru_1_out_t4_59 + (-0.19284471869468689) * gru_1_out_t4_60 + (-0.25067079067230225) * gru_1_out_t4_61 + (-0.054696328938007355) * gru_1_out_t4_62 + (0.15899783372879028) * gru_1_out_t4_63 + gate_r * ((-1.7568490505218506) + (0.18729798495769501) * gru_2_fwd_t3_h_0 + (0.16189019381999969) * gru_2_fwd_t3_h_1 + (-0.35968080163002014) * gru_2_fwd_t3_h_2 + (-0.82894331216812134) * gru_2_fwd_t3_h_3 + (-0.27764075994491577) * gru_2_fwd_t3_h_4 + (-0.40037837624549866) * gru_2_fwd_t3_h_5 + (-0.075673870742321014) * gru_2_fwd_t3_h_6 + (-0.53658115863800049) * gru_2_fwd_t3_h_7 + (-0.20165690779685974) * gru_2_fwd_t3_h_8 + (0.1486954391002655) * gru_2_fwd_t3_h_9 + (0.13870486617088318) * gru_2_fwd_t3_h_10 + (-0.17908844351768494) * gru_2_fwd_t3_h_11 + (0.04533771425485611) * gru_2_fwd_t3_h_12 + (-4.5775833129882812) * gru_2_fwd_t3_h_13 + (-0.39020445942878723) * gru_2_fwd_t3_h_14 + (-0.48505118489265442) * gru_2_fwd_t3_h_15 + (0.89071071147918701) * gru_2_fwd_t3_h_16 + (-0.77001214027404785) * gru_2_fwd_t3_h_17 + (-0.73935365676879883) * gru_2_fwd_t3_h_18 + (0.0088056595996022224) * gru_2_fwd_t3_h_19 + (0.71168911457061768) * gru_2_fwd_t3_h_20 + (0.70193326473236084) * gru_2_fwd_t3_h_21 + (-0.23601226508617401) * gru_2_fwd_t3_h_22 + (-0.57800668478012085) * gru_2_fwd_t3_h_23 + (0.14366379380226135) * gru_2_fwd_t3_h_24 + (0.31635242700576782) * gru_2_fwd_t3_h_25 + (0.050658475607633591) * gru_2_fwd_t3_h_26 + (-0.53125482797622681) * gru_2_fwd_t3_h_27 + (0.36530548334121704) * gru_2_fwd_t3_h_28 + (-0.23513190448284149) * gru_2_fwd_t3_h_29 + (0.38897183537483215) * gru_2_fwd_t3_h_30 + (-0.54264873266220093) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_13 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_13;
    // h=14
    gate_r = sigmoid((-0.98139077425003052) + (-0.74998462200164795) * gru_1_out_t4_0 + (-1.3388795852661133) * gru_1_out_t4_1 + (-0.43307632207870483) * gru_1_out_t4_2 + (-0.16048702597618103) * gru_1_out_t4_3 + (0.5432475209236145) * gru_1_out_t4_4 + (0.77344310283660889) * gru_1_out_t4_5 + (-2.3996045589447021) * gru_1_out_t4_6 + (-0.072904191911220551) * gru_1_out_t4_7 + (-1.0170365571975708) * gru_1_out_t4_8 + (1.7237399816513062) * gru_1_out_t4_9 + (-0.25805240869522095) * gru_1_out_t4_10 + (-0.021846771240234375) * gru_1_out_t4_11 + (0.55676466226577759) * gru_1_out_t4_12 + (-0.41091802716255188) * gru_1_out_t4_13 + (1.4661507606506348) * gru_1_out_t4_14 + (2.3193440437316895) * gru_1_out_t4_15 + (-0.014090403914451599) * gru_1_out_t4_16 + (-1.4649800062179565) * gru_1_out_t4_17 + (-1.6641650199890137) * gru_1_out_t4_18 + (-0.14033980667591095) * gru_1_out_t4_19 + (-0.33689019083976746) * gru_1_out_t4_20 + (0.81885111331939697) * gru_1_out_t4_21 + (-0.50070983171463013) * gru_1_out_t4_22 + (-0.46968346834182739) * gru_1_out_t4_23 + (-2.7372636795043945) * gru_1_out_t4_24 + (0.12237231433391571) * gru_1_out_t4_25 + (-0.87489020824432373) * gru_1_out_t4_26 + (-1.5685356855392456) * gru_1_out_t4_27 + (1.1608496904373169) * gru_1_out_t4_28 + (-0.99908220767974854) * gru_1_out_t4_29 + (1.488121509552002) * gru_1_out_t4_30 + (-0.012814423069357872) * gru_1_out_t4_31 + (-0.13238587975502014) * gru_1_out_t4_32 + (0.7904784083366394) * gru_1_out_t4_33 + (-0.21361206471920013) * gru_1_out_t4_34 + (-0.46903231739997864) * gru_1_out_t4_35 + (-1.5758050680160522) * gru_1_out_t4_36 + (-1.1758370399475098) * gru_1_out_t4_37 + (-0.93818920850753784) * gru_1_out_t4_38 + (0.14996646344661713) * gru_1_out_t4_39 + (0.41417360305786133) * gru_1_out_t4_40 + (-0.056054897606372833) * gru_1_out_t4_41 + (0.10248541831970215) * gru_1_out_t4_42 + (-1.8501461744308472) * gru_1_out_t4_43 + (-1.5185614824295044) * gru_1_out_t4_44 + (-0.34556546807289124) * gru_1_out_t4_45 + (-1.0113381147384644) * gru_1_out_t4_46 + (-0.61341804265975952) * gru_1_out_t4_47 + (-0.91043996810913086) * gru_1_out_t4_48 + (2.0446052551269531) * gru_1_out_t4_49 + (0.38389742374420166) * gru_1_out_t4_50 + (1.0793395042419434) * gru_1_out_t4_51 + (0.65876740217208862) * gru_1_out_t4_52 + (-1.2009749412536621) * gru_1_out_t4_53 + (-1.8363161087036133) * gru_1_out_t4_54 + (0.5354684591293335) * gru_1_out_t4_55 + (-0.16373626887798309) * gru_1_out_t4_56 + (-0.2314186692237854) * gru_1_out_t4_57 + (1.1765966415405273) * gru_1_out_t4_58 + (-1.10466468334198) * gru_1_out_t4_59 + (-0.56136083602905273) * gru_1_out_t4_60 + (0.15566833317279816) * gru_1_out_t4_61 + (0.18278312683105469) * gru_1_out_t4_62 + (-0.63151061534881592) * gru_1_out_t4_63 + (0.74846124649047852) * gru_2_fwd_t3_h_0 + (-0.95615404844284058) * gru_2_fwd_t3_h_1 + (0.30868715047836304) * gru_2_fwd_t3_h_2 + (-0.28561931848526001) * gru_2_fwd_t3_h_3 + (0.093151144683361053) * gru_2_fwd_t3_h_4 + (0.27696678042411804) * gru_2_fwd_t3_h_5 + (0.66084492206573486) * gru_2_fwd_t3_h_6 + (-1.6829599142074585) * gru_2_fwd_t3_h_7 + (-0.0082470430061221123) * gru_2_fwd_t3_h_8 + (0.5371289849281311) * gru_2_fwd_t3_h_9 + (0.11803159117698669) * gru_2_fwd_t3_h_10 + (0.51269811391830444) * gru_2_fwd_t3_h_11 + (-0.21658317744731903) * gru_2_fwd_t3_h_12 + (0.3961881697177887) * gru_2_fwd_t3_h_13 + (-0.26360321044921875) * gru_2_fwd_t3_h_14 + (-0.1804121732711792) * gru_2_fwd_t3_h_15 + (-0.38599979877471924) * gru_2_fwd_t3_h_16 + (-2.0038077831268311) * gru_2_fwd_t3_h_17 + (0.065703332424163818) * gru_2_fwd_t3_h_18 + (0.52301043272018433) * gru_2_fwd_t3_h_19 + (-0.032833479344844818) * gru_2_fwd_t3_h_20 + (-0.30115851759910583) * gru_2_fwd_t3_h_21 + (-0.27464509010314941) * gru_2_fwd_t3_h_22 + (-1.8191161155700684) * gru_2_fwd_t3_h_23 + (0.93747627735137939) * gru_2_fwd_t3_h_24 + (0.58573800325393677) * gru_2_fwd_t3_h_25 + (-0.29001575708389282) * gru_2_fwd_t3_h_26 + (1.0324525833129883) * gru_2_fwd_t3_h_27 + (0.53855788707733154) * gru_2_fwd_t3_h_28 + (0.29658395051956177) * gru_2_fwd_t3_h_29 + (1.5156058073043823) * gru_2_fwd_t3_h_30 + (0.22447605431079865) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((1.0423792600631714) + (0.021000631153583527) * gru_1_out_t4_0 + (1.3824746608734131) * gru_1_out_t4_1 + (0.31484860181808472) * gru_1_out_t4_2 + (-0.016365399584174156) * gru_1_out_t4_3 + (-0.45040136575698853) * gru_1_out_t4_4 + (-0.61881518363952637) * gru_1_out_t4_5 + (0.12952439486980438) * gru_1_out_t4_6 + (0.33494681119918823) * gru_1_out_t4_7 + (0.98191052675247192) * gru_1_out_t4_8 + (-0.59603935480117798) * gru_1_out_t4_9 + (-0.31447547674179077) * gru_1_out_t4_10 + (-0.35928982496261597) * gru_1_out_t4_11 + (0.18593215942382812) * gru_1_out_t4_12 + (0.60739558935165405) * gru_1_out_t4_13 + (-0.082366921007633209) * gru_1_out_t4_14 + (-0.58186668157577515) * gru_1_out_t4_15 + (0.44452422857284546) * gru_1_out_t4_16 + (0.55906140804290771) * gru_1_out_t4_17 + (0.014633565209805965) * gru_1_out_t4_18 + (-0.1656610369682312) * gru_1_out_t4_19 + (0.079040065407752991) * gru_1_out_t4_20 + (0.060663316398859024) * gru_1_out_t4_21 + (0.16725210845470428) * gru_1_out_t4_22 + (0.92463403940200806) * gru_1_out_t4_23 + (0.70227277278900146) * gru_1_out_t4_24 + (-0.1242244690656662) * gru_1_out_t4_25 + (0.23429940640926361) * gru_1_out_t4_26 + (0.9362180233001709) * gru_1_out_t4_27 + (1.0253115892410278) * gru_1_out_t4_28 + (0.42605692148208618) * gru_1_out_t4_29 + (-0.51889073848724365) * gru_1_out_t4_30 + (-0.45226845145225525) * gru_1_out_t4_31 + (-0.901722252368927) * gru_1_out_t4_32 + (0.36771422624588013) * gru_1_out_t4_33 + (0.082478977739810944) * gru_1_out_t4_34 + (0.082225747406482697) * gru_1_out_t4_35 + (0.87587028741836548) * gru_1_out_t4_36 + (-0.4644700288772583) * gru_1_out_t4_37 + (-0.22296789288520813) * gru_1_out_t4_38 + (1.1790435314178467) * gru_1_out_t4_39 + (-0.11536389589309692) * gru_1_out_t4_40 + (-0.18256057798862457) * gru_1_out_t4_41 + (-0.43633949756622314) * gru_1_out_t4_42 + (-0.22431366145610809) * gru_1_out_t4_43 + (-0.17111416161060333) * gru_1_out_t4_44 + (0.64983868598937988) * gru_1_out_t4_45 + (0.36111035943031311) * gru_1_out_t4_46 + (-0.75304019451141357) * gru_1_out_t4_47 + (-0.13904079794883728) * gru_1_out_t4_48 + (0.08305281400680542) * gru_1_out_t4_49 + (-0.25970306992530823) * gru_1_out_t4_50 + (0.2253347784280777) * gru_1_out_t4_51 + (0.32220935821533203) * gru_1_out_t4_52 + (0.63635009527206421) * gru_1_out_t4_53 + (-0.023965567350387573) * gru_1_out_t4_54 + (0.022707341238856316) * gru_1_out_t4_55 + (-0.049300424754619598) * gru_1_out_t4_56 + (0.071198165416717529) * gru_1_out_t4_57 + (0.53670716285705566) * gru_1_out_t4_58 + (0.072037220001220703) * gru_1_out_t4_59 + (1.1177161931991577) * gru_1_out_t4_60 + (-0.0826244056224823) * gru_1_out_t4_61 + (-0.56415063142776489) * gru_1_out_t4_62 + (-0.086961790919303894) * gru_1_out_t4_63 + (0.043606232851743698) * gru_2_fwd_t3_h_0 + (0.010530515573918819) * gru_2_fwd_t3_h_1 + (0.3348272442817688) * gru_2_fwd_t3_h_2 + (-0.95059072971343994) * gru_2_fwd_t3_h_3 + (0.084346987307071686) * gru_2_fwd_t3_h_4 + (-0.14020974934101105) * gru_2_fwd_t3_h_5 + (-0.14103180170059204) * gru_2_fwd_t3_h_6 + (-0.29607856273651123) * gru_2_fwd_t3_h_7 + (0.79550838470458984) * gru_2_fwd_t3_h_8 + (-0.27660402655601501) * gru_2_fwd_t3_h_9 + (-0.47474083304405212) * gru_2_fwd_t3_h_10 + (0.80725818872451782) * gru_2_fwd_t3_h_11 + (-0.43015700578689575) * gru_2_fwd_t3_h_12 + (0.89214062690734863) * gru_2_fwd_t3_h_13 + (0.67666369676589966) * gru_2_fwd_t3_h_14 + (0.20974041521549225) * gru_2_fwd_t3_h_15 + (0.35836592316627502) * gru_2_fwd_t3_h_16 + (0.1908801943063736) * gru_2_fwd_t3_h_17 + (-0.61760729551315308) * gru_2_fwd_t3_h_18 + (-0.2425571084022522) * gru_2_fwd_t3_h_19 + (-0.52476710081100464) * gru_2_fwd_t3_h_20 + (-1.0961666107177734) * gru_2_fwd_t3_h_21 + (-0.2534632682800293) * gru_2_fwd_t3_h_22 + (0.55594044923782349) * gru_2_fwd_t3_h_23 + (0.027888022363185883) * gru_2_fwd_t3_h_24 + (-0.47891801595687866) * gru_2_fwd_t3_h_25 + (-0.68263894319534302) * gru_2_fwd_t3_h_26 + (-0.1747964471578598) * gru_2_fwd_t3_h_27 + (-0.35101398825645447) * gru_2_fwd_t3_h_28 + (0.15512968599796295) * gru_2_fwd_t3_h_29 + (0.39407822489738464) * gru_2_fwd_t3_h_30 + (-0.41295322775840759) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.23825021088123322) + (0.51395541429519653) * gru_1_out_t4_0 + (-0.43904915452003479) * gru_1_out_t4_1 + (0.82733821868896484) * gru_1_out_t4_2 + (0.68133127689361572) * gru_1_out_t4_3 + (0.076934933662414551) * gru_1_out_t4_4 + (0.142491415143013) * gru_1_out_t4_5 + (1.0678343772888184) * gru_1_out_t4_6 + (0.24392658472061157) * gru_1_out_t4_7 + (1.7820557355880737) * gru_1_out_t4_8 + (-0.34137812256813049) * gru_1_out_t4_9 + (0.26822444796562195) * gru_1_out_t4_10 + (1.6940315961837769) * gru_1_out_t4_11 + (-0.074917733669281006) * gru_1_out_t4_12 + (-0.32225856184959412) * gru_1_out_t4_13 + (-0.19260354340076447) * gru_1_out_t4_14 + (0.15028496086597443) * gru_1_out_t4_15 + (0.11283267289400101) * gru_1_out_t4_16 + (0.21302258968353271) * gru_1_out_t4_17 + (0.88799256086349487) * gru_1_out_t4_18 + (0.80354249477386475) * gru_1_out_t4_19 + (-0.082227028906345367) * gru_1_out_t4_20 + (0.59974509477615356) * gru_1_out_t4_21 + (0.86238092184066772) * gru_1_out_t4_22 + (-0.99863582849502563) * gru_1_out_t4_23 + (1.1465914249420166) * gru_1_out_t4_24 + (0.71095019578933716) * gru_1_out_t4_25 + (0.25409621000289917) * gru_1_out_t4_26 + (-0.33735069632530212) * gru_1_out_t4_27 + (1.0455405712127686) * gru_1_out_t4_28 + (-0.021693490445613861) * gru_1_out_t4_29 + (-0.085634618997573853) * gru_1_out_t4_30 + (-0.24612683057785034) * gru_1_out_t4_31 + (0.31446382403373718) * gru_1_out_t4_32 + (-0.19118747115135193) * gru_1_out_t4_33 + (-0.19599288702011108) * gru_1_out_t4_34 + (-0.10619448870420456) * gru_1_out_t4_35 + (-0.14368438720703125) * gru_1_out_t4_36 + (-0.11794870346784592) * gru_1_out_t4_37 + (0.53405451774597168) * gru_1_out_t4_38 + (0.24758447706699371) * gru_1_out_t4_39 + (0.46824371814727783) * gru_1_out_t4_40 + (-0.63576102256774902) * gru_1_out_t4_41 + (0.47674140334129333) * gru_1_out_t4_42 + (-0.52700865268707275) * gru_1_out_t4_43 + (1.1428416967391968) * gru_1_out_t4_44 + (0.47241896390914917) * gru_1_out_t4_45 + (0.70649915933609009) * gru_1_out_t4_46 + (0.35031053423881531) * gru_1_out_t4_47 + (0.037763513624668121) * gru_1_out_t4_48 + (0.39182326197624207) * gru_1_out_t4_49 + (0.82539749145507812) * gru_1_out_t4_50 + (-0.090322777628898621) * gru_1_out_t4_51 + (0.33325541019439697) * gru_1_out_t4_52 + (0.14795644581317902) * gru_1_out_t4_53 + (1.0950382947921753) * gru_1_out_t4_54 + (-0.021626479923725128) * gru_1_out_t4_55 + (-0.32992562651634216) * gru_1_out_t4_56 + (0.67823189496994019) * gru_1_out_t4_57 + (0.015067306347191334) * gru_1_out_t4_58 + (-0.64715796709060669) * gru_1_out_t4_59 + (-0.027330566197633743) * gru_1_out_t4_60 + (-0.22805818915367126) * gru_1_out_t4_61 + (0.13398614525794983) * gru_1_out_t4_62 + (-0.12789927423000336) * gru_1_out_t4_63 + gate_r * ((0.44422870874404907) + (0.23795384168624878) * gru_2_fwd_t3_h_0 + (-0.025456370785832405) * gru_2_fwd_t3_h_1 + (-1.100806713104248) * gru_2_fwd_t3_h_2 + (0.92234784364700317) * gru_2_fwd_t3_h_3 + (0.33921283483505249) * gru_2_fwd_t3_h_4 + (-0.22152088582515717) * gru_2_fwd_t3_h_5 + (-0.28665211796760559) * gru_2_fwd_t3_h_6 + (-0.72622847557067871) * gru_2_fwd_t3_h_7 + (-0.18135283887386322) * gru_2_fwd_t3_h_8 + (0.66540002822875977) * gru_2_fwd_t3_h_9 + (1.5475102663040161) * gru_2_fwd_t3_h_10 + (-0.84934991598129272) * gru_2_fwd_t3_h_11 + (-0.35207954049110413) * gru_2_fwd_t3_h_12 + (1.5647399425506592) * gru_2_fwd_t3_h_13 + (-0.058147378265857697) * gru_2_fwd_t3_h_14 + (-0.15118595957756042) * gru_2_fwd_t3_h_15 + (0.18652501702308655) * gru_2_fwd_t3_h_16 + (-0.067695587873458862) * gru_2_fwd_t3_h_17 + (-0.46224972605705261) * gru_2_fwd_t3_h_18 + (0.62018424272537231) * gru_2_fwd_t3_h_19 + (0.33551749587059021) * gru_2_fwd_t3_h_20 + (0.46135810017585754) * gru_2_fwd_t3_h_21 + (-0.46003416180610657) * gru_2_fwd_t3_h_22 + (0.45304930210113525) * gru_2_fwd_t3_h_23 + (0.66042691469192505) * gru_2_fwd_t3_h_24 + (-0.090201765298843384) * gru_2_fwd_t3_h_25 + (-0.39451184868812561) * gru_2_fwd_t3_h_26 + (-0.55477041006088257) * gru_2_fwd_t3_h_27 + (-0.14027684926986694) * gru_2_fwd_t3_h_28 + (0.58952987194061279) * gru_2_fwd_t3_h_29 + (1.2075736522674561) * gru_2_fwd_t3_h_30 + (-0.48139721155166626) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_14 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_14;
    // h=15
    gate_r = sigmoid((-0.099712938070297241) + (1.2344439029693604) * gru_1_out_t4_0 + (-0.35967421531677246) * gru_1_out_t4_1 + (-0.75983840227127075) * gru_1_out_t4_2 + (-0.5682671070098877) * gru_1_out_t4_3 + (-0.2700234055519104) * gru_1_out_t4_4 + (-2.307659387588501) * gru_1_out_t4_5 + (0.13333913683891296) * gru_1_out_t4_6 + (0.035674404352903366) * gru_1_out_t4_7 + (-0.7839047908782959) * gru_1_out_t4_8 + (0.80947846174240112) * gru_1_out_t4_9 + (-0.15220116078853607) * gru_1_out_t4_10 + (1.2643662691116333) * gru_1_out_t4_11 + (-0.65820610523223877) * gru_1_out_t4_12 + (0.36703968048095703) * gru_1_out_t4_13 + (0.60569053888320923) * gru_1_out_t4_14 + (-1.2507985830307007) * gru_1_out_t4_15 + (-0.58726435899734497) * gru_1_out_t4_16 + (-0.219014972448349) * gru_1_out_t4_17 + (1.2312827110290527) * gru_1_out_t4_18 + (-0.8131830096244812) * gru_1_out_t4_19 + (-0.70312595367431641) * gru_1_out_t4_20 + (-0.31020039319992065) * gru_1_out_t4_21 + (0.19150495529174805) * gru_1_out_t4_22 + (2.0266785621643066) * gru_1_out_t4_23 + (-1.3777910470962524) * gru_1_out_t4_24 + (1.1463949680328369) * gru_1_out_t4_25 + (0.13773041963577271) * gru_1_out_t4_26 + (-0.80282574892044067) * gru_1_out_t4_27 + (-0.34118011593818665) * gru_1_out_t4_28 + (0.52024710178375244) * gru_1_out_t4_29 + (2.0119740962982178) * gru_1_out_t4_30 + (-0.059225980192422867) * gru_1_out_t4_31 + (1.4174985885620117) * gru_1_out_t4_32 + (-0.57981628179550171) * gru_1_out_t4_33 + (0.39372158050537109) * gru_1_out_t4_34 + (0.24586416780948639) * gru_1_out_t4_35 + (-0.15991027653217316) * gru_1_out_t4_36 + (0.018095873296260834) * gru_1_out_t4_37 + (-0.019025521352887154) * gru_1_out_t4_38 + (1.0612548589706421) * gru_1_out_t4_39 + (-0.99318736791610718) * gru_1_out_t4_40 + (0.34218975901603699) * gru_1_out_t4_41 + (-1.5380276441574097) * gru_1_out_t4_42 + (-0.58356624841690063) * gru_1_out_t4_43 + (-1.7112160921096802) * gru_1_out_t4_44 + (-0.30877140164375305) * gru_1_out_t4_45 + (-0.79361695051193237) * gru_1_out_t4_46 + (1.9081676006317139) * gru_1_out_t4_47 + (-1.345948338508606) * gru_1_out_t4_48 + (-1.0362606048583984) * gru_1_out_t4_49 + (-0.62014001607894897) * gru_1_out_t4_50 + (-1.4615205526351929) * gru_1_out_t4_51 + (1.874022364616394) * gru_1_out_t4_52 + (1.3949344158172607) * gru_1_out_t4_53 + (1.1434203386306763) * gru_1_out_t4_54 + (-0.48745942115783691) * gru_1_out_t4_55 + (-0.17977717518806458) * gru_1_out_t4_56 + (0.0013087195111438632) * gru_1_out_t4_57 + (0.98865282535552979) * gru_1_out_t4_58 + (-0.91762733459472656) * gru_1_out_t4_59 + (2.85614013671875) * gru_1_out_t4_60 + (-1.0421533584594727) * gru_1_out_t4_61 + (0.77237915992736816) * gru_1_out_t4_62 + (1.2689826488494873) * gru_1_out_t4_63 + (0.65668982267379761) * gru_2_fwd_t3_h_0 + (-0.32196611166000366) * gru_2_fwd_t3_h_1 + (2.5332980155944824) * gru_2_fwd_t3_h_2 + (-1.2141462564468384) * gru_2_fwd_t3_h_3 + (0.016162445768713951) * gru_2_fwd_t3_h_4 + (0.11245572566986084) * gru_2_fwd_t3_h_5 + (0.0028356590773910284) * gru_2_fwd_t3_h_6 + (-0.61227631568908691) * gru_2_fwd_t3_h_7 + (0.64389824867248535) * gru_2_fwd_t3_h_8 + (0.45881193876266479) * gru_2_fwd_t3_h_9 + (-1.8222137689590454) * gru_2_fwd_t3_h_10 + (1.6760849952697754) * gru_2_fwd_t3_h_11 + (-0.23600196838378906) * gru_2_fwd_t3_h_12 + (0.97295689582824707) * gru_2_fwd_t3_h_13 + (-0.082982137799263) * gru_2_fwd_t3_h_14 + (0.68374204635620117) * gru_2_fwd_t3_h_15 + (0.26198792457580566) * gru_2_fwd_t3_h_16 + (0.34279128909111023) * gru_2_fwd_t3_h_17 + (5.2429933547973633) * gru_2_fwd_t3_h_18 + (0.18280769884586334) * gru_2_fwd_t3_h_19 + (0.6712762713432312) * gru_2_fwd_t3_h_20 + (-1.6124889850616455) * gru_2_fwd_t3_h_21 + (0.46657770872116089) * gru_2_fwd_t3_h_22 + (-0.046149745583534241) * gru_2_fwd_t3_h_23 + (0.30325093865394592) * gru_2_fwd_t3_h_24 + (-0.32827070355415344) * gru_2_fwd_t3_h_25 + (-0.56229287385940552) * gru_2_fwd_t3_h_26 + (-0.76090240478515625) * gru_2_fwd_t3_h_27 + (-0.57253903150558472) * gru_2_fwd_t3_h_28 + (-1.3216735124588013) * gru_2_fwd_t3_h_29 + (0.70708221197128296) * gru_2_fwd_t3_h_30 + (0.85487443208694458) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((0.86796432733535767) + (-0.3674314022064209) * gru_1_out_t4_0 + (0.011421734467148781) * gru_1_out_t4_1 + (-0.39588817954063416) * gru_1_out_t4_2 + (0.91233503818511963) * gru_1_out_t4_3 + (-0.69349545240402222) * gru_1_out_t4_4 + (0.62558883428573608) * gru_1_out_t4_5 + (0.22403493523597717) * gru_1_out_t4_6 + (-0.0051159174181520939) * gru_1_out_t4_7 + (0.40518206357955933) * gru_1_out_t4_8 + (-0.63209110498428345) * gru_1_out_t4_9 + (-0.17349937558174133) * gru_1_out_t4_10 + (-0.011373948305845261) * gru_1_out_t4_11 + (0.4693157970905304) * gru_1_out_t4_12 + (0.57174569368362427) * gru_1_out_t4_13 + (-0.11404962837696075) * gru_1_out_t4_14 + (-1.1810101270675659) * gru_1_out_t4_15 + (0.14403370022773743) * gru_1_out_t4_16 + (0.036192141473293304) * gru_1_out_t4_17 + (0.23284029960632324) * gru_1_out_t4_18 + (-0.13251702487468719) * gru_1_out_t4_19 + (-0.50567537546157837) * gru_1_out_t4_20 + (-0.67273867130279541) * gru_1_out_t4_21 + (0.19810812175273895) * gru_1_out_t4_22 + (0.17150084674358368) * gru_1_out_t4_23 + (1.4766669273376465) * gru_1_out_t4_24 + (-0.080309294164180756) * gru_1_out_t4_25 + (1.140605092048645) * gru_1_out_t4_26 + (0.20950727164745331) * gru_1_out_t4_27 + (-0.44454452395439148) * gru_1_out_t4_28 + (0.21902097761631012) * gru_1_out_t4_29 + (-0.43202382326126099) * gru_1_out_t4_30 + (-0.68993079662322998) * gru_1_out_t4_31 + (1.2918044328689575) * gru_1_out_t4_32 + (-0.40467995405197144) * gru_1_out_t4_33 + (-0.19459633529186249) * gru_1_out_t4_34 + (0.21746960282325745) * gru_1_out_t4_35 + (-0.31528300046920776) * gru_1_out_t4_36 + (-0.35935661196708679) * gru_1_out_t4_37 + (0.49077177047729492) * gru_1_out_t4_38 + (-0.98359978199005127) * gru_1_out_t4_39 + (0.19479916989803314) * gru_1_out_t4_40 + (-1.466838002204895) * gru_1_out_t4_41 + (-0.27959537506103516) * gru_1_out_t4_42 + (-1.0416791439056396) * gru_1_out_t4_43 + (-0.16814090311527252) * gru_1_out_t4_44 + (1.1341265439987183) * gru_1_out_t4_45 + (1.3218027353286743) * gru_1_out_t4_46 + (-0.15987001359462738) * gru_1_out_t4_47 + (-0.71389615535736084) * gru_1_out_t4_48 + (-0.57847762107849121) * gru_1_out_t4_49 + (-0.66114902496337891) * gru_1_out_t4_50 + (-0.60167890787124634) * gru_1_out_t4_51 + (-0.419292151927948) * gru_1_out_t4_52 + (0.11893682926893234) * gru_1_out_t4_53 + (0.9930456280708313) * gru_1_out_t4_54 + (-0.27176764607429504) * gru_1_out_t4_55 + (-0.25265571475028992) * gru_1_out_t4_56 + (-0.41597244143486023) * gru_1_out_t4_57 + (-0.64117783308029175) * gru_1_out_t4_58 + (0.3081170916557312) * gru_1_out_t4_59 + (-0.3865586519241333) * gru_1_out_t4_60 + (0.20725463330745697) * gru_1_out_t4_61 + (0.0024640315677970648) * gru_1_out_t4_62 + (0.19030804932117462) * gru_1_out_t4_63 + (-0.36935395002365112) * gru_2_fwd_t3_h_0 + (-0.6106610894203186) * gru_2_fwd_t3_h_1 + (-0.55907618999481201) * gru_2_fwd_t3_h_2 + (-0.81628817319869995) * gru_2_fwd_t3_h_3 + (0.35744625329971313) * gru_2_fwd_t3_h_4 + (0.12245208770036697) * gru_2_fwd_t3_h_5 + (0.23117765784263611) * gru_2_fwd_t3_h_6 + (1.4869725704193115) * gru_2_fwd_t3_h_7 + (0.87980777025222778) * gru_2_fwd_t3_h_8 + (0.13652804493904114) * gru_2_fwd_t3_h_9 + (0.27808269858360291) * gru_2_fwd_t3_h_10 + (1.1069825887680054) * gru_2_fwd_t3_h_11 + (-0.69535648822784424) * gru_2_fwd_t3_h_12 + (-0.75075364112854004) * gru_2_fwd_t3_h_13 + (-1.1671301126480103) * gru_2_fwd_t3_h_14 + (-0.49047094583511353) * gru_2_fwd_t3_h_15 + (1.098656177520752) * gru_2_fwd_t3_h_16 + (0.027010887861251831) * gru_2_fwd_t3_h_17 + (0.40718412399291992) * gru_2_fwd_t3_h_18 + (-0.64603126049041748) * gru_2_fwd_t3_h_19 + (0.084744572639465332) * gru_2_fwd_t3_h_20 + (-0.22180630266666412) * gru_2_fwd_t3_h_21 + (0.47444424033164978) * gru_2_fwd_t3_h_22 + (-0.13988929986953735) * gru_2_fwd_t3_h_23 + (-0.27076485753059387) * gru_2_fwd_t3_h_24 + (-1.1173679828643799) * gru_2_fwd_t3_h_25 + (0.33800655603408813) * gru_2_fwd_t3_h_26 + (-0.92009294033050537) * gru_2_fwd_t3_h_27 + (0.16319681704044342) * gru_2_fwd_t3_h_28 + (-0.15332271158695221) * gru_2_fwd_t3_h_29 + (-0.47971644997596741) * gru_2_fwd_t3_h_30 + (-0.40767934918403625) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.1986270397901535) + (-0.23109325766563416) * gru_1_out_t4_0 + (0.51752477884292603) * gru_1_out_t4_1 + (-0.19213198125362396) * gru_1_out_t4_2 + (-0.64243149757385254) * gru_1_out_t4_3 + (0.68001085519790649) * gru_1_out_t4_4 + (-0.30074447393417358) * gru_1_out_t4_5 + (-0.13066530227661133) * gru_1_out_t4_6 + (-0.031194902956485748) * gru_1_out_t4_7 + (0.47297501564025879) * gru_1_out_t4_8 + (-0.036317475140094757) * gru_1_out_t4_9 + (0.31469443440437317) * gru_1_out_t4_10 + (0.48222297430038452) * gru_1_out_t4_11 + (0.62522095441818237) * gru_1_out_t4_12 + (0.11308009177446365) * gru_1_out_t4_13 + (0.56571656465530396) * gru_1_out_t4_14 + (0.24551582336425781) * gru_1_out_t4_15 + (0.098780326545238495) * gru_1_out_t4_16 + (-0.071407467126846313) * gru_1_out_t4_17 + (0.086097754538059235) * gru_1_out_t4_18 + (0.61664283275604248) * gru_1_out_t4_19 + (-0.77060234546661377) * gru_1_out_t4_20 + (-0.38191735744476318) * gru_1_out_t4_21 + (-0.13671413064002991) * gru_1_out_t4_22 + (0.50795853137969971) * gru_1_out_t4_23 + (-0.42212957143783569) * gru_1_out_t4_24 + (0.074501588940620422) * gru_1_out_t4_25 + (-0.51492083072662354) * gru_1_out_t4_26 + (0.0097360657528042793) * gru_1_out_t4_27 + (0.28733626008033752) * gru_1_out_t4_28 + (0.6192963719367981) * gru_1_out_t4_29 + (0.47168126702308655) * gru_1_out_t4_30 + (0.19138269126415253) * gru_1_out_t4_31 + (1.1573127508163452) * gru_1_out_t4_32 + (-0.1367620974779129) * gru_1_out_t4_33 + (-0.08304731547832489) * gru_1_out_t4_34 + (-0.036361042410135269) * gru_1_out_t4_35 + (0.080528482794761658) * gru_1_out_t4_36 + (-0.1844211220741272) * gru_1_out_t4_37 + (1.0513179302215576) * gru_1_out_t4_38 + (-0.88202488422393799) * gru_1_out_t4_39 + (1.4967111349105835) * gru_1_out_t4_40 + (-0.10946391522884369) * gru_1_out_t4_41 + (1.2225415706634521) * gru_1_out_t4_42 + (0.083228208124637604) * gru_1_out_t4_43 + (0.34085822105407715) * gru_1_out_t4_44 + (-0.5102570652961731) * gru_1_out_t4_45 + (1.5460896492004395) * gru_1_out_t4_46 + (1.3498759269714355) * gru_1_out_t4_47 + (-0.58923941850662231) * gru_1_out_t4_48 + (0.85878586769104004) * gru_1_out_t4_49 + (1.7695879936218262) * gru_1_out_t4_50 + (-0.17635637521743774) * gru_1_out_t4_51 + (1.068307638168335) * gru_1_out_t4_52 + (-0.057781409472227097) * gru_1_out_t4_53 + (-0.98460006713867188) * gru_1_out_t4_54 + (0.13444608449935913) * gru_1_out_t4_55 + (-0.36470049619674683) * gru_1_out_t4_56 + (0.11647451668977737) * gru_1_out_t4_57 + (-1.2428932189941406) * gru_1_out_t4_58 + (0.59699571132659912) * gru_1_out_t4_59 + (0.25991621613502502) * gru_1_out_t4_60 + (0.26686671376228333) * gru_1_out_t4_61 + (-0.70623713731765747) * gru_1_out_t4_62 + (-0.6790015697479248) * gru_1_out_t4_63 + gate_r * ((0.237383633852005) + (0.60139495134353638) * gru_2_fwd_t3_h_0 + (0.2096017450094223) * gru_2_fwd_t3_h_1 + (-0.69522082805633545) * gru_2_fwd_t3_h_2 + (0.11159804463386536) * gru_2_fwd_t3_h_3 + (-0.18000809848308563) * gru_2_fwd_t3_h_4 + (-0.13865187764167786) * gru_2_fwd_t3_h_5 + (0.017238963395357132) * gru_2_fwd_t3_h_6 + (0.48503127694129944) * gru_2_fwd_t3_h_7 + (-0.10935140401124954) * gru_2_fwd_t3_h_8 + (0.17716817557811737) * gru_2_fwd_t3_h_9 + (0.55296725034713745) * gru_2_fwd_t3_h_10 + (-0.55124235153198242) * gru_2_fwd_t3_h_11 + (-0.12166103720664978) * gru_2_fwd_t3_h_12 + (1.5297843217849731) * gru_2_fwd_t3_h_13 + (-0.43455994129180908) * gru_2_fwd_t3_h_14 + (-0.32780748605728149) * gru_2_fwd_t3_h_15 + (0.47034075856208801) * gru_2_fwd_t3_h_16 + (0.39467275142669678) * gru_2_fwd_t3_h_17 + (-0.13785707950592041) * gru_2_fwd_t3_h_18 + (-0.070492923259735107) * gru_2_fwd_t3_h_19 + (0.081816285848617554) * gru_2_fwd_t3_h_20 + (-0.12881703674793243) * gru_2_fwd_t3_h_21 + (-0.50419849157333374) * gru_2_fwd_t3_h_22 + (0.49415460228919983) * gru_2_fwd_t3_h_23 + (0.59722715616226196) * gru_2_fwd_t3_h_24 + (-0.79994583129882812) * gru_2_fwd_t3_h_25 + (-0.77685946226119995) * gru_2_fwd_t3_h_26 + (0.30692371726036072) * gru_2_fwd_t3_h_27 + (-0.3053339421749115) * gru_2_fwd_t3_h_28 + (-0.76847034692764282) * gru_2_fwd_t3_h_29 + (0.095194369554519653) * gru_2_fwd_t3_h_30 + (0.73450207710266113) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_15 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_15;
    // h=16
    gate_r = sigmoid((1.7873998880386353) + (1.3126356601715088) * gru_1_out_t4_0 + (-0.58859282732009888) * gru_1_out_t4_1 + (-0.82331961393356323) * gru_1_out_t4_2 + (1.2347263097763062) * gru_1_out_t4_3 + (0.35785713791847229) * gru_1_out_t4_4 + (-0.67393743991851807) * gru_1_out_t4_5 + (-0.9873199462890625) * gru_1_out_t4_6 + (-0.0049171210266649723) * gru_1_out_t4_7 + (-0.2172614187002182) * gru_1_out_t4_8 + (0.63182747364044189) * gru_1_out_t4_9 + (0.26017823815345764) * gru_1_out_t4_10 + (-0.034069560468196869) * gru_1_out_t4_11 + (0.36782541871070862) * gru_1_out_t4_12 + (-0.46455869078636169) * gru_1_out_t4_13 + (-0.1541820615530014) * gru_1_out_t4_14 + (-0.040552899241447449) * gru_1_out_t4_15 + (-0.29707229137420654) * gru_1_out_t4_16 + (0.66204005479812622) * gru_1_out_t4_17 + (1.115532398223877) * gru_1_out_t4_18 + (-1.680785059928894) * gru_1_out_t4_19 + (-0.077288322150707245) * gru_1_out_t4_20 + (4.5616583824157715) * gru_1_out_t4_21 + (-0.44867894053459167) * gru_1_out_t4_22 + (-1.5006905794143677) * gru_1_out_t4_23 + (-2.8946139812469482) * gru_1_out_t4_24 + (0.27125060558319092) * gru_1_out_t4_25 + (0.47125473618507385) * gru_1_out_t4_26 + (0.90841460227966309) * gru_1_out_t4_27 + (-2.78855299949646) * gru_1_out_t4_28 + (1.1035343408584595) * gru_1_out_t4_29 + (2.833336353302002) * gru_1_out_t4_30 + (1.5856872797012329) * gru_1_out_t4_31 + (-0.022020237520337105) * gru_1_out_t4_32 + (-1.2235409021377563) * gru_1_out_t4_33 + (0.89237582683563232) * gru_1_out_t4_34 + (-0.19660596549510956) * gru_1_out_t4_35 + (0.40795698761940002) * gru_1_out_t4_36 + (1.339573860168457) * gru_1_out_t4_37 + (0.33744588494300842) * gru_1_out_t4_38 + (0.92059528827667236) * gru_1_out_t4_39 + (1.7253440618515015) * gru_1_out_t4_40 + (0.7359539270401001) * gru_1_out_t4_41 + (0.036698125302791595) * gru_1_out_t4_42 + (-1.8781143426895142) * gru_1_out_t4_43 + (0.25500890612602234) * gru_1_out_t4_44 + (0.066969923675060272) * gru_1_out_t4_45 + (0.083649009466171265) * gru_1_out_t4_46 + (0.26683929562568665) * gru_1_out_t4_47 + (-0.045093800872564316) * gru_1_out_t4_48 + (-1.0591150522232056) * gru_1_out_t4_49 + (0.27210056781768799) * gru_1_out_t4_50 + (0.29128417372703552) * gru_1_out_t4_51 + (0.31252390146255493) * gru_1_out_t4_52 + (0.59472763538360596) * gru_1_out_t4_53 + (-0.41199100017547607) * gru_1_out_t4_54 + (-1.0675783157348633) * gru_1_out_t4_55 + (-0.12863641977310181) * gru_1_out_t4_56 + (-0.52616250514984131) * gru_1_out_t4_57 + (0.5592682957649231) * gru_1_out_t4_58 + (0.52084195613861084) * gru_1_out_t4_59 + (-2.0192315578460693) * gru_1_out_t4_60 + (-0.56120169162750244) * gru_1_out_t4_61 + (-0.70859295129776001) * gru_1_out_t4_62 + (0.17687548696994781) * gru_1_out_t4_63 + (0.084535479545593262) * gru_2_fwd_t3_h_0 + (1.616175651550293) * gru_2_fwd_t3_h_1 + (-1.0718457698822021) * gru_2_fwd_t3_h_2 + (-0.032702375203371048) * gru_2_fwd_t3_h_3 + (0.78256469964981079) * gru_2_fwd_t3_h_4 + (-0.38684704899787903) * gru_2_fwd_t3_h_5 + (1.6073664426803589) * gru_2_fwd_t3_h_6 + (-1.4091967344284058) * gru_2_fwd_t3_h_7 + (0.38430163264274597) * gru_2_fwd_t3_h_8 + (0.41507786512374878) * gru_2_fwd_t3_h_9 + (-0.4759247899055481) * gru_2_fwd_t3_h_10 + (-0.01672670803964138) * gru_2_fwd_t3_h_11 + (-2.9220788478851318) * gru_2_fwd_t3_h_12 + (1.0540561676025391) * gru_2_fwd_t3_h_13 + (1.6173721551895142) * gru_2_fwd_t3_h_14 + (-1.2370331287384033) * gru_2_fwd_t3_h_15 + (1.2582210302352905) * gru_2_fwd_t3_h_16 + (-0.95171207189559937) * gru_2_fwd_t3_h_17 + (0.09479830414056778) * gru_2_fwd_t3_h_18 + (-0.39988544583320618) * gru_2_fwd_t3_h_19 + (0.15615633130073547) * gru_2_fwd_t3_h_20 + (-0.31244304776191711) * gru_2_fwd_t3_h_21 + (-0.15021435916423798) * gru_2_fwd_t3_h_22 + (0.44210723042488098) * gru_2_fwd_t3_h_23 + (-0.96204304695129395) * gru_2_fwd_t3_h_24 + (-0.67991536855697632) * gru_2_fwd_t3_h_25 + (0.25658535957336426) * gru_2_fwd_t3_h_26 + (-0.73779058456420898) * gru_2_fwd_t3_h_27 + (-0.33774843811988831) * gru_2_fwd_t3_h_28 + (0.946441650390625) * gru_2_fwd_t3_h_29 + (0.54452592134475708) * gru_2_fwd_t3_h_30 + (-0.27292835712432861) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((1.2640155553817749) + (-0.0671420618891716) * gru_1_out_t4_0 + (0.28772816061973572) * gru_1_out_t4_1 + (-0.03068389929831028) * gru_1_out_t4_2 + (0.40514740347862244) * gru_1_out_t4_3 + (0.42106547951698303) * gru_1_out_t4_4 + (-0.34062743186950684) * gru_1_out_t4_5 + (-0.041167601943016052) * gru_1_out_t4_6 + (0.56179851293563843) * gru_1_out_t4_7 + (-0.096378535032272339) * gru_1_out_t4_8 + (-0.59453177452087402) * gru_1_out_t4_9 + (-0.53731375932693481) * gru_1_out_t4_10 + (-0.21018564701080322) * gru_1_out_t4_11 + (0.068409450352191925) * gru_1_out_t4_12 + (-0.43984830379486084) * gru_1_out_t4_13 + (-1.7673325538635254) * gru_1_out_t4_14 + (-1.3707312345504761) * gru_1_out_t4_15 + (0.55483329296112061) * gru_1_out_t4_16 + (0.48506870865821838) * gru_1_out_t4_17 + (1.099915623664856) * gru_1_out_t4_18 + (-0.3957417905330658) * gru_1_out_t4_19 + (-0.12372412532567978) * gru_1_out_t4_20 + (-0.61775726079940796) * gru_1_out_t4_21 + (-0.80864226818084717) * gru_1_out_t4_22 + (0.55945420265197754) * gru_1_out_t4_23 + (-1.0479463338851929) * gru_1_out_t4_24 + (-0.10157300531864166) * gru_1_out_t4_25 + (-0.90567028522491455) * gru_1_out_t4_26 + (-0.34403130412101746) * gru_1_out_t4_27 + (1.0289782285690308) * gru_1_out_t4_28 + (-0.41504812240600586) * gru_1_out_t4_29 + (0.11227728426456451) * gru_1_out_t4_30 + (-0.45069333910942078) * gru_1_out_t4_31 + (0.36732080578804016) * gru_1_out_t4_32 + (-0.29652902483940125) * gru_1_out_t4_33 + (-0.33530133962631226) * gru_1_out_t4_34 + (-0.40733945369720459) * gru_1_out_t4_35 + (0.25787913799285889) * gru_1_out_t4_36 + (-0.10050442814826965) * gru_1_out_t4_37 + (-0.47376492619514465) * gru_1_out_t4_38 + (-0.20894291996955872) * gru_1_out_t4_39 + (0.020375235006213188) * gru_1_out_t4_40 + (-0.011454002931714058) * gru_1_out_t4_41 + (-0.29088589549064636) * gru_1_out_t4_42 + (-0.45224791765213013) * gru_1_out_t4_43 + (0.38449180126190186) * gru_1_out_t4_44 + (-0.011588858440518379) * gru_1_out_t4_45 + (0.20585186779499054) * gru_1_out_t4_46 + (-0.069687396287918091) * gru_1_out_t4_47 + (-1.1842204332351685) * gru_1_out_t4_48 + (-1.480518102645874) * gru_1_out_t4_49 + (-0.27727410197257996) * gru_1_out_t4_50 + (1.1781233549118042) * gru_1_out_t4_51 + (-0.055218491703271866) * gru_1_out_t4_52 + (1.3247201442718506) * gru_1_out_t4_53 + (0.39163029193878174) * gru_1_out_t4_54 + (-0.042490608990192413) * gru_1_out_t4_55 + (0.3819720447063446) * gru_1_out_t4_56 + (0.3999468982219696) * gru_1_out_t4_57 + (-0.12590512633323669) * gru_1_out_t4_58 + (0.037637617439031601) * gru_1_out_t4_59 + (-0.077690266072750092) * gru_1_out_t4_60 + (0.035045601427555084) * gru_1_out_t4_61 + (0.17848971486091614) * gru_1_out_t4_62 + (0.48950237035751343) * gru_1_out_t4_63 + (0.17353782057762146) * gru_2_fwd_t3_h_0 + (-0.015033048577606678) * gru_2_fwd_t3_h_1 + (-1.4285587072372437) * gru_2_fwd_t3_h_2 + (-0.34919202327728271) * gru_2_fwd_t3_h_3 + (-0.21483460068702698) * gru_2_fwd_t3_h_4 + (-0.16579632461071014) * gru_2_fwd_t3_h_5 + (-0.03274691104888916) * gru_2_fwd_t3_h_6 + (0.50209510326385498) * gru_2_fwd_t3_h_7 + (0.098148949444293976) * gru_2_fwd_t3_h_8 + (0.024392999708652496) * gru_2_fwd_t3_h_9 + (0.36063423752784729) * gru_2_fwd_t3_h_10 + (0.70057529211044312) * gru_2_fwd_t3_h_11 + (-0.033778928220272064) * gru_2_fwd_t3_h_12 + (0.87924665212631226) * gru_2_fwd_t3_h_13 + (-0.42236754298210144) * gru_2_fwd_t3_h_14 + (0.10892026126384735) * gru_2_fwd_t3_h_15 + (1.1765316724777222) * gru_2_fwd_t3_h_16 + (0.2593282163143158) * gru_2_fwd_t3_h_17 + (-1.7410452365875244) * gru_2_fwd_t3_h_18 + (-0.042498532682657242) * gru_2_fwd_t3_h_19 + (-0.68058526515960693) * gru_2_fwd_t3_h_20 + (0.6371304988861084) * gru_2_fwd_t3_h_21 + (-0.23902532458305359) * gru_2_fwd_t3_h_22 + (0.023254232481122017) * gru_2_fwd_t3_h_23 + (-0.025339744985103607) * gru_2_fwd_t3_h_24 + (0.4314035177230835) * gru_2_fwd_t3_h_25 + (0.95957809686660767) * gru_2_fwd_t3_h_26 + (-0.37355509400367737) * gru_2_fwd_t3_h_27 + (-0.73567724227905273) * gru_2_fwd_t3_h_28 + (0.29442530870437622) * gru_2_fwd_t3_h_29 + (0.079376429319381714) * gru_2_fwd_t3_h_30 + (0.20590680837631226) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.55826348066329956) + (0.7710883617401123) * gru_1_out_t4_0 + (-0.32697170972824097) * gru_1_out_t4_1 + (-0.27190622687339783) * gru_1_out_t4_2 + (0.46493300795555115) * gru_1_out_t4_3 + (0.80890876054763794) * gru_1_out_t4_4 + (0.309588223695755) * gru_1_out_t4_5 + (-0.067042231559753418) * gru_1_out_t4_6 + (0.44742298126220703) * gru_1_out_t4_7 + (0.094808705151081085) * gru_1_out_t4_8 + (0.35704442858695984) * gru_1_out_t4_9 + (0.49628141522407532) * gru_1_out_t4_10 + (0.4585416316986084) * gru_1_out_t4_11 + (-0.50555562973022461) * gru_1_out_t4_12 + (0.83318668603897095) * gru_1_out_t4_13 + (1.2871850728988647) * gru_1_out_t4_14 + (0.35534572601318359) * gru_1_out_t4_15 + (-0.79684364795684814) * gru_1_out_t4_16 + (-0.084903903305530548) * gru_1_out_t4_17 + (0.58116745948791504) * gru_1_out_t4_18 + (-0.014914519153535366) * gru_1_out_t4_19 + (-0.86654835939407349) * gru_1_out_t4_20 + (0.75671917200088501) * gru_1_out_t4_21 + (-0.4514213502407074) * gru_1_out_t4_22 + (-2.6153500080108643) * gru_1_out_t4_23 + (-1.3519439697265625) * gru_1_out_t4_24 + (-0.33903306722640991) * gru_1_out_t4_25 + (-0.0037989325355738401) * gru_1_out_t4_26 + (1.8440482616424561) * gru_1_out_t4_27 + (-2.5571906566619873) * gru_1_out_t4_28 + (0.57401752471923828) * gru_1_out_t4_29 + (0.58255726099014282) * gru_1_out_t4_30 + (-0.030146947130560875) * gru_1_out_t4_31 + (0.81557643413543701) * gru_1_out_t4_32 + (-0.29959991574287415) * gru_1_out_t4_33 + (0.82623940706253052) * gru_1_out_t4_34 + (0.68084812164306641) * gru_1_out_t4_35 + (0.13912205398082733) * gru_1_out_t4_36 + (-0.12137956917285919) * gru_1_out_t4_37 + (0.56575262546539307) * gru_1_out_t4_38 + (-0.25468525290489197) * gru_1_out_t4_39 + (-0.1403089314699173) * gru_1_out_t4_40 + (0.11636773496866226) * gru_1_out_t4_41 + (1.0021591186523438) * gru_1_out_t4_42 + (-0.50693094730377197) * gru_1_out_t4_43 + (-1.4354323148727417) * gru_1_out_t4_44 + (0.38763821125030518) * gru_1_out_t4_45 + (-0.049890018999576569) * gru_1_out_t4_46 + (0.48659119009971619) * gru_1_out_t4_47 + (0.40167069435119629) * gru_1_out_t4_48 + (0.7770230770111084) * gru_1_out_t4_49 + (-0.58251804113388062) * gru_1_out_t4_50 + (-0.84253066778182983) * gru_1_out_t4_51 + (0.22889725863933563) * gru_1_out_t4_52 + (-1.0875504016876221) * gru_1_out_t4_53 + (-1.5019323825836182) * gru_1_out_t4_54 + (-0.51297628879547119) * gru_1_out_t4_55 + (0.067249171435832977) * gru_1_out_t4_56 + (0.49136623740196228) * gru_1_out_t4_57 + (0.8640817403793335) * gru_1_out_t4_58 + (-0.12335313111543655) * gru_1_out_t4_59 + (0.94900137186050415) * gru_1_out_t4_60 + (0.58288627862930298) * gru_1_out_t4_61 + (-0.18927489221096039) * gru_1_out_t4_62 + (0.32711243629455566) * gru_1_out_t4_63 + gate_r * ((0.85728716850280762) + (-0.2613639235496521) * gru_2_fwd_t3_h_0 + (-0.29232898354530334) * gru_2_fwd_t3_h_1 + (-0.34427845478057861) * gru_2_fwd_t3_h_2 + (-0.28488737344741821) * gru_2_fwd_t3_h_3 + (0.75398081541061401) * gru_2_fwd_t3_h_4 + (-0.15176987648010254) * gru_2_fwd_t3_h_5 + (-0.36930614709854126) * gru_2_fwd_t3_h_6 + (0.38256609439849854) * gru_2_fwd_t3_h_7 + (-0.044140085577964783) * gru_2_fwd_t3_h_8 + (-0.050089918076992035) * gru_2_fwd_t3_h_9 + (-0.18093536794185638) * gru_2_fwd_t3_h_10 + (1.332976222038269) * gru_2_fwd_t3_h_11 + (-1.6407657861709595) * gru_2_fwd_t3_h_12 + (0.30337285995483398) * gru_2_fwd_t3_h_13 + (0.39222031831741333) * gru_2_fwd_t3_h_14 + (-0.19983851909637451) * gru_2_fwd_t3_h_15 + (-0.0043326378799974918) * gru_2_fwd_t3_h_16 + (-0.33165842294692993) * gru_2_fwd_t3_h_17 + (-1.6460027694702148) * gru_2_fwd_t3_h_18 + (-0.59980785846710205) * gru_2_fwd_t3_h_19 + (-0.37976434826850891) * gru_2_fwd_t3_h_20 + (-0.71489071846008301) * gru_2_fwd_t3_h_21 + (0.054475601762533188) * gru_2_fwd_t3_h_22 + (-0.15301059186458588) * gru_2_fwd_t3_h_23 + (-0.04304436594247818) * gru_2_fwd_t3_h_24 + (-0.66275328397750854) * gru_2_fwd_t3_h_25 + (-1.8117305040359497) * gru_2_fwd_t3_h_26 + (-0.47725656628608704) * gru_2_fwd_t3_h_27 + (-0.2530972957611084) * gru_2_fwd_t3_h_28 + (-1.1606887578964233) * gru_2_fwd_t3_h_29 + (0.093336485326290131) * gru_2_fwd_t3_h_30 + (0.12406186014413834) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_16 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_16;
    // h=17
    gate_r = sigmoid((0.021549340337514877) + (1.2636804580688477) * gru_1_out_t4_0 + (0.16169597208499908) * gru_1_out_t4_1 + (0.24536940455436707) * gru_1_out_t4_2 + (0.71913111209869385) * gru_1_out_t4_3 + (-0.5736272931098938) * gru_1_out_t4_4 + (1.4281376600265503) * gru_1_out_t4_5 + (-0.12270449101924896) * gru_1_out_t4_6 + (0.67721343040466309) * gru_1_out_t4_7 + (-0.98408913612365723) * gru_1_out_t4_8 + (-0.21522223949432373) * gru_1_out_t4_9 + (1.9800719022750854) * gru_1_out_t4_10 + (1.0803093910217285) * gru_1_out_t4_11 + (-0.45104026794433594) * gru_1_out_t4_12 + (-0.74236249923706055) * gru_1_out_t4_13 + (-0.91018128395080566) * gru_1_out_t4_14 + (-1.2221018075942993) * gru_1_out_t4_15 + (-1.2330448627471924) * gru_1_out_t4_16 + (1.1542905569076538) * gru_1_out_t4_17 + (0.20149163901805878) * gru_1_out_t4_18 + (-0.47856271266937256) * gru_1_out_t4_19 + (-0.043388538062572479) * gru_1_out_t4_20 + (0.78447186946868896) * gru_1_out_t4_21 + (-0.99291074275970459) * gru_1_out_t4_22 + (2.2875189781188965) * gru_1_out_t4_23 + (-1.4739151000976562) * gru_1_out_t4_24 + (-0.33991304039955139) * gru_1_out_t4_25 + (1.7563220262527466) * gru_1_out_t4_26 + (0.5214959979057312) * gru_1_out_t4_27 + (0.16614103317260742) * gru_1_out_t4_28 + (0.1799643486738205) * gru_1_out_t4_29 + (1.8873052597045898) * gru_1_out_t4_30 + (-1.9207322597503662) * gru_1_out_t4_31 + (0.55558162927627563) * gru_1_out_t4_32 + (0.78628832101821899) * gru_1_out_t4_33 + (0.0024437264073640108) * gru_1_out_t4_34 + (0.37056535482406616) * gru_1_out_t4_35 + (-0.53878086805343628) * gru_1_out_t4_36 + (0.1283235102891922) * gru_1_out_t4_37 + (0.041197609156370163) * gru_1_out_t4_38 + (0.21605655550956726) * gru_1_out_t4_39 + (0.93911826610565186) * gru_1_out_t4_40 + (-0.023716617375612259) * gru_1_out_t4_41 + (-0.59846317768096924) * gru_1_out_t4_42 + (-0.97551470994949341) * gru_1_out_t4_43 + (1.4631307125091553) * gru_1_out_t4_44 + (0.2849629819393158) * gru_1_out_t4_45 + (-0.70415252447128296) * gru_1_out_t4_46 + (-0.525687575340271) * gru_1_out_t4_47 + (-0.34513044357299805) * gru_1_out_t4_48 + (-0.42007172107696533) * gru_1_out_t4_49 + (0.86923795938491821) * gru_1_out_t4_50 + (2.6697864532470703) * gru_1_out_t4_51 + (-0.13386932015419006) * gru_1_out_t4_52 + (-0.30250141024589539) * gru_1_out_t4_53 + (-0.68215465545654297) * gru_1_out_t4_54 + (-0.6602853536605835) * gru_1_out_t4_55 + (-0.52853685617446899) * gru_1_out_t4_56 + (0.27203124761581421) * gru_1_out_t4_57 + (-0.24475856125354767) * gru_1_out_t4_58 + (-0.49960228800773621) * gru_1_out_t4_59 + (3.5556061267852783) * gru_1_out_t4_60 + (-0.64135253429412842) * gru_1_out_t4_61 + (-1.352180004119873) * gru_1_out_t4_62 + (-0.096296228468418121) * gru_1_out_t4_63 + (0.034841258078813553) * gru_2_fwd_t3_h_0 + (-0.43385329842567444) * gru_2_fwd_t3_h_1 + (1.6080894470214844) * gru_2_fwd_t3_h_2 + (0.81924748420715332) * gru_2_fwd_t3_h_3 + (0.27552732825279236) * gru_2_fwd_t3_h_4 + (0.18126706779003143) * gru_2_fwd_t3_h_5 + (0.1723027378320694) * gru_2_fwd_t3_h_6 + (-0.61030161380767822) * gru_2_fwd_t3_h_7 + (-0.39791584014892578) * gru_2_fwd_t3_h_8 + (1.1139663457870483) * gru_2_fwd_t3_h_9 + (-0.83574312925338745) * gru_2_fwd_t3_h_10 + (-0.17274689674377441) * gru_2_fwd_t3_h_11 + (-0.5085412859916687) * gru_2_fwd_t3_h_12 + (0.91046637296676636) * gru_2_fwd_t3_h_13 + (-0.15254078805446625) * gru_2_fwd_t3_h_14 + (-0.21543808281421661) * gru_2_fwd_t3_h_15 + (0.73540472984313965) * gru_2_fwd_t3_h_16 + (0.44924697279930115) * gru_2_fwd_t3_h_17 + (0.95865839719772339) * gru_2_fwd_t3_h_18 + (-0.1027306392788887) * gru_2_fwd_t3_h_19 + (-0.24206598103046417) * gru_2_fwd_t3_h_20 + (0.61078745126724243) * gru_2_fwd_t3_h_21 + (-0.029728937894105911) * gru_2_fwd_t3_h_22 + (-0.87730759382247925) * gru_2_fwd_t3_h_23 + (0.30949258804321289) * gru_2_fwd_t3_h_24 + (-1.2151943445205688) * gru_2_fwd_t3_h_25 + (-0.23554350435733795) * gru_2_fwd_t3_h_26 + (1.1832011938095093) * gru_2_fwd_t3_h_27 + (0.16718079149723053) * gru_2_fwd_t3_h_28 + (-0.29818904399871826) * gru_2_fwd_t3_h_29 + (-0.14198268949985504) * gru_2_fwd_t3_h_30 + (0.58133405447006226) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.23630239069461823) + (-0.16652904450893402) * gru_1_out_t4_0 + (0.15863227844238281) * gru_1_out_t4_1 + (-0.75610631704330444) * gru_1_out_t4_2 + (0.46987912058830261) * gru_1_out_t4_3 + (-0.15256865322589874) * gru_1_out_t4_4 + (0.78844845294952393) * gru_1_out_t4_5 + (0.71722584962844849) * gru_1_out_t4_6 + (-0.45786184072494507) * gru_1_out_t4_7 + (0.11892122775316238) * gru_1_out_t4_8 + (-0.059163175523281097) * gru_1_out_t4_9 + (-0.34564051032066345) * gru_1_out_t4_10 + (1.3903465270996094) * gru_1_out_t4_11 + (1.0134483575820923) * gru_1_out_t4_12 + (0.38107964396476746) * gru_1_out_t4_13 + (0.69851970672607422) * gru_1_out_t4_14 + (-0.69377315044403076) * gru_1_out_t4_15 + (-0.11982888728380203) * gru_1_out_t4_16 + (0.041333489120006561) * gru_1_out_t4_17 + (-0.13584223389625549) * gru_1_out_t4_18 + (-0.090033248066902161) * gru_1_out_t4_19 + (0.20484891533851624) * gru_1_out_t4_20 + (-0.05002916231751442) * gru_1_out_t4_21 + (0.96704256534576416) * gru_1_out_t4_22 + (-1.321276068687439) * gru_1_out_t4_23 + (0.12812498211860657) * gru_1_out_t4_24 + (0.42011177539825439) * gru_1_out_t4_25 + (-1.0923572778701782) * gru_1_out_t4_26 + (-0.17544260621070862) * gru_1_out_t4_27 + (-0.62958014011383057) * gru_1_out_t4_28 + (0.092493988573551178) * gru_1_out_t4_29 + (-0.58007127046585083) * gru_1_out_t4_30 + (-0.4226250946521759) * gru_1_out_t4_31 + (-0.2568916380405426) * gru_1_out_t4_32 + (0.091812878847122192) * gru_1_out_t4_33 + (0.18751995265483856) * gru_1_out_t4_34 + (0.060393389314413071) * gru_1_out_t4_35 + (0.35314089059829712) * gru_1_out_t4_36 + (-0.11833905428647995) * gru_1_out_t4_37 + (-0.18323914706707001) * gru_1_out_t4_38 + (-0.24519811570644379) * gru_1_out_t4_39 + (0.14984457194805145) * gru_1_out_t4_40 + (0.21662570536136627) * gru_1_out_t4_41 + (-0.16619804501533508) * gru_1_out_t4_42 + (0.17088386416435242) * gru_1_out_t4_43 + (0.017262261360883713) * gru_1_out_t4_44 + (0.12087768316268921) * gru_1_out_t4_45 + (-0.3103451132774353) * gru_1_out_t4_46 + (-0.080620661377906799) * gru_1_out_t4_47 + (0.43480792641639709) * gru_1_out_t4_48 + (-0.40495580434799194) * gru_1_out_t4_49 + (0.027710899710655212) * gru_1_out_t4_50 + (0.16922628879547119) * gru_1_out_t4_51 + (-1.2342755794525146) * gru_1_out_t4_52 + (0.10955343395471573) * gru_1_out_t4_53 + (-0.27639266848564148) * gru_1_out_t4_54 + (-0.80080634355545044) * gru_1_out_t4_55 + (0.24041570723056793) * gru_1_out_t4_56 + (0.15113784372806549) * gru_1_out_t4_57 + (-0.67512649297714233) * gru_1_out_t4_58 + (0.23366011679172516) * gru_1_out_t4_59 + (0.018135072663426399) * gru_1_out_t4_60 + (-0.30419430136680603) * gru_1_out_t4_61 + (0.15037168562412262) * gru_1_out_t4_62 + (-0.20471686124801636) * gru_1_out_t4_63 + (-0.4058917760848999) * gru_2_fwd_t3_h_0 + (-0.71384364366531372) * gru_2_fwd_t3_h_1 + (0.39745870232582092) * gru_2_fwd_t3_h_2 + (-0.36596402525901794) * gru_2_fwd_t3_h_3 + (0.24526423215866089) * gru_2_fwd_t3_h_4 + (-0.071462817490100861) * gru_2_fwd_t3_h_5 + (-0.28501427173614502) * gru_2_fwd_t3_h_6 + (-0.011437088251113892) * gru_2_fwd_t3_h_7 + (-0.095980927348136902) * gru_2_fwd_t3_h_8 + (0.44096764922142029) * gru_2_fwd_t3_h_9 + (-0.029011625796556473) * gru_2_fwd_t3_h_10 + (-0.87999469041824341) * gru_2_fwd_t3_h_11 + (0.67910820245742798) * gru_2_fwd_t3_h_12 + (-1.6927375793457031) * gru_2_fwd_t3_h_13 + (-0.064469911158084869) * gru_2_fwd_t3_h_14 + (-0.50562351942062378) * gru_2_fwd_t3_h_15 + (0.31539228558540344) * gru_2_fwd_t3_h_16 + (1.4047272205352783) * gru_2_fwd_t3_h_17 + (-0.24742278456687927) * gru_2_fwd_t3_h_18 + (-0.70993602275848389) * gru_2_fwd_t3_h_19 + (-0.16743884980678558) * gru_2_fwd_t3_h_20 + (0.12194518744945526) * gru_2_fwd_t3_h_21 + (-0.26792037487030029) * gru_2_fwd_t3_h_22 + (0.70886248350143433) * gru_2_fwd_t3_h_23 + (-0.26537701487541199) * gru_2_fwd_t3_h_24 + (0.42129155993461609) * gru_2_fwd_t3_h_25 + (-0.26620462536811829) * gru_2_fwd_t3_h_26 + (-0.2700444757938385) * gru_2_fwd_t3_h_27 + (-0.36272376775741577) * gru_2_fwd_t3_h_28 + (0.64427304267883301) * gru_2_fwd_t3_h_29 + (-0.10227981954813004) * gru_2_fwd_t3_h_30 + (0.47395217418670654) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.41642266511917114) + (0.11714036017656326) * gru_1_out_t4_0 + (0.5222594141960144) * gru_1_out_t4_1 + (0.76402127742767334) * gru_1_out_t4_2 + (-0.29072558879852295) * gru_1_out_t4_3 + (1.0969754457473755) * gru_1_out_t4_4 + (-0.98854696750640869) * gru_1_out_t4_5 + (0.17492711544036865) * gru_1_out_t4_6 + (0.46315410733222961) * gru_1_out_t4_7 + (-0.4145064651966095) * gru_1_out_t4_8 + (-0.01855962723493576) * gru_1_out_t4_9 + (-0.42074564099311829) * gru_1_out_t4_10 + (-0.33555522561073303) * gru_1_out_t4_11 + (-0.090121261775493622) * gru_1_out_t4_12 + (-0.092883355915546417) * gru_1_out_t4_13 + (-0.96939307451248169) * gru_1_out_t4_14 + (-0.15521591901779175) * gru_1_out_t4_15 + (0.32812392711639404) * gru_1_out_t4_16 + (-0.67072278261184692) * gru_1_out_t4_17 + (-0.44426119327545166) * gru_1_out_t4_18 + (-0.40832117199897766) * gru_1_out_t4_19 + (0.10177379101514816) * gru_1_out_t4_20 + (-0.066158764064311981) * gru_1_out_t4_21 + (-0.71039706468582153) * gru_1_out_t4_22 + (0.23189535737037659) * gru_1_out_t4_23 + (-1.36479651927948) * gru_1_out_t4_24 + (-0.36136558651924133) * gru_1_out_t4_25 + (-1.1804836988449097) * gru_1_out_t4_26 + (0.15850247442722321) * gru_1_out_t4_27 + (-1.5394659042358398) * gru_1_out_t4_28 + (-0.36666017770767212) * gru_1_out_t4_29 + (-0.46622428297996521) * gru_1_out_t4_30 + (0.37768560647964478) * gru_1_out_t4_31 + (-2.4645829200744629) * gru_1_out_t4_32 + (-0.01847931370139122) * gru_1_out_t4_33 + (0.61493504047393799) * gru_1_out_t4_34 + (-0.55340856313705444) * gru_1_out_t4_35 + (-0.023607080802321434) * gru_1_out_t4_36 + (0.76896941661834717) * gru_1_out_t4_37 + (-0.64609497785568237) * gru_1_out_t4_38 + (0.64323264360427856) * gru_1_out_t4_39 + (-0.54122722148895264) * gru_1_out_t4_40 + (-0.38456413149833679) * gru_1_out_t4_41 + (-0.39147546887397766) * gru_1_out_t4_42 + (-0.73891347646713257) * gru_1_out_t4_43 + (-0.61506515741348267) * gru_1_out_t4_44 + (-0.13199800252914429) * gru_1_out_t4_45 + (0.54029601812362671) * gru_1_out_t4_46 + (-1.0548179149627686) * gru_1_out_t4_47 + (-0.5677449107170105) * gru_1_out_t4_48 + (-0.29357495903968811) * gru_1_out_t4_49 + (-0.33273968100547791) * gru_1_out_t4_50 + (-0.77738118171691895) * gru_1_out_t4_51 + (1.2557326555252075) * gru_1_out_t4_52 + (0.13370299339294434) * gru_1_out_t4_53 + (-0.26614496111869812) * gru_1_out_t4_54 + (0.14113572239875793) * gru_1_out_t4_55 + (-0.30691847205162048) * gru_1_out_t4_56 + (-0.38899561762809753) * gru_1_out_t4_57 + (0.47738951444625854) * gru_1_out_t4_58 + (-0.042010292410850525) * gru_1_out_t4_59 + (-0.37414801120758057) * gru_1_out_t4_60 + (0.4288632869720459) * gru_1_out_t4_61 + (1.0886400938034058) * gru_1_out_t4_62 + (-0.47426879405975342) * gru_1_out_t4_63 + gate_r * ((-0.16186384856700897) + (0.015696607530117035) * gru_2_fwd_t3_h_0 + (-0.063901692628860474) * gru_2_fwd_t3_h_1 + (0.54926055669784546) * gru_2_fwd_t3_h_2 + (-1.064897894859314) * gru_2_fwd_t3_h_3 + (-0.54872536659240723) * gru_2_fwd_t3_h_4 + (0.14024543762207031) * gru_2_fwd_t3_h_5 + (0.69422441720962524) * gru_2_fwd_t3_h_6 + (0.36955112218856812) * gru_2_fwd_t3_h_7 + (-0.23462675511837006) * gru_2_fwd_t3_h_8 + (-0.60816949605941772) * gru_2_fwd_t3_h_9 + (-1.3937956094741821) * gru_2_fwd_t3_h_10 + (0.36881682276725769) * gru_2_fwd_t3_h_11 + (0.26060673594474792) * gru_2_fwd_t3_h_12 + (1.5182687044143677) * gru_2_fwd_t3_h_13 + (0.21454437077045441) * gru_2_fwd_t3_h_14 + (-0.0027025800663977861) * gru_2_fwd_t3_h_15 + (-0.066841199994087219) * gru_2_fwd_t3_h_16 + (-0.21349562704563141) * gru_2_fwd_t3_h_17 + (-0.053666591644287109) * gru_2_fwd_t3_h_18 + (-0.46285966038703918) * gru_2_fwd_t3_h_19 + (-0.099989920854568481) * gru_2_fwd_t3_h_20 + (-0.8583717942237854) * gru_2_fwd_t3_h_21 + (0.96211373805999756) * gru_2_fwd_t3_h_22 + (-0.12313795834779739) * gru_2_fwd_t3_h_23 + (0.076301626861095428) * gru_2_fwd_t3_h_24 + (-0.32083621621131897) * gru_2_fwd_t3_h_25 + (0.06182435154914856) * gru_2_fwd_t3_h_26 + (0.48448902368545532) * gru_2_fwd_t3_h_27 + (0.14682714641094208) * gru_2_fwd_t3_h_28 + (-0.12085271626710892) * gru_2_fwd_t3_h_29 + (-0.45747986435890198) * gru_2_fwd_t3_h_30 + (0.53504377603530884) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_17 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_17;
    // h=18
    gate_r = sigmoid((1.6537623405456543) + (0.14032736420631409) * gru_1_out_t4_0 + (-0.82460731267929077) * gru_1_out_t4_1 + (-0.81588965654373169) * gru_1_out_t4_2 + (0.028317209333181381) * gru_1_out_t4_3 + (0.38674828410148621) * gru_1_out_t4_4 + (-1.7346780300140381) * gru_1_out_t4_5 + (-0.57491976022720337) * gru_1_out_t4_6 + (-0.045937430113554001) * gru_1_out_t4_7 + (-0.62407964468002319) * gru_1_out_t4_8 + (0.040837205946445465) * gru_1_out_t4_9 + (0.36525526642799377) * gru_1_out_t4_10 + (0.58658301830291748) * gru_1_out_t4_11 + (-0.39318588376045227) * gru_1_out_t4_12 + (0.17779988050460815) * gru_1_out_t4_13 + (-0.43312537670135498) * gru_1_out_t4_14 + (-0.14125637710094452) * gru_1_out_t4_15 + (-0.96216362714767456) * gru_1_out_t4_16 + (1.0204846858978271) * gru_1_out_t4_17 + (1.0388555526733398) * gru_1_out_t4_18 + (0.82015854120254517) * gru_1_out_t4_19 + (-0.29440736770629883) * gru_1_out_t4_20 + (-2.0000736713409424) * gru_1_out_t4_21 + (0.62953346967697144) * gru_1_out_t4_22 + (-0.86841762065887451) * gru_1_out_t4_23 + (0.29648840427398682) * gru_1_out_t4_24 + (0.59554940462112427) * gru_1_out_t4_25 + (1.8569091558456421) * gru_1_out_t4_26 + (2.2288055419921875) * gru_1_out_t4_27 + (-0.18814773857593536) * gru_1_out_t4_28 + (0.37637963891029358) * gru_1_out_t4_29 + (-0.16659910976886749) * gru_1_out_t4_30 + (-1.45667564868927) * gru_1_out_t4_31 + (-0.3779035210609436) * gru_1_out_t4_32 + (1.4947949647903442) * gru_1_out_t4_33 + (-0.37525996565818787) * gru_1_out_t4_34 + (-0.037181925028562546) * gru_1_out_t4_35 + (0.43332582712173462) * gru_1_out_t4_36 + (-1.1162011623382568) * gru_1_out_t4_37 + (-0.25860664248466492) * gru_1_out_t4_38 + (-0.67701929807662964) * gru_1_out_t4_39 + (-0.38020309805870056) * gru_1_out_t4_40 + (0.58804643154144287) * gru_1_out_t4_41 + (-0.45220386981964111) * gru_1_out_t4_42 + (-1.4146767854690552) * gru_1_out_t4_43 + (-0.91696518659591675) * gru_1_out_t4_44 + (-1.18896484375) * gru_1_out_t4_45 + (-0.79334461688995361) * gru_1_out_t4_46 + (-0.72255170345306396) * gru_1_out_t4_47 + (-0.92481344938278198) * gru_1_out_t4_48 + (2.778430700302124) * gru_1_out_t4_49 + (0.37811192870140076) * gru_1_out_t4_50 + (0.23819118738174438) * gru_1_out_t4_51 + (-0.7206997275352478) * gru_1_out_t4_52 + (-1.4153844118118286) * gru_1_out_t4_53 + (0.04668227955698967) * gru_1_out_t4_54 + (-0.72015529870986938) * gru_1_out_t4_55 + (2.1135594844818115) * gru_1_out_t4_56 + (0.23865814507007599) * gru_1_out_t4_57 + (0.80568933486938477) * gru_1_out_t4_58 + (-0.70690619945526123) * gru_1_out_t4_59 + (-2.0822029113769531) * gru_1_out_t4_60 + (1.0345476865768433) * gru_1_out_t4_61 + (-0.90774935483932495) * gru_1_out_t4_62 + (0.28050273656845093) * gru_1_out_t4_63 + (0.86964231729507446) * gru_2_fwd_t3_h_0 + (1.0816502571105957) * gru_2_fwd_t3_h_1 + (0.16879181563854218) * gru_2_fwd_t3_h_2 + (-0.34506484866142273) * gru_2_fwd_t3_h_3 + (0.24044354259967804) * gru_2_fwd_t3_h_4 + (0.93216210603713989) * gru_2_fwd_t3_h_5 + (2.6333286762237549) * gru_2_fwd_t3_h_6 + (1.0499686002731323) * gru_2_fwd_t3_h_7 + (-0.59557175636291504) * gru_2_fwd_t3_h_8 + (-0.6930730938911438) * gru_2_fwd_t3_h_9 + (0.93804216384887695) * gru_2_fwd_t3_h_10 + (0.20681031048297882) * gru_2_fwd_t3_h_11 + (-1.0007140636444092) * gru_2_fwd_t3_h_12 + (2.8928773403167725) * gru_2_fwd_t3_h_13 + (0.55744248628616333) * gru_2_fwd_t3_h_14 + (0.23176231980323792) * gru_2_fwd_t3_h_15 + (-0.24163782596588135) * gru_2_fwd_t3_h_16 + (0.037316456437110901) * gru_2_fwd_t3_h_17 + (0.45583677291870117) * gru_2_fwd_t3_h_18 + (0.25462502241134644) * gru_2_fwd_t3_h_19 + (-0.38185170292854309) * gru_2_fwd_t3_h_20 + (-0.62589424848556519) * gru_2_fwd_t3_h_21 + (0.039114285260438919) * gru_2_fwd_t3_h_22 + (0.19591817259788513) * gru_2_fwd_t3_h_23 + (0.15806670486927032) * gru_2_fwd_t3_h_24 + (-0.15808641910552979) * gru_2_fwd_t3_h_25 + (0.032270893454551697) * gru_2_fwd_t3_h_26 + (0.37567877769470215) * gru_2_fwd_t3_h_27 + (-0.67229312658309937) * gru_2_fwd_t3_h_28 + (0.3343144953250885) * gru_2_fwd_t3_h_29 + (-0.01690656878054142) * gru_2_fwd_t3_h_30 + (-0.092292845249176025) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.1553758829832077) + (-1.2147040367126465) * gru_1_out_t4_0 + (-0.39048600196838379) * gru_1_out_t4_1 + (-0.041542172431945801) * gru_1_out_t4_2 + (-0.79396843910217285) * gru_1_out_t4_3 + (0.90189856290817261) * gru_1_out_t4_4 + (-0.085298493504524231) * gru_1_out_t4_5 + (-0.84412044286727905) * gru_1_out_t4_6 + (0.46545085310935974) * gru_1_out_t4_7 + (0.54792451858520508) * gru_1_out_t4_8 + (-0.034488048404455185) * gru_1_out_t4_9 + (0.39200380444526672) * gru_1_out_t4_10 + (1.8015854358673096) * gru_1_out_t4_11 + (0.43239209055900574) * gru_1_out_t4_12 + (0.95036458969116211) * gru_1_out_t4_13 + (0.59072768688201904) * gru_1_out_t4_14 + (0.49409019947052002) * gru_1_out_t4_15 + (0.26906085014343262) * gru_1_out_t4_16 + (-0.98732542991638184) * gru_1_out_t4_17 + (-0.0030904433224350214) * gru_1_out_t4_18 + (0.47917729616165161) * gru_1_out_t4_19 + (0.12843906879425049) * gru_1_out_t4_20 + (-0.80814170837402344) * gru_1_out_t4_21 + (-0.1979982852935791) * gru_1_out_t4_22 + (-0.0013349559158086777) * gru_1_out_t4_23 + (-2.8546137809753418) * gru_1_out_t4_24 + (0.41883385181427002) * gru_1_out_t4_25 + (0.69233506917953491) * gru_1_out_t4_26 + (0.68680316209793091) * gru_1_out_t4_27 + (1.0072536468505859) * gru_1_out_t4_28 + (-0.047480713576078415) * gru_1_out_t4_29 + (0.94622278213500977) * gru_1_out_t4_30 + (-0.70551216602325439) * gru_1_out_t4_31 + (-1.016222357749939) * gru_1_out_t4_32 + (-0.024237683042883873) * gru_1_out_t4_33 + (0.47041937708854675) * gru_1_out_t4_34 + (0.077269189059734344) * gru_1_out_t4_35 + (0.62714570760726929) * gru_1_out_t4_36 + (0.90259367227554321) * gru_1_out_t4_37 + (0.95460641384124756) * gru_1_out_t4_38 + (0.49607834219932556) * gru_1_out_t4_39 + (-1.0926554203033447) * gru_1_out_t4_40 + (-0.90540981292724609) * gru_1_out_t4_41 + (0.84869223833084106) * gru_1_out_t4_42 + (0.17650653421878815) * gru_1_out_t4_43 + (-0.13000354170799255) * gru_1_out_t4_44 + (-0.2221125066280365) * gru_1_out_t4_45 + (0.10668648779392242) * gru_1_out_t4_46 + (1.4696515798568726) * gru_1_out_t4_47 + (-1.0813385248184204) * gru_1_out_t4_48 + (-0.50821095705032349) * gru_1_out_t4_49 + (-0.39519026875495911) * gru_1_out_t4_50 + (-1.9377769231796265) * gru_1_out_t4_51 + (0.34250363707542419) * gru_1_out_t4_52 + (-0.67615938186645508) * gru_1_out_t4_53 + (0.28203338384628296) * gru_1_out_t4_54 + (0.54079598188400269) * gru_1_out_t4_55 + (-1.9021377563476562) * gru_1_out_t4_56 + (-0.41894125938415527) * gru_1_out_t4_57 + (-0.21807673573493958) * gru_1_out_t4_58 + (0.16892686486244202) * gru_1_out_t4_59 + (0.85537362098693848) * gru_1_out_t4_60 + (0.10158512741327286) * gru_1_out_t4_61 + (1.1488193273544312) * gru_1_out_t4_62 + (-0.4339354932308197) * gru_1_out_t4_63 + (0.16650134325027466) * gru_2_fwd_t3_h_0 + (0.40749314427375793) * gru_2_fwd_t3_h_1 + (0.81357914209365845) * gru_2_fwd_t3_h_2 + (-0.094563476741313934) * gru_2_fwd_t3_h_3 + (0.2298596054315567) * gru_2_fwd_t3_h_4 + (-0.33797529339790344) * gru_2_fwd_t3_h_5 + (0.50885307788848877) * gru_2_fwd_t3_h_6 + (-1.167805552482605) * gru_2_fwd_t3_h_7 + (0.085828207433223724) * gru_2_fwd_t3_h_8 + (0.35966944694519043) * gru_2_fwd_t3_h_9 + (1.1512904167175293) * gru_2_fwd_t3_h_10 + (0.4241478443145752) * gru_2_fwd_t3_h_11 + (-0.019356947392225266) * gru_2_fwd_t3_h_12 + (1.7953906059265137) * gru_2_fwd_t3_h_13 + (-0.78668999671936035) * gru_2_fwd_t3_h_14 + (0.80442553758621216) * gru_2_fwd_t3_h_15 + (-0.6843220591545105) * gru_2_fwd_t3_h_16 + (0.28619146347045898) * gru_2_fwd_t3_h_17 + (0.36994177103042603) * gru_2_fwd_t3_h_18 + (0.051252707839012146) * gru_2_fwd_t3_h_19 + (0.34614041447639465) * gru_2_fwd_t3_h_20 + (-1.478379487991333) * gru_2_fwd_t3_h_21 + (-0.81883710622787476) * gru_2_fwd_t3_h_22 + (-0.10815779119729996) * gru_2_fwd_t3_h_23 + (-1.7502768039703369) * gru_2_fwd_t3_h_24 + (-0.12207687646150589) * gru_2_fwd_t3_h_25 + (-0.43232467770576477) * gru_2_fwd_t3_h_26 + (0.21179619431495667) * gru_2_fwd_t3_h_27 + (0.076893329620361328) * gru_2_fwd_t3_h_28 + (-0.69731783866882324) * gru_2_fwd_t3_h_29 + (-0.34181565046310425) * gru_2_fwd_t3_h_30 + (0.54809623956680298) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-1.0693172216415405) + (-0.25192573666572571) * gru_1_out_t4_0 + (-0.28266581892967224) * gru_1_out_t4_1 + (0.83579695224761963) * gru_1_out_t4_2 + (-0.44305452704429626) * gru_1_out_t4_3 + (1.4684075117111206) * gru_1_out_t4_4 + (-0.19693005084991455) * gru_1_out_t4_5 + (0.23710620403289795) * gru_1_out_t4_6 + (0.49320673942565918) * gru_1_out_t4_7 + (-0.33207571506500244) * gru_1_out_t4_8 + (0.5565524697303772) * gru_1_out_t4_9 + (0.04459710419178009) * gru_1_out_t4_10 + (-0.23437049984931946) * gru_1_out_t4_11 + (-0.25436654686927795) * gru_1_out_t4_12 + (0.17508456110954285) * gru_1_out_t4_13 + (0.03863060474395752) * gru_1_out_t4_14 + (-0.17095041275024414) * gru_1_out_t4_15 + (0.14404350519180298) * gru_1_out_t4_16 + (-0.47490984201431274) * gru_1_out_t4_17 + (0.16544297337532043) * gru_1_out_t4_18 + (0.533866286277771) * gru_1_out_t4_19 + (0.34124881029129028) * gru_1_out_t4_20 + (-0.12221422046422958) * gru_1_out_t4_21 + (2.2402713298797607) * gru_1_out_t4_22 + (0.98390913009643555) * gru_1_out_t4_23 + (-1.4166406393051147) * gru_1_out_t4_24 + (-0.36884057521820068) * gru_1_out_t4_25 + (0.49567002058029175) * gru_1_out_t4_26 + (0.18790601193904877) * gru_1_out_t4_27 + (-0.35605815052986145) * gru_1_out_t4_28 + (1.37518310546875) * gru_1_out_t4_29 + (-0.59660941362380981) * gru_1_out_t4_30 + (-0.047309335321187973) * gru_1_out_t4_31 + (-0.10433258861303329) * gru_1_out_t4_32 + (0.093743637204170227) * gru_1_out_t4_33 + (-0.38484188914299011) * gru_1_out_t4_34 + (0.44660535454750061) * gru_1_out_t4_35 + (-0.57084095478057861) * gru_1_out_t4_36 + (0.65078091621398926) * gru_1_out_t4_37 + (0.63564378023147583) * gru_1_out_t4_38 + (0.21412527561187744) * gru_1_out_t4_39 + (-0.11687731742858887) * gru_1_out_t4_40 + (-0.084363862872123718) * gru_1_out_t4_41 + (0.2136380523443222) * gru_1_out_t4_42 + (-0.13535203039646149) * gru_1_out_t4_43 + (-1.6679602861404419) * gru_1_out_t4_44 + (0.92061978578567505) * gru_1_out_t4_45 + (0.12794570624828339) * gru_1_out_t4_46 + (0.88302642107009888) * gru_1_out_t4_47 + (0.39956328272819519) * gru_1_out_t4_48 + (0.37883219122886658) * gru_1_out_t4_49 + (0.34840700030326843) * gru_1_out_t4_50 + (-0.20495675504207611) * gru_1_out_t4_51 + (0.25870072841644287) * gru_1_out_t4_52 + (-0.97806596755981445) * gru_1_out_t4_53 + (0.37642383575439453) * gru_1_out_t4_54 + (-0.464681476354599) * gru_1_out_t4_55 + (-1.2760758399963379) * gru_1_out_t4_56 + (-0.045984264463186264) * gru_1_out_t4_57 + (0.15920679271221161) * gru_1_out_t4_58 + (0.99638074636459351) * gru_1_out_t4_59 + (-0.62279713153839111) * gru_1_out_t4_60 + (-0.71863508224487305) * gru_1_out_t4_61 + (0.51895487308502197) * gru_1_out_t4_62 + (-0.9066203236579895) * gru_1_out_t4_63 + gate_r * ((-1.4315930604934692) + (-0.945514976978302) * gru_2_fwd_t3_h_0 + (0.47723206877708435) * gru_2_fwd_t3_h_1 + (-0.16096615791320801) * gru_2_fwd_t3_h_2 + (-0.11477550864219666) * gru_2_fwd_t3_h_3 + (-1.8874155282974243) * gru_2_fwd_t3_h_4 + (0.24192185699939728) * gru_2_fwd_t3_h_5 + (-0.3051639199256897) * gru_2_fwd_t3_h_6 + (0.85097193717956543) * gru_2_fwd_t3_h_7 + (-0.58873134851455688) * gru_2_fwd_t3_h_8 + (1.0782917737960815) * gru_2_fwd_t3_h_9 + (0.21001413464546204) * gru_2_fwd_t3_h_10 + (0.84518742561340332) * gru_2_fwd_t3_h_11 + (-1.413139820098877) * gru_2_fwd_t3_h_12 + (0.034624744206666946) * gru_2_fwd_t3_h_13 + (0.33977130055427551) * gru_2_fwd_t3_h_14 + (0.96115678548812866) * gru_2_fwd_t3_h_15 + (0.020610097795724869) * gru_2_fwd_t3_h_16 + (-0.6950148344039917) * gru_2_fwd_t3_h_17 + (-0.25049597024917603) * gru_2_fwd_t3_h_18 + (0.38450828194618225) * gru_2_fwd_t3_h_19 + (0.051080368459224701) * gru_2_fwd_t3_h_20 + (1.4475705623626709) * gru_2_fwd_t3_h_21 + (0.1164625957608223) * gru_2_fwd_t3_h_22 + (0.065216749906539917) * gru_2_fwd_t3_h_23 + (0.38616138696670532) * gru_2_fwd_t3_h_24 + (-0.4848625659942627) * gru_2_fwd_t3_h_25 + (0.39840477705001831) * gru_2_fwd_t3_h_26 + (-0.47220876812934875) * gru_2_fwd_t3_h_27 + (0.65183329582214355) * gru_2_fwd_t3_h_28 + (0.013682641088962555) * gru_2_fwd_t3_h_29 + (0.043543815612792969) * gru_2_fwd_t3_h_30 + (-0.086036317050457001) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_18 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_18;
    // h=19
    gate_r = sigmoid((-0.082705333828926086) + (-0.44868692755699158) * gru_1_out_t4_0 + (-0.28306975960731506) * gru_1_out_t4_1 + (0.39466974139213562) * gru_1_out_t4_2 + (-1.0755223035812378) * gru_1_out_t4_3 + (0.10705868154764175) * gru_1_out_t4_4 + (1.5740941762924194) * gru_1_out_t4_5 + (2.279353141784668) * gru_1_out_t4_6 + (0.53292948007583618) * gru_1_out_t4_7 + (0.2357281893491745) * gru_1_out_t4_8 + (0.097594976425170898) * gru_1_out_t4_9 + (0.16091369092464447) * gru_1_out_t4_10 + (1.2094660997390747) * gru_1_out_t4_11 + (-0.14277607202529907) * gru_1_out_t4_12 + (0.2116868793964386) * gru_1_out_t4_13 + (1.4425392150878906) * gru_1_out_t4_14 + (-3.6258003711700439) * gru_1_out_t4_15 + (0.70254504680633545) * gru_1_out_t4_16 + (1.2153282165527344) * gru_1_out_t4_17 + (-1.5287282466888428) * gru_1_out_t4_18 + (-0.18310651183128357) * gru_1_out_t4_19 + (0.9697914719581604) * gru_1_out_t4_20 + (0.0671854168176651) * gru_1_out_t4_21 + (3.0409255027770996) * gru_1_out_t4_22 + (0.33833596110343933) * gru_1_out_t4_23 + (0.98040390014648438) * gru_1_out_t4_24 + (-0.96533691883087158) * gru_1_out_t4_25 + (-0.86658221483230591) * gru_1_out_t4_26 + (0.27932292222976685) * gru_1_out_t4_27 + (0.080482609570026398) * gru_1_out_t4_28 + (3.1375911235809326) * gru_1_out_t4_29 + (-0.4937853217124939) * gru_1_out_t4_30 + (1.1026943922042847) * gru_1_out_t4_31 + (-1.1479597091674805) * gru_1_out_t4_32 + (0.17000123858451843) * gru_1_out_t4_33 + (1.6744221448898315) * gru_1_out_t4_34 + (0.42256233096122742) * gru_1_out_t4_35 + (-0.78615760803222656) * gru_1_out_t4_36 + (2.0286450386047363) * gru_1_out_t4_37 + (-1.8184469938278198) * gru_1_out_t4_38 + (4.1371059417724609) * gru_1_out_t4_39 + (-2.855588436126709) * gru_1_out_t4_40 + (0.17215509712696075) * gru_1_out_t4_41 + (-1.5880502462387085) * gru_1_out_t4_42 + (1.2891795635223389) * gru_1_out_t4_43 + (-1.599605917930603) * gru_1_out_t4_44 + (-0.16723747551441193) * gru_1_out_t4_45 + (-0.86345744132995605) * gru_1_out_t4_46 + (-1.8756604194641113) * gru_1_out_t4_47 + (0.7484060525894165) * gru_1_out_t4_48 + (-1.6269928216934204) * gru_1_out_t4_49 + (-2.4983439445495605) * gru_1_out_t4_50 + (-0.14081129431724548) * gru_1_out_t4_51 + (0.61693716049194336) * gru_1_out_t4_52 + (-1.3924973011016846) * gru_1_out_t4_53 + (0.89373761415481567) * gru_1_out_t4_54 + (1.9406865835189819) * gru_1_out_t4_55 + (-1.5794007778167725) * gru_1_out_t4_56 + (0.05786069855093956) * gru_1_out_t4_57 + (1.7485240697860718) * gru_1_out_t4_58 + (0.30989328026771545) * gru_1_out_t4_59 + (2.2391476631164551) * gru_1_out_t4_60 + (-0.27561572194099426) * gru_1_out_t4_61 + (-0.41094547510147095) * gru_1_out_t4_62 + (0.7239764928817749) * gru_1_out_t4_63 + (0.24131105840206146) * gru_2_fwd_t3_h_0 + (0.2400309145450592) * gru_2_fwd_t3_h_1 + (0.25514054298400879) * gru_2_fwd_t3_h_2 + (-0.048791296780109406) * gru_2_fwd_t3_h_3 + (-1.0159910917282104) * gru_2_fwd_t3_h_4 + (0.39190647006034851) * gru_2_fwd_t3_h_5 + (0.20992973446846008) * gru_2_fwd_t3_h_6 + (-0.57650703191757202) * gru_2_fwd_t3_h_7 + (-0.25204560160636902) * gru_2_fwd_t3_h_8 + (0.22617372870445251) * gru_2_fwd_t3_h_9 + (-0.052995380014181137) * gru_2_fwd_t3_h_10 + (-0.42715924978256226) * gru_2_fwd_t3_h_11 + (0.25354769825935364) * gru_2_fwd_t3_h_12 + (0.051379870623350143) * gru_2_fwd_t3_h_13 + (0.86077874898910522) * gru_2_fwd_t3_h_14 + (-0.48609340190887451) * gru_2_fwd_t3_h_15 + (1.864531397819519) * gru_2_fwd_t3_h_16 + (-0.43582522869110107) * gru_2_fwd_t3_h_17 + (-0.20411938428878784) * gru_2_fwd_t3_h_18 + (-0.19762067496776581) * gru_2_fwd_t3_h_19 + (0.12629687786102295) * gru_2_fwd_t3_h_20 + (0.96962016820907593) * gru_2_fwd_t3_h_21 + (0.49995589256286621) * gru_2_fwd_t3_h_22 + (0.54330974817276001) * gru_2_fwd_t3_h_23 + (-0.32519307732582092) * gru_2_fwd_t3_h_24 + (-1.5781079530715942) * gru_2_fwd_t3_h_25 + (-0.14115935564041138) * gru_2_fwd_t3_h_26 + (-0.73267978429794312) * gru_2_fwd_t3_h_27 + (-0.54924601316452026) * gru_2_fwd_t3_h_28 + (-0.61893570423126221) * gru_2_fwd_t3_h_29 + (-0.1286076158285141) * gru_2_fwd_t3_h_30 + (-0.35401713848114014) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.077814921736717224) + (0.63697302341461182) * gru_1_out_t4_0 + (-0.14346611499786377) * gru_1_out_t4_1 + (-0.61499226093292236) * gru_1_out_t4_2 + (-0.17845933139324188) * gru_1_out_t4_3 + (-0.15711662173271179) * gru_1_out_t4_4 + (0.22258754074573517) * gru_1_out_t4_5 + (0.54833728075027466) * gru_1_out_t4_6 + (-0.43454524874687195) * gru_1_out_t4_7 + (1.115496039390564) * gru_1_out_t4_8 + (0.29394704103469849) * gru_1_out_t4_9 + (-0.17762929201126099) * gru_1_out_t4_10 + (1.7007285356521606) * gru_1_out_t4_11 + (0.089686118066310883) * gru_1_out_t4_12 + (1.1293877363204956) * gru_1_out_t4_13 + (1.3469816446304321) * gru_1_out_t4_14 + (0.31393662095069885) * gru_1_out_t4_15 + (0.036681924015283585) * gru_1_out_t4_16 + (0.18968114256858826) * gru_1_out_t4_17 + (-0.75905084609985352) * gru_1_out_t4_18 + (0.47812896966934204) * gru_1_out_t4_19 + (-0.36430403590202332) * gru_1_out_t4_20 + (-1.0855014324188232) * gru_1_out_t4_21 + (-0.090647734701633453) * gru_1_out_t4_22 + (-0.13151374459266663) * gru_1_out_t4_23 + (0.26169553399085999) * gru_1_out_t4_24 + (-0.73688894510269165) * gru_1_out_t4_25 + (-0.82528340816497803) * gru_1_out_t4_26 + (-0.20312047004699707) * gru_1_out_t4_27 + (0.74607276916503906) * gru_1_out_t4_28 + (-0.09418071061372757) * gru_1_out_t4_29 + (0.32526910305023193) * gru_1_out_t4_30 + (0.48001095652580261) * gru_1_out_t4_31 + (1.3767868280410767) * gru_1_out_t4_32 + (0.21025243401527405) * gru_1_out_t4_33 + (-0.097300238907337189) * gru_1_out_t4_34 + (0.45277690887451172) * gru_1_out_t4_35 + (0.09323476254940033) * gru_1_out_t4_36 + (0.14149963855743408) * gru_1_out_t4_37 + (-0.4833509624004364) * gru_1_out_t4_38 + (-0.005415765568614006) * gru_1_out_t4_39 + (-0.13088269531726837) * gru_1_out_t4_40 + (-0.71513211727142334) * gru_1_out_t4_41 + (-0.28043821454048157) * gru_1_out_t4_42 + (0.0096608102321624756) * gru_1_out_t4_43 + (-0.9255407452583313) * gru_1_out_t4_44 + (0.23069167137145996) * gru_1_out_t4_45 + (0.48643982410430908) * gru_1_out_t4_46 + (0.7568279504776001) * gru_1_out_t4_47 + (-0.62649154663085938) * gru_1_out_t4_48 + (0.097206979990005493) * gru_1_out_t4_49 + (-0.77470576763153076) * gru_1_out_t4_50 + (-0.80738407373428345) * gru_1_out_t4_51 + (0.027657566592097282) * gru_1_out_t4_52 + (-0.072382919490337372) * gru_1_out_t4_53 + (0.27506515383720398) * gru_1_out_t4_54 + (0.11952124536037445) * gru_1_out_t4_55 + (0.20059414207935333) * gru_1_out_t4_56 + (-0.0045003066770732403) * gru_1_out_t4_57 + (-0.10113246738910675) * gru_1_out_t4_58 + (-0.59726989269256592) * gru_1_out_t4_59 + (-0.7995036244392395) * gru_1_out_t4_60 + (-0.142447829246521) * gru_1_out_t4_61 + (-1.048808217048645) * gru_1_out_t4_62 + (0.80408585071563721) * gru_1_out_t4_63 + (0.75549614429473877) * gru_2_fwd_t3_h_0 + (-0.00015494860417675227) * gru_2_fwd_t3_h_1 + (-0.1515679806470871) * gru_2_fwd_t3_h_2 + (1.5878127813339233) * gru_2_fwd_t3_h_3 + (0.40685132145881653) * gru_2_fwd_t3_h_4 + (0.38809728622436523) * gru_2_fwd_t3_h_5 + (-0.53642278909683228) * gru_2_fwd_t3_h_6 + (-0.3024362325668335) * gru_2_fwd_t3_h_7 + (0.49119240045547485) * gru_2_fwd_t3_h_8 + (0.38099420070648193) * gru_2_fwd_t3_h_9 + (-0.27106693387031555) * gru_2_fwd_t3_h_10 + (-0.26924276351928711) * gru_2_fwd_t3_h_11 + (-0.011484093032777309) * gru_2_fwd_t3_h_12 + (-1.4544659852981567) * gru_2_fwd_t3_h_13 + (-0.90204393863677979) * gru_2_fwd_t3_h_14 + (0.68642401695251465) * gru_2_fwd_t3_h_15 + (0.32248717546463013) * gru_2_fwd_t3_h_16 + (0.077834300696849823) * gru_2_fwd_t3_h_17 + (0.084064513444900513) * gru_2_fwd_t3_h_18 + (-0.99449628591537476) * gru_2_fwd_t3_h_19 + (-0.62810599803924561) * gru_2_fwd_t3_h_20 + (0.55833619832992554) * gru_2_fwd_t3_h_21 + (-0.31241893768310547) * gru_2_fwd_t3_h_22 + (-0.012213987298309803) * gru_2_fwd_t3_h_23 + (0.061529342085123062) * gru_2_fwd_t3_h_24 + (-0.73871767520904541) * gru_2_fwd_t3_h_25 + (-0.27037224173545837) * gru_2_fwd_t3_h_26 + (0.22501666843891144) * gru_2_fwd_t3_h_27 + (0.078661598265171051) * gru_2_fwd_t3_h_28 + (-0.71469694375991821) * gru_2_fwd_t3_h_29 + (0.17108698189258575) * gru_2_fwd_t3_h_30 + (-0.11969047784805298) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.2189779132604599) + (0.28241917490959167) * gru_1_out_t4_0 + (0.14336580038070679) * gru_1_out_t4_1 + (-0.11900131404399872) * gru_1_out_t4_2 + (0.73004865646362305) * gru_1_out_t4_3 + (-0.20443500578403473) * gru_1_out_t4_4 + (-0.65724611282348633) * gru_1_out_t4_5 + (0.21926289796829224) * gru_1_out_t4_6 + (-0.63763439655303955) * gru_1_out_t4_7 + (0.52324783802032471) * gru_1_out_t4_8 + (0.35108381509780884) * gru_1_out_t4_9 + (0.48143661022186279) * gru_1_out_t4_10 + (-0.32312384247779846) * gru_1_out_t4_11 + (-0.53880029916763306) * gru_1_out_t4_12 + (0.17210212349891663) * gru_1_out_t4_13 + (0.0029475190676748753) * gru_1_out_t4_14 + (-0.41520342230796814) * gru_1_out_t4_15 + (0.73619061708450317) * gru_1_out_t4_16 + (-0.23945744335651398) * gru_1_out_t4_17 + (-0.14811220765113831) * gru_1_out_t4_18 + (-0.11190328747034073) * gru_1_out_t4_19 + (-0.35382670164108276) * gru_1_out_t4_20 + (-0.59973633289337158) * gru_1_out_t4_21 + (0.35083898901939392) * gru_1_out_t4_22 + (-0.36267709732055664) * gru_1_out_t4_23 + (-1.000982403755188) * gru_1_out_t4_24 + (-0.42616382241249084) * gru_1_out_t4_25 + (0.23261532187461853) * gru_1_out_t4_26 + (-0.51029223203659058) * gru_1_out_t4_27 + (0.43212315440177917) * gru_1_out_t4_28 + (-0.13898201286792755) * gru_1_out_t4_29 + (-0.35991212725639343) * gru_1_out_t4_30 + (0.28611940145492554) * gru_1_out_t4_31 + (-0.45761317014694214) * gru_1_out_t4_32 + (-0.42480877041816711) * gru_1_out_t4_33 + (-0.62117081880569458) * gru_1_out_t4_34 + (0.4993039071559906) * gru_1_out_t4_35 + (-0.84717541933059692) * gru_1_out_t4_36 + (0.027043642476201057) * gru_1_out_t4_37 + (0.23083744943141937) * gru_1_out_t4_38 + (-1.1353816986083984) * gru_1_out_t4_39 + (1.1306647062301636) * gru_1_out_t4_40 + (-0.81602990627288818) * gru_1_out_t4_41 + (-0.21536360681056976) * gru_1_out_t4_42 + (-0.10289443284273148) * gru_1_out_t4_43 + (0.34699112176895142) * gru_1_out_t4_44 + (-0.44609174132347107) * gru_1_out_t4_45 + (0.33727052807807922) * gru_1_out_t4_46 + (1.5131398439407349) * gru_1_out_t4_47 + (1.4810941219329834) * gru_1_out_t4_48 + (0.52498430013656616) * gru_1_out_t4_49 + (1.033739447593689) * gru_1_out_t4_50 + (0.29555109143257141) * gru_1_out_t4_51 + (0.82265746593475342) * gru_1_out_t4_52 + (-0.693572998046875) * gru_1_out_t4_53 + (-0.92421633005142212) * gru_1_out_t4_54 + (0.21460285782814026) * gru_1_out_t4_55 + (-0.30563285946846008) * gru_1_out_t4_56 + (-0.21716932952404022) * gru_1_out_t4_57 + (-0.72355765104293823) * gru_1_out_t4_58 + (0.4334336519241333) * gru_1_out_t4_59 + (-0.16294553875923157) * gru_1_out_t4_60 + (-0.068285718560218811) * gru_1_out_t4_61 + (-0.46519619226455688) * gru_1_out_t4_62 + (-0.12500730156898499) * gru_1_out_t4_63 + gate_r * ((-1.1310220956802368) + (1.0121171474456787) * gru_2_fwd_t3_h_0 + (-1.1709270477294922) * gru_2_fwd_t3_h_1 + (-0.23474419116973877) * gru_2_fwd_t3_h_2 + (1.2465887069702148) * gru_2_fwd_t3_h_3 + (-0.18022707104682922) * gru_2_fwd_t3_h_4 + (0.055305052548646927) * gru_2_fwd_t3_h_5 + (0.075109682977199554) * gru_2_fwd_t3_h_6 + (-0.22822202742099762) * gru_2_fwd_t3_h_7 + (-0.26030445098876953) * gru_2_fwd_t3_h_8 + (1.7554314136505127) * gru_2_fwd_t3_h_9 + (0.64442914724349976) * gru_2_fwd_t3_h_10 + (-0.56486666202545166) * gru_2_fwd_t3_h_11 + (-0.55871814489364624) * gru_2_fwd_t3_h_12 + (-0.076380714774131775) * gru_2_fwd_t3_h_13 + (-0.049353621900081635) * gru_2_fwd_t3_h_14 + (0.50409626960754395) * gru_2_fwd_t3_h_15 + (-0.44437086582183838) * gru_2_fwd_t3_h_16 + (-0.20182126760482788) * gru_2_fwd_t3_h_17 + (0.48812556266784668) * gru_2_fwd_t3_h_18 + (1.1729881763458252) * gru_2_fwd_t3_h_19 + (0.18799875676631927) * gru_2_fwd_t3_h_20 + (0.93810892105102539) * gru_2_fwd_t3_h_21 + (-0.0094738258048892021) * gru_2_fwd_t3_h_22 + (-0.080817908048629761) * gru_2_fwd_t3_h_23 + (0.16439484059810638) * gru_2_fwd_t3_h_24 + (-0.059667568653821945) * gru_2_fwd_t3_h_25 + (1.3411426544189453) * gru_2_fwd_t3_h_26 + (-1.6839385032653809) * gru_2_fwd_t3_h_27 + (0.59461116790771484) * gru_2_fwd_t3_h_28 + (-0.88884347677230835) * gru_2_fwd_t3_h_29 + (-0.52709043025970459) * gru_2_fwd_t3_h_30 + (0.33233720064163208) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_19 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_19;
    // h=20
    gate_r = sigmoid((-0.54950141906738281) + (-0.028445389121770859) * gru_1_out_t4_0 + (0.57196241617202759) * gru_1_out_t4_1 + (-0.50093179941177368) * gru_1_out_t4_2 + (0.26136931777000427) * gru_1_out_t4_3 + (0.3020966649055481) * gru_1_out_t4_4 + (1.9116518497467041) * gru_1_out_t4_5 + (0.22054798901081085) * gru_1_out_t4_6 + (0.33286646008491516) * gru_1_out_t4_7 + (-0.6626552939414978) * gru_1_out_t4_8 + (0.49234423041343689) * gru_1_out_t4_9 + (0.52370560169219971) * gru_1_out_t4_10 + (0.83678722381591797) * gru_1_out_t4_11 + (0.35026296973228455) * gru_1_out_t4_12 + (-0.090534418821334839) * gru_1_out_t4_13 + (1.550236701965332) * gru_1_out_t4_14 + (0.077510654926300049) * gru_1_out_t4_15 + (-0.37721270322799683) * gru_1_out_t4_16 + (-0.58988785743713379) * gru_1_out_t4_17 + (2.7447240352630615) * gru_1_out_t4_18 + (0.81646060943603516) * gru_1_out_t4_19 + (0.33356153964996338) * gru_1_out_t4_20 + (0.034706629812717438) * gru_1_out_t4_21 + (-0.81010270118713379) * gru_1_out_t4_22 + (0.17419612407684326) * gru_1_out_t4_23 + (0.20880831778049469) * gru_1_out_t4_24 + (1.4312137365341187) * gru_1_out_t4_25 + (-1.1675388813018799) * gru_1_out_t4_26 + (-0.36679494380950928) * gru_1_out_t4_27 + (1.3015670776367188) * gru_1_out_t4_28 + (-0.36824396252632141) * gru_1_out_t4_29 + (1.0616594552993774) * gru_1_out_t4_30 + (-0.51430642604827881) * gru_1_out_t4_31 + (1.0237991809844971) * gru_1_out_t4_32 + (-0.24000565707683563) * gru_1_out_t4_33 + (0.053305529057979584) * gru_1_out_t4_34 + (0.33375972509384155) * gru_1_out_t4_35 + (0.11531641334295273) * gru_1_out_t4_36 + (-0.18261176347732544) * gru_1_out_t4_37 + (-1.4991185665130615) * gru_1_out_t4_38 + (-1.2624297142028809) * gru_1_out_t4_39 + (-0.25946754217147827) * gru_1_out_t4_40 + (-0.3450121283531189) * gru_1_out_t4_41 + (-0.86790657043457031) * gru_1_out_t4_42 + (-1.8249920606613159) * gru_1_out_t4_43 + (0.066522583365440369) * gru_1_out_t4_44 + (-0.90345519781112671) * gru_1_out_t4_45 + (-0.88409566879272461) * gru_1_out_t4_46 + (1.9973428249359131) * gru_1_out_t4_47 + (-0.58855032920837402) * gru_1_out_t4_48 + (0.14236220717430115) * gru_1_out_t4_49 + (1.2005610466003418) * gru_1_out_t4_50 + (0.19945915043354034) * gru_1_out_t4_51 + (1.3491890430450439) * gru_1_out_t4_52 + (0.25910690426826477) * gru_1_out_t4_53 + (0.055810887366533279) * gru_1_out_t4_54 + (1.1401735544204712) * gru_1_out_t4_55 + (-1.3563051223754883) * gru_1_out_t4_56 + (-0.1248633861541748) * gru_1_out_t4_57 + (-0.41845488548278809) * gru_1_out_t4_58 + (-0.77469700574874878) * gru_1_out_t4_59 + (1.8920108079910278) * gru_1_out_t4_60 + (-0.082910694181919098) * gru_1_out_t4_61 + (-0.70680689811706543) * gru_1_out_t4_62 + (-0.15654665231704712) * gru_1_out_t4_63 + (0.020880613476037979) * gru_2_fwd_t3_h_0 + (-0.51195603609085083) * gru_2_fwd_t3_h_1 + (-0.021468343213200569) * gru_2_fwd_t3_h_2 + (1.3573957681655884) * gru_2_fwd_t3_h_3 + (0.54564976692199707) * gru_2_fwd_t3_h_4 + (-0.21680566668510437) * gru_2_fwd_t3_h_5 + (0.48312997817993164) * gru_2_fwd_t3_h_6 + (-0.82941746711730957) * gru_2_fwd_t3_h_7 + (0.1984843909740448) * gru_2_fwd_t3_h_8 + (0.66555452346801758) * gru_2_fwd_t3_h_9 + (-0.53176611661911011) * gru_2_fwd_t3_h_10 + (0.52528715133666992) * gru_2_fwd_t3_h_11 + (-0.71037882566452026) * gru_2_fwd_t3_h_12 + (1.5844295024871826) * gru_2_fwd_t3_h_13 + (-0.038223836570978165) * gru_2_fwd_t3_h_14 + (-0.068330764770507812) * gru_2_fwd_t3_h_15 + (-0.34162002801895142) * gru_2_fwd_t3_h_16 + (-0.55063092708587646) * gru_2_fwd_t3_h_17 + (0.086156204342842102) * gru_2_fwd_t3_h_18 + (1.0486618280410767) * gru_2_fwd_t3_h_19 + (0.18485051393508911) * gru_2_fwd_t3_h_20 + (-0.23779508471488953) * gru_2_fwd_t3_h_21 + (-0.79715073108673096) * gru_2_fwd_t3_h_22 + (-0.05224127322435379) * gru_2_fwd_t3_h_23 + (-0.15086297690868378) * gru_2_fwd_t3_h_24 + (0.02965208888053894) * gru_2_fwd_t3_h_25 + (0.49379011988639832) * gru_2_fwd_t3_h_26 + (-0.41764155030250549) * gru_2_fwd_t3_h_27 + (0.29129165410995483) * gru_2_fwd_t3_h_28 + (0.52648138999938965) * gru_2_fwd_t3_h_29 + (-0.025485457852482796) * gru_2_fwd_t3_h_30 + (0.41178581118583679) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.21540595591068268) + (-0.062447085976600647) * gru_1_out_t4_0 + (0.19710658490657806) * gru_1_out_t4_1 + (0.22304537892341614) * gru_1_out_t4_2 + (-0.22655822336673737) * gru_1_out_t4_3 + (-0.28544896841049194) * gru_1_out_t4_4 + (-0.79141074419021606) * gru_1_out_t4_5 + (-0.076427921652793884) * gru_1_out_t4_6 + (-0.65295261144638062) * gru_1_out_t4_7 + (0.078971602022647858) * gru_1_out_t4_8 + (0.12620921432971954) * gru_1_out_t4_9 + (-0.16612808406352997) * gru_1_out_t4_10 + (-0.50807523727416992) * gru_1_out_t4_11 + (0.58610707521438599) * gru_1_out_t4_12 + (-0.21289952099323273) * gru_1_out_t4_13 + (0.33254772424697876) * gru_1_out_t4_14 + (0.29820331931114197) * gru_1_out_t4_15 + (0.6394156813621521) * gru_1_out_t4_16 + (-0.76382273435592651) * gru_1_out_t4_17 + (-0.40327426791191101) * gru_1_out_t4_18 + (0.026292705908417702) * gru_1_out_t4_19 + (-0.83958137035369873) * gru_1_out_t4_20 + (-0.29140341281890869) * gru_1_out_t4_21 + (0.420453280210495) * gru_1_out_t4_22 + (0.16636776924133301) * gru_1_out_t4_23 + (-0.84373712539672852) * gru_1_out_t4_24 + (0.73724222183227539) * gru_1_out_t4_25 + (-0.52726453542709351) * gru_1_out_t4_26 + (0.42343917489051819) * gru_1_out_t4_27 + (0.31719768047332764) * gru_1_out_t4_28 + (0.09289916604757309) * gru_1_out_t4_29 + (-1.0459674596786499) * gru_1_out_t4_30 + (0.17842990159988403) * gru_1_out_t4_31 + (0.74463635683059692) * gru_1_out_t4_32 + (0.25899797677993774) * gru_1_out_t4_33 + (-0.22104665637016296) * gru_1_out_t4_34 + (0.21321561932563782) * gru_1_out_t4_35 + (0.56181502342224121) * gru_1_out_t4_36 + (0.0037053248379379511) * gru_1_out_t4_37 + (0.3996836245059967) * gru_1_out_t4_38 + (1.4589189291000366) * gru_1_out_t4_39 + (0.011392473243176937) * gru_1_out_t4_40 + (-0.33374163508415222) * gru_1_out_t4_41 + (0.4011085033416748) * gru_1_out_t4_42 + (-1.2922153472900391) * gru_1_out_t4_43 + (0.14770334959030151) * gru_1_out_t4_44 + (0.21554625034332275) * gru_1_out_t4_45 + (0.25629574060440063) * gru_1_out_t4_46 + (-1.9022254943847656) * gru_1_out_t4_47 + (1.5334067344665527) * gru_1_out_t4_48 + (0.15874797105789185) * gru_1_out_t4_49 + (1.9202425479888916) * gru_1_out_t4_50 + (-0.5647767186164856) * gru_1_out_t4_51 + (-0.77475357055664062) * gru_1_out_t4_52 + (-0.12867213785648346) * gru_1_out_t4_53 + (0.5648958683013916) * gru_1_out_t4_54 + (-0.043451651930809021) * gru_1_out_t4_55 + (-0.24236686527729034) * gru_1_out_t4_56 + (-0.41896262764930725) * gru_1_out_t4_57 + (0.37943923473358154) * gru_1_out_t4_58 + (-1.7419379949569702) * gru_1_out_t4_59 + (0.96148163080215454) * gru_1_out_t4_60 + (-0.95176470279693604) * gru_1_out_t4_61 + (-1.1861317157745361) * gru_1_out_t4_62 + (-0.45780137181282043) * gru_1_out_t4_63 + (0.45594495534896851) * gru_2_fwd_t3_h_0 + (0.29299193620681763) * gru_2_fwd_t3_h_1 + (0.52408343553543091) * gru_2_fwd_t3_h_2 + (0.191335529088974) * gru_2_fwd_t3_h_3 + (0.018842233344912529) * gru_2_fwd_t3_h_4 + (-0.056268408894538879) * gru_2_fwd_t3_h_5 + (-0.093232758343219757) * gru_2_fwd_t3_h_6 + (-1.3030612468719482) * gru_2_fwd_t3_h_7 + (0.47885811328887939) * gru_2_fwd_t3_h_8 + (0.4616333544254303) * gru_2_fwd_t3_h_9 + (-0.67543613910675049) * gru_2_fwd_t3_h_10 + (-0.16103933751583099) * gru_2_fwd_t3_h_11 + (-0.23319190740585327) * gru_2_fwd_t3_h_12 + (0.54211145639419556) * gru_2_fwd_t3_h_13 + (-0.42915433645248413) * gru_2_fwd_t3_h_14 + (-0.26200470328330994) * gru_2_fwd_t3_h_15 + (-0.028702797368168831) * gru_2_fwd_t3_h_16 + (0.35522422194480896) * gru_2_fwd_t3_h_17 + (-0.13864500820636749) * gru_2_fwd_t3_h_18 + (0.11436054855585098) * gru_2_fwd_t3_h_19 + (0.127815842628479) * gru_2_fwd_t3_h_20 + (-0.72537863254547119) * gru_2_fwd_t3_h_21 + (-0.34493443369865417) * gru_2_fwd_t3_h_22 + (-0.026633245870471001) * gru_2_fwd_t3_h_23 + (0.1711747795343399) * gru_2_fwd_t3_h_24 + (0.3223298192024231) * gru_2_fwd_t3_h_25 + (-0.18684731423854828) * gru_2_fwd_t3_h_26 + (-0.47155442833900452) * gru_2_fwd_t3_h_27 + (0.15031924843788147) * gru_2_fwd_t3_h_28 + (-0.009854721836745739) * gru_2_fwd_t3_h_29 + (-0.19903799891471863) * gru_2_fwd_t3_h_30 + (-0.1138361468911171) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.17752301692962646) + (0.29254907369613647) * gru_1_out_t4_0 + (0.10081542283296585) * gru_1_out_t4_1 + (-0.303974449634552) * gru_1_out_t4_2 + (0.76221704483032227) * gru_1_out_t4_3 + (-0.057978946715593338) * gru_1_out_t4_4 + (0.27594807744026184) * gru_1_out_t4_5 + (-0.0094996290281414986) * gru_1_out_t4_6 + (-0.28469234704971313) * gru_1_out_t4_7 + (0.33654379844665527) * gru_1_out_t4_8 + (0.1726241409778595) * gru_1_out_t4_9 + (0.61838001012802124) * gru_1_out_t4_10 + (-0.088928341865539551) * gru_1_out_t4_11 + (0.77576011419296265) * gru_1_out_t4_12 + (-0.21127665042877197) * gru_1_out_t4_13 + (0.5637965202331543) * gru_1_out_t4_14 + (0.33355829119682312) * gru_1_out_t4_15 + (0.37436410784721375) * gru_1_out_t4_16 + (-0.17695207893848419) * gru_1_out_t4_17 + (0.22815875709056854) * gru_1_out_t4_18 + (0.28944399952888489) * gru_1_out_t4_19 + (0.13347424566745758) * gru_1_out_t4_20 + (-0.088616825640201569) * gru_1_out_t4_21 + (0.040927562862634659) * gru_1_out_t4_22 + (0.86185109615325928) * gru_1_out_t4_23 + (-1.0314691066741943) * gru_1_out_t4_24 + (-0.1365770548582077) * gru_1_out_t4_25 + (-0.18390278518199921) * gru_1_out_t4_26 + (-0.31354370713233948) * gru_1_out_t4_27 + (0.52801614999771118) * gru_1_out_t4_28 + (0.63795608282089233) * gru_1_out_t4_29 + (0.084013171494007111) * gru_1_out_t4_30 + (-0.52091085910797119) * gru_1_out_t4_31 + (0.052964821457862854) * gru_1_out_t4_32 + (-0.057234033942222595) * gru_1_out_t4_33 + (-0.72388136386871338) * gru_1_out_t4_34 + (0.16734346747398376) * gru_1_out_t4_35 + (-0.36760926246643066) * gru_1_out_t4_36 + (0.25334513187408447) * gru_1_out_t4_37 + (-0.25233516097068787) * gru_1_out_t4_38 + (-1.1464488506317139) * gru_1_out_t4_39 + (0.92114537954330444) * gru_1_out_t4_40 + (0.068244293332099915) * gru_1_out_t4_41 + (-0.77219057083129883) * gru_1_out_t4_42 + (0.35374173521995544) * gru_1_out_t4_43 + (0.33089959621429443) * gru_1_out_t4_44 + (-0.032683189958333969) * gru_1_out_t4_45 + (-0.23952262103557587) * gru_1_out_t4_46 + (0.054491549730300903) * gru_1_out_t4_47 + (0.63443905115127563) * gru_1_out_t4_48 + (-0.27270302176475525) * gru_1_out_t4_49 + (-0.10325831174850464) * gru_1_out_t4_50 + (0.61181533336639404) * gru_1_out_t4_51 + (-0.44981294870376587) * gru_1_out_t4_52 + (-0.011557241901755333) * gru_1_out_t4_53 + (-0.44994375109672546) * gru_1_out_t4_54 + (0.3322223424911499) * gru_1_out_t4_55 + (-0.069231607019901276) * gru_1_out_t4_56 + (-0.087306849658489227) * gru_1_out_t4_57 + (-0.40325802564620972) * gru_1_out_t4_58 + (0.17556558549404144) * gru_1_out_t4_59 + (0.45482334494590759) * gru_1_out_t4_60 + (0.13832241296768188) * gru_1_out_t4_61 + (-0.022683195769786835) * gru_1_out_t4_62 + (-0.026869719848036766) * gru_1_out_t4_63 + gate_r * ((0.19364142417907715) + (0.49725759029388428) * gru_2_fwd_t3_h_0 + (1.0513243675231934) * gru_2_fwd_t3_h_1 + (-1.3902019262313843) * gru_2_fwd_t3_h_2 + (0.73225712776184082) * gru_2_fwd_t3_h_3 + (-0.28735455870628357) * gru_2_fwd_t3_h_4 + (-0.015947209671139717) * gru_2_fwd_t3_h_5 + (0.093828700482845306) * gru_2_fwd_t3_h_6 + (-0.051199648529291153) * gru_2_fwd_t3_h_7 + (0.1800110936164856) * gru_2_fwd_t3_h_8 + (-0.078988611698150635) * gru_2_fwd_t3_h_9 + (4.0857272148132324) * gru_2_fwd_t3_h_10 + (0.039845786988735199) * gru_2_fwd_t3_h_11 + (-0.011403596960008144) * gru_2_fwd_t3_h_12 + (-0.90055006742477417) * gru_2_fwd_t3_h_13 + (0.10996711999177933) * gru_2_fwd_t3_h_14 + (-0.29353153705596924) * gru_2_fwd_t3_h_15 + (0.94583463668823242) * gru_2_fwd_t3_h_16 + (0.29302182793617249) * gru_2_fwd_t3_h_17 + (0.46148681640625) * gru_2_fwd_t3_h_18 + (0.5003235936164856) * gru_2_fwd_t3_h_19 + (0.18846908211708069) * gru_2_fwd_t3_h_20 + (1.2873741388320923) * gru_2_fwd_t3_h_21 + (0.36575302481651306) * gru_2_fwd_t3_h_22 + (-0.085571810603141785) * gru_2_fwd_t3_h_23 + (-0.016479127109050751) * gru_2_fwd_t3_h_24 + (0.41375443339347839) * gru_2_fwd_t3_h_25 + (-0.069798104465007782) * gru_2_fwd_t3_h_26 + (-0.70349776744842529) * gru_2_fwd_t3_h_27 + (0.17038898169994354) * gru_2_fwd_t3_h_28 + (-0.57169246673583984) * gru_2_fwd_t3_h_29 + (-0.37823641300201416) * gru_2_fwd_t3_h_30 + (-0.30640667676925659) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_20 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_20;
    // h=21
    gate_r = sigmoid((-0.41085311770439148) + (-2.1175956726074219) * gru_1_out_t4_0 + (-1.1514532566070557) * gru_1_out_t4_1 + (0.094657540321350098) * gru_1_out_t4_2 + (1.6376582384109497) * gru_1_out_t4_3 + (0.0092540895566344261) * gru_1_out_t4_4 + (-0.61162590980529785) * gru_1_out_t4_5 + (0.023723404854536057) * gru_1_out_t4_6 + (-0.30057612061500549) * gru_1_out_t4_7 + (0.081637457013130188) * gru_1_out_t4_8 + (-0.26221883296966553) * gru_1_out_t4_9 + (-0.091787755489349365) * gru_1_out_t4_10 + (-1.593367338180542) * gru_1_out_t4_11 + (-0.15290087461471558) * gru_1_out_t4_12 + (0.042701311409473419) * gru_1_out_t4_13 + (-1.3093334436416626) * gru_1_out_t4_14 + (0.96090096235275269) * gru_1_out_t4_15 + (-0.085761912167072296) * gru_1_out_t4_16 + (0.84867358207702637) * gru_1_out_t4_17 + (-1.1734315156936646) * gru_1_out_t4_18 + (-0.024421337991952896) * gru_1_out_t4_19 + (-0.30884519219398499) * gru_1_out_t4_20 + (-0.45355877280235291) * gru_1_out_t4_21 + (-0.2222890704870224) * gru_1_out_t4_22 + (0.74104291200637817) * gru_1_out_t4_23 + (2.4034206867218018) * gru_1_out_t4_24 + (-1.2558438777923584) * gru_1_out_t4_25 + (1.173764705657959) * gru_1_out_t4_26 + (0.41259211301803589) * gru_1_out_t4_27 + (-1.4630422592163086) * gru_1_out_t4_28 + (0.73190182447433472) * gru_1_out_t4_29 + (2.6868343353271484) * gru_1_out_t4_30 + (-0.64959311485290527) * gru_1_out_t4_31 + (-0.25143396854400635) * gru_1_out_t4_32 + (0.067020617425441742) * gru_1_out_t4_33 + (-0.67796045541763306) * gru_1_out_t4_34 + (0.2792288064956665) * gru_1_out_t4_35 + (0.3562634289264679) * gru_1_out_t4_36 + (0.45980337262153625) * gru_1_out_t4_37 + (0.48201665282249451) * gru_1_out_t4_38 + (-0.24847054481506348) * gru_1_out_t4_39 + (-0.16669709980487823) * gru_1_out_t4_40 + (0.59393149614334106) * gru_1_out_t4_41 + (-1.0901809930801392) * gru_1_out_t4_42 + (-0.37497356534004211) * gru_1_out_t4_43 + (0.13409458100795746) * gru_1_out_t4_44 + (-0.8338092565536499) * gru_1_out_t4_45 + (-0.030050069093704224) * gru_1_out_t4_46 + (-1.5882831811904907) * gru_1_out_t4_47 + (-0.86539983749389648) * gru_1_out_t4_48 + (-0.14470085501670837) * gru_1_out_t4_49 + (-0.70560336112976074) * gru_1_out_t4_50 + (-0.14211806654930115) * gru_1_out_t4_51 + (-0.8625836968421936) * gru_1_out_t4_52 + (0.98606777191162109) * gru_1_out_t4_53 + (-0.52155745029449463) * gru_1_out_t4_54 + (0.28513112664222717) * gru_1_out_t4_55 + (0.27814251184463501) * gru_1_out_t4_56 + (0.28228330612182617) * gru_1_out_t4_57 + (-0.61640787124633789) * gru_1_out_t4_58 + (0.28103050589561462) * gru_1_out_t4_59 + (1.7513893842697144) * gru_1_out_t4_60 + (-0.35556471347808838) * gru_1_out_t4_61 + (-0.81709831953048706) * gru_1_out_t4_62 + (-0.98777240514755249) * gru_1_out_t4_63 + (0.67810994386672974) * gru_2_fwd_t3_h_0 + (0.2945868968963623) * gru_2_fwd_t3_h_1 + (-0.51391875743865967) * gru_2_fwd_t3_h_2 + (1.3654099702835083) * gru_2_fwd_t3_h_3 + (0.21833650767803192) * gru_2_fwd_t3_h_4 + (0.50976014137268066) * gru_2_fwd_t3_h_5 + (0.72221213579177856) * gru_2_fwd_t3_h_6 + (-0.75834941864013672) * gru_2_fwd_t3_h_7 + (-1.5519131422042847) * gru_2_fwd_t3_h_8 + (0.14774055778980255) * gru_2_fwd_t3_h_9 + (-0.32753610610961914) * gru_2_fwd_t3_h_10 + (1.1296765804290771) * gru_2_fwd_t3_h_11 + (-0.26510971784591675) * gru_2_fwd_t3_h_12 + (-0.61875998973846436) * gru_2_fwd_t3_h_13 + (-0.48313793540000916) * gru_2_fwd_t3_h_14 + (-0.84145635366439819) * gru_2_fwd_t3_h_15 + (1.6690299510955811) * gru_2_fwd_t3_h_16 + (-0.80382663011550903) * gru_2_fwd_t3_h_17 + (0.36135154962539673) * gru_2_fwd_t3_h_18 + (-0.15926970541477203) * gru_2_fwd_t3_h_19 + (0.33021101355552673) * gru_2_fwd_t3_h_20 + (1.2783195972442627) * gru_2_fwd_t3_h_21 + (-0.091254979372024536) * gru_2_fwd_t3_h_22 + (0.51289010047912598) * gru_2_fwd_t3_h_23 + (0.35327687859535217) * gru_2_fwd_t3_h_24 + (-0.051717404276132584) * gru_2_fwd_t3_h_25 + (0.20442269742488861) * gru_2_fwd_t3_h_26 + (-0.4057210385799408) * gru_2_fwd_t3_h_27 + (0.17702008783817291) * gru_2_fwd_t3_h_28 + (-0.085679888725280762) * gru_2_fwd_t3_h_29 + (-0.86724162101745605) * gru_2_fwd_t3_h_30 + (-0.3768303394317627) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((0.51385629177093506) + (0.37207534909248352) * gru_1_out_t4_0 + (0.064254149794578552) * gru_1_out_t4_1 + (0.26732233166694641) * gru_1_out_t4_2 + (0.19992221891880035) * gru_1_out_t4_3 + (0.62904804944992065) * gru_1_out_t4_4 + (1.0610771179199219) * gru_1_out_t4_5 + (0.70428496599197388) * gru_1_out_t4_6 + (-0.51096951961517334) * gru_1_out_t4_7 + (-0.13854178786277771) * gru_1_out_t4_8 + (-0.26161259412765503) * gru_1_out_t4_9 + (0.6707492470741272) * gru_1_out_t4_10 + (1.1317105293273926) * gru_1_out_t4_11 + (0.29354628920555115) * gru_1_out_t4_12 + (-0.095147401094436646) * gru_1_out_t4_13 + (0.41109606623649597) * gru_1_out_t4_14 + (-0.39471754431724548) * gru_1_out_t4_15 + (-0.83567184209823608) * gru_1_out_t4_16 + (1.1051061153411865) * gru_1_out_t4_17 + (0.40588855743408203) * gru_1_out_t4_18 + (-0.24876336753368378) * gru_1_out_t4_19 + (-0.24655218422412872) * gru_1_out_t4_20 + (-0.18733631074428558) * gru_1_out_t4_21 + (-1.0518691539764404) * gru_1_out_t4_22 + (0.036488857120275497) * gru_1_out_t4_23 + (-0.25321963429450989) * gru_1_out_t4_24 + (-0.14605914056301117) * gru_1_out_t4_25 + (0.60077190399169922) * gru_1_out_t4_26 + (-0.44268479943275452) * gru_1_out_t4_27 + (0.2769855260848999) * gru_1_out_t4_28 + (-0.30815371870994568) * gru_1_out_t4_29 + (-1.0396198034286499) * gru_1_out_t4_30 + (-0.43569073081016541) * gru_1_out_t4_31 + (0.28526023030281067) * gru_1_out_t4_32 + (0.29230201244354248) * gru_1_out_t4_33 + (-0.36811593174934387) * gru_1_out_t4_34 + (0.25433000922203064) * gru_1_out_t4_35 + (-0.31234708428382874) * gru_1_out_t4_36 + (0.045589979737997055) * gru_1_out_t4_37 + (-0.26722455024719238) * gru_1_out_t4_38 + (-0.57158881425857544) * gru_1_out_t4_39 + (-0.071148693561553955) * gru_1_out_t4_40 + (-0.14104351401329041) * gru_1_out_t4_41 + (-0.055966898798942566) * gru_1_out_t4_42 + (0.51795631647109985) * gru_1_out_t4_43 + (-0.058084852993488312) * gru_1_out_t4_44 + (0.0042424555867910385) * gru_1_out_t4_45 + (-0.810097336769104) * gru_1_out_t4_46 + (-0.65428382158279419) * gru_1_out_t4_47 + (-0.74085313081741333) * gru_1_out_t4_48 + (0.069331623613834381) * gru_1_out_t4_49 + (-0.89539563655853271) * gru_1_out_t4_50 + (-0.29942682385444641) * gru_1_out_t4_51 + (-0.78762316703796387) * gru_1_out_t4_52 + (-0.11654308438301086) * gru_1_out_t4_53 + (0.0073445714078843594) * gru_1_out_t4_54 + (0.28068861365318298) * gru_1_out_t4_55 + (-1.6662617921829224) * gru_1_out_t4_56 + (-0.45449215173721313) * gru_1_out_t4_57 + (0.4044097363948822) * gru_1_out_t4_58 + (0.19018487632274628) * gru_1_out_t4_59 + (0.54402840137481689) * gru_1_out_t4_60 + (0.038217648863792419) * gru_1_out_t4_61 + (0.14708909392356873) * gru_1_out_t4_62 + (0.31532546877861023) * gru_1_out_t4_63 + (0.080458372831344604) * gru_2_fwd_t3_h_0 + (-0.17959730327129364) * gru_2_fwd_t3_h_1 + (0.41160082817077637) * gru_2_fwd_t3_h_2 + (-0.085934586822986603) * gru_2_fwd_t3_h_3 + (0.17800624668598175) * gru_2_fwd_t3_h_4 + (0.22696247696876526) * gru_2_fwd_t3_h_5 + (0.45752570033073425) * gru_2_fwd_t3_h_6 + (-1.2479296922683716) * gru_2_fwd_t3_h_7 + (0.095741786062717438) * gru_2_fwd_t3_h_8 + (0.032241370528936386) * gru_2_fwd_t3_h_9 + (-0.61992478370666504) * gru_2_fwd_t3_h_10 + (0.82952123880386353) * gru_2_fwd_t3_h_11 + (-0.59721219539642334) * gru_2_fwd_t3_h_12 + (-1.8462852239608765) * gru_2_fwd_t3_h_13 + (-0.84484648704528809) * gru_2_fwd_t3_h_14 + (-0.006148110143840313) * gru_2_fwd_t3_h_15 + (-0.059893786907196045) * gru_2_fwd_t3_h_16 + (-0.17931249737739563) * gru_2_fwd_t3_h_17 + (-0.86577606201171875) * gru_2_fwd_t3_h_18 + (-0.2357977032661438) * gru_2_fwd_t3_h_19 + (0.080580383539199829) * gru_2_fwd_t3_h_20 + (-0.072185046970844269) * gru_2_fwd_t3_h_21 + (0.14747782051563263) * gru_2_fwd_t3_h_22 + (0.1738048642873764) * gru_2_fwd_t3_h_23 + (-0.25725364685058594) * gru_2_fwd_t3_h_24 + (-1.5007901191711426) * gru_2_fwd_t3_h_25 + (-0.46260711550712585) * gru_2_fwd_t3_h_26 + (0.17932863533496857) * gru_2_fwd_t3_h_27 + (-0.46429124474525452) * gru_2_fwd_t3_h_28 + (0.70923799276351929) * gru_2_fwd_t3_h_29 + (0.20261940360069275) * gru_2_fwd_t3_h_30 + (-0.32387298345565796) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.059235170483589172) + (-0.10768552124500275) * gru_1_out_t4_0 + (0.15082165598869324) * gru_1_out_t4_1 + (-0.013013914227485657) * gru_1_out_t4_2 + (0.91154938936233521) * gru_1_out_t4_3 + (-0.50300794839859009) * gru_1_out_t4_4 + (0.30522522330284119) * gru_1_out_t4_5 + (0.10518790036439896) * gru_1_out_t4_6 + (0.10219262540340424) * gru_1_out_t4_7 + (0.22126960754394531) * gru_1_out_t4_8 + (-0.24762572348117828) * gru_1_out_t4_9 + (0.35280948877334595) * gru_1_out_t4_10 + (0.26572495698928833) * gru_1_out_t4_11 + (0.27837687730789185) * gru_1_out_t4_12 + (0.34346190094947815) * gru_1_out_t4_13 + (-0.4190080463886261) * gru_1_out_t4_14 + (0.27260169386863708) * gru_1_out_t4_15 + (-0.092596128582954407) * gru_1_out_t4_16 + (0.14537501335144043) * gru_1_out_t4_17 + (0.62817716598510742) * gru_1_out_t4_18 + (-0.066940642893314362) * gru_1_out_t4_19 + (-0.22865478694438934) * gru_1_out_t4_20 + (-0.3251737654209137) * gru_1_out_t4_21 + (0.11933120340108871) * gru_1_out_t4_22 + (-0.055363524705171585) * gru_1_out_t4_23 + (0.50039225816726685) * gru_1_out_t4_24 + (-0.068058423697948456) * gru_1_out_t4_25 + (0.025690998882055283) * gru_1_out_t4_26 + (-0.17750999331474304) * gru_1_out_t4_27 + (-0.33152246475219727) * gru_1_out_t4_28 + (-0.072450898587703705) * gru_1_out_t4_29 + (0.15496557950973511) * gru_1_out_t4_30 + (-0.51674586534500122) * gru_1_out_t4_31 + (-0.29137897491455078) * gru_1_out_t4_32 + (-0.03144783154129982) * gru_1_out_t4_33 + (-0.0065676020458340645) * gru_1_out_t4_34 + (0.23378379642963409) * gru_1_out_t4_35 + (-0.098160631954669952) * gru_1_out_t4_36 + (-0.060915708541870117) * gru_1_out_t4_37 + (0.030496232211589813) * gru_1_out_t4_38 + (-0.27100232243537903) * gru_1_out_t4_39 + (-0.18794271349906921) * gru_1_out_t4_40 + (0.27447286248207092) * gru_1_out_t4_41 + (0.26050710678100586) * gru_1_out_t4_42 + (0.062046151608228683) * gru_1_out_t4_43 + (0.62349343299865723) * gru_1_out_t4_44 + (-0.17839114367961884) * gru_1_out_t4_45 + (-0.017422376200556755) * gru_1_out_t4_46 + (-0.3473602831363678) * gru_1_out_t4_47 + (0.96528112888336182) * gru_1_out_t4_48 + (0.056087784469127655) * gru_1_out_t4_49 + (0.1062556654214859) * gru_1_out_t4_50 + (0.047943904995918274) * gru_1_out_t4_51 + (-0.10951235890388489) * gru_1_out_t4_52 + (-0.2179199755191803) * gru_1_out_t4_53 + (0.023238880559802055) * gru_1_out_t4_54 + (0.036984365433454514) * gru_1_out_t4_55 + (-0.26362663507461548) * gru_1_out_t4_56 + (-0.23231934010982513) * gru_1_out_t4_57 + (-0.13068868219852448) * gru_1_out_t4_58 + (-0.41759991645812988) * gru_1_out_t4_59 + (-0.047218676656484604) * gru_1_out_t4_60 + (-0.11818970739841461) * gru_1_out_t4_61 + (-0.63378679752349854) * gru_1_out_t4_62 + (-0.31481730937957764) * gru_1_out_t4_63 + gate_r * ((0.53255921602249146) + (0.035684004426002502) * gru_2_fwd_t3_h_0 + (-0.39259320497512817) * gru_2_fwd_t3_h_1 + (0.12664641439914703) * gru_2_fwd_t3_h_2 + (-0.71250611543655396) * gru_2_fwd_t3_h_3 + (-0.054767683148384094) * gru_2_fwd_t3_h_4 + (0.38494381308555603) * gru_2_fwd_t3_h_5 + (-0.057496730238199234) * gru_2_fwd_t3_h_6 + (-0.31641086935997009) * gru_2_fwd_t3_h_7 + (0.45450571179389954) * gru_2_fwd_t3_h_8 + (0.50629961490631104) * gru_2_fwd_t3_h_9 + (-0.40125676989555359) * gru_2_fwd_t3_h_10 + (-0.7250511646270752) * gru_2_fwd_t3_h_11 + (0.26027297973632812) * gru_2_fwd_t3_h_12 + (-0.13102295994758606) * gru_2_fwd_t3_h_13 + (-0.51185810565948486) * gru_2_fwd_t3_h_14 + (-0.1055125966668129) * gru_2_fwd_t3_h_15 + (0.3645206093788147) * gru_2_fwd_t3_h_16 + (-0.16107502579689026) * gru_2_fwd_t3_h_17 + (0.097062826156616211) * gru_2_fwd_t3_h_18 + (0.17195488512516022) * gru_2_fwd_t3_h_19 + (-0.12680160999298096) * gru_2_fwd_t3_h_20 + (0.099052965641021729) * gru_2_fwd_t3_h_21 + (0.015481559559702873) * gru_2_fwd_t3_h_22 + (0.49775832891464233) * gru_2_fwd_t3_h_23 + (0.42794519662857056) * gru_2_fwd_t3_h_24 + (-0.084753960371017456) * gru_2_fwd_t3_h_25 + (0.46916720271110535) * gru_2_fwd_t3_h_26 + (-0.91149759292602539) * gru_2_fwd_t3_h_27 + (0.9165990948677063) * gru_2_fwd_t3_h_28 + (0.065886788070201874) * gru_2_fwd_t3_h_29 + (-0.16627778112888336) * gru_2_fwd_t3_h_30 + (0.084444664418697357) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_21 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_21;
    // h=22
    gate_r = sigmoid((2.0746722221374512) + (0.25101163983345032) * gru_1_out_t4_0 + (-0.60227686166763306) * gru_1_out_t4_1 + (0.25599274039268494) * gru_1_out_t4_2 + (0.33706963062286377) * gru_1_out_t4_3 + (-0.52215588092803955) * gru_1_out_t4_4 + (-0.88232928514480591) * gru_1_out_t4_5 + (-0.44416841864585876) * gru_1_out_t4_6 + (0.39813128113746643) * gru_1_out_t4_7 + (1.2596918344497681) * gru_1_out_t4_8 + (-0.084983848035335541) * gru_1_out_t4_9 + (-0.18221040070056915) * gru_1_out_t4_10 + (-0.44675564765930176) * gru_1_out_t4_11 + (0.84645849466323853) * gru_1_out_t4_12 + (-1.4450067281723022) * gru_1_out_t4_13 + (-0.17330382764339447) * gru_1_out_t4_14 + (0.55864948034286499) * gru_1_out_t4_15 + (-0.53564882278442383) * gru_1_out_t4_16 + (0.29013726115226746) * gru_1_out_t4_17 + (0.23183004558086395) * gru_1_out_t4_18 + (-0.15396611392498016) * gru_1_out_t4_19 + (0.12737785279750824) * gru_1_out_t4_20 + (1.5095975399017334) * gru_1_out_t4_21 + (0.23359082639217377) * gru_1_out_t4_22 + (0.71496415138244629) * gru_1_out_t4_23 + (0.0038493233732879162) * gru_1_out_t4_24 + (-0.097147755324840546) * gru_1_out_t4_25 + (0.1518254280090332) * gru_1_out_t4_26 + (-0.15905162692070007) * gru_1_out_t4_27 + (0.97296661138534546) * gru_1_out_t4_28 + (0.46421292424201965) * gru_1_out_t4_29 + (1.1318730115890503) * gru_1_out_t4_30 + (0.0012410178314894438) * gru_1_out_t4_31 + (0.43683835864067078) * gru_1_out_t4_32 + (0.40905389189720154) * gru_1_out_t4_33 + (-0.65777236223220825) * gru_1_out_t4_34 + (1.2982580661773682) * gru_1_out_t4_35 + (1.3712904453277588) * gru_1_out_t4_36 + (0.39106607437133789) * gru_1_out_t4_37 + (-0.067429102957248688) * gru_1_out_t4_38 + (0.63399028778076172) * gru_1_out_t4_39 + (-1.3093798160552979) * gru_1_out_t4_40 + (0.94386583566665649) * gru_1_out_t4_41 + (0.88779395818710327) * gru_1_out_t4_42 + (-2.5344448089599609) * gru_1_out_t4_43 + (1.0624871253967285) * gru_1_out_t4_44 + (-1.8341507911682129) * gru_1_out_t4_45 + (0.44010511040687561) * gru_1_out_t4_46 + (0.9182397723197937) * gru_1_out_t4_47 + (0.22666558623313904) * gru_1_out_t4_48 + (-0.45270946621894836) * gru_1_out_t4_49 + (-0.42759788036346436) * gru_1_out_t4_50 + (0.35173124074935913) * gru_1_out_t4_51 + (0.046317264437675476) * gru_1_out_t4_52 + (0.31908741593360901) * gru_1_out_t4_53 + (-0.25950795412063599) * gru_1_out_t4_54 + (0.67543625831604004) * gru_1_out_t4_55 + (1.809598445892334) * gru_1_out_t4_56 + (0.48504635691642761) * gru_1_out_t4_57 + (0.5902666449546814) * gru_1_out_t4_58 + (0.45628821849822998) * gru_1_out_t4_59 + (1.8319989442825317) * gru_1_out_t4_60 + (0.62336850166320801) * gru_1_out_t4_61 + (-0.64004701375961304) * gru_1_out_t4_62 + (-0.12148680537939072) * gru_1_out_t4_63 + (0.44059872627258301) * gru_2_fwd_t3_h_0 + (-0.80778223276138306) * gru_2_fwd_t3_h_1 + (0.72943878173828125) * gru_2_fwd_t3_h_2 + (1.392767071723938) * gru_2_fwd_t3_h_3 + (0.086769357323646545) * gru_2_fwd_t3_h_4 + (-0.62849032878875732) * gru_2_fwd_t3_h_5 + (-0.83276581764221191) * gru_2_fwd_t3_h_6 + (-0.81958431005477905) * gru_2_fwd_t3_h_7 + (-0.42597976326942444) * gru_2_fwd_t3_h_8 + (-0.12093677371740341) * gru_2_fwd_t3_h_9 + (2.5199699401855469) * gru_2_fwd_t3_h_10 + (-0.1206774115562439) * gru_2_fwd_t3_h_11 + (-0.57618802785873413) * gru_2_fwd_t3_h_12 + (0.87407541275024414) * gru_2_fwd_t3_h_13 + (0.32654446363449097) * gru_2_fwd_t3_h_14 + (-0.23618620634078979) * gru_2_fwd_t3_h_15 + (-0.0090434839949011803) * gru_2_fwd_t3_h_16 + (1.2152583599090576) * gru_2_fwd_t3_h_17 + (-1.0573492050170898) * gru_2_fwd_t3_h_18 + (0.59965938329696655) * gru_2_fwd_t3_h_19 + (-0.21424683928489685) * gru_2_fwd_t3_h_20 + (0.70376664400100708) * gru_2_fwd_t3_h_21 + (-0.74818980693817139) * gru_2_fwd_t3_h_22 + (1.2913399934768677) * gru_2_fwd_t3_h_23 + (1.3659001588821411) * gru_2_fwd_t3_h_24 + (0.52438855171203613) * gru_2_fwd_t3_h_25 + (0.46452382206916809) * gru_2_fwd_t3_h_26 + (-1.7436636686325073) * gru_2_fwd_t3_h_27 + (-1.107108473777771) * gru_2_fwd_t3_h_28 + (0.22951380908489227) * gru_2_fwd_t3_h_29 + (0.35204404592514038) * gru_2_fwd_t3_h_30 + (-0.22107641398906708) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.13255952298641205) + (-0.55883419513702393) * gru_1_out_t4_0 + (0.14030671119689941) * gru_1_out_t4_1 + (-0.25962820649147034) * gru_1_out_t4_2 + (0.49126142263412476) * gru_1_out_t4_3 + (0.3657798171043396) * gru_1_out_t4_4 + (0.48353138566017151) * gru_1_out_t4_5 + (-1.3399809598922729) * gru_1_out_t4_6 + (0.14969098567962646) * gru_1_out_t4_7 + (0.84376102685928345) * gru_1_out_t4_8 + (-0.28111258149147034) * gru_1_out_t4_9 + (0.332344651222229) * gru_1_out_t4_10 + (0.23340348899364471) * gru_1_out_t4_11 + (0.71632260084152222) * gru_1_out_t4_12 + (-0.080833494663238525) * gru_1_out_t4_13 + (-0.26049193739891052) * gru_1_out_t4_14 + (0.2281792014837265) * gru_1_out_t4_15 + (-0.61934494972229004) * gru_1_out_t4_16 + (-0.1803562194108963) * gru_1_out_t4_17 + (-0.50407940149307251) * gru_1_out_t4_18 + (-0.31688818335533142) * gru_1_out_t4_19 + (0.14714577794075012) * gru_1_out_t4_20 + (0.1356513500213623) * gru_1_out_t4_21 + (-0.28133454918861389) * gru_1_out_t4_22 + (0.76639950275421143) * gru_1_out_t4_23 + (-0.45733624696731567) * gru_1_out_t4_24 + (0.63386327028274536) * gru_1_out_t4_25 + (0.24382221698760986) * gru_1_out_t4_26 + (-0.49925675988197327) * gru_1_out_t4_27 + (0.060152303427457809) * gru_1_out_t4_28 + (-0.68578505516052246) * gru_1_out_t4_29 + (-0.017029440030455589) * gru_1_out_t4_30 + (0.11803505569696426) * gru_1_out_t4_31 + (1.1626839637756348) * gru_1_out_t4_32 + (0.38862785696983337) * gru_1_out_t4_33 + (-0.15951475501060486) * gru_1_out_t4_34 + (0.16251328587532043) * gru_1_out_t4_35 + (-0.53205138444900513) * gru_1_out_t4_36 + (0.085023634135723114) * gru_1_out_t4_37 + (-0.20326483249664307) * gru_1_out_t4_38 + (0.40539881587028503) * gru_1_out_t4_39 + (0.46895354986190796) * gru_1_out_t4_40 + (0.20888559520244598) * gru_1_out_t4_41 + (1.0912764072418213) * gru_1_out_t4_42 + (0.069236606359481812) * gru_1_out_t4_43 + (-0.098227694630622864) * gru_1_out_t4_44 + (0.31580546498298645) * gru_1_out_t4_45 + (0.31177857518196106) * gru_1_out_t4_46 + (0.63868939876556396) * gru_1_out_t4_47 + (0.21140366792678833) * gru_1_out_t4_48 + (0.17980995774269104) * gru_1_out_t4_49 + (0.46596798300743103) * gru_1_out_t4_50 + (-2.1383142471313477) * gru_1_out_t4_51 + (-0.75013530254364014) * gru_1_out_t4_52 + (0.49293678998947144) * gru_1_out_t4_53 + (0.83143013715744019) * gru_1_out_t4_54 + (0.015607022680342197) * gru_1_out_t4_55 + (-0.73226642608642578) * gru_1_out_t4_56 + (0.17624768614768982) * gru_1_out_t4_57 + (0.060565326362848282) * gru_1_out_t4_58 + (1.1314330101013184) * gru_1_out_t4_59 + (0.30861937999725342) * gru_1_out_t4_60 + (0.060700394213199615) * gru_1_out_t4_61 + (0.10355164110660553) * gru_1_out_t4_62 + (0.17478218674659729) * gru_1_out_t4_63 + (-0.065084695816040039) * gru_2_fwd_t3_h_0 + (0.041096556931734085) * gru_2_fwd_t3_h_1 + (-0.58417648077011108) * gru_2_fwd_t3_h_2 + (-0.23064117133617401) * gru_2_fwd_t3_h_3 + (0.4796326756477356) * gru_2_fwd_t3_h_4 + (0.17792560160160065) * gru_2_fwd_t3_h_5 + (0.28863522410392761) * gru_2_fwd_t3_h_6 + (0.90603893995285034) * gru_2_fwd_t3_h_7 + (0.10137619078159332) * gru_2_fwd_t3_h_8 + (0.4130328893661499) * gru_2_fwd_t3_h_9 + (-0.60355943441390991) * gru_2_fwd_t3_h_10 + (-0.17563115060329437) * gru_2_fwd_t3_h_11 + (-0.24399195611476898) * gru_2_fwd_t3_h_12 + (-0.51937097311019897) * gru_2_fwd_t3_h_13 + (0.5586434006690979) * gru_2_fwd_t3_h_14 + (0.19321556389331818) * gru_2_fwd_t3_h_15 + (-0.13376647233963013) * gru_2_fwd_t3_h_16 + (-0.060348384082317352) * gru_2_fwd_t3_h_17 + (-0.046535570174455643) * gru_2_fwd_t3_h_18 + (0.00073191284900531173) * gru_2_fwd_t3_h_19 + (0.45417094230651855) * gru_2_fwd_t3_h_20 + (-0.018711257725954056) * gru_2_fwd_t3_h_21 + (-1.1962380409240723) * gru_2_fwd_t3_h_22 + (-0.5413939356803894) * gru_2_fwd_t3_h_23 + (-0.13206617534160614) * gru_2_fwd_t3_h_24 + (-0.61639398336410522) * gru_2_fwd_t3_h_25 + (-0.45088228583335876) * gru_2_fwd_t3_h_26 + (-0.11398700624704361) * gru_2_fwd_t3_h_27 + (0.53908848762512207) * gru_2_fwd_t3_h_28 + (0.10529299080371857) * gru_2_fwd_t3_h_29 + (0.038731973618268967) * gru_2_fwd_t3_h_30 + (0.22331029176712036) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.41778099536895752) + (0.0095594227313995361) * gru_1_out_t4_0 + (-1.3231042623519897) * gru_1_out_t4_1 + (0.15466630458831787) * gru_1_out_t4_2 + (-0.025127293542027473) * gru_1_out_t4_3 + (0.048250522464513779) * gru_1_out_t4_4 + (0.1969936192035675) * gru_1_out_t4_5 + (-1.916151762008667) * gru_1_out_t4_6 + (-0.10891006141901016) * gru_1_out_t4_7 + (-0.28521513938903809) * gru_1_out_t4_8 + (-0.15668825805187225) * gru_1_out_t4_9 + (-0.053943119943141937) * gru_1_out_t4_10 + (-0.090261049568653107) * gru_1_out_t4_11 + (-0.11900219321250916) * gru_1_out_t4_12 + (0.061616137623786926) * gru_1_out_t4_13 + (0.061735823750495911) * gru_1_out_t4_14 + (0.15280231833457947) * gru_1_out_t4_15 + (-0.2402796745300293) * gru_1_out_t4_16 + (-0.22904171049594879) * gru_1_out_t4_17 + (0.31377232074737549) * gru_1_out_t4_18 + (-0.18095405399799347) * gru_1_out_t4_19 + (-0.089521989226341248) * gru_1_out_t4_20 + (-0.88325875997543335) * gru_1_out_t4_21 + (0.41251394152641296) * gru_1_out_t4_22 + (0.091502927243709564) * gru_1_out_t4_23 + (0.51780575513839722) * gru_1_out_t4_24 + (-0.38825365900993347) * gru_1_out_t4_25 + (-0.31793114542961121) * gru_1_out_t4_26 + (-0.49099335074424744) * gru_1_out_t4_27 + (0.255170077085495) * gru_1_out_t4_28 + (0.27161711454391479) * gru_1_out_t4_29 + (-1.6192402839660645) * gru_1_out_t4_30 + (0.85144037008285522) * gru_1_out_t4_31 + (0.3300652801990509) * gru_1_out_t4_32 + (0.19546380639076233) * gru_1_out_t4_33 + (-0.21378576755523682) * gru_1_out_t4_34 + (1.1446200609207153) * gru_1_out_t4_35 + (-1.1469582319259644) * gru_1_out_t4_36 + (-0.052663493901491165) * gru_1_out_t4_37 + (-0.59846252202987671) * gru_1_out_t4_38 + (0.15347051620483398) * gru_1_out_t4_39 + (0.66116821765899658) * gru_1_out_t4_40 + (-0.097912363708019257) * gru_1_out_t4_41 + (0.63647204637527466) * gru_1_out_t4_42 + (0.61152142286300659) * gru_1_out_t4_43 + (-0.79150170087814331) * gru_1_out_t4_44 + (0.031156096607446671) * gru_1_out_t4_45 + (0.43415549397468567) * gru_1_out_t4_46 + (0.43316754698753357) * gru_1_out_t4_47 + (0.020345848053693771) * gru_1_out_t4_48 + (0.38068872690200806) * gru_1_out_t4_49 + (0.48539495468139648) * gru_1_out_t4_50 + (-0.90086746215820312) * gru_1_out_t4_51 + (-0.66446137428283691) * gru_1_out_t4_52 + (-0.28305345773696899) * gru_1_out_t4_53 + (-0.30623158812522888) * gru_1_out_t4_54 + (0.59654539823532104) * gru_1_out_t4_55 + (-0.45147988200187683) * gru_1_out_t4_56 + (-0.32875630259513855) * gru_1_out_t4_57 + (0.37799277901649475) * gru_1_out_t4_58 + (0.48912498354911804) * gru_1_out_t4_59 + (0.62139350175857544) * gru_1_out_t4_60 + (-0.11775408685207367) * gru_1_out_t4_61 + (0.53859543800354004) * gru_1_out_t4_62 + (0.55621296167373657) * gru_1_out_t4_63 + gate_r * ((-0.64109975099563599) + (-0.19011326134204865) * gru_2_fwd_t3_h_0 + (0.51542538404464722) * gru_2_fwd_t3_h_1 + (0.24713641405105591) * gru_2_fwd_t3_h_2 + (0.045745186507701874) * gru_2_fwd_t3_h_3 + (-0.45506078004837036) * gru_2_fwd_t3_h_4 + (0.138991579413414) * gru_2_fwd_t3_h_5 + (0.11073185503482819) * gru_2_fwd_t3_h_6 + (0.13591240346431732) * gru_2_fwd_t3_h_7 + (0.17922794818878174) * gru_2_fwd_t3_h_8 + (0.05250520259141922) * gru_2_fwd_t3_h_9 + (-0.5584835410118103) * gru_2_fwd_t3_h_10 + (0.12060124427080154) * gru_2_fwd_t3_h_11 + (-0.31360992789268494) * gru_2_fwd_t3_h_12 + (1.1507892608642578) * gru_2_fwd_t3_h_13 + (0.35148593783378601) * gru_2_fwd_t3_h_14 + (0.28031027317047119) * gru_2_fwd_t3_h_15 + (0.11251798272132874) * gru_2_fwd_t3_h_16 + (-1.0066612958908081) * gru_2_fwd_t3_h_17 + (0.79646623134613037) * gru_2_fwd_t3_h_18 + (0.14119391143321991) * gru_2_fwd_t3_h_19 + (0.49677947163581848) * gru_2_fwd_t3_h_20 + (0.94705140590667725) * gru_2_fwd_t3_h_21 + (-1.1082483530044556) * gru_2_fwd_t3_h_22 + (-0.14734660089015961) * gru_2_fwd_t3_h_23 + (-0.030486224219202995) * gru_2_fwd_t3_h_24 + (-1.037104606628418) * gru_2_fwd_t3_h_25 + (-0.24768313765525818) * gru_2_fwd_t3_h_26 + (0.55090492963790894) * gru_2_fwd_t3_h_27 + (0.68062001466751099) * gru_2_fwd_t3_h_28 + (-0.12711820006370544) * gru_2_fwd_t3_h_29 + (-0.20500892400741577) * gru_2_fwd_t3_h_30 + (-0.2204662412405014) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_22 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_22;
    // h=23
    gate_r = sigmoid((1.3856973648071289) + (0.78917241096496582) * gru_1_out_t4_0 + (-1.2410851716995239) * gru_1_out_t4_1 + (-0.44381237030029297) * gru_1_out_t4_2 + (-0.62441092729568481) * gru_1_out_t4_3 + (-0.91051661968231201) * gru_1_out_t4_4 + (1.4601631164550781) * gru_1_out_t4_5 + (-3.4535882472991943) * gru_1_out_t4_6 + (-0.45458415150642395) * gru_1_out_t4_7 + (-0.49291566014289856) * gru_1_out_t4_8 + (-0.84441125392913818) * gru_1_out_t4_9 + (-0.04696110263466835) * gru_1_out_t4_10 + (-1.3350522518157959) * gru_1_out_t4_11 + (-0.28869199752807617) * gru_1_out_t4_12 + (-0.89669430255889893) * gru_1_out_t4_13 + (-0.47325077652931213) * gru_1_out_t4_14 + (0.021392161026597023) * gru_1_out_t4_15 + (-0.39350202679634094) * gru_1_out_t4_16 + (1.3474031686782837) * gru_1_out_t4_17 + (-0.097958572208881378) * gru_1_out_t4_18 + (-0.94190323352813721) * gru_1_out_t4_19 + (-0.32520270347595215) * gru_1_out_t4_20 + (1.1677086353302002) * gru_1_out_t4_21 + (0.50687336921691895) * gru_1_out_t4_22 + (1.9845380783081055) * gru_1_out_t4_23 + (0.084130242466926575) * gru_1_out_t4_24 + (1.452276349067688) * gru_1_out_t4_25 + (0.1216854453086853) * gru_1_out_t4_26 + (-0.62771636247634888) * gru_1_out_t4_27 + (1.4205021858215332) * gru_1_out_t4_28 + (-0.34562093019485474) * gru_1_out_t4_29 + (-2.0372970104217529) * gru_1_out_t4_30 + (0.58200746774673462) * gru_1_out_t4_31 + (0.35316601395606995) * gru_1_out_t4_32 + (0.93197321891784668) * gru_1_out_t4_33 + (1.3245409727096558) * gru_1_out_t4_34 + (-0.13875153660774231) * gru_1_out_t4_35 + (-0.84670549631118774) * gru_1_out_t4_36 + (-0.38243004679679871) * gru_1_out_t4_37 + (-0.80935955047607422) * gru_1_out_t4_38 + (0.96766942739486694) * gru_1_out_t4_39 + (0.62332040071487427) * gru_1_out_t4_40 + (0.59718614816665649) * gru_1_out_t4_41 + (3.4287214279174805) * gru_1_out_t4_42 + (0.41077601909637451) * gru_1_out_t4_43 + (-0.90998506546020508) * gru_1_out_t4_44 + (0.4972166121006012) * gru_1_out_t4_45 + (0.45989957451820374) * gru_1_out_t4_46 + (-0.21847198903560638) * gru_1_out_t4_47 + (1.8623566627502441) * gru_1_out_t4_48 + (0.71135604381561279) * gru_1_out_t4_49 + (0.25240659713745117) * gru_1_out_t4_50 + (-0.53833550214767456) * gru_1_out_t4_51 + (-0.86469793319702148) * gru_1_out_t4_52 + (-0.40980842709541321) * gru_1_out_t4_53 + (-0.37177255749702454) * gru_1_out_t4_54 + (0.63687354326248169) * gru_1_out_t4_55 + (-1.8544310331344604) * gru_1_out_t4_56 + (-0.20980633795261383) * gru_1_out_t4_57 + (-0.64017903804779053) * gru_1_out_t4_58 + (0.41707900166511536) * gru_1_out_t4_59 + (-3.6738555431365967) * gru_1_out_t4_60 + (-2.4399979114532471) * gru_1_out_t4_61 + (1.0465980768203735) * gru_1_out_t4_62 + (1.2781497240066528) * gru_1_out_t4_63 + (-0.70535463094711304) * gru_2_fwd_t3_h_0 + (-0.27454814314842224) * gru_2_fwd_t3_h_1 + (0.004030176904052496) * gru_2_fwd_t3_h_2 + (-0.76266872882843018) * gru_2_fwd_t3_h_3 + (-0.62380534410476685) * gru_2_fwd_t3_h_4 + (-0.092061333358287811) * gru_2_fwd_t3_h_5 + (0.0013828022638335824) * gru_2_fwd_t3_h_6 + (-0.94883698225021362) * gru_2_fwd_t3_h_7 + (0.47859713435173035) * gru_2_fwd_t3_h_8 + (-0.49033626914024353) * gru_2_fwd_t3_h_9 + (-0.73382568359375) * gru_2_fwd_t3_h_10 + (-0.17400962114334106) * gru_2_fwd_t3_h_11 + (0.94638806581497192) * gru_2_fwd_t3_h_12 + (1.3432657718658447) * gru_2_fwd_t3_h_13 + (-0.54344320297241211) * gru_2_fwd_t3_h_14 + (-0.64018005132675171) * gru_2_fwd_t3_h_15 + (0.54305356740951538) * gru_2_fwd_t3_h_16 + (-0.3762584924697876) * gru_2_fwd_t3_h_17 + (0.1904805600643158) * gru_2_fwd_t3_h_18 + (-0.21614988148212433) * gru_2_fwd_t3_h_19 + (-1.276671290397644) * gru_2_fwd_t3_h_20 + (0.26240909099578857) * gru_2_fwd_t3_h_21 + (0.88248050212860107) * gru_2_fwd_t3_h_22 + (0.18822331726551056) * gru_2_fwd_t3_h_23 + (-0.22843450307846069) * gru_2_fwd_t3_h_24 + (-0.57223838567733765) * gru_2_fwd_t3_h_25 + (0.56197500228881836) * gru_2_fwd_t3_h_26 + (0.76962697505950928) * gru_2_fwd_t3_h_27 + (-0.22084665298461914) * gru_2_fwd_t3_h_28 + (0.65756028890609741) * gru_2_fwd_t3_h_29 + (1.5489675998687744) * gru_2_fwd_t3_h_30 + (-0.21265189349651337) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.080896459519863129) + (-0.20545960962772369) * gru_1_out_t4_0 + (0.14881576597690582) * gru_1_out_t4_1 + (-0.39357256889343262) * gru_1_out_t4_2 + (0.40238288044929504) * gru_1_out_t4_3 + (0.30182197690010071) * gru_1_out_t4_4 + (0.31502607464790344) * gru_1_out_t4_5 + (1.0386515855789185) * gru_1_out_t4_6 + (-0.087774969637393951) * gru_1_out_t4_7 + (1.2227314710617065) * gru_1_out_t4_8 + (0.20022973418235779) * gru_1_out_t4_9 + (-0.24202157557010651) * gru_1_out_t4_10 + (0.28753301501274109) * gru_1_out_t4_11 + (0.40048006176948547) * gru_1_out_t4_12 + (-0.14606863260269165) * gru_1_out_t4_13 + (0.066339954733848572) * gru_1_out_t4_14 + (-0.31292611360549927) * gru_1_out_t4_15 + (0.49535605311393738) * gru_1_out_t4_16 + (0.25644275546073914) * gru_1_out_t4_17 + (-0.096026875078678131) * gru_1_out_t4_18 + (-0.4971981942653656) * gru_1_out_t4_19 + (0.038691829890012741) * gru_1_out_t4_20 + (0.80434513092041016) * gru_1_out_t4_21 + (-0.28771570324897766) * gru_1_out_t4_22 + (-0.23809598386287689) * gru_1_out_t4_23 + (0.67181688547134399) * gru_1_out_t4_24 + (-0.19987352192401886) * gru_1_out_t4_25 + (0.14188650250434875) * gru_1_out_t4_26 + (0.8021395206451416) * gru_1_out_t4_27 + (0.084606409072875977) * gru_1_out_t4_28 + (0.17685984075069427) * gru_1_out_t4_29 + (-0.61622422933578491) * gru_1_out_t4_30 + (-0.25802761316299438) * gru_1_out_t4_31 + (-0.37795373797416687) * gru_1_out_t4_32 + (0.23507475852966309) * gru_1_out_t4_33 + (0.11875605583190918) * gru_1_out_t4_34 + (-0.099364154040813446) * gru_1_out_t4_35 + (0.048919301480054855) * gru_1_out_t4_36 + (-0.48844832181930542) * gru_1_out_t4_37 + (0.28651678562164307) * gru_1_out_t4_38 + (-0.37144291400909424) * gru_1_out_t4_39 + (-0.0076654711738228798) * gru_1_out_t4_40 + (-0.097399845719337463) * gru_1_out_t4_41 + (-0.072898395359516144) * gru_1_out_t4_42 + (-0.088562138378620148) * gru_1_out_t4_43 + (0.49557170271873474) * gru_1_out_t4_44 + (0.18197828531265259) * gru_1_out_t4_45 + (0.28375735878944397) * gru_1_out_t4_46 + (0.087862707674503326) * gru_1_out_t4_47 + (-0.71973758935928345) * gru_1_out_t4_48 + (-0.6486620306968689) * gru_1_out_t4_49 + (-0.067816421389579773) * gru_1_out_t4_50 + (-0.25859501957893372) * gru_1_out_t4_51 + (-0.48113244771957397) * gru_1_out_t4_52 + (-0.035905629396438599) * gru_1_out_t4_53 + (-0.13010518252849579) * gru_1_out_t4_54 + (-0.05888792872428894) * gru_1_out_t4_55 + (-0.26724854111671448) * gru_1_out_t4_56 + (-0.13134163618087769) * gru_1_out_t4_57 + (-0.30570566654205322) * gru_1_out_t4_58 + (0.68446052074432373) * gru_1_out_t4_59 + (0.57993996143341064) * gru_1_out_t4_60 + (0.14256468415260315) * gru_1_out_t4_61 + (-0.27642518281936646) * gru_1_out_t4_62 + (0.21511463820934296) * gru_1_out_t4_63 + (0.26470890641212463) * gru_2_fwd_t3_h_0 + (0.19921544194221497) * gru_2_fwd_t3_h_1 + (-0.30964624881744385) * gru_2_fwd_t3_h_2 + (-0.6985018253326416) * gru_2_fwd_t3_h_3 + (0.077393896877765656) * gru_2_fwd_t3_h_4 + (-0.21482045948505402) * gru_2_fwd_t3_h_5 + (-0.48074641823768616) * gru_2_fwd_t3_h_6 + (0.0086521198973059654) * gru_2_fwd_t3_h_7 + (0.43436211347579956) * gru_2_fwd_t3_h_8 + (-0.089537635445594788) * gru_2_fwd_t3_h_9 + (0.12498778849840164) * gru_2_fwd_t3_h_10 + (0.22337807714939117) * gru_2_fwd_t3_h_11 + (0.42414107918739319) * gru_2_fwd_t3_h_12 + (0.78337299823760986) * gru_2_fwd_t3_h_13 + (-0.74991202354431152) * gru_2_fwd_t3_h_14 + (-0.18093961477279663) * gru_2_fwd_t3_h_15 + (-0.17370389401912689) * gru_2_fwd_t3_h_16 + (0.24194133281707764) * gru_2_fwd_t3_h_17 + (-0.014935960061848164) * gru_2_fwd_t3_h_18 + (-0.32033732533454895) * gru_2_fwd_t3_h_19 + (0.083958052098751068) * gru_2_fwd_t3_h_20 + (-0.46117615699768066) * gru_2_fwd_t3_h_21 + (-0.11984139680862427) * gru_2_fwd_t3_h_22 + (0.26107034087181091) * gru_2_fwd_t3_h_23 + (-0.070762224495410919) * gru_2_fwd_t3_h_24 + (-0.18356636166572571) * gru_2_fwd_t3_h_25 + (-0.043569870293140411) * gru_2_fwd_t3_h_26 + (-0.036540552973747253) * gru_2_fwd_t3_h_27 + (0.16268549859523773) * gru_2_fwd_t3_h_28 + (0.27773088216781616) * gru_2_fwd_t3_h_29 + (-0.0055355480872094631) * gru_2_fwd_t3_h_30 + (-0.1681751161813736) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.31493040919303894) + (0.018777238205075264) * gru_1_out_t4_0 + (0.50696581602096558) * gru_1_out_t4_1 + (0.30875474214553833) * gru_1_out_t4_2 + (0.25567901134490967) * gru_1_out_t4_3 + (0.13182616233825684) * gru_1_out_t4_4 + (-0.54735320806503296) * gru_1_out_t4_5 + (0.74286353588104248) * gru_1_out_t4_6 + (1.0754051208496094) * gru_1_out_t4_7 + (-1.1093050241470337) * gru_1_out_t4_8 + (0.060750111937522888) * gru_1_out_t4_9 + (-0.035665538161993027) * gru_1_out_t4_10 + (-0.39539241790771484) * gru_1_out_t4_11 + (-1.3770726919174194) * gru_1_out_t4_12 + (0.11891638487577438) * gru_1_out_t4_13 + (-0.66599047183990479) * gru_1_out_t4_14 + (-0.78592091798782349) * gru_1_out_t4_15 + (0.1618727445602417) * gru_1_out_t4_16 + (-0.184160515666008) * gru_1_out_t4_17 + (-0.82605141401290894) * gru_1_out_t4_18 + (-0.82823818922042847) * gru_1_out_t4_19 + (0.2318238765001297) * gru_1_out_t4_20 + (-0.69148629903793335) * gru_1_out_t4_21 + (-0.16078698635101318) * gru_1_out_t4_22 + (0.35650956630706787) * gru_1_out_t4_23 + (-1.3228468894958496) * gru_1_out_t4_24 + (-0.52429455518722534) * gru_1_out_t4_25 + (0.66069978475570679) * gru_1_out_t4_26 + (-0.17782846093177795) * gru_1_out_t4_27 + (0.0034028857480734587) * gru_1_out_t4_28 + (-0.70381134748458862) * gru_1_out_t4_29 + (-0.21602743864059448) * gru_1_out_t4_30 + (0.063544310629367828) * gru_1_out_t4_31 + (-0.081784456968307495) * gru_1_out_t4_32 + (-0.11678104102611542) * gru_1_out_t4_33 + (0.73069536685943604) * gru_1_out_t4_34 + (-0.53177756071090698) * gru_1_out_t4_35 + (0.55734020471572876) * gru_1_out_t4_36 + (-0.038893535733222961) * gru_1_out_t4_37 + (-0.55576860904693604) * gru_1_out_t4_38 + (-0.69039314985275269) * gru_1_out_t4_39 + (-0.070776268839836121) * gru_1_out_t4_40 + (0.095408782362937927) * gru_1_out_t4_41 + (-0.092817328870296478) * gru_1_out_t4_42 + (-0.079312272369861603) * gru_1_out_t4_43 + (0.028020810335874557) * gru_1_out_t4_44 + (1.2750213146209717) * gru_1_out_t4_45 + (0.44376742839813232) * gru_1_out_t4_46 + (-0.59220367670059204) * gru_1_out_t4_47 + (0.617725670337677) * gru_1_out_t4_48 + (-0.24988606572151184) * gru_1_out_t4_49 + (-0.67080461978912354) * gru_1_out_t4_50 + (0.44045558571815491) * gru_1_out_t4_51 + (0.44244968891143799) * gru_1_out_t4_52 + (0.23436546325683594) * gru_1_out_t4_53 + (-0.55162256956100464) * gru_1_out_t4_54 + (-0.27711427211761475) * gru_1_out_t4_55 + (0.16119007766246796) * gru_1_out_t4_56 + (0.1161620244383812) * gru_1_out_t4_57 + (0.064772926270961761) * gru_1_out_t4_58 + (-0.22830305993556976) * gru_1_out_t4_59 + (-1.9725714921951294) * gru_1_out_t4_60 + (1.070024847984314) * gru_1_out_t4_61 + (0.068062342703342438) * gru_1_out_t4_62 + (0.91617178916931152) * gru_1_out_t4_63 + gate_r * ((0.14955808222293854) + (-0.057038959115743637) * gru_2_fwd_t3_h_0 + (-0.07959602028131485) * gru_2_fwd_t3_h_1 + (0.92162823677062988) * gru_2_fwd_t3_h_2 + (-0.53966802358627319) * gru_2_fwd_t3_h_3 + (0.07383747398853302) * gru_2_fwd_t3_h_4 + (0.27178359031677246) * gru_2_fwd_t3_h_5 + (0.0014072471531108022) * gru_2_fwd_t3_h_6 + (1.010939359664917) * gru_2_fwd_t3_h_7 + (0.040022373199462891) * gru_2_fwd_t3_h_8 + (0.095186159014701843) * gru_2_fwd_t3_h_9 + (-0.22764022648334503) * gru_2_fwd_t3_h_10 + (0.48784217238426208) * gru_2_fwd_t3_h_11 + (0.30391883850097656) * gru_2_fwd_t3_h_12 + (-1.1431647539138794) * gru_2_fwd_t3_h_13 + (0.39971950650215149) * gru_2_fwd_t3_h_14 + (-0.32296937704086304) * gru_2_fwd_t3_h_15 + (-0.23491804301738739) * gru_2_fwd_t3_h_16 + (-0.44476845860481262) * gru_2_fwd_t3_h_17 + (0.16976988315582275) * gru_2_fwd_t3_h_18 + (0.05334119126200676) * gru_2_fwd_t3_h_19 + (0.076059892773628235) * gru_2_fwd_t3_h_20 + (-0.19170036911964417) * gru_2_fwd_t3_h_21 + (0.25761088728904724) * gru_2_fwd_t3_h_22 + (-0.78242361545562744) * gru_2_fwd_t3_h_23 + (-0.080135010182857513) * gru_2_fwd_t3_h_24 + (0.46163129806518555) * gru_2_fwd_t3_h_25 + (0.78444212675094604) * gru_2_fwd_t3_h_26 + (0.031748447567224503) * gru_2_fwd_t3_h_27 + (-0.042542707175016403) * gru_2_fwd_t3_h_28 + (-0.057218711823225021) * gru_2_fwd_t3_h_29 + (-0.46197792887687683) * gru_2_fwd_t3_h_30 + (-0.037597078830003738) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_23 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_23;
    // h=24
    gate_r = sigmoid((0.4673646092414856) + (0.35247558355331421) * gru_1_out_t4_0 + (0.93637698888778687) * gru_1_out_t4_1 + (-0.10327769070863724) * gru_1_out_t4_2 + (-0.53679114580154419) * gru_1_out_t4_3 + (0.50518035888671875) * gru_1_out_t4_4 + (-0.23685111105442047) * gru_1_out_t4_5 + (-0.62549865245819092) * gru_1_out_t4_6 + (0.2070385068655014) * gru_1_out_t4_7 + (-1.6941090822219849) * gru_1_out_t4_8 + (0.50846403837203979) * gru_1_out_t4_9 + (0.165358766913414) * gru_1_out_t4_10 + (-0.19876578450202942) * gru_1_out_t4_11 + (-0.5457313060760498) * gru_1_out_t4_12 + (-1.3513485193252563) * gru_1_out_t4_13 + (-1.9118117094039917) * gru_1_out_t4_14 + (0.54784864187240601) * gru_1_out_t4_15 + (-0.3699662983417511) * gru_1_out_t4_16 + (-0.36923018097877502) * gru_1_out_t4_17 + (-1.0070182085037231) * gru_1_out_t4_18 + (-0.57311230897903442) * gru_1_out_t4_19 + (0.30371510982513428) * gru_1_out_t4_20 + (-0.37247595191001892) * gru_1_out_t4_21 + (-1.4043493270874023) * gru_1_out_t4_22 + (-0.7820127010345459) * gru_1_out_t4_23 + (-2.5950231552124023) * gru_1_out_t4_24 + (0.60855066776275635) * gru_1_out_t4_25 + (1.0422152280807495) * gru_1_out_t4_26 + (0.46932479739189148) * gru_1_out_t4_27 + (0.31901875138282776) * gru_1_out_t4_28 + (0.81940335035324097) * gru_1_out_t4_29 + (1.4390691518783569) * gru_1_out_t4_30 + (-0.36960998177528381) * gru_1_out_t4_31 + (-0.033101551234722137) * gru_1_out_t4_32 + (-1.1895773410797119) * gru_1_out_t4_33 + (-1.2625670433044434) * gru_1_out_t4_34 + (-0.8538815975189209) * gru_1_out_t4_35 + (1.5695781707763672) * gru_1_out_t4_36 + (0.58618497848510742) * gru_1_out_t4_37 + (-0.12650814652442932) * gru_1_out_t4_38 + (1.0394401550292969) * gru_1_out_t4_39 + (-0.56169015169143677) * gru_1_out_t4_40 + (-0.55560541152954102) * gru_1_out_t4_41 + (-0.16931378841400146) * gru_1_out_t4_42 + (1.2329567670822144) * gru_1_out_t4_43 + (-0.52986359596252441) * gru_1_out_t4_44 + (-1.3312066793441772) * gru_1_out_t4_45 + (0.129588782787323) * gru_1_out_t4_46 + (0.06193215399980545) * gru_1_out_t4_47 + (0.15378542244434357) * gru_1_out_t4_48 + (1.0861635208129883) * gru_1_out_t4_49 + (0.73000043630599976) * gru_1_out_t4_50 + (0.71545624732971191) * gru_1_out_t4_51 + (2.1046969890594482) * gru_1_out_t4_52 + (-0.26057237386703491) * gru_1_out_t4_53 + (-0.43234702944755554) * gru_1_out_t4_54 + (0.076704211533069611) * gru_1_out_t4_55 + (-1.0309680700302124) * gru_1_out_t4_56 + (-0.48905754089355469) * gru_1_out_t4_57 + (0.45485660433769226) * gru_1_out_t4_58 + (0.74517810344696045) * gru_1_out_t4_59 + (0.81629610061645508) * gru_1_out_t4_60 + (0.44307166337966919) * gru_1_out_t4_61 + (-0.52546089887619019) * gru_1_out_t4_62 + (1.8187072277069092) * gru_1_out_t4_63 + (0.72959822416305542) * gru_2_fwd_t3_h_0 + (0.1223699152469635) * gru_2_fwd_t3_h_1 + (1.3012970685958862) * gru_2_fwd_t3_h_2 + (-0.087142191827297211) * gru_2_fwd_t3_h_3 + (-0.48561513423919678) * gru_2_fwd_t3_h_4 + (0.17354677617549896) * gru_2_fwd_t3_h_5 + (0.87683713436126709) * gru_2_fwd_t3_h_6 + (0.52894365787506104) * gru_2_fwd_t3_h_7 + (0.82091063261032104) * gru_2_fwd_t3_h_8 + (0.53467369079589844) * gru_2_fwd_t3_h_9 + (-0.21231415867805481) * gru_2_fwd_t3_h_10 + (0.41024491190910339) * gru_2_fwd_t3_h_11 + (0.0035616664681583643) * gru_2_fwd_t3_h_12 + (-0.017971307039260864) * gru_2_fwd_t3_h_13 + (0.37257057428359985) * gru_2_fwd_t3_h_14 + (-0.36182478070259094) * gru_2_fwd_t3_h_15 + (0.74249941110610962) * gru_2_fwd_t3_h_16 + (0.056056257337331772) * gru_2_fwd_t3_h_17 + (0.18526211380958557) * gru_2_fwd_t3_h_18 + (0.072816409170627594) * gru_2_fwd_t3_h_19 + (-0.52519255876541138) * gru_2_fwd_t3_h_20 + (1.3345217704772949) * gru_2_fwd_t3_h_21 + (-0.82716411352157593) * gru_2_fwd_t3_h_22 + (-0.16383609175682068) * gru_2_fwd_t3_h_23 + (0.35603168606758118) * gru_2_fwd_t3_h_24 + (-0.32842010259628296) * gru_2_fwd_t3_h_25 + (-0.20866227149963379) * gru_2_fwd_t3_h_26 + (0.10670541971921921) * gru_2_fwd_t3_h_27 + (-0.37556418776512146) * gru_2_fwd_t3_h_28 + (0.18641890585422516) * gru_2_fwd_t3_h_29 + (-1.1659656763076782) * gru_2_fwd_t3_h_30 + (-0.2443205714225769) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((0.37149518728256226) + (-0.2052067369222641) * gru_1_out_t4_0 + (-1.2925759553909302) * gru_1_out_t4_1 + (-0.40121445059776306) * gru_1_out_t4_2 + (-0.69402873516082764) * gru_1_out_t4_3 + (-0.44430088996887207) * gru_1_out_t4_4 + (0.16407832503318787) * gru_1_out_t4_5 + (-0.41145831346511841) * gru_1_out_t4_6 + (-0.54956787824630737) * gru_1_out_t4_7 + (0.12248726934194565) * gru_1_out_t4_8 + (-0.36311957240104675) * gru_1_out_t4_9 + (-0.79786151647567749) * gru_1_out_t4_10 + (1.7965935468673706) * gru_1_out_t4_11 + (-0.20941263437271118) * gru_1_out_t4_12 + (0.75773108005523682) * gru_1_out_t4_13 + (0.89026725292205811) * gru_1_out_t4_14 + (0.12352640926837921) * gru_1_out_t4_15 + (0.70307439565658569) * gru_1_out_t4_16 + (-0.34771144390106201) * gru_1_out_t4_17 + (-0.34768441319465637) * gru_1_out_t4_18 + (-0.29592216014862061) * gru_1_out_t4_19 + (-0.21788641810417175) * gru_1_out_t4_20 + (-0.70787304639816284) * gru_1_out_t4_21 + (-0.17936478555202484) * gru_1_out_t4_22 + (0.22118335962295532) * gru_1_out_t4_23 + (-1.2784970998764038) * gru_1_out_t4_24 + (0.86480796337127686) * gru_1_out_t4_25 + (-0.041989702731370926) * gru_1_out_t4_26 + (-0.28476044535636902) * gru_1_out_t4_27 + (1.7493894100189209) * gru_1_out_t4_28 + (0.43033179640769958) * gru_1_out_t4_29 + (-0.77521729469299316) * gru_1_out_t4_30 + (0.18207255005836487) * gru_1_out_t4_31 + (1.1679642200469971) * gru_1_out_t4_32 + (-0.18111643195152283) * gru_1_out_t4_33 + (-0.39127439260482788) * gru_1_out_t4_34 + (0.79954278469085693) * gru_1_out_t4_35 + (0.61915451288223267) * gru_1_out_t4_36 + (-0.163176029920578) * gru_1_out_t4_37 + (-0.41251266002655029) * gru_1_out_t4_38 + (-0.10857484489679337) * gru_1_out_t4_39 + (-0.12926287949085236) * gru_1_out_t4_40 + (-1.0561610460281372) * gru_1_out_t4_41 + (-0.74949777126312256) * gru_1_out_t4_42 + (-0.84209901094436646) * gru_1_out_t4_43 + (-0.50763434171676636) * gru_1_out_t4_44 + (0.85890847444534302) * gru_1_out_t4_45 + (0.29788768291473389) * gru_1_out_t4_46 + (0.39198786020278931) * gru_1_out_t4_47 + (-0.65973258018493652) * gru_1_out_t4_48 + (0.12766410410404205) * gru_1_out_t4_49 + (1.3862347602844238) * gru_1_out_t4_50 + (-0.42722794413566589) * gru_1_out_t4_51 + (-1.0731182098388672) * gru_1_out_t4_52 + (0.52443969249725342) * gru_1_out_t4_53 + (-0.43356230854988098) * gru_1_out_t4_54 + (0.19522799551486969) * gru_1_out_t4_55 + (-1.1219958066940308) * gru_1_out_t4_56 + (-0.21781663596630096) * gru_1_out_t4_57 + (-0.75443059206008911) * gru_1_out_t4_58 + (-0.96104425191879272) * gru_1_out_t4_59 + (-0.10029629617929459) * gru_1_out_t4_60 + (0.062160231173038483) * gru_1_out_t4_61 + (-0.66717654466629028) * gru_1_out_t4_62 + (-0.033043622970581055) * gru_1_out_t4_63 + (0.73720508813858032) * gru_2_fwd_t3_h_0 + (0.084997713565826416) * gru_2_fwd_t3_h_1 + (0.51038169860839844) * gru_2_fwd_t3_h_2 + (2.1744880676269531) * gru_2_fwd_t3_h_3 + (-0.27785861492156982) * gru_2_fwd_t3_h_4 + (-0.13541029393672943) * gru_2_fwd_t3_h_5 + (0.47903913259506226) * gru_2_fwd_t3_h_6 + (-0.19918082654476166) * gru_2_fwd_t3_h_7 + (0.95572519302368164) * gru_2_fwd_t3_h_8 + (0.79198020696640015) * gru_2_fwd_t3_h_9 + (-0.76031643152236938) * gru_2_fwd_t3_h_10 + (-1.2989304065704346) * gru_2_fwd_t3_h_11 + (-0.83266222476959229) * gru_2_fwd_t3_h_12 + (0.21402211487293243) * gru_2_fwd_t3_h_13 + (-0.47248849272727966) * gru_2_fwd_t3_h_14 + (-0.17455913126468658) * gru_2_fwd_t3_h_15 + (-0.45321056246757507) * gru_2_fwd_t3_h_16 + (0.76065725088119507) * gru_2_fwd_t3_h_17 + (-0.16107313334941864) * gru_2_fwd_t3_h_18 + (-1.4460049867630005) * gru_2_fwd_t3_h_19 + (-0.29067534208297729) * gru_2_fwd_t3_h_20 + (0.74727904796600342) * gru_2_fwd_t3_h_21 + (-0.86521345376968384) * gru_2_fwd_t3_h_22 + (-1.0843793153762817) * gru_2_fwd_t3_h_23 + (-0.43608787655830383) * gru_2_fwd_t3_h_24 + (0.052217338234186172) * gru_2_fwd_t3_h_25 + (-0.84015923738479614) * gru_2_fwd_t3_h_26 + (0.092902280390262604) * gru_2_fwd_t3_h_27 + (0.13056068122386932) * gru_2_fwd_t3_h_28 + (0.55159205198287964) * gru_2_fwd_t3_h_29 + (-0.034049026668071747) * gru_2_fwd_t3_h_30 + (-0.67287665605545044) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.52527981996536255) + (0.028285833075642586) * gru_1_out_t4_0 + (-0.45029869675636292) * gru_1_out_t4_1 + (-0.55895769596099854) * gru_1_out_t4_2 + (-0.56304472684860229) * gru_1_out_t4_3 + (-0.30793404579162598) * gru_1_out_t4_4 + (0.18651273846626282) * gru_1_out_t4_5 + (-0.61046671867370605) * gru_1_out_t4_6 + (-0.10623575001955032) * gru_1_out_t4_7 + (0.25674808025360107) * gru_1_out_t4_8 + (0.129135861992836) * gru_1_out_t4_9 + (0.34831470251083374) * gru_1_out_t4_10 + (-0.44525894522666931) * gru_1_out_t4_11 + (-0.074231535196304321) * gru_1_out_t4_12 + (0.01831374503672123) * gru_1_out_t4_13 + (-0.048573870211839676) * gru_1_out_t4_14 + (0.19309590756893158) * gru_1_out_t4_15 + (-0.17389845848083496) * gru_1_out_t4_16 + (-0.063781045377254486) * gru_1_out_t4_17 + (0.0015015116659924388) * gru_1_out_t4_18 + (-0.2131815105676651) * gru_1_out_t4_19 + (-0.21812146902084351) * gru_1_out_t4_20 + (-0.64212697744369507) * gru_1_out_t4_21 + (-0.62772631645202637) * gru_1_out_t4_22 + (-0.22713145613670349) * gru_1_out_t4_23 + (0.21193283796310425) * gru_1_out_t4_24 + (0.46509882807731628) * gru_1_out_t4_25 + (-0.7677997350692749) * gru_1_out_t4_26 + (-0.42033210396766663) * gru_1_out_t4_27 + (0.3126315176486969) * gru_1_out_t4_28 + (-0.4197135865688324) * gru_1_out_t4_29 + (0.93476366996765137) * gru_1_out_t4_30 + (-0.26553207635879517) * gru_1_out_t4_31 + (0.33596527576446533) * gru_1_out_t4_32 + (-0.083317659795284271) * gru_1_out_t4_33 + (0.59368115663528442) * gru_1_out_t4_34 + (-0.81892555952072144) * gru_1_out_t4_35 + (0.78556334972381592) * gru_1_out_t4_36 + (0.28016236424446106) * gru_1_out_t4_37 + (-0.03971487283706665) * gru_1_out_t4_38 + (0.5227656364440918) * gru_1_out_t4_39 + (-0.59910601377487183) * gru_1_out_t4_40 + (0.36231544613838196) * gru_1_out_t4_41 + (-0.41476759314537048) * gru_1_out_t4_42 + (-0.42130067944526672) * gru_1_out_t4_43 + (0.1511048823595047) * gru_1_out_t4_44 + (0.81594663858413696) * gru_1_out_t4_45 + (0.08609260618686676) * gru_1_out_t4_46 + (-1.1672836542129517) * gru_1_out_t4_47 + (0.21514579653739929) * gru_1_out_t4_48 + (0.055982101708650589) * gru_1_out_t4_49 + (-0.38753250241279602) * gru_1_out_t4_50 + (0.47130560874938965) * gru_1_out_t4_51 + (0.5247424840927124) * gru_1_out_t4_52 + (-0.36222803592681885) * gru_1_out_t4_53 + (0.17719320952892303) * gru_1_out_t4_54 + (0.18356692790985107) * gru_1_out_t4_55 + (0.79807877540588379) * gru_1_out_t4_56 + (-0.1005273163318634) * gru_1_out_t4_57 + (0.11582723259925842) * gru_1_out_t4_58 + (-0.13494521379470825) * gru_1_out_t4_59 + (-0.32238897681236267) * gru_1_out_t4_60 + (-0.19158834218978882) * gru_1_out_t4_61 + (0.28233730792999268) * gru_1_out_t4_62 + (0.43124166131019592) * gru_1_out_t4_63 + gate_r * ((0.21849149465560913) + (-0.23557490110397339) * gru_2_fwd_t3_h_0 + (-0.97655373811721802) * gru_2_fwd_t3_h_1 + (-0.77284353971481323) * gru_2_fwd_t3_h_2 + (-0.72490602731704712) * gru_2_fwd_t3_h_3 + (-0.42279356718063354) * gru_2_fwd_t3_h_4 + (-0.3279651403427124) * gru_2_fwd_t3_h_5 + (0.84417027235031128) * gru_2_fwd_t3_h_6 + (0.70090055465698242) * gru_2_fwd_t3_h_7 + (0.032624382525682449) * gru_2_fwd_t3_h_8 + (-0.13954077661037445) * gru_2_fwd_t3_h_9 + (-1.1498069763183594) * gru_2_fwd_t3_h_10 + (-0.28937605023384094) * gru_2_fwd_t3_h_11 + (0.52740830183029175) * gru_2_fwd_t3_h_12 + (-0.67197078466415405) * gru_2_fwd_t3_h_13 + (0.19560210406780243) * gru_2_fwd_t3_h_14 + (-0.46650373935699463) * gru_2_fwd_t3_h_15 + (-0.1604628711938858) * gru_2_fwd_t3_h_16 + (0.056946143507957458) * gru_2_fwd_t3_h_17 + (-0.52646547555923462) * gru_2_fwd_t3_h_18 + (-0.42470872402191162) * gru_2_fwd_t3_h_19 + (-0.2451649010181427) * gru_2_fwd_t3_h_20 + (-0.66087549924850464) * gru_2_fwd_t3_h_21 + (-0.073261894285678864) * gru_2_fwd_t3_h_22 + (0.073959171772003174) * gru_2_fwd_t3_h_23 + (-0.19375669956207275) * gru_2_fwd_t3_h_24 + (0.78050309419631958) * gru_2_fwd_t3_h_25 + (0.42445653676986694) * gru_2_fwd_t3_h_26 + (1.0095964670181274) * gru_2_fwd_t3_h_27 + (-0.2398858368396759) * gru_2_fwd_t3_h_28 + (-0.53965151309967041) * gru_2_fwd_t3_h_29 + (0.59489291906356812) * gru_2_fwd_t3_h_30 + (0.63224905729293823) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_24 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_24;
    // h=25
    gate_r = sigmoid((-0.13911190629005432) + (-0.74884223937988281) * gru_1_out_t4_0 + (1.4952476024627686) * gru_1_out_t4_1 + (-0.096099540591239929) * gru_1_out_t4_2 + (0.33777570724487305) * gru_1_out_t4_3 + (-0.21848736703395844) * gru_1_out_t4_4 + (1.1303707361221313) * gru_1_out_t4_5 + (1.0223513841629028) * gru_1_out_t4_6 + (-0.39082658290863037) * gru_1_out_t4_7 + (-0.15167652070522308) * gru_1_out_t4_8 + (0.20396402478218079) * gru_1_out_t4_9 + (-1.3515660762786865) * gru_1_out_t4_10 + (-0.01382903940975666) * gru_1_out_t4_11 + (0.049498084932565689) * gru_1_out_t4_12 + (-0.20253771543502808) * gru_1_out_t4_13 + (1.2001274824142456) * gru_1_out_t4_14 + (0.091363720595836639) * gru_1_out_t4_15 + (-0.43682795763015747) * gru_1_out_t4_16 + (0.79960834980010986) * gru_1_out_t4_17 + (0.86959719657897949) * gru_1_out_t4_18 + (-0.16588173806667328) * gru_1_out_t4_19 + (0.035142086446285248) * gru_1_out_t4_20 + (1.2600973844528198) * gru_1_out_t4_21 + (1.5998013019561768) * gru_1_out_t4_22 + (0.51038116216659546) * gru_1_out_t4_23 + (1.8165864944458008) * gru_1_out_t4_24 + (-0.24423703551292419) * gru_1_out_t4_25 + (-0.096976049244403839) * gru_1_out_t4_26 + (0.41760867834091187) * gru_1_out_t4_27 + (0.22566437721252441) * gru_1_out_t4_28 + (0.67941039800643921) * gru_1_out_t4_29 + (-1.1434328556060791) * gru_1_out_t4_30 + (-0.77067285776138306) * gru_1_out_t4_31 + (1.5782463550567627) * gru_1_out_t4_32 + (0.97780460119247437) * gru_1_out_t4_33 + (-0.50434446334838867) * gru_1_out_t4_34 + (0.42615470290184021) * gru_1_out_t4_35 + (-0.35157465934753418) * gru_1_out_t4_36 + (-1.5342257022857666) * gru_1_out_t4_37 + (-0.9812089204788208) * gru_1_out_t4_38 + (-0.76583975553512573) * gru_1_out_t4_39 + (0.62424278259277344) * gru_1_out_t4_40 + (0.064028277993202209) * gru_1_out_t4_41 + (-1.7800111770629883) * gru_1_out_t4_42 + (0.86528366804122925) * gru_1_out_t4_43 + (-1.7529394626617432) * gru_1_out_t4_44 + (0.33419892191886902) * gru_1_out_t4_45 + (-1.0739176273345947) * gru_1_out_t4_46 + (-0.42274141311645508) * gru_1_out_t4_47 + (0.83790034055709839) * gru_1_out_t4_48 + (-1.545401930809021) * gru_1_out_t4_49 + (-1.1446218490600586) * gru_1_out_t4_50 + (3.7184476852416992) * gru_1_out_t4_51 + (-1.0489485263824463) * gru_1_out_t4_52 + (-0.06993025541305542) * gru_1_out_t4_53 + (-0.29259073734283447) * gru_1_out_t4_54 + (-1.2040654420852661) * gru_1_out_t4_55 + (0.019697174429893494) * gru_1_out_t4_56 + (0.23414821922779083) * gru_1_out_t4_57 + (0.054722469300031662) * gru_1_out_t4_58 + (-0.95283716917037964) * gru_1_out_t4_59 + (-0.93420910835266113) * gru_1_out_t4_60 + (0.0018306792480871081) * gru_1_out_t4_61 + (1.202085018157959) * gru_1_out_t4_62 + (0.8555063009262085) * gru_1_out_t4_63 + (-0.51887887716293335) * gru_2_fwd_t3_h_0 + (-0.89496129751205444) * gru_2_fwd_t3_h_1 + (-1.0219513177871704) * gru_2_fwd_t3_h_2 + (-0.062855280935764313) * gru_2_fwd_t3_h_3 + (0.19741038978099823) * gru_2_fwd_t3_h_4 + (1.0759836435317993) * gru_2_fwd_t3_h_5 + (0.44888824224472046) * gru_2_fwd_t3_h_6 + (-0.76208925247192383) * gru_2_fwd_t3_h_7 + (1.1098008155822754) * gru_2_fwd_t3_h_8 + (-0.81575995683670044) * gru_2_fwd_t3_h_9 + (0.495647132396698) * gru_2_fwd_t3_h_10 + (-1.6310548782348633) * gru_2_fwd_t3_h_11 + (1.6195417642593384) * gru_2_fwd_t3_h_12 + (-2.20835280418396) * gru_2_fwd_t3_h_13 + (0.30992111563682556) * gru_2_fwd_t3_h_14 + (-0.35440254211425781) * gru_2_fwd_t3_h_15 + (1.2491873502731323) * gru_2_fwd_t3_h_16 + (-1.7550584077835083) * gru_2_fwd_t3_h_17 + (0.30700135231018066) * gru_2_fwd_t3_h_18 + (-0.14439249038696289) * gru_2_fwd_t3_h_19 + (0.24486412107944489) * gru_2_fwd_t3_h_20 + (-0.23787491023540497) * gru_2_fwd_t3_h_21 + (1.2248818874359131) * gru_2_fwd_t3_h_22 + (0.090462386608123779) * gru_2_fwd_t3_h_23 + (-0.53990823030471802) * gru_2_fwd_t3_h_24 + (0.65721839666366577) * gru_2_fwd_t3_h_25 + (-0.94679540395736694) * gru_2_fwd_t3_h_26 + (0.63261276483535767) * gru_2_fwd_t3_h_27 + (-0.23469318449497223) * gru_2_fwd_t3_h_28 + (-2.1959438323974609) * gru_2_fwd_t3_h_29 + (0.71450459957122803) * gru_2_fwd_t3_h_30 + (-0.57980257272720337) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((0.68813371658325195) + (-0.038842715322971344) * gru_1_out_t4_0 + (0.11078698933124542) * gru_1_out_t4_1 + (0.49061894416809082) * gru_1_out_t4_2 + (0.093512430787086487) * gru_1_out_t4_3 + (0.13934674859046936) * gru_1_out_t4_4 + (1.3907451629638672) * gru_1_out_t4_5 + (0.041032511740922928) * gru_1_out_t4_6 + (0.31529819965362549) * gru_1_out_t4_7 + (0.092930600047111511) * gru_1_out_t4_8 + (-0.71662938594818115) * gru_1_out_t4_9 + (-0.67985343933105469) * gru_1_out_t4_10 + (-0.69343370199203491) * gru_1_out_t4_11 + (0.14162690937519073) * gru_1_out_t4_12 + (0.1818174421787262) * gru_1_out_t4_13 + (0.66497665643692017) * gru_1_out_t4_14 + (-0.10337434709072113) * gru_1_out_t4_15 + (0.50752937793731689) * gru_1_out_t4_16 + (0.28734299540519714) * gru_1_out_t4_17 + (0.01458175852894783) * gru_1_out_t4_18 + (-0.21465873718261719) * gru_1_out_t4_19 + (0.66359204053878784) * gru_1_out_t4_20 + (0.56994479894638062) * gru_1_out_t4_21 + (0.50571787357330322) * gru_1_out_t4_22 + (0.33632180094718933) * gru_1_out_t4_23 + (0.53706032037734985) * gru_1_out_t4_24 + (0.15992997586727142) * gru_1_out_t4_25 + (-0.09399230033159256) * gru_1_out_t4_26 + (0.063154846429824829) * gru_1_out_t4_27 + (-0.21219570934772491) * gru_1_out_t4_28 + (0.087515860795974731) * gru_1_out_t4_29 + (-1.0134462118148804) * gru_1_out_t4_30 + (0.53287994861602783) * gru_1_out_t4_31 + (-0.1646883636713028) * gru_1_out_t4_32 + (-0.24773561954498291) * gru_1_out_t4_33 + (0.168839231133461) * gru_1_out_t4_34 + (0.046957653015851974) * gru_1_out_t4_35 + (0.63433152437210083) * gru_1_out_t4_36 + (-0.20580798387527466) * gru_1_out_t4_37 + (0.23009791970252991) * gru_1_out_t4_38 + (0.39112651348114014) * gru_1_out_t4_39 + (0.24010251462459564) * gru_1_out_t4_40 + (0.10770433396100998) * gru_1_out_t4_41 + (-0.35188135504722595) * gru_1_out_t4_42 + (0.09411156177520752) * gru_1_out_t4_43 + (0.52559030055999756) * gru_1_out_t4_44 + (0.13654491305351257) * gru_1_out_t4_45 + (0.55550724267959595) * gru_1_out_t4_46 + (-0.49137145280838013) * gru_1_out_t4_47 + (-0.054394543170928955) * gru_1_out_t4_48 + (-0.50316739082336426) * gru_1_out_t4_49 + (0.27084836363792419) * gru_1_out_t4_50 + (1.4028559923171997) * gru_1_out_t4_51 + (0.063805505633354187) * gru_1_out_t4_52 + (0.51783382892608643) * gru_1_out_t4_53 + (-0.76736998558044434) * gru_1_out_t4_54 + (-0.51454848051071167) * gru_1_out_t4_55 + (-0.091150820255279541) * gru_1_out_t4_56 + (0.39368349313735962) * gru_1_out_t4_57 + (0.72896087169647217) * gru_1_out_t4_58 + (0.28375953435897827) * gru_1_out_t4_59 + (-0.70826739072799683) * gru_1_out_t4_60 + (0.41784539818763733) * gru_1_out_t4_61 + (-0.27206134796142578) * gru_1_out_t4_62 + (0.14112566411495209) * gru_1_out_t4_63 + (0.00047722065937705338) * gru_2_fwd_t3_h_0 + (-0.56488478183746338) * gru_2_fwd_t3_h_1 + (0.50763106346130371) * gru_2_fwd_t3_h_2 + (0.12475316226482391) * gru_2_fwd_t3_h_3 + (0.29096782207489014) * gru_2_fwd_t3_h_4 + (-0.75938481092453003) * gru_2_fwd_t3_h_5 + (0.67631006240844727) * gru_2_fwd_t3_h_6 + (0.58651679754257202) * gru_2_fwd_t3_h_7 + (0.15189351141452789) * gru_2_fwd_t3_h_8 + (0.2032138854265213) * gru_2_fwd_t3_h_9 + (-0.45610314607620239) * gru_2_fwd_t3_h_10 + (1.0044223070144653) * gru_2_fwd_t3_h_11 + (-0.39774808287620544) * gru_2_fwd_t3_h_12 + (-0.86670058965682983) * gru_2_fwd_t3_h_13 + (0.7927398681640625) * gru_2_fwd_t3_h_14 + (-0.010849456302821636) * gru_2_fwd_t3_h_15 + (-0.89409053325653076) * gru_2_fwd_t3_h_16 + (-0.35520917177200317) * gru_2_fwd_t3_h_17 + (-0.56659156084060669) * gru_2_fwd_t3_h_18 + (-0.78215128183364868) * gru_2_fwd_t3_h_19 + (-0.18316203355789185) * gru_2_fwd_t3_h_20 + (0.69251912832260132) * gru_2_fwd_t3_h_21 + (-0.42323395609855652) * gru_2_fwd_t3_h_22 + (-0.56633412837982178) * gru_2_fwd_t3_h_23 + (-0.016681285575032234) * gru_2_fwd_t3_h_24 + (-0.30772486329078674) * gru_2_fwd_t3_h_25 + (1.0659769773483276) * gru_2_fwd_t3_h_26 + (0.0029041108209639788) * gru_2_fwd_t3_h_27 + (-0.14627416431903839) * gru_2_fwd_t3_h_28 + (1.0131826400756836) * gru_2_fwd_t3_h_29 + (0.51114088296890259) * gru_2_fwd_t3_h_30 + (-0.5567510724067688) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.074005588889122009) + (-1.2369143962860107) * gru_1_out_t4_0 + (0.68402111530303955) * gru_1_out_t4_1 + (0.66591501235961914) * gru_1_out_t4_2 + (-0.04051496833562851) * gru_1_out_t4_3 + (-0.47070527076721191) * gru_1_out_t4_4 + (3.0898900032043457) * gru_1_out_t4_5 + (1.5335904359817505) * gru_1_out_t4_6 + (0.08094005286693573) * gru_1_out_t4_7 + (0.71569567918777466) * gru_1_out_t4_8 + (0.15385781228542328) * gru_1_out_t4_9 + (-0.8374055027961731) * gru_1_out_t4_10 + (-0.12457315623760223) * gru_1_out_t4_11 + (0.29568672180175781) * gru_1_out_t4_12 + (-0.65149110555648804) * gru_1_out_t4_13 + (-0.23395073413848877) * gru_1_out_t4_14 + (0.60972332954406738) * gru_1_out_t4_15 + (1.6616543531417847) * gru_1_out_t4_16 + (-0.57126426696777344) * gru_1_out_t4_17 + (-2.2264351844787598) * gru_1_out_t4_18 + (0.18242144584655762) * gru_1_out_t4_19 + (-0.25245964527130127) * gru_1_out_t4_20 + (-1.122431755065918) * gru_1_out_t4_21 + (0.94328534603118896) * gru_1_out_t4_22 + (3.9716353416442871) * gru_1_out_t4_23 + (1.5939474105834961) * gru_1_out_t4_24 + (0.037542574107646942) * gru_1_out_t4_25 + (-0.24186427891254425) * gru_1_out_t4_26 + (-1.8668984174728394) * gru_1_out_t4_27 + (2.4404745101928711) * gru_1_out_t4_28 + (0.36105954647064209) * gru_1_out_t4_29 + (-3.4821517467498779) * gru_1_out_t4_30 + (-1.9511008262634277) * gru_1_out_t4_31 + (-0.85294145345687866) * gru_1_out_t4_32 + (-0.69362270832061768) * gru_1_out_t4_33 + (0.477102130651474) * gru_1_out_t4_34 + (-0.57014793157577515) * gru_1_out_t4_35 + (0.49566829204559326) * gru_1_out_t4_36 + (-0.17568893730640411) * gru_1_out_t4_37 + (-0.080022819340229034) * gru_1_out_t4_38 + (0.32815268635749817) * gru_1_out_t4_39 + (-0.050667185336351395) * gru_1_out_t4_40 + (-0.34652537107467651) * gru_1_out_t4_41 + (-0.56599670648574829) * gru_1_out_t4_42 + (0.53619307279586792) * gru_1_out_t4_43 + (2.14048171043396) * gru_1_out_t4_44 + (0.72516930103302002) * gru_1_out_t4_45 + (0.77292543649673462) * gru_1_out_t4_46 + (-2.2475216388702393) * gru_1_out_t4_47 + (0.26747500896453857) * gru_1_out_t4_48 + (-1.1024981737136841) * gru_1_out_t4_49 + (0.44986778497695923) * gru_1_out_t4_50 + (-0.55125731229782104) * gru_1_out_t4_51 + (0.52797782421112061) * gru_1_out_t4_52 + (0.12135373800992966) * gru_1_out_t4_53 + (-0.59775501489639282) * gru_1_out_t4_54 + (0.35554921627044678) * gru_1_out_t4_55 + (1.0247483253479004) * gru_1_out_t4_56 + (-0.38548266887664795) * gru_1_out_t4_57 + (-0.059060920029878616) * gru_1_out_t4_58 + (0.20514534413814545) * gru_1_out_t4_59 + (1.9166020154953003) * gru_1_out_t4_60 + (0.66354537010192871) * gru_1_out_t4_61 + (-1.3004556894302368) * gru_1_out_t4_62 + (0.22160391509532928) * gru_1_out_t4_63 + gate_r * ((0.44456362724304199) + (0.36805179715156555) * gru_2_fwd_t3_h_0 + (-0.23323765397071838) * gru_2_fwd_t3_h_1 + (-0.15117797255516052) * gru_2_fwd_t3_h_2 + (-0.13239593803882599) * gru_2_fwd_t3_h_3 + (1.2263823747634888) * gru_2_fwd_t3_h_4 + (0.96568810939788818) * gru_2_fwd_t3_h_5 + (-0.26942384243011475) * gru_2_fwd_t3_h_6 + (3.7531983852386475) * gru_2_fwd_t3_h_7 + (0.80942606925964355) * gru_2_fwd_t3_h_8 + (-0.033423777669668198) * gru_2_fwd_t3_h_9 + (0.54870682954788208) * gru_2_fwd_t3_h_10 + (0.46200555562973022) * gru_2_fwd_t3_h_11 + (0.65651649236679077) * gru_2_fwd_t3_h_12 + (0.10184084624052048) * gru_2_fwd_t3_h_13 + (-0.83247345685958862) * gru_2_fwd_t3_h_14 + (-2.006566047668457) * gru_2_fwd_t3_h_15 + (-0.215715691447258) * gru_2_fwd_t3_h_16 + (1.0052629709243774) * gru_2_fwd_t3_h_17 + (-0.26464465260505676) * gru_2_fwd_t3_h_18 + (-0.25178608298301697) * gru_2_fwd_t3_h_19 + (-0.77292013168334961) * gru_2_fwd_t3_h_20 + (-0.27611526846885681) * gru_2_fwd_t3_h_21 + (-0.44481059908866882) * gru_2_fwd_t3_h_22 + (0.26343852281570435) * gru_2_fwd_t3_h_23 + (1.0000176429748535) * gru_2_fwd_t3_h_24 + (0.32382297515869141) * gru_2_fwd_t3_h_25 + (-0.29118353128433228) * gru_2_fwd_t3_h_26 + (-0.36822345852851868) * gru_2_fwd_t3_h_27 + (-0.27505424618721008) * gru_2_fwd_t3_h_28 + (0.42499065399169922) * gru_2_fwd_t3_h_29 + (-0.5005459189414978) * gru_2_fwd_t3_h_30 + (0.39551365375518799) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_25 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_25;
    // h=26
    gate_r = sigmoid((0.10689800232648849) + (-0.18316248059272766) * gru_1_out_t4_0 + (1.4888871908187866) * gru_1_out_t4_1 + (0.15313154458999634) * gru_1_out_t4_2 + (-0.73088455200195312) * gru_1_out_t4_3 + (-0.35855385661125183) * gru_1_out_t4_4 + (0.54722040891647339) * gru_1_out_t4_5 + (0.22342461347579956) * gru_1_out_t4_6 + (-0.06343609094619751) * gru_1_out_t4_7 + (-0.032313812524080276) * gru_1_out_t4_8 + (0.18431994318962097) * gru_1_out_t4_9 + (-0.85149061679840088) * gru_1_out_t4_10 + (0.38520386815071106) * gru_1_out_t4_11 + (-0.2541237473487854) * gru_1_out_t4_12 + (1.1792020797729492) * gru_1_out_t4_13 + (1.1283130645751953) * gru_1_out_t4_14 + (0.054941780865192413) * gru_1_out_t4_15 + (0.43381932377815247) * gru_1_out_t4_16 + (-0.55045437812805176) * gru_1_out_t4_17 + (-0.96835780143737793) * gru_1_out_t4_18 + (0.18522128462791443) * gru_1_out_t4_19 + (0.29718068242073059) * gru_1_out_t4_20 + (0.25216600298881531) * gru_1_out_t4_21 + (-0.26735836267471313) * gru_1_out_t4_22 + (3.1086788177490234) * gru_1_out_t4_23 + (-0.19657939672470093) * gru_1_out_t4_24 + (0.54944878816604614) * gru_1_out_t4_25 + (-0.40156117081642151) * gru_1_out_t4_26 + (-0.15184205770492554) * gru_1_out_t4_27 + (1.9075691699981689) * gru_1_out_t4_28 + (0.10091401636600494) * gru_1_out_t4_29 + (-3.1260185241699219) * gru_1_out_t4_30 + (0.32227304577827454) * gru_1_out_t4_31 + (-1.4731384515762329) * gru_1_out_t4_32 + (0.72767829895019531) * gru_1_out_t4_33 + (-0.13296008110046387) * gru_1_out_t4_34 + (1.1502406597137451) * gru_1_out_t4_35 + (0.47861200571060181) * gru_1_out_t4_36 + (1.0191847085952759) * gru_1_out_t4_37 + (0.26508703827857971) * gru_1_out_t4_38 + (0.75664412975311279) * gru_1_out_t4_39 + (0.45910665392875671) * gru_1_out_t4_40 + (-0.11774518340826035) * gru_1_out_t4_41 + (0.4339066743850708) * gru_1_out_t4_42 + (-0.20965863764286041) * gru_1_out_t4_43 + (-0.22902439534664154) * gru_1_out_t4_44 + (-0.45312735438346863) * gru_1_out_t4_45 + (0.17511627078056335) * gru_1_out_t4_46 + (-0.81364274024963379) * gru_1_out_t4_47 + (1.5442333221435547) * gru_1_out_t4_48 + (0.34145262837409973) * gru_1_out_t4_49 + (0.77093714475631714) * gru_1_out_t4_50 + (0.24053916335105896) * gru_1_out_t4_51 + (-0.41484370827674866) * gru_1_out_t4_52 + (0.17817206680774689) * gru_1_out_t4_53 + (-0.47277680039405823) * gru_1_out_t4_54 + (0.080902554094791412) * gru_1_out_t4_55 + (-1.4545679092407227) * gru_1_out_t4_56 + (0.1859317272901535) * gru_1_out_t4_57 + (0.032128423452377319) * gru_1_out_t4_58 + (-1.3250042200088501) * gru_1_out_t4_59 + (-0.77583754062652588) * gru_1_out_t4_60 + (-0.61020517349243164) * gru_1_out_t4_61 + (0.77488654851913452) * gru_1_out_t4_62 + (0.23833677172660828) * gru_1_out_t4_63 + (-0.32423549890518188) * gru_2_fwd_t3_h_0 + (0.78412288427352905) * gru_2_fwd_t3_h_1 + (1.1607983112335205) * gru_2_fwd_t3_h_2 + (0.39819419384002686) * gru_2_fwd_t3_h_3 + (0.427104651927948) * gru_2_fwd_t3_h_4 + (0.83908581733703613) * gru_2_fwd_t3_h_5 + (0.77150470018386841) * gru_2_fwd_t3_h_6 + (-0.001604526536539197) * gru_2_fwd_t3_h_7 + (0.34214362502098083) * gru_2_fwd_t3_h_8 + (0.26792469620704651) * gru_2_fwd_t3_h_9 + (-1.4942550659179688) * gru_2_fwd_t3_h_10 + (-0.89243638515472412) * gru_2_fwd_t3_h_11 + (-0.29353758692741394) * gru_2_fwd_t3_h_12 + (1.1931254863739014) * gru_2_fwd_t3_h_13 + (-0.0099019818007946014) * gru_2_fwd_t3_h_14 + (0.81363403797149658) * gru_2_fwd_t3_h_15 + (0.52310049533843994) * gru_2_fwd_t3_h_16 + (-0.18292798101902008) * gru_2_fwd_t3_h_17 + (0.38811662793159485) * gru_2_fwd_t3_h_18 + (-0.41710737347602844) * gru_2_fwd_t3_h_19 + (-0.25498467683792114) * gru_2_fwd_t3_h_20 + (0.15383803844451904) * gru_2_fwd_t3_h_21 + (-0.20288947224617004) * gru_2_fwd_t3_h_22 + (-0.55462592840194702) * gru_2_fwd_t3_h_23 + (-0.36693701148033142) * gru_2_fwd_t3_h_24 + (-0.20511466264724731) * gru_2_fwd_t3_h_25 + (-2.3058850765228271) * gru_2_fwd_t3_h_26 + (0.3646949827671051) * gru_2_fwd_t3_h_27 + (-0.78278607130050659) * gru_2_fwd_t3_h_28 + (-1.7226247787475586) * gru_2_fwd_t3_h_29 + (0.53107470273971558) * gru_2_fwd_t3_h_30 + (-0.28294655680656433) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((1.4906297922134399) + (-0.10185521095991135) * gru_1_out_t4_0 + (-0.17789915204048157) * gru_1_out_t4_1 + (0.40005728602409363) * gru_1_out_t4_2 + (-0.33060839772224426) * gru_1_out_t4_3 + (-0.1648714691400528) * gru_1_out_t4_4 + (1.4689217805862427) * gru_1_out_t4_5 + (-0.088939473032951355) * gru_1_out_t4_6 + (0.086823001503944397) * gru_1_out_t4_7 + (-0.17372195422649384) * gru_1_out_t4_8 + (0.024666471406817436) * gru_1_out_t4_9 + (-0.07053443044424057) * gru_1_out_t4_10 + (0.014476575888693333) * gru_1_out_t4_11 + (-0.94500696659088135) * gru_1_out_t4_12 + (-0.36262384057044983) * gru_1_out_t4_13 + (0.22860568761825562) * gru_1_out_t4_14 + (0.051371399313211441) * gru_1_out_t4_15 + (0.94250297546386719) * gru_1_out_t4_16 + (0.43795901536941528) * gru_1_out_t4_17 + (0.0035999349784106016) * gru_1_out_t4_18 + (-0.74355554580688477) * gru_1_out_t4_19 + (0.25715804100036621) * gru_1_out_t4_20 + (1.2550472021102905) * gru_1_out_t4_21 + (1.5005980730056763) * gru_1_out_t4_22 + (-0.048415329307317734) * gru_1_out_t4_23 + (-0.3682730495929718) * gru_1_out_t4_24 + (0.19391992688179016) * gru_1_out_t4_25 + (0.63027507066726685) * gru_1_out_t4_26 + (0.038145389407873154) * gru_1_out_t4_27 + (-0.028867334127426147) * gru_1_out_t4_28 + (-0.123035728931427) * gru_1_out_t4_29 + (0.97668689489364624) * gru_1_out_t4_30 + (0.20128707587718964) * gru_1_out_t4_31 + (0.29799702763557434) * gru_1_out_t4_32 + (-0.094211295247077942) * gru_1_out_t4_33 + (-0.057660255581140518) * gru_1_out_t4_34 + (0.16921858489513397) * gru_1_out_t4_35 + (1.1242141723632812) * gru_1_out_t4_36 + (0.27940800786018372) * gru_1_out_t4_37 + (-0.35793983936309814) * gru_1_out_t4_38 + (-0.37903618812561035) * gru_1_out_t4_39 + (0.043937820941209793) * gru_1_out_t4_40 + (-0.18020065128803253) * gru_1_out_t4_41 + (0.14797677099704742) * gru_1_out_t4_42 + (0.29885107278823853) * gru_1_out_t4_43 + (-0.061922866851091385) * gru_1_out_t4_44 + (0.36354097723960876) * gru_1_out_t4_45 + (-0.22548997402191162) * gru_1_out_t4_46 + (-1.0071890354156494) * gru_1_out_t4_47 + (-0.10394540429115295) * gru_1_out_t4_48 + (0.1631205677986145) * gru_1_out_t4_49 + (0.13262827694416046) * gru_1_out_t4_50 + (0.96944731473922729) * gru_1_out_t4_51 + (1.1466548442840576) * gru_1_out_t4_52 + (0.68706876039505005) * gru_1_out_t4_53 + (1.0062174797058105) * gru_1_out_t4_54 + (0.05204014852643013) * gru_1_out_t4_55 + (0.17742727696895599) * gru_1_out_t4_56 + (-0.30688273906707764) * gru_1_out_t4_57 + (0.91437047719955444) * gru_1_out_t4_58 + (-0.45980426669120789) * gru_1_out_t4_59 + (0.53268724679946899) * gru_1_out_t4_60 + (0.18460473418235779) * gru_1_out_t4_61 + (0.77188771963119507) * gru_1_out_t4_62 + (0.70561343431472778) * gru_1_out_t4_63 + (-0.073395907878875732) * gru_2_fwd_t3_h_0 + (-0.097539208829402924) * gru_2_fwd_t3_h_1 + (0.11917325854301453) * gru_2_fwd_t3_h_2 + (0.20914326608181) * gru_2_fwd_t3_h_3 + (0.48022234439849854) * gru_2_fwd_t3_h_4 + (0.16752244532108307) * gru_2_fwd_t3_h_5 + (0.038213636726140976) * gru_2_fwd_t3_h_6 + (-0.32627749443054199) * gru_2_fwd_t3_h_7 + (-0.12666116654872894) * gru_2_fwd_t3_h_8 + (-0.16212709248065948) * gru_2_fwd_t3_h_9 + (-0.37792304158210754) * gru_2_fwd_t3_h_10 + (-0.33513286709785461) * gru_2_fwd_t3_h_11 + (0.1925281286239624) * gru_2_fwd_t3_h_12 + (3.5354471206665039) * gru_2_fwd_t3_h_13 + (0.25570538640022278) * gru_2_fwd_t3_h_14 + (-1.2316875457763672) * gru_2_fwd_t3_h_15 + (-0.73989921808242798) * gru_2_fwd_t3_h_16 + (0.38964688777923584) * gru_2_fwd_t3_h_17 + (0.072259560227394104) * gru_2_fwd_t3_h_18 + (0.36184597015380859) * gru_2_fwd_t3_h_19 + (-0.28779491782188416) * gru_2_fwd_t3_h_20 + (0.048095516860485077) * gru_2_fwd_t3_h_21 + (-0.25036242604255676) * gru_2_fwd_t3_h_22 + (-0.064631998538970947) * gru_2_fwd_t3_h_23 + (-0.025571705773472786) * gru_2_fwd_t3_h_24 + (-0.27043598890304565) * gru_2_fwd_t3_h_25 + (0.45517894625663757) * gru_2_fwd_t3_h_26 + (-0.34115201234817505) * gru_2_fwd_t3_h_27 + (0.3491346538066864) * gru_2_fwd_t3_h_28 + (0.31713229417800903) * gru_2_fwd_t3_h_29 + (0.12591050565242767) * gru_2_fwd_t3_h_30 + (-0.29054608941078186) * gru_2_fwd_t3_h_31);
    gate_n = tanh((0.054834265261888504) + (-0.46956756711006165) * gru_1_out_t4_0 + (0.14283636212348938) * gru_1_out_t4_1 + (0.71871387958526611) * gru_1_out_t4_2 + (-1.041450023651123) * gru_1_out_t4_3 + (-0.33199092745780945) * gru_1_out_t4_4 + (0.5341455340385437) * gru_1_out_t4_5 + (-1.0786583423614502) * gru_1_out_t4_6 + (0.090845033526420593) * gru_1_out_t4_7 + (-0.049735378473997116) * gru_1_out_t4_8 + (0.21218626201152802) * gru_1_out_t4_9 + (0.054017063230276108) * gru_1_out_t4_10 + (-0.40643242001533508) * gru_1_out_t4_11 + (0.38050305843353271) * gru_1_out_t4_12 + (-1.531998872756958) * gru_1_out_t4_13 + (-0.71277469396591187) * gru_1_out_t4_14 + (-0.12473146617412567) * gru_1_out_t4_15 + (0.48627570271492004) * gru_1_out_t4_16 + (-0.11893695592880249) * gru_1_out_t4_17 + (-0.54584187269210815) * gru_1_out_t4_18 + (-0.88483947515487671) * gru_1_out_t4_19 + (-0.15610051155090332) * gru_1_out_t4_20 + (-0.58347874879837036) * gru_1_out_t4_21 + (-0.51420849561691284) * gru_1_out_t4_22 + (1.72075355052948) * gru_1_out_t4_23 + (-0.47643214464187622) * gru_1_out_t4_24 + (0.30141738057136536) * gru_1_out_t4_25 + (-0.15457440912723541) * gru_1_out_t4_26 + (-0.7765997052192688) * gru_1_out_t4_27 + (1.2824186086654663) * gru_1_out_t4_28 + (0.13060513138771057) * gru_1_out_t4_29 + (-0.42382964491844177) * gru_1_out_t4_30 + (2.1138098239898682) * gru_1_out_t4_31 + (0.02286246232688427) * gru_1_out_t4_32 + (0.25586074590682983) * gru_1_out_t4_33 + (0.29201480746269226) * gru_1_out_t4_34 + (-0.60120928287506104) * gru_1_out_t4_35 + (0.078785531222820282) * gru_1_out_t4_36 + (0.25998204946517944) * gru_1_out_t4_37 + (0.24553139507770538) * gru_1_out_t4_38 + (0.40602850914001465) * gru_1_out_t4_39 + (0.41439637541770935) * gru_1_out_t4_40 + (-0.20253723859786987) * gru_1_out_t4_41 + (-0.46944081783294678) * gru_1_out_t4_42 + (0.10174597054719925) * gru_1_out_t4_43 + (1.1528556346893311) * gru_1_out_t4_44 + (1.3292281627655029) * gru_1_out_t4_45 + (0.43599718809127808) * gru_1_out_t4_46 + (-0.97197705507278442) * gru_1_out_t4_47 + (0.27662080526351929) * gru_1_out_t4_48 + (-0.058269869536161423) * gru_1_out_t4_49 + (-0.13074110448360443) * gru_1_out_t4_50 + (0.58249408006668091) * gru_1_out_t4_51 + (0.66777306795120239) * gru_1_out_t4_52 + (0.14795903861522675) * gru_1_out_t4_53 + (-0.55216234922409058) * gru_1_out_t4_54 + (0.75648421049118042) * gru_1_out_t4_55 + (0.94173383712768555) * gru_1_out_t4_56 + (-0.31568092107772827) * gru_1_out_t4_57 + (0.041591409593820572) * gru_1_out_t4_58 + (0.38527780771255493) * gru_1_out_t4_59 + (-0.11555605381727219) * gru_1_out_t4_60 + (-0.1455942690372467) * gru_1_out_t4_61 + (-2.3821315765380859) * gru_1_out_t4_62 + (0.044680286198854446) * gru_1_out_t4_63 + gate_r * ((0.21356229484081268) + (-0.18819111585617065) * gru_2_fwd_t3_h_0 + (-0.29850360751152039) * gru_2_fwd_t3_h_1 + (1.0045901536941528) * gru_2_fwd_t3_h_2 + (-0.26019921898841858) * gru_2_fwd_t3_h_3 + (0.93203055858612061) * gru_2_fwd_t3_h_4 + (0.096165835857391357) * gru_2_fwd_t3_h_5 + (-1.46257483959198) * gru_2_fwd_t3_h_6 + (-0.35794082283973694) * gru_2_fwd_t3_h_7 + (-0.3138178288936615) * gru_2_fwd_t3_h_8 + (-0.24969100952148438) * gru_2_fwd_t3_h_9 + (0.26859185099601746) * gru_2_fwd_t3_h_10 + (-0.79974353313446045) * gru_2_fwd_t3_h_11 + (0.86110013723373413) * gru_2_fwd_t3_h_12 + (3.4958391189575195) * gru_2_fwd_t3_h_13 + (0.36271956562995911) * gru_2_fwd_t3_h_14 + (-0.11046791821718216) * gru_2_fwd_t3_h_15 + (0.69563597440719604) * gru_2_fwd_t3_h_16 + (-0.056847508996725082) * gru_2_fwd_t3_h_17 + (-0.53904235363006592) * gru_2_fwd_t3_h_18 + (0.23126550018787384) * gru_2_fwd_t3_h_19 + (-0.18399989604949951) * gru_2_fwd_t3_h_20 + (0.074902437627315521) * gru_2_fwd_t3_h_21 + (-0.39521944522857666) * gru_2_fwd_t3_h_22 + (0.63766556978225708) * gru_2_fwd_t3_h_23 + (-0.06441720575094223) * gru_2_fwd_t3_h_24 + (-0.13117286562919617) * gru_2_fwd_t3_h_25 + (-1.2239081859588623) * gru_2_fwd_t3_h_26 + (0.50446635484695435) * gru_2_fwd_t3_h_27 + (-0.57602322101593018) * gru_2_fwd_t3_h_28 + (0.65047723054885864) * gru_2_fwd_t3_h_29 + (0.29434579610824585) * gru_2_fwd_t3_h_30 + (-0.27306997776031494) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_26 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_26;
    // h=27
    gate_r = sigmoid((0.41580018401145935) + (3.7086246013641357) * gru_1_out_t4_0 + (0.27879434823989868) * gru_1_out_t4_1 + (-0.36931648850440979) * gru_1_out_t4_2 + (0.26378723978996277) * gru_1_out_t4_3 + (-0.8253900408744812) * gru_1_out_t4_4 + (0.43274262547492981) * gru_1_out_t4_5 + (-0.61202269792556763) * gru_1_out_t4_6 + (-0.27769488096237183) * gru_1_out_t4_7 + (-0.044994384050369263) * gru_1_out_t4_8 + (-0.77026087045669556) * gru_1_out_t4_9 + (0.11727739125490189) * gru_1_out_t4_10 + (-0.15276014804840088) * gru_1_out_t4_11 + (0.38785856962203979) * gru_1_out_t4_12 + (2.0633747577667236) * gru_1_out_t4_13 + (-0.52875083684921265) * gru_1_out_t4_14 + (-0.064678587019443512) * gru_1_out_t4_15 + (-0.091352276504039764) * gru_1_out_t4_16 + (0.48003265261650085) * gru_1_out_t4_17 + (2.3973169326782227) * gru_1_out_t4_18 + (0.2015422135591507) * gru_1_out_t4_19 + (-0.51784908771514893) * gru_1_out_t4_20 + (-0.95553076267242432) * gru_1_out_t4_21 + (-0.96238923072814941) * gru_1_out_t4_22 + (-1.6482492685317993) * gru_1_out_t4_23 + (0.95636886358261108) * gru_1_out_t4_24 + (-0.29985335469245911) * gru_1_out_t4_25 + (0.052295487374067307) * gru_1_out_t4_26 + (-1.2501161098480225) * gru_1_out_t4_27 + (0.81457972526550293) * gru_1_out_t4_28 + (-1.0923364162445068) * gru_1_out_t4_29 + (-2.822577953338623) * gru_1_out_t4_30 + (0.50433957576751709) * gru_1_out_t4_31 + (0.19929143786430359) * gru_1_out_t4_32 + (1.3107587099075317) * gru_1_out_t4_33 + (2.2480208873748779) * gru_1_out_t4_34 + (-0.0085353543981909752) * gru_1_out_t4_35 + (-0.1342131495475769) * gru_1_out_t4_36 + (-0.05615336075425148) * gru_1_out_t4_37 + (-0.44415304064750671) * gru_1_out_t4_38 + (-0.73249608278274536) * gru_1_out_t4_39 + (0.88065177202224731) * gru_1_out_t4_40 + (-0.089959278702735901) * gru_1_out_t4_41 + (-0.013593791052699089) * gru_1_out_t4_42 + (-0.62030649185180664) * gru_1_out_t4_43 + (2.1590580940246582) * gru_1_out_t4_44 + (0.62537211179733276) * gru_1_out_t4_45 + (-0.67549538612365723) * gru_1_out_t4_46 + (-0.46986356377601624) * gru_1_out_t4_47 + (-2.7329883575439453) * gru_1_out_t4_48 + (-0.35300147533416748) * gru_1_out_t4_49 + (0.39231079816818237) * gru_1_out_t4_50 + (0.49848547577857971) * gru_1_out_t4_51 + (-1.3591911792755127) * gru_1_out_t4_52 + (0.057544104754924774) * gru_1_out_t4_53 + (0.76176881790161133) * gru_1_out_t4_54 + (-0.25341764092445374) * gru_1_out_t4_55 + (1.1952433586120605) * gru_1_out_t4_56 + (0.13332542777061462) * gru_1_out_t4_57 + (-2.4399712085723877) * gru_1_out_t4_58 + (-0.47432634234428406) * gru_1_out_t4_59 + (-1.255840539932251) * gru_1_out_t4_60 + (0.27080929279327393) * gru_1_out_t4_61 + (-0.69473624229431152) * gru_1_out_t4_62 + (-0.79403865337371826) * gru_1_out_t4_63 + (-0.165292888879776) * gru_2_fwd_t3_h_0 + (-0.21893928945064545) * gru_2_fwd_t3_h_1 + (-0.92442762851715088) * gru_2_fwd_t3_h_2 + (-0.65818184614181519) * gru_2_fwd_t3_h_3 + (0.27935612201690674) * gru_2_fwd_t3_h_4 + (-1.0344796180725098) * gru_2_fwd_t3_h_5 + (0.1886294037103653) * gru_2_fwd_t3_h_6 + (-0.35502117872238159) * gru_2_fwd_t3_h_7 + (-1.3478869199752808) * gru_2_fwd_t3_h_8 + (0.2018553614616394) * gru_2_fwd_t3_h_9 + (0.24340264499187469) * gru_2_fwd_t3_h_10 + (-0.20411421358585358) * gru_2_fwd_t3_h_11 + (-1.0225920677185059) * gru_2_fwd_t3_h_12 + (-0.87608516216278076) * gru_2_fwd_t3_h_13 + (0.31687313318252563) * gru_2_fwd_t3_h_14 + (-1.5123345851898193) * gru_2_fwd_t3_h_15 + (0.28692999482154846) * gru_2_fwd_t3_h_16 + (-0.35973858833312988) * gru_2_fwd_t3_h_17 + (-0.57419908046722412) * gru_2_fwd_t3_h_18 + (0.051823016256093979) * gru_2_fwd_t3_h_19 + (0.59608173370361328) * gru_2_fwd_t3_h_20 + (1.0018236637115479) * gru_2_fwd_t3_h_21 + (-0.050600331276655197) * gru_2_fwd_t3_h_22 + (0.92198950052261353) * gru_2_fwd_t3_h_23 + (0.41749700903892517) * gru_2_fwd_t3_h_24 + (0.15392290055751801) * gru_2_fwd_t3_h_25 + (0.72043412923812866) * gru_2_fwd_t3_h_26 + (-0.4580371081829071) * gru_2_fwd_t3_h_27 + (-0.95135772228240967) * gru_2_fwd_t3_h_28 + (0.78534942865371704) * gru_2_fwd_t3_h_29 + (0.035045608878135681) * gru_2_fwd_t3_h_30 + (-0.15490244328975677) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((0.32804688811302185) + (0.45961940288543701) * gru_1_out_t4_0 + (0.79854792356491089) * gru_1_out_t4_1 + (-0.051412686705589294) * gru_1_out_t4_2 + (-0.43305358290672302) * gru_1_out_t4_3 + (-0.48481106758117676) * gru_1_out_t4_4 + (-0.91550153493881226) * gru_1_out_t4_5 + (0.61693805456161499) * gru_1_out_t4_6 + (0.40314227342605591) * gru_1_out_t4_7 + (-0.23037973046302795) * gru_1_out_t4_8 + (0.15173393487930298) * gru_1_out_t4_9 + (-0.31163761019706726) * gru_1_out_t4_10 + (-0.37985849380493164) * gru_1_out_t4_11 + (-0.42228677868843079) * gru_1_out_t4_12 + (0.38088586926460266) * gru_1_out_t4_13 + (-0.037102729082107544) * gru_1_out_t4_14 + (0.15762236714363098) * gru_1_out_t4_15 + (0.31431299448013306) * gru_1_out_t4_16 + (-0.45536124706268311) * gru_1_out_t4_17 + (0.94310593605041504) * gru_1_out_t4_18 + (0.70627957582473755) * gru_1_out_t4_19 + (-0.20465125143527985) * gru_1_out_t4_20 + (-0.083394475281238556) * gru_1_out_t4_21 + (-0.16415148973464966) * gru_1_out_t4_22 + (1.0514651536941528) * gru_1_out_t4_23 + (0.76530671119689941) * gru_1_out_t4_24 + (-0.27175509929656982) * gru_1_out_t4_25 + (-0.49267181754112244) * gru_1_out_t4_26 + (0.65047621726989746) * gru_1_out_t4_27 + (-0.56621861457824707) * gru_1_out_t4_28 + (-0.14590355753898621) * gru_1_out_t4_29 + (0.12451981753110886) * gru_1_out_t4_30 + (0.1864459365606308) * gru_1_out_t4_31 + (-0.26697462797164917) * gru_1_out_t4_32 + (-0.14563797414302826) * gru_1_out_t4_33 + (-0.096174284815788269) * gru_1_out_t4_34 + (-0.053099043667316437) * gru_1_out_t4_35 + (0.26278451085090637) * gru_1_out_t4_36 + (-0.47411003708839417) * gru_1_out_t4_37 + (-0.30231022834777832) * gru_1_out_t4_38 + (0.16569596529006958) * gru_1_out_t4_39 + (-0.1551542729139328) * gru_1_out_t4_40 + (-0.013591929338872433) * gru_1_out_t4_41 + (-0.29572036862373352) * gru_1_out_t4_42 + (-0.062138598412275314) * gru_1_out_t4_43 + (-0.37600886821746826) * gru_1_out_t4_44 + (-0.061830911785364151) * gru_1_out_t4_45 + (0.36463576555252075) * gru_1_out_t4_46 + (-0.24188199639320374) * gru_1_out_t4_47 + (-0.16672343015670776) * gru_1_out_t4_48 + (0.21325981616973877) * gru_1_out_t4_49 + (-0.0032028309069573879) * gru_1_out_t4_50 + (0.20494003593921661) * gru_1_out_t4_51 + (-0.0048749828711152077) * gru_1_out_t4_52 + (0.22401495277881622) * gru_1_out_t4_53 + (-0.13976873457431793) * gru_1_out_t4_54 + (-0.22613584995269775) * gru_1_out_t4_55 + (0.4398251473903656) * gru_1_out_t4_56 + (0.32782065868377686) * gru_1_out_t4_57 + (0.08051665872335434) * gru_1_out_t4_58 + (-0.10666608065366745) * gru_1_out_t4_59 + (-0.4341810941696167) * gru_1_out_t4_60 + (0.38550674915313721) * gru_1_out_t4_61 + (-0.02272835373878479) * gru_1_out_t4_62 + (0.32444599270820618) * gru_1_out_t4_63 + (-0.43910658359527588) * gru_2_fwd_t3_h_0 + (-0.82729905843734741) * gru_2_fwd_t3_h_1 + (-0.38743939995765686) * gru_2_fwd_t3_h_2 + (0.6176447868347168) * gru_2_fwd_t3_h_3 + (0.32824519276618958) * gru_2_fwd_t3_h_4 + (-0.89317774772644043) * gru_2_fwd_t3_h_5 + (-0.0089539382606744766) * gru_2_fwd_t3_h_6 + (0.7598114013671875) * gru_2_fwd_t3_h_7 + (0.22019413113594055) * gru_2_fwd_t3_h_8 + (-0.19106772541999817) * gru_2_fwd_t3_h_9 + (-0.13162766396999359) * gru_2_fwd_t3_h_10 + (-0.16781602799892426) * gru_2_fwd_t3_h_11 + (0.033803727477788925) * gru_2_fwd_t3_h_12 + (0.22031548619270325) * gru_2_fwd_t3_h_13 + (-0.39923977851867676) * gru_2_fwd_t3_h_14 + (-0.35971015691757202) * gru_2_fwd_t3_h_15 + (0.30897617340087891) * gru_2_fwd_t3_h_16 + (0.35094767808914185) * gru_2_fwd_t3_h_17 + (-0.8766779899597168) * gru_2_fwd_t3_h_18 + (-0.0059914407320320606) * gru_2_fwd_t3_h_19 + (-0.29464399814605713) * gru_2_fwd_t3_h_20 + (-0.2913566529750824) * gru_2_fwd_t3_h_21 + (-0.018853221088647842) * gru_2_fwd_t3_h_22 + (-0.27790850400924683) * gru_2_fwd_t3_h_23 + (0.58924931287765503) * gru_2_fwd_t3_h_24 + (-0.15701884031295776) * gru_2_fwd_t3_h_25 + (0.269520103931427) * gru_2_fwd_t3_h_26 + (0.90093827247619629) * gru_2_fwd_t3_h_27 + (-0.6721874475479126) * gru_2_fwd_t3_h_28 + (0.59799003601074219) * gru_2_fwd_t3_h_29 + (0.16168883442878723) * gru_2_fwd_t3_h_30 + (-0.086465895175933838) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.071578800678253174) + (-0.69615578651428223) * gru_1_out_t4_0 + (-0.28391730785369873) * gru_1_out_t4_1 + (0.17077928781509399) * gru_1_out_t4_2 + (-0.83024531602859497) * gru_1_out_t4_3 + (0.68842297792434692) * gru_1_out_t4_4 + (-0.53634905815124512) * gru_1_out_t4_5 + (-0.71416401863098145) * gru_1_out_t4_6 + (0.40654760599136353) * gru_1_out_t4_7 + (-0.23945091664791107) * gru_1_out_t4_8 + (0.85853248834609985) * gru_1_out_t4_9 + (-0.054806482046842575) * gru_1_out_t4_10 + (0.41330164670944214) * gru_1_out_t4_11 + (0.51357185840606689) * gru_1_out_t4_12 + (0.28535473346710205) * gru_1_out_t4_13 + (-6.9654321123380214e-05) * gru_1_out_t4_14 + (0.48430562019348145) * gru_1_out_t4_15 + (0.46909844875335693) * gru_1_out_t4_16 + (-0.67559027671813965) * gru_1_out_t4_17 + (0.41689795255661011) * gru_1_out_t4_18 + (-0.37869557738304138) * gru_1_out_t4_19 + (0.15335416793823242) * gru_1_out_t4_20 + (-0.22824820876121521) * gru_1_out_t4_21 + (-0.97115021944046021) * gru_1_out_t4_22 + (-0.40898597240447998) * gru_1_out_t4_23 + (-1.2844247817993164) * gru_1_out_t4_24 + (0.14099547266960144) * gru_1_out_t4_25 + (0.10164864361286163) * gru_1_out_t4_26 + (-0.99745035171508789) * gru_1_out_t4_27 + (-1.0242366790771484) * gru_1_out_t4_28 + (0.65554261207580566) * gru_1_out_t4_29 + (0.5451200008392334) * gru_1_out_t4_30 + (0.58187252283096313) * gru_1_out_t4_31 + (-0.90134847164154053) * gru_1_out_t4_32 + (-0.50214046239852905) * gru_1_out_t4_33 + (0.48849436640739441) * gru_1_out_t4_34 + (-0.27724814414978027) * gru_1_out_t4_35 + (0.21774117648601532) * gru_1_out_t4_36 + (-0.34722131490707397) * gru_1_out_t4_37 + (0.84531682729721069) * gru_1_out_t4_38 + (0.24543243646621704) * gru_1_out_t4_39 + (0.41307586431503296) * gru_1_out_t4_40 + (-0.27557599544525146) * gru_1_out_t4_41 + (0.12522973120212555) * gru_1_out_t4_42 + (-0.1927386075258255) * gru_1_out_t4_43 + (-0.18155312538146973) * gru_1_out_t4_44 + (0.90065431594848633) * gru_1_out_t4_45 + (0.54620856046676636) * gru_1_out_t4_46 + (-0.19095702469348907) * gru_1_out_t4_47 + (-0.24318204820156097) * gru_1_out_t4_48 + (-0.15006965398788452) * gru_1_out_t4_49 + (0.16425967216491699) * gru_1_out_t4_50 + (0.23669461905956268) * gru_1_out_t4_51 + (-0.18842722475528717) * gru_1_out_t4_52 + (0.0042753973975777626) * gru_1_out_t4_53 + (1.2584464550018311) * gru_1_out_t4_54 + (1.2750664949417114) * gru_1_out_t4_55 + (-0.47451943159103394) * gru_1_out_t4_56 + (-0.36584466695785522) * gru_1_out_t4_57 + (-0.25194633007049561) * gru_1_out_t4_58 + (0.55924469232559204) * gru_1_out_t4_59 + (-1.0836969614028931) * gru_1_out_t4_60 + (0.43094450235366821) * gru_1_out_t4_61 + (1.399687647819519) * gru_1_out_t4_62 + (-0.04467179998755455) * gru_1_out_t4_63 + gate_r * ((0.07338821142911911) + (-0.038693059235811234) * gru_2_fwd_t3_h_0 + (0.069722287356853485) * gru_2_fwd_t3_h_1 + (0.7035146951675415) * gru_2_fwd_t3_h_2 + (-1.0927408933639526) * gru_2_fwd_t3_h_3 + (1.414547324180603) * gru_2_fwd_t3_h_4 + (0.19045552611351013) * gru_2_fwd_t3_h_5 + (0.2347683310508728) * gru_2_fwd_t3_h_6 + (-0.04371580109000206) * gru_2_fwd_t3_h_7 + (-0.76916176080703735) * gru_2_fwd_t3_h_8 + (0.3054070770740509) * gru_2_fwd_t3_h_9 + (0.2020527720451355) * gru_2_fwd_t3_h_10 + (0.5267835259437561) * gru_2_fwd_t3_h_11 + (0.52121591567993164) * gru_2_fwd_t3_h_12 + (0.12784749269485474) * gru_2_fwd_t3_h_13 + (-0.043851695954799652) * gru_2_fwd_t3_h_14 + (1.9045209884643555) * gru_2_fwd_t3_h_15 + (0.49423962831497192) * gru_2_fwd_t3_h_16 + (-0.23269189894199371) * gru_2_fwd_t3_h_17 + (0.9787369966506958) * gru_2_fwd_t3_h_18 + (0.51004707813262939) * gru_2_fwd_t3_h_19 + (-0.37285864353179932) * gru_2_fwd_t3_h_20 + (-0.39849108457565308) * gru_2_fwd_t3_h_21 + (-0.40880519151687622) * gru_2_fwd_t3_h_22 + (-0.67788970470428467) * gru_2_fwd_t3_h_23 + (0.15352898836135864) * gru_2_fwd_t3_h_24 + (-0.38869717717170715) * gru_2_fwd_t3_h_25 + (-0.33765894174575806) * gru_2_fwd_t3_h_26 + (-1.3458960056304932) * gru_2_fwd_t3_h_27 + (0.9667239785194397) * gru_2_fwd_t3_h_28 + (-0.1327710747718811) * gru_2_fwd_t3_h_29 + (0.88518452644348145) * gru_2_fwd_t3_h_30 + (0.016129510477185249) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_27 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_27;
    // h=28
    gate_r = sigmoid((1.1170806884765625) + (-1.2967590093612671) * gru_1_out_t4_0 + (0.9028325080871582) * gru_1_out_t4_1 + (-0.42581677436828613) * gru_1_out_t4_2 + (-0.42284071445465088) * gru_1_out_t4_3 + (-2.6211867332458496) * gru_1_out_t4_4 + (-1.4938701391220093) * gru_1_out_t4_5 + (2.2780041694641113) * gru_1_out_t4_6 + (0.46688687801361084) * gru_1_out_t4_7 + (-0.033835079520940781) * gru_1_out_t4_8 + (0.50523722171783447) * gru_1_out_t4_9 + (0.34245246648788452) * gru_1_out_t4_10 + (-0.64736306667327881) * gru_1_out_t4_11 + (0.26818963885307312) * gru_1_out_t4_12 + (-1.0582691431045532) * gru_1_out_t4_13 + (0.24692894518375397) * gru_1_out_t4_14 + (-0.73977994918823242) * gru_1_out_t4_15 + (0.42608469724655151) * gru_1_out_t4_16 + (-0.049303788691759109) * gru_1_out_t4_17 + (-0.91933178901672363) * gru_1_out_t4_18 + (-0.79125255346298218) * gru_1_out_t4_19 + (-0.52567493915557861) * gru_1_out_t4_20 + (-0.65829157829284668) * gru_1_out_t4_21 + (-3.5879130363464355) * gru_1_out_t4_22 + (-1.4670025110244751) * gru_1_out_t4_23 + (-1.5425759553909302) * gru_1_out_t4_24 + (-0.58593446016311646) * gru_1_out_t4_25 + (1.1616331338882446) * gru_1_out_t4_26 + (0.99392443895339966) * gru_1_out_t4_27 + (-1.9191586971282959) * gru_1_out_t4_28 + (0.43660524487495422) * gru_1_out_t4_29 + (1.9824197292327881) * gru_1_out_t4_30 + (0.17158624529838562) * gru_1_out_t4_31 + (-1.856863260269165) * gru_1_out_t4_32 + (0.50728189945220947) * gru_1_out_t4_33 + (0.095842413604259491) * gru_1_out_t4_34 + (0.40860059857368469) * gru_1_out_t4_35 + (0.092369481921195984) * gru_1_out_t4_36 + (-0.44300800561904907) * gru_1_out_t4_37 + (0.60195213556289673) * gru_1_out_t4_38 + (0.24483698606491089) * gru_1_out_t4_39 + (-1.0711474418640137) * gru_1_out_t4_40 + (-0.67678141593933105) * gru_1_out_t4_41 + (-0.61776334047317505) * gru_1_out_t4_42 + (1.853980541229248) * gru_1_out_t4_43 + (-0.393818199634552) * gru_1_out_t4_44 + (-1.5616822242736816) * gru_1_out_t4_45 + (-1.0709168910980225) * gru_1_out_t4_46 + (-0.10334233939647675) * gru_1_out_t4_47 + (-1.9349422454833984) * gru_1_out_t4_48 + (-1.0550938844680786) * gru_1_out_t4_49 + (-0.22409519553184509) * gru_1_out_t4_50 + (0.41025722026824951) * gru_1_out_t4_51 + (0.98111987113952637) * gru_1_out_t4_52 + (-0.15557181835174561) * gru_1_out_t4_53 + (0.73194456100463867) * gru_1_out_t4_54 + (0.090679444372653961) * gru_1_out_t4_55 + (-0.27741137146949768) * gru_1_out_t4_56 + (-1.3093100786209106) * gru_1_out_t4_57 + (0.61330032348632812) * gru_1_out_t4_58 + (0.064260639250278473) * gru_1_out_t4_59 + (-0.17360961437225342) * gru_1_out_t4_60 + (-0.12058087438344955) * gru_1_out_t4_61 + (-0.31108325719833374) * gru_1_out_t4_62 + (-0.77554011344909668) * gru_1_out_t4_63 + (-0.2400147020816803) * gru_2_fwd_t3_h_0 + (-0.32816672325134277) * gru_2_fwd_t3_h_1 + (0.0062728463672101498) * gru_2_fwd_t3_h_2 + (1.0788130760192871) * gru_2_fwd_t3_h_3 + (0.47481971979141235) * gru_2_fwd_t3_h_4 + (0.26043525338172913) * gru_2_fwd_t3_h_5 + (-0.90246939659118652) * gru_2_fwd_t3_h_6 + (-1.2244911193847656) * gru_2_fwd_t3_h_7 + (-0.51324379444122314) * gru_2_fwd_t3_h_8 + (-0.4271065890789032) * gru_2_fwd_t3_h_9 + (-0.65195626020431519) * gru_2_fwd_t3_h_10 + (-0.48166897892951965) * gru_2_fwd_t3_h_11 + (-0.060162045061588287) * gru_2_fwd_t3_h_12 + (2.6051149368286133) * gru_2_fwd_t3_h_13 + (0.57273602485656738) * gru_2_fwd_t3_h_14 + (0.35425606369972229) * gru_2_fwd_t3_h_15 + (0.36466559767723083) * gru_2_fwd_t3_h_16 + (-0.28864982724189758) * gru_2_fwd_t3_h_17 + (-0.1464078426361084) * gru_2_fwd_t3_h_18 + (0.093973487615585327) * gru_2_fwd_t3_h_19 + (-0.36259913444519043) * gru_2_fwd_t3_h_20 + (0.26903346180915833) * gru_2_fwd_t3_h_21 + (0.099754482507705688) * gru_2_fwd_t3_h_22 + (-0.059695370495319366) * gru_2_fwd_t3_h_23 + (0.25333425402641296) * gru_2_fwd_t3_h_24 + (-0.36376887559890747) * gru_2_fwd_t3_h_25 + (-0.13113230466842651) * gru_2_fwd_t3_h_26 + (1.9161849021911621) * gru_2_fwd_t3_h_27 + (1.2410694360733032) * gru_2_fwd_t3_h_28 + (0.18572835624217987) * gru_2_fwd_t3_h_29 + (0.24949203431606293) * gru_2_fwd_t3_h_30 + (-0.72382336854934692) * gru_2_fwd_t3_h_31);
    gate_z = sigmoid((-0.37027975916862488) + (0.30526870489120483) * gru_1_out_t4_0 + (-1.2309169769287109) * gru_1_out_t4_1 + (0.50694853067398071) * gru_1_out_t4_2 + (0.058804161846637726) * gru_1_out_t4_3 + (0.090288683772087097) * gru_1_out_t4_4 + (0.86798399686813354) * gru_1_out_t4_5 + (-0.77444589138031006) * gru_1_out_t4_6 + (0.56577384471893311) * gru_1_out_t4_7 + (-0.50492972135543823) * gru_1_out_t4_8 + (-0.12548185884952545) * gru_1_out_t4_9 + (-0.45968997478485107) * gru_1_out_t4_10 + (-0.60753387212753296) * gru_1_out_t4_11 + (-0.44124948978424072) * gru_1_out_t4_12 + (-0.023395610973238945) * gru_1_out_t4_13 + (-0.14289647340774536) * gru_1_out_t4_14 + (-0.10563436150550842) * gru_1_out_t4_15 + (-0.054798383265733719) * gru_1_out_t4_16 + (-0.16547827422618866) * gru_1_out_t4_17 + (-0.1611328125) * gru_1_out_t4_18 + (0.30655726790428162) * gru_1_out_t4_19 + (-0.15290753543376923) * gru_1_out_t4_20 + (-0.021461445838212967) * gru_1_out_t4_21 + (0.007224526721984148) * gru_1_out_t4_22 + (-0.21269242465496063) * gru_1_out_t4_23 + (-2.0056929588317871) * gru_1_out_t4_24 + (-0.064549855887889862) * gru_1_out_t4_25 + (0.18294709920883179) * gru_1_out_t4_26 + (0.34903454780578613) * gru_1_out_t4_27 + (-0.11637317389249802) * gru_1_out_t4_28 + (-0.19664911925792694) * gru_1_out_t4_29 + (0.88234364986419678) * gru_1_out_t4_30 + (0.088892392814159393) * gru_1_out_t4_31 + (0.1583559662103653) * gru_1_out_t4_32 + (0.12506350874900818) * gru_1_out_t4_33 + (-0.037688132375478745) * gru_1_out_t4_34 + (-0.48491010069847107) * gru_1_out_t4_35 + (0.17735202610492706) * gru_1_out_t4_36 + (0.069282136857509613) * gru_1_out_t4_37 + (0.016531364992260933) * gru_1_out_t4_38 + (-0.30957385897636414) * gru_1_out_t4_39 + (0.17990747094154358) * gru_1_out_t4_40 + (-0.027048539370298386) * gru_1_out_t4_41 + (0.077697359025478363) * gru_1_out_t4_42 + (-0.060357104986906052) * gru_1_out_t4_43 + (-0.11884570866823196) * gru_1_out_t4_44 + (0.53653675317764282) * gru_1_out_t4_45 + (0.029773999005556107) * gru_1_out_t4_46 + (-0.10056977719068527) * gru_1_out_t4_47 + (-0.036650072783231735) * gru_1_out_t4_48 + (0.22061353921890259) * gru_1_out_t4_49 + (0.27281120419502258) * gru_1_out_t4_50 + (0.29081490635871887) * gru_1_out_t4_51 + (-0.040592499077320099) * gru_1_out_t4_52 + (-0.086713530123233795) * gru_1_out_t4_53 + (0.052844170480966568) * gru_1_out_t4_54 + (-0.28755432367324829) * gru_1_out_t4_55 + (-0.051014091819524765) * gru_1_out_t4_56 + (0.089517600834369659) * gru_1_out_t4_57 + (0.46082749962806702) * gru_1_out_t4_58 + (0.12313845753669739) * gru_1_out_t4_59 + (-0.091130316257476807) * gru_1_out_t4_60 + (-0.14881472289562225) * gru_1_out_t4_61 + (-0.029487328603863716) * gru_1_out_t4_62 + (-0.03344295546412468) * gru_1_out_t4_63 + (0.01443953812122345) * gru_2_fwd_t3_h_0 + (-0.031904920935630798) * gru_2_fwd_t3_h_1 + (0.0035044346004724503) * gru_2_fwd_t3_h_2 + (0.27518916130065918) * gru_2_fwd_t3_h_3 + (0.50284022092819214) * gru_2_fwd_t3_h_4 + (0.21952119469642639) * gru_2_fwd_t3_h_5 + (0.078639492392539978) * gru_2_fwd_t3_h_6 + (-1.8903332948684692) * gru_2_fwd_t3_h_7 + (0.25841882824897766) * gru_2_fwd_t3_h_8 + (0.070015713572502136) * gru_2_fwd_t3_h_9 + (0.081009894609451294) * gru_2_fwd_t3_h_10 + (-1.1027950048446655) * gru_2_fwd_t3_h_11 + (-0.0012336155632510781) * gru_2_fwd_t3_h_12 + (0.47721976041793823) * gru_2_fwd_t3_h_13 + (-1.2458701133728027) * gru_2_fwd_t3_h_14 + (0.0023367193061858416) * gru_2_fwd_t3_h_15 + (1.1107848882675171) * gru_2_fwd_t3_h_16 + (-0.12205018848180771) * gru_2_fwd_t3_h_17 + (-0.015997428447008133) * gru_2_fwd_t3_h_18 + (0.025384437292814255) * gru_2_fwd_t3_h_19 + (-0.019647553563117981) * gru_2_fwd_t3_h_20 + (0.0212834682315588) * gru_2_fwd_t3_h_21 + (-0.024182049557566643) * gru_2_fwd_t3_h_22 + (0.040101036429405212) * gru_2_fwd_t3_h_23 + (0.052226293832063675) * gru_2_fwd_t3_h_24 + (0.028159238398075104) * gru_2_fwd_t3_h_25 + (3.2282588481903076) * gru_2_fwd_t3_h_26 + (-0.35584676265716553) * gru_2_fwd_t3_h_27 + (-1.6782248020172119) * gru_2_fwd_t3_h_28 + (-0.012740777805447578) * gru_2_fwd_t3_h_29 + (-0.30679547786712646) * gru_2_fwd_t3_h_30 + (-0.13347053527832031) * gru_2_fwd_t3_h_31);
    gate_n = tanh((-0.47201827168464661) + (-0.27722576260566711) * gru_1_out_t4_0 + (-0.3958774209022522) * gru_1_out_t4_1 + (0.60805892944335938) * gru_1_out_t4_2 + (-0.83109796047210693) * gru_1_out_t4_3 + (0.30026456713676453) * gru_1_out_t4_4 + (0.14769832789897919) * gru_1_out_t4_5 + (-0.87506771087646484) * gru_1_out_t4_6 + (-0.010086673311889172) * gru_1_out_t4_7 + (-0.4451526403427124) * gru_1_out_t4_8 + (0.41272756457328796) * gru_1_out_t4_9 + (-0.33770540356636047) * gru_1_out_t4_10 + (-0.55525177717208862) * gru_1_out_t4_11 + (0.19176684319972992) * gru_1_out_t4_12 + (-0.29127165675163269) * gru_1_out_t4_13 + (0.11479844897985458) * gru_1_out_t4_14 + (0.15615461766719818) * gru_1_out_t4_15 + (-0.41491696238517761) * gru_1_out_t4_16 + (-0.39673095941543579) * gru_1_out_t4_17 + (0.0040986379608511925) * gru_1_out_t4_18 + (0.096343174576759338) * gru_1_out_t4_19 + (0.25345709919929504) * gru_1_out_t4_20 + (0.011902938596904278) * gru_1_out_t4_21 + (0.3153950572013855) * gru_1_out_t4_22 + (-0.17603808641433716) * gru_1_out_t4_23 + (-2.0158889293670654) * gru_1_out_t4_24 + (-0.62003076076507568) * gru_1_out_t4_25 + (0.082758627831935883) * gru_1_out_t4_26 + (0.40812331438064575) * gru_1_out_t4_27 + (-0.094929218292236328) * gru_1_out_t4_28 + (-0.096843235194683075) * gru_1_out_t4_29 + (0.12479756772518158) * gru_1_out_t4_30 + (0.57444357872009277) * gru_1_out_t4_31 + (0.47875240445137024) * gru_1_out_t4_32 + (0.6576961874961853) * gru_1_out_t4_33 + (0.18932685256004333) * gru_1_out_t4_34 + (0.27019456028938293) * gru_1_out_t4_35 + (-0.19678276777267456) * gru_1_out_t4_36 + (-0.53844332695007324) * gru_1_out_t4_37 + (0.1639750599861145) * gru_1_out_t4_38 + (-0.21807602047920227) * gru_1_out_t4_39 + (1.243410587310791) * gru_1_out_t4_40 + (-0.1725132018327713) * gru_1_out_t4_41 + (-0.17781171202659607) * gru_1_out_t4_42 + (-0.13003820180892944) * gru_1_out_t4_43 + (-0.26735791563987732) * gru_1_out_t4_44 + (0.39312294125556946) * gru_1_out_t4_45 + (-0.24664770066738129) * gru_1_out_t4_46 + (-0.018071478232741356) * gru_1_out_t4_47 + (-0.86573368310928345) * gru_1_out_t4_48 + (-0.071698099374771118) * gru_1_out_t4_49 + (-0.038592908531427383) * gru_1_out_t4_50 + (-0.23152501881122589) * gru_1_out_t4_51 + (-0.092969298362731934) * gru_1_out_t4_52 + (0.16723303496837616) * gru_1_out_t4_53 + (-0.081203065812587738) * gru_1_out_t4_54 + (-0.34754028916358948) * gru_1_out_t4_55 + (0.19831310212612152) * gru_1_out_t4_56 + (0.61445474624633789) * gru_1_out_t4_57 + (0.17247271537780762) * gru_1_out_t4_58 + (0.26096951961517334) * gru_1_out_t4_59 + (-0.43987718224525452) * gru_1_out_t4_60 + (-0.48867300152778625) * gru_1_out_t4_61 + (-0.078533120453357697) * gru_1_out_t4_62 + (-0.29024809598922729) * gru_1_out_t4_63 + gate_r * ((-0.25809669494628906) + (0.031730286777019501) * gru_2_fwd_t3_h_0 + (0.12513387203216553) * gru_2_fwd_t3_h_1 + (0.0091931335628032684) * gru_2_fwd_t3_h_2 + (-0.26786869764328003) * gru_2_fwd_t3_h_3 + (0.25195762515068054) * gru_2_fwd_t3_h_4 + (-0.28554883599281311) * gru_2_fwd_t3_h_5 + (0.33363202214241028) * gru_2_fwd_t3_h_6 + (0.34597024321556091) * gru_2_fwd_t3_h_7 + (-0.24496866762638092) * gru_2_fwd_t3_h_8 + (0.70226502418518066) * gru_2_fwd_t3_h_9 + (-0.13700717687606812) * gru_2_fwd_t3_h_10 + (-1.2230370044708252) * gru_2_fwd_t3_h_11 + (0.54143416881561279) * gru_2_fwd_t3_h_12 + (-1.4821003675460815) * gru_2_fwd_t3_h_13 + (-2.3304827213287354) * gru_2_fwd_t3_h_14 + (-0.097158253192901611) * gru_2_fwd_t3_h_15 + (-0.37607663869857788) * gru_2_fwd_t3_h_16 + (0.2550005316734314) * gru_2_fwd_t3_h_17 + (0.62168306112289429) * gru_2_fwd_t3_h_18 + (-0.75362104177474976) * gru_2_fwd_t3_h_19 + (-0.083767116069793701) * gru_2_fwd_t3_h_20 + (-0.2679535448551178) * gru_2_fwd_t3_h_21 + (0.44754317402839661) * gru_2_fwd_t3_h_22 + (0.50191545486450195) * gru_2_fwd_t3_h_23 + (-0.12358377873897552) * gru_2_fwd_t3_h_24 + (1.5058104991912842) * gru_2_fwd_t3_h_25 + (2.6184027194976807) * gru_2_fwd_t3_h_26 + (-0.47530102729797363) * gru_2_fwd_t3_h_27 + (2.5256638526916504) * gru_2_fwd_t3_h_28 + (-0.064816579222679138) * gru_2_fwd_t3_h_29 + (-0.4339539110660553) * gru_2_fwd_t3_h_30 + (0.99577265977859497) * gru_2_fwd_t3_h_31));
    gru_2_fwd_t4_h_28 = (1.0 - gate_z) * gate_n + gate_z * gru_2_fwd_t3_h_28;
    // h=29
