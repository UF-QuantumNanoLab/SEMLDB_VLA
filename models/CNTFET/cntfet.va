    gate_z = sigmoid((-0.16296866536140442) + (0.1532631516456604) * gru_0_out_t1_0 + (-0.61915451288223267) * gru_0_out_t1_1 + (0.074869431555271149) * gru_0_out_t1_2 + (0.54278123378753662) * gru_0_out_t1_3 + (0.039842478930950165) * gru_0_out_t1_4 + (-0.1616823822259903) * gru_0_out_t1_5 + (0.1021784245967865) * gru_0_out_t1_6 + (0.36382991075515747) * gru_0_out_t1_7 + (0.077224716544151306) * gru_0_out_t1_8 + (-0.18239586055278778) * gru_0_out_t1_9 + (-0.25780755281448364) * gru_0_out_t1_10 + (0.68119543790817261) * gru_0_out_t1_11 + (-0.11030463129281998) * gru_0_out_t1_12 + (0.3421122133731842) * gru_0_out_t1_13 + (-0.46572303771972656) * gru_0_out_t1_14 + (0.41332787275314331) * gru_0_out_t1_15 + (0.68423593044281006) * gru_0_out_t1_16 + (0.81394696235656738) * gru_0_out_t1_17 + (0.098360829055309296) * gru_0_out_t1_18 + (0.51598650217056274) * gru_0_out_t1_19 + (1.3858033418655396) * gru_0_out_t1_20 + (0.33486023545265198) * gru_0_out_t1_21 + (0.50753843784332275) * gru_0_out_t1_22 + (-0.41474831104278564) * gru_0_out_t1_23 + (-0.64757919311523438) * gru_0_out_t1_24 + (-0.05926162376999855) * gru_0_out_t1_25 + (-0.33416551351547241) * gru_0_out_t1_26 + (0.19750687479972839) * gru_0_out_t1_27 + (-1.6423913240432739) * gru_0_out_t1_28 + (0.82888263463973999) * gru_0_out_t1_29 + (-0.011365357786417007) * gru_0_out_t1_30 + (0.27506965398788452) * gru_0_out_t1_31 + (-0.088003717362880707) * gru_0_out_t1_32 + (-0.57611697912216187) * gru_0_out_t1_33 + (-0.45926523208618164) * gru_0_out_t1_34 + (0.039115488529205322) * gru_0_out_t1_35 + (0.45749962329864502) * gru_0_out_t1_36 + (0.13006094098091125) * gru_0_out_t1_37 + (0.75557416677474976) * gru_0_out_t1_38 + (-0.57008731365203857) * gru_0_out_t1_39 + (0.7773665189743042) * gru_0_out_t1_40 + (-0.15872423350811005) * gru_0_out_t1_41 + (-0.36064416170120239) * gru_0_out_t1_42 + (0.11046507209539413) * gru_0_out_t1_43 + (-0.076829344034194946) * gru_0_out_t1_44 + (-0.4532371461391449) * gru_0_out_t1_45 + (-1.6157467365264893) * gru_0_out_t1_46 + (0.046743594110012054) * gru_0_out_t1_47 + (0.48785626888275146) * gru_0_out_t1_48 + (-0.23775121569633484) * gru_0_out_t1_49 + (0.614296555519104) * gru_0_out_t1_50 + (-0.20721395313739777) * gru_0_out_t1_51 + (0.59868758916854858) * gru_0_out_t1_52 + (0.11702436953783035) * gru_0_out_t1_53 + (-0.34612852334976196) * gru_0_out_t1_54 + (0.6845734715461731) * gru_0_out_t1_55 + (-0.15184815227985382) * gru_0_out_t1_56 + (-0.26018008589744568) * gru_0_out_t1_57 + (0.040635313838720322) * gru_0_out_t1_58 + (0.42831382155418396) * gru_0_out_t1_59 + (-0.39042747020721436) * gru_0_out_t1_60 + (0.12128127366304398) * gru_0_out_t1_61 + (-0.39848178625106812) * gru_0_out_t1_62 + (-1.281664252281189) * gru_0_out_t1_63 + (-0.046609837561845779) * gru_1_rev_t2_h_0 + (0.72684967517852783) * gru_1_rev_t2_h_1 + (0.24697364866733551) * gru_1_rev_t2_h_2 + (0.77732443809509277) * gru_1_rev_t2_h_3 + (-1.0642678737640381) * gru_1_rev_t2_h_4 + (-0.8105437159538269) * gru_1_rev_t2_h_5 + (0.19246083498001099) * gru_1_rev_t2_h_6 + (0.010306928306818008) * gru_1_rev_t2_h_7 + (0.26187005639076233) * gru_1_rev_t2_h_8 + (-1.072833776473999) * gru_1_rev_t2_h_9 + (0.82778781652450562) * gru_1_rev_t2_h_10 + (1.5634140968322754) * gru_1_rev_t2_h_11 + (1.1738986968994141) * gru_1_rev_t2_h_12 + (2.344390869140625) * gru_1_rev_t2_h_13 + (0.60699152946472168) * gru_1_rev_t2_h_14 + (0.28138783574104309) * gru_1_rev_t2_h_15 + (0.22183319926261902) * gru_1_rev_t2_h_16 + (-0.73195558786392212) * gru_1_rev_t2_h_17 + (0.16448508203029633) * gru_1_rev_t2_h_18 + (-0.88525259494781494) * gru_1_rev_t2_h_19 + (-2.0793793201446533) * gru_1_rev_t2_h_20 + (0.12166190892457962) * gru_1_rev_t2_h_21 + (1.0161861181259155) * gru_1_rev_t2_h_22 + (0.18954348564147949) * gru_1_rev_t2_h_23 + (2.2387914657592773) * gru_1_rev_t2_h_24 + (-1.3264570236206055) * gru_1_rev_t2_h_25 + (-1.0823590755462646) * gru_1_rev_t2_h_26 + (1.2973599433898926) * gru_1_rev_t2_h_27 + (1.6622099876403809) * gru_1_rev_t2_h_28 + (-0.42558130621910095) * gru_1_rev_t2_h_29 + (-0.75155282020568848) * gru_1_rev_t2_h_30 + (-0.22933517396450043) * gru_1_rev_t2_h_31);
    gate_n = tanh((0.24233773350715637) + (0.42769870162010193) * gru_0_out_t1_0 + (-0.093199752271175385) * gru_0_out_t1_1 + (-0.23331144452095032) * gru_0_out_t1_2 + (-0.95216339826583862) * gru_0_out_t1_3 + (-0.043934833258390427) * gru_0_out_t1_4 + (-0.33234021067619324) * gru_0_out_t1_5 + (-0.0071947770193219185) * gru_0_out_t1_6 + (1.2455120086669922) * gru_0_out_t1_7 + (0.21658831834793091) * gru_0_out_t1_8 + (-0.29356372356414795) * gru_0_out_t1_9 + (0.32628095149993896) * gru_0_out_t1_10 + (0.12682090699672699) * gru_0_out_t1_11 + (-0.13583275675773621) * gru_0_out_t1_12 + (0.16946811974048615) * gru_0_out_t1_13 + (0.44435712695121765) * gru_0_out_t1_14 + (-0.34305348992347717) * gru_0_out_t1_15 + (-0.6105351448059082) * gru_0_out_t1_16 + (-0.50137782096862793) * gru_0_out_t1_17 + (-0.26719820499420166) * gru_0_out_t1_18 + (0.017057968303561211) * gru_0_out_t1_19 + (0.10998648405075073) * gru_0_out_t1_20 + (-0.77550971508026123) * gru_0_out_t1_21 + (-0.058590933680534363) * gru_0_out_t1_22 + (-0.3645203709602356) * gru_0_out_t1_23 + (0.70039337873458862) * gru_0_out_t1_24 + (0.29853531718254089) * gru_0_out_t1_25 + (-0.11782580614089966) * gru_0_out_t1_26 + (-0.18577118217945099) * gru_0_out_t1_27 + (0.41717174649238586) * gru_0_out_t1_28 + (0.74937188625335693) * gru_0_out_t1_29 + (0.33273395895957947) * gru_0_out_t1_30 + (-1.0429728031158447) * gru_0_out_t1_31 + (2.5278427600860596) * gru_0_out_t1_32 + (0.15409055352210999) * gru_0_out_t1_33 + (-0.073881037533283234) * gru_0_out_t1_34 + (0.034905578941106796) * gru_0_out_t1_35 + (0.28732883930206299) * gru_0_out_t1_36 + (-0.040987115353345871) * gru_0_out_t1_37 + (-0.086160756647586823) * gru_0_out_t1_38 + (0.32070344686508179) * gru_0_out_t1_39 + (-0.60531079769134521) * gru_0_out_t1_40 + (-0.12663641571998596) * gru_0_out_t1_41 + (0.59953141212463379) * gru_0_out_t1_42 + (0.016223754733800888) * gru_0_out_t1_43 + (-0.054653074592351913) * gru_0_out_t1_44 + (-0.24534384906291962) * gru_0_out_t1_45 + (1.3737455606460571) * gru_0_out_t1_46 + (-0.76306742429733276) * gru_0_out_t1_47 + (0.067664369940757751) * gru_0_out_t1_48 + (0.11779728531837463) * gru_0_out_t1_49 + (-0.37777045369148254) * gru_0_out_t1_50 + (-0.1212870329618454) * gru_0_out_t1_51 + (-0.18890190124511719) * gru_0_out_t1_52 + (0.57070964574813843) * gru_0_out_t1_53 + (-0.11837755888700485) * gru_0_out_t1_54 + (0.54012036323547363) * gru_0_out_t1_55 + (0.059383399784564972) * gru_0_out_t1_56 + (-0.17909801006317139) * gru_0_out_t1_57 + (0.20343297719955444) * gru_0_out_t1_58 + (-1.0960054397583008) * gru_0_out_t1_59 + (-1.1222445964813232) * gru_0_out_t1_60 + (-1.0134117603302002) * gru_0_out_t1_61 + (-0.16041722893714905) * gru_0_out_t1_62 + (0.76451492309570312) * gru_0_out_t1_63 + gate_r * ((0.31511962413787842) + (-0.647408127784729) * gru_1_rev_t2_h_0 + (0.42277529835700989) * gru_1_rev_t2_h_1 + (-0.17567196488380432) * gru_1_rev_t2_h_2 + (-0.27702856063842773) * gru_1_rev_t2_h_3 + (0.54943692684173584) * gru_1_rev_t2_h_4 + (0.35554459691047668) * gru_1_rev_t2_h_5 + (-0.064035601913928986) * gru_1_rev_t2_h_6 + (-0.11003079265356064) * gru_1_rev_t2_h_7 + (-0.42061084508895874) * gru_1_rev_t2_h_8 + (0.67624366283416748) * gru_1_rev_t2_h_9 + (-0.46658337116241455) * gru_1_rev_t2_h_10 + (-1.1924782991409302) * gru_1_rev_t2_h_11 + (1.28794264793396) * gru_1_rev_t2_h_12 + (-0.81556075811386108) * gru_1_rev_t2_h_13 + (-0.31411981582641602) * gru_1_rev_t2_h_14 + (-0.0044255699031054974) * gru_1_rev_t2_h_15 + (-0.098814971745014191) * gru_1_rev_t2_h_16 + (0.55211502313613892) * gru_1_rev_t2_h_17 + (-0.51023662090301514) * gru_1_rev_t2_h_18 + (0.97332876920700073) * gru_1_rev_t2_h_19 + (1.4454872608184814) * gru_1_rev_t2_h_20 + (-0.042069762945175171) * gru_1_rev_t2_h_21 + (0.22468595206737518) * gru_1_rev_t2_h_22 + (-0.12342973053455353) * gru_1_rev_t2_h_23 + (0.56658488512039185) * gru_1_rev_t2_h_24 + (0.75614380836486816) * gru_1_rev_t2_h_25 + (0.062464281916618347) * gru_1_rev_t2_h_26 + (-0.24281127750873566) * gru_1_rev_t2_h_27 + (0.43438053131103516) * gru_1_rev_t2_h_28 + (0.48558735847473145) * gru_1_rev_t2_h_29 + (-0.9780610203742981) * gru_1_rev_t2_h_30 + (-0.55911368131637573) * gru_1_rev_t2_h_31));
    gru_1_rev_t1_h_21 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t2_h_21;
    // h=22
    gate_r = sigmoid((0.057750921696424484) + (-0.056154847145080566) * gru_0_out_t1_0 + (0.13897086679935455) * gru_0_out_t1_1 + (0.0013480753405019641) * gru_0_out_t1_2 + (0.84241616725921631) * gru_0_out_t1_3 + (1.5201041698455811) * gru_0_out_t1_4 + (0.18867923319339752) * gru_0_out_t1_5 + (-0.41475176811218262) * gru_0_out_t1_6 + (-0.88454413414001465) * gru_0_out_t1_7 + (0.94310766458511353) * gru_0_out_t1_8 + (1.6871911287307739) * gru_0_out_t1_9 + (-1.4982982873916626) * gru_0_out_t1_10 + (-0.037357538938522339) * gru_0_out_t1_11 + (0.11211337894201279) * gru_0_out_t1_12 + (-0.033419989049434662) * gru_0_out_t1_13 + (0.073133848607540131) * gru_0_out_t1_14 + (1.0399951934814453) * gru_0_out_t1_15 + (-0.074085615575313568) * gru_0_out_t1_16 + (0.31649738550186157) * gru_0_out_t1_17 + (0.12414709478616714) * gru_0_out_t1_18 + (2.0231220722198486) * gru_0_out_t1_19 + (1.1347267627716064) * gru_0_out_t1_20 + (1.1279611587524414) * gru_0_out_t1_21 + (-0.90489894151687622) * gru_0_out_t1_22 + (0.42612096667289734) * gru_0_out_t1_23 + (-2.1843688488006592) * gru_0_out_t1_24 + (-0.24569439888000488) * gru_0_out_t1_25 + (1.36988365650177) * gru_0_out_t1_26 + (1.8121097087860107) * gru_0_out_t1_27 + (2.2856457233428955) * gru_0_out_t1_28 + (1.5955206155776978) * gru_0_out_t1_29 + (-0.8710293173789978) * gru_0_out_t1_30 + (2.5988976955413818) * gru_0_out_t1_31 + (0.1235545426607132) * gru_0_out_t1_32 + (-0.26221072673797607) * gru_0_out_t1_33 + (-0.25203260779380798) * gru_0_out_t1_34 + (0.2506517767906189) * gru_0_out_t1_35 + (0.18021835386753082) * gru_0_out_t1_36 + (-0.20845691859722137) * gru_0_out_t1_37 + (0.18121108412742615) * gru_0_out_t1_38 + (1.5272489786148071) * gru_0_out_t1_39 + (-1.0454883575439453) * gru_0_out_t1_40 + (0.47630134224891663) * gru_0_out_t1_41 + (-1.2767690420150757) * gru_0_out_t1_42 + (0.34895554184913635) * gru_0_out_t1_43 + (-0.92250460386276245) * gru_0_out_t1_44 + (0.50776797533035278) * gru_0_out_t1_45 + (0.096638485789299011) * gru_0_out_t1_46 + (-0.052310612052679062) * gru_0_out_t1_47 + (-0.15840868651866913) * gru_0_out_t1_48 + (-0.43107223510742188) * gru_0_out_t1_49 + (-0.50884926319122314) * gru_0_out_t1_50 + (0.86771476268768311) * gru_0_out_t1_51 + (0.057381913065910339) * gru_0_out_t1_52 + (-0.25849461555480957) * gru_0_out_t1_53 + (-1.2260463237762451) * gru_0_out_t1_54 + (-3.3921341896057129) * gru_0_out_t1_55 + (-0.52439725399017334) * gru_0_out_t1_56 + (-0.11193255335092545) * gru_0_out_t1_57 + (1.3856498003005981) * gru_0_out_t1_58 + (-2.0449039936065674) * gru_0_out_t1_59 + (0.33423393964767456) * gru_0_out_t1_60 + (0.67172849178314209) * gru_0_out_t1_61 + (0.95241349935531616) * gru_0_out_t1_62 + (1.1145249605178833) * gru_0_out_t1_63 + (0.82594448328018188) * gru_1_rev_t2_h_0 + (0.34742063283920288) * gru_1_rev_t2_h_1 + (-0.9520682692527771) * gru_1_rev_t2_h_2 + (-0.54514050483703613) * gru_1_rev_t2_h_3 + (-0.12529785931110382) * gru_1_rev_t2_h_4 + (-0.91637319326400757) * gru_1_rev_t2_h_5 + (0.60567164421081543) * gru_1_rev_t2_h_6 + (-0.12158635258674622) * gru_1_rev_t2_h_7 + (-0.22215896844863892) * gru_1_rev_t2_h_8 + (1.1385641098022461) * gru_1_rev_t2_h_9 + (-0.42934224009513855) * gru_1_rev_t2_h_10 + (1.600522518157959) * gru_1_rev_t2_h_11 + (-0.42535543441772461) * gru_1_rev_t2_h_12 + (-1.3368288278579712) * gru_1_rev_t2_h_13 + (-0.59059882164001465) * gru_1_rev_t2_h_14 + (-0.027790982276201248) * gru_1_rev_t2_h_15 + (0.12042590975761414) * gru_1_rev_t2_h_16 + (0.30117371678352356) * gru_1_rev_t2_h_17 + (0.56971359252929688) * gru_1_rev_t2_h_18 + (0.23860064148902893) * gru_1_rev_t2_h_19 + (0.18275520205497742) * gru_1_rev_t2_h_20 + (-0.10323323309421539) * gru_1_rev_t2_h_21 + (-0.10748326033353806) * gru_1_rev_t2_h_22 + (0.69824504852294922) * gru_1_rev_t2_h_23 + (0.23407538235187531) * gru_1_rev_t2_h_24 + (0.42144590616226196) * gru_1_rev_t2_h_25 + (0.68003606796264648) * gru_1_rev_t2_h_26 + (-0.3259570300579071) * gru_1_rev_t2_h_27 + (-2.7651863098144531) * gru_1_rev_t2_h_28 + (-0.60263597965240479) * gru_1_rev_t2_h_29 + (-2.2399814128875732) * gru_1_rev_t2_h_30 + (0.48584973812103271) * gru_1_rev_t2_h_31);
    gate_z = sigmoid((1.3430523872375488) + (0.013889334164559841) * gru_0_out_t1_0 + (-0.5356372594833374) * gru_0_out_t1_1 + (-1.2895878553390503) * gru_0_out_t1_2 + (-1.0495072603225708) * gru_0_out_t1_3 + (-0.033183876425027847) * gru_0_out_t1_4 + (0.42511123418807983) * gru_0_out_t1_5 + (-1.2656540870666504) * gru_0_out_t1_6 + (-0.51720172166824341) * gru_0_out_t1_7 + (-0.34565845131874084) * gru_0_out_t1_8 + (-0.029040638357400894) * gru_0_out_t1_9 + (1.1226614713668823) * gru_0_out_t1_10 + (0.15075351297855377) * gru_0_out_t1_11 + (-0.22274598479270935) * gru_0_out_t1_12 + (0.60623210668563843) * gru_0_out_t1_13 + (0.63378649950027466) * gru_0_out_t1_14 + (0.068881422281265259) * gru_0_out_t1_15 + (0.034448318183422089) * gru_0_out_t1_16 + (-0.15120050311088562) * gru_0_out_t1_17 + (-0.51955109834671021) * gru_0_out_t1_18 + (0.68477970361709595) * gru_0_out_t1_19 + (1.3593225479125977) * gru_0_out_t1_20 + (0.20678189396858215) * gru_0_out_t1_21 + (-0.54600894451141357) * gru_0_out_t1_22 + (-0.44547775387763977) * gru_0_out_t1_23 + (-0.13123823702335358) * gru_0_out_t1_24 + (-0.61925911903381348) * gru_0_out_t1_25 + (-0.12913720309734344) * gru_0_out_t1_26 + (0.10447137057781219) * gru_0_out_t1_27 + (-0.045564617961645126) * gru_0_out_t1_28 + (-0.23027780652046204) * gru_0_out_t1_29 + (0.73600399494171143) * gru_0_out_t1_30 + (0.41531771421432495) * gru_0_out_t1_31 + (0.30127134919166565) * gru_0_out_t1_32 + (0.054785780608654022) * gru_0_out_t1_33 + (-0.39064204692840576) * gru_0_out_t1_34 + (1.0434416532516479) * gru_0_out_t1_35 + (-0.038481492549180984) * gru_0_out_t1_36 + (-0.14371579885482788) * gru_0_out_t1_37 + (-0.20561836659908295) * gru_0_out_t1_38 + (-0.19823424518108368) * gru_0_out_t1_39 + (-2.0175232887268066) * gru_0_out_t1_40 + (-0.017632249742746353) * gru_0_out_t1_41 + (0.35067400336265564) * gru_0_out_t1_42 + (0.055032625794410706) * gru_0_out_t1_43 + (0.54710888862609863) * gru_0_out_t1_44 + (0.37148800492286682) * gru_0_out_t1_45 + (-0.80432158708572388) * gru_0_out_t1_46 + (-0.33048826456069946) * gru_0_out_t1_47 + (-0.71915537118911743) * gru_0_out_t1_48 + (0.1518896222114563) * gru_0_out_t1_49 + (-0.82423019409179688) * gru_0_out_t1_50 + (0.30971330404281616) * gru_0_out_t1_51 + (0.12231264263391495) * gru_0_out_t1_52 + (0.24122056365013123) * gru_0_out_t1_53 + (-0.22144995629787445) * gru_0_out_t1_54 + (-0.020980218425393105) * gru_0_out_t1_55 + (0.45581918954849243) * gru_0_out_t1_56 + (0.35016795992851257) * gru_0_out_t1_57 + (0.090445183217525482) * gru_0_out_t1_58 + (1.9483424425125122) * gru_0_out_t1_59 + (0.94795984029769897) * gru_0_out_t1_60 + (1.3683040142059326) * gru_0_out_t1_61 + (-0.37391418218612671) * gru_0_out_t1_62 + (0.56186920404434204) * gru_0_out_t1_63 + (-0.6437690258026123) * gru_1_rev_t2_h_0 + (-0.50128811597824097) * gru_1_rev_t2_h_1 + (-0.60391402244567871) * gru_1_rev_t2_h_2 + (-0.28998616337776184) * gru_1_rev_t2_h_3 + (-0.14618688821792603) * gru_1_rev_t2_h_4 + (0.71750050783157349) * gru_1_rev_t2_h_5 + (0.11274527013301849) * gru_1_rev_t2_h_6 + (-0.12757864594459534) * gru_1_rev_t2_h_7 + (-0.49147328734397888) * gru_1_rev_t2_h_8 + (0.11160275340080261) * gru_1_rev_t2_h_9 + (-0.16009573638439178) * gru_1_rev_t2_h_10 + (0.45426768064498901) * gru_1_rev_t2_h_11 + (-0.66326415538787842) * gru_1_rev_t2_h_12 + (0.84251028299331665) * gru_1_rev_t2_h_13 + (-0.13162185251712799) * gru_1_rev_t2_h_14 + (-0.23347215354442596) * gru_1_rev_t2_h_15 + (0.30931606888771057) * gru_1_rev_t2_h_16 + (0.37610247731208801) * gru_1_rev_t2_h_17 + (0.097947828471660614) * gru_1_rev_t2_h_18 + (0.24867589771747589) * gru_1_rev_t2_h_19 + (1.9795181751251221) * gru_1_rev_t2_h_20 + (0.42106518149375916) * gru_1_rev_t2_h_21 + (-1.7667545080184937) * gru_1_rev_t2_h_22 + (0.6429639458656311) * gru_1_rev_t2_h_23 + (0.44902694225311279) * gru_1_rev_t2_h_24 + (0.92394447326660156) * gru_1_rev_t2_h_25 + (0.47967562079429626) * gru_1_rev_t2_h_26 + (0.69406092166900635) * gru_1_rev_t2_h_27 + (-0.44688227772712708) * gru_1_rev_t2_h_28 + (0.42540860176086426) * gru_1_rev_t2_h_29 + (1.7737963199615479) * gru_1_rev_t2_h_30 + (-0.1357877254486084) * gru_1_rev_t2_h_31);
    gate_n = tanh((0.041076365858316422) + (0.30681049823760986) * gru_0_out_t1_0 + (-0.14824993908405304) * gru_0_out_t1_1 + (0.36111143231391907) * gru_0_out_t1_2 + (-0.78955298662185669) * gru_0_out_t1_3 + (-2.1200120449066162) * gru_0_out_t1_4 + (0.23089653253555298) * gru_0_out_t1_5 + (-0.11731218546628952) * gru_0_out_t1_6 + (1.176706075668335) * gru_0_out_t1_7 + (-0.051518682390451431) * gru_0_out_t1_8 + (-1.3824454545974731) * gru_0_out_t1_9 + (-0.51499390602111816) * gru_0_out_t1_10 + (0.46933811902999878) * gru_0_out_t1_11 + (-0.81383669376373291) * gru_0_out_t1_12 + (-0.28008148074150085) * gru_0_out_t1_13 + (0.29727181792259216) * gru_0_out_t1_14 + (-0.1719098687171936) * gru_0_out_t1_15 + (0.33642524480819702) * gru_0_out_t1_16 + (0.20388582348823547) * gru_0_out_t1_17 + (-0.13840657472610474) * gru_0_out_t1_18 + (0.095529749989509583) * gru_0_out_t1_19 + (0.46676459908485413) * gru_0_out_t1_20 + (0.8827667236328125) * gru_0_out_t1_21 + (0.06217682734131813) * gru_0_out_t1_22 + (-0.36629402637481689) * gru_0_out_t1_23 + (0.22614669799804688) * gru_0_out_t1_24 + (0.44407930970191956) * gru_0_out_t1_25 + (1.4078409671783447) * gru_0_out_t1_26 + (-0.54250109195709229) * gru_0_out_t1_27 + (-1.6869549751281738) * gru_0_out_t1_28 + (0.23521864414215088) * gru_0_out_t1_29 + (0.072822071611881256) * gru_0_out_t1_30 + (-0.97959613800048828) * gru_0_out_t1_31 + (1.1799769401550293) * gru_0_out_t1_32 + (0.21055474877357483) * gru_0_out_t1_33 + (-0.040410742163658142) * gru_0_out_t1_34 + (0.32957890629768372) * gru_0_out_t1_35 + (-0.0005777247715741396) * gru_0_out_t1_36 + (0.048569560050964355) * gru_0_out_t1_37 + (0.22198639810085297) * gru_0_out_t1_38 + (-1.2681800127029419) * gru_0_out_t1_39 + (0.40665030479431152) * gru_0_out_t1_40 + (-0.98193603754043579) * gru_0_out_t1_41 + (-2.006523609161377) * gru_0_out_t1_42 + (0.19985388219356537) * gru_0_out_t1_43 + (0.9103049635887146) * gru_0_out_t1_44 + (0.015629034489393234) * gru_0_out_t1_45 + (1.615606427192688) * gru_0_out_t1_46 + (-0.79374998807907104) * gru_0_out_t1_47 + (-0.44329735636711121) * gru_0_out_t1_48 + (0.46246448159217834) * gru_0_out_t1_49 + (-0.076922833919525146) * gru_0_out_t1_50 + (0.32351997494697571) * gru_0_out_t1_51 + (0.032646194100379944) * gru_0_out_t1_52 + (0.35222214460372925) * gru_0_out_t1_53 + (0.69927585124969482) * gru_0_out_t1_54 + (-0.27106162905693054) * gru_0_out_t1_55 + (-1.4039241075515747) * gru_0_out_t1_56 + (0.19063282012939453) * gru_0_out_t1_57 + (-0.87392652034759521) * gru_0_out_t1_58 + (-0.099939815700054169) * gru_0_out_t1_59 + (-0.38854578137397766) * gru_0_out_t1_60 + (-0.0058568152599036694) * gru_0_out_t1_61 + (-0.4768214225769043) * gru_0_out_t1_62 + (1.9110003709793091) * gru_0_out_t1_63 + gate_r * ((-0.72957420349121094) + (-0.91804677248001099) * gru_1_rev_t2_h_0 + (-0.19567789137363434) * gru_1_rev_t2_h_1 + (0.89793300628662109) * gru_1_rev_t2_h_2 + (-0.35803073644638062) * gru_1_rev_t2_h_3 + (0.16755181550979614) * gru_1_rev_t2_h_4 + (0.65617823600769043) * gru_1_rev_t2_h_5 + (1.0033358335494995) * gru_1_rev_t2_h_6 + (0.11710573732852936) * gru_1_rev_t2_h_7 + (1.4375920295715332) * gru_1_rev_t2_h_8 + (0.2616783082485199) * gru_1_rev_t2_h_9 + (-0.30419912934303284) * gru_1_rev_t2_h_10 + (0.26006925106048584) * gru_1_rev_t2_h_11 + (0.68746364116668701) * gru_1_rev_t2_h_12 + (1.8257802724838257) * gru_1_rev_t2_h_13 + (0.16062659025192261) * gru_1_rev_t2_h_14 + (0.049167849123477936) * gru_1_rev_t2_h_15 + (1.218126654624939) * gru_1_rev_t2_h_16 + (-1.1750348806381226) * gru_1_rev_t2_h_17 + (0.10771293938159943) * gru_1_rev_t2_h_18 + (1.8838931322097778) * gru_1_rev_t2_h_19 + (0.67132651805877686) * gru_1_rev_t2_h_20 + (0.90741914510726929) * gru_1_rev_t2_h_21 + (1.4612314701080322) * gru_1_rev_t2_h_22 + (0.4346010684967041) * gru_1_rev_t2_h_23 + (0.51001781225204468) * gru_1_rev_t2_h_24 + (-0.094051219522953033) * gru_1_rev_t2_h_25 + (-0.24493266642093658) * gru_1_rev_t2_h_26 + (1.2932156324386597) * gru_1_rev_t2_h_27 + (-2.0425763130187988) * gru_1_rev_t2_h_28 + (0.39931395649909973) * gru_1_rev_t2_h_29 + (-0.24287617206573486) * gru_1_rev_t2_h_30 + (-0.45157921314239502) * gru_1_rev_t2_h_31));
    gru_1_rev_t1_h_22 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t2_h_22;
    // h=23
    gate_r = sigmoid((0.57912248373031616) + (-0.060610782355070114) * gru_0_out_t1_0 + (-2.4822282791137695) * gru_0_out_t1_1 + (1.2930433750152588) * gru_0_out_t1_2 + (1.0794585943222046) * gru_0_out_t1_3 + (-0.23055748641490936) * gru_0_out_t1_4 + (0.77691227197647095) * gru_0_out_t1_5 + (-0.96379095315933228) * gru_0_out_t1_6 + (-0.79916435480117798) * gru_0_out_t1_7 + (-0.56424790620803833) * gru_0_out_t1_8 + (1.9146583080291748) * gru_0_out_t1_9 + (-1.3327031135559082) * gru_0_out_t1_10 + (-0.56662720441818237) * gru_0_out_t1_11 + (0.064468078315258026) * gru_0_out_t1_12 + (1.5441648960113525) * gru_0_out_t1_13 + (0.045211747288703918) * gru_0_out_t1_14 + (1.7488610744476318) * gru_0_out_t1_15 + (-0.10053617507219315) * gru_0_out_t1_16 + (0.050078056752681732) * gru_0_out_t1_17 + (-0.20855963230133057) * gru_0_out_t1_18 + (-0.43739992380142212) * gru_0_out_t1_19 + (0.49685609340667725) * gru_0_out_t1_20 + (-0.75689160823822021) * gru_0_out_t1_21 + (1.5578945875167847) * gru_0_out_t1_22 + (0.43617698550224304) * gru_0_out_t1_23 + (-1.9216568470001221) * gru_0_out_t1_24 + (-0.14378717541694641) * gru_0_out_t1_25 + (0.0009998345049098134) * gru_0_out_t1_26 + (1.398045539855957) * gru_0_out_t1_27 + (0.28634163737297058) * gru_0_out_t1_28 + (-0.86058545112609863) * gru_0_out_t1_29 + (0.47926723957061768) * gru_0_out_t1_30 + (1.8596919775009155) * gru_0_out_t1_31 + (0.28452193737030029) * gru_0_out_t1_32 + (-0.011272946372628212) * gru_0_out_t1_33 + (0.0011794993188232183) * gru_0_out_t1_34 + (2.7754321098327637) * gru_0_out_t1_35 + (-0.21812771260738373) * gru_0_out_t1_36 + (-0.83816665410995483) * gru_0_out_t1_37 + (0.43304184079170227) * gru_0_out_t1_38 + (1.3147377967834473) * gru_0_out_t1_39 + (0.56476986408233643) * gru_0_out_t1_40 + (3.2157347202301025) * gru_0_out_t1_41 + (1.3864707946777344) * gru_0_out_t1_42 + (0.072475507855415344) * gru_0_out_t1_43 + (0.36776167154312134) * gru_0_out_t1_44 + (0.35382428765296936) * gru_0_out_t1_45 + (0.37392261624336243) * gru_0_out_t1_46 + (-0.40313887596130371) * gru_0_out_t1_47 + (0.26513242721557617) * gru_0_out_t1_48 + (-0.11508964747190475) * gru_0_out_t1_49 + (0.38999029994010925) * gru_0_out_t1_50 + (2.5998020172119141) * gru_0_out_t1_51 + (0.30950894951820374) * gru_0_out_t1_52 + (-0.14022338390350342) * gru_0_out_t1_53 + (1.7979782819747925) * gru_0_out_t1_54 + (0.41404670476913452) * gru_0_out_t1_55 + (1.2918124198913574) * gru_0_out_t1_56 + (0.82758808135986328) * gru_0_out_t1_57 + (-0.47905108332633972) * gru_0_out_t1_58 + (-1.1227724552154541) * gru_0_out_t1_59 + (0.11583571881055832) * gru_0_out_t1_60 + (0.88509285449981689) * gru_0_out_t1_61 + (0.6007656455039978) * gru_0_out_t1_62 + (-2.3330786228179932) * gru_0_out_t1_63 + (0.078306719660758972) * gru_1_rev_t2_h_0 + (-0.59744828939437866) * gru_1_rev_t2_h_1 + (0.56526100635528564) * gru_1_rev_t2_h_2 + (-0.16300034523010254) * gru_1_rev_t2_h_3 + (-0.40841051936149597) * gru_1_rev_t2_h_4 + (1.1211690902709961) * gru_1_rev_t2_h_5 + (-0.078890301287174225) * gru_1_rev_t2_h_6 + (0.025704450905323029) * gru_1_rev_t2_h_7 + (-0.36082515120506287) * gru_1_rev_t2_h_8 + (0.2198510468006134) * gru_1_rev_t2_h_9 + (0.065204158425331116) * gru_1_rev_t2_h_10 + (0.37083712220191956) * gru_1_rev_t2_h_11 + (0.41083091497421265) * gru_1_rev_t2_h_12 + (-0.76392561197280884) * gru_1_rev_t2_h_13 + (-0.024855675175786018) * gru_1_rev_t2_h_14 + (0.37839919328689575) * gru_1_rev_t2_h_15 + (0.16213476657867432) * gru_1_rev_t2_h_16 + (1.2540156841278076) * gru_1_rev_t2_h_17 + (-0.09157998114824295) * gru_1_rev_t2_h_18 + (-0.92853909730911255) * gru_1_rev_t2_h_19 + (-0.35588786005973816) * gru_1_rev_t2_h_20 + (-0.12859392166137695) * gru_1_rev_t2_h_21 + (-0.5163688063621521) * gru_1_rev_t2_h_22 + (-0.022556483745574951) * gru_1_rev_t2_h_23 + (-1.1354420185089111) * gru_1_rev_t2_h_24 + (-0.034524332731962204) * gru_1_rev_t2_h_25 + (0.3575209379196167) * gru_1_rev_t2_h_26 + (-1.2580492496490479) * gru_1_rev_t2_h_27 + (-0.77270752191543579) * gru_1_rev_t2_h_28 + (0.066260375082492828) * gru_1_rev_t2_h_29 + (-0.81471306085586548) * gru_1_rev_t2_h_30 + (-0.020977433770895004) * gru_1_rev_t2_h_31);
    gate_z = sigmoid((-0.25151574611663818) + (0.28577888011932373) * gru_0_out_t1_0 + (0.20749232172966003) * gru_0_out_t1_1 + (0.63410884141921997) * gru_0_out_t1_2 + (-0.17025986313819885) * gru_0_out_t1_3 + (0.086461164057254791) * gru_0_out_t1_4 + (1.0372211933135986) * gru_0_out_t1_5 + (-0.072778031229972839) * gru_0_out_t1_6 + (0.89526069164276123) * gru_0_out_t1_7 + (0.74514442682266235) * gru_0_out_t1_8 + (0.31512308120727539) * gru_0_out_t1_9 + (-0.51057332754135132) * gru_0_out_t1_10 + (-0.068456389009952545) * gru_0_out_t1_11 + (-0.30696448683738708) * gru_0_out_t1_12 + (-0.073415353894233704) * gru_0_out_t1_13 + (0.60118353366851807) * gru_0_out_t1_14 + (-1.0354100465774536) * gru_0_out_t1_15 + (1.5873328447341919) * gru_0_out_t1_16 + (0.69110840559005737) * gru_0_out_t1_17 + (0.014662942849099636) * gru_0_out_t1_18 + (-0.13595007359981537) * gru_0_out_t1_19 + (-0.44445362687110901) * gru_0_out_t1_20 + (3.0455377101898193) * gru_0_out_t1_21 + (-0.12854313850402832) * gru_0_out_t1_22 + (-0.94811779260635376) * gru_0_out_t1_23 + (0.62374234199523926) * gru_0_out_t1_24 + (0.24717363715171814) * gru_0_out_t1_25 + (-0.56860077381134033) * gru_0_out_t1_26 + (0.19470959901809692) * gru_0_out_t1_27 + (0.28060171008110046) * gru_0_out_t1_28 + (-0.38385903835296631) * gru_0_out_t1_29 + (-0.22718565165996552) * gru_0_out_t1_30 + (0.9415745735168457) * gru_0_out_t1_31 + (-1.553417444229126) * gru_0_out_t1_32 + (0.10065502673387527) * gru_0_out_t1_33 + (0.4113616943359375) * gru_0_out_t1_34 + (-0.28567588329315186) * gru_0_out_t1_35 + (0.34574729204177856) * gru_0_out_t1_36 + (-0.19665670394897461) * gru_0_out_t1_37 + (-0.64330911636352539) * gru_0_out_t1_38 + (0.26661631464958191) * gru_0_out_t1_39 + (-3.2169120311737061) * gru_0_out_t1_40 + (-0.47723942995071411) * gru_0_out_t1_41 + (0.27988433837890625) * gru_0_out_t1_42 + (-0.05139295756816864) * gru_0_out_t1_43 + (0.023977510631084442) * gru_0_out_t1_44 + (-0.34234252572059631) * gru_0_out_t1_45 + (-1.0300320386886597) * gru_0_out_t1_46 + (0.75000321865081787) * gru_0_out_t1_47 + (-0.30720952153205872) * gru_0_out_t1_48 + (-0.061271972954273224) * gru_0_out_t1_49 + (0.065337829291820526) * gru_0_out_t1_50 + (0.39977595210075378) * gru_0_out_t1_51 + (-0.37217453122138977) * gru_0_out_t1_52 + (-0.27658239006996155) * gru_0_out_t1_53 + (0.30236941576004028) * gru_0_out_t1_54 + (-0.11339209973812103) * gru_0_out_t1_55 + (0.43587720394134521) * gru_0_out_t1_56 + (0.2908855676651001) * gru_0_out_t1_57 + (0.55984830856323242) * gru_0_out_t1_58 + (0.46695578098297119) * gru_0_out_t1_59 + (0.93862301111221313) * gru_0_out_t1_60 + (0.38193109631538391) * gru_0_out_t1_61 + (0.19808365404605865) * gru_0_out_t1_62 + (-1.0700350999832153) * gru_0_out_t1_63 + (-0.79401862621307373) * gru_1_rev_t2_h_0 + (0.11077437549829483) * gru_1_rev_t2_h_1 + (0.66126930713653564) * gru_1_rev_t2_h_2 + (-0.076787449419498444) * gru_1_rev_t2_h_3 + (-0.29193291068077087) * gru_1_rev_t2_h_4 + (-0.42978444695472717) * gru_1_rev_t2_h_5 + (0.052302252501249313) * gru_1_rev_t2_h_6 + (-0.61247760057449341) * gru_1_rev_t2_h_7 + (0.35741817951202393) * gru_1_rev_t2_h_8 + (0.17685091495513916) * gru_1_rev_t2_h_9 + (-0.43660950660705566) * gru_1_rev_t2_h_10 + (-0.61202120780944824) * gru_1_rev_t2_h_11 + (0.22485090792179108) * gru_1_rev_t2_h_12 + (-0.20352114737033844) * gru_1_rev_t2_h_13 + (0.09755445271730423) * gru_1_rev_t2_h_14 + (-0.0057502305135130882) * gru_1_rev_t2_h_15 + (0.0308732520788908) * gru_1_rev_t2_h_16 + (-0.68934065103530884) * gru_1_rev_t2_h_17 + (-0.77646750211715698) * gru_1_rev_t2_h_18 + (0.53572440147399902) * gru_1_rev_t2_h_19 + (-0.52634060382843018) * gru_1_rev_t2_h_20 + (-0.45791754126548767) * gru_1_rev_t2_h_21 + (-0.37393292784690857) * gru_1_rev_t2_h_22 + (-0.87604033946990967) * gru_1_rev_t2_h_23 + (0.30867010354995728) * gru_1_rev_t2_h_24 + (-0.081227406859397888) * gru_1_rev_t2_h_25 + (-0.96684074401855469) * gru_1_rev_t2_h_26 + (0.3077264130115509) * gru_1_rev_t2_h_27 + (-1.4082832336425781) * gru_1_rev_t2_h_28 + (0.18718896806240082) * gru_1_rev_t2_h_29 + (-0.021717367693781853) * gru_1_rev_t2_h_30 + (-0.55933725833892822) * gru_1_rev_t2_h_31);
    gate_n = tanh((-0.12496943771839142) + (0.1448565274477005) * gru_0_out_t1_0 + (0.22692506015300751) * gru_0_out_t1_1 + (-0.097553104162216187) * gru_0_out_t1_2 + (-0.1036965623497963) * gru_0_out_t1_3 + (0.031517598778009415) * gru_0_out_t1_4 + (-0.34878420829772949) * gru_0_out_t1_5 + (-0.37062937021255493) * gru_0_out_t1_6 + (0.20441484451293945) * gru_0_out_t1_7 + (-0.025669548660516739) * gru_0_out_t1_8 + (0.18017725646495819) * gru_0_out_t1_9 + (-0.073015592992305756) * gru_0_out_t1_10 + (0.28086802363395691) * gru_0_out_t1_11 + (-0.09160478413105011) * gru_0_out_t1_12 + (-0.31614860892295837) * gru_0_out_t1_13 + (-0.14097005128860474) * gru_0_out_t1_14 + (-0.082336030900478363) * gru_0_out_t1_15 + (0.26241940259933472) * gru_0_out_t1_16 + (-0.11670865118503571) * gru_0_out_t1_17 + (-0.23459981381893158) * gru_0_out_t1_18 + (0.13176323473453522) * gru_0_out_t1_19 + (0.23414605855941772) * gru_0_out_t1_20 + (0.095174945890903473) * gru_0_out_t1_21 + (-0.37852540612220764) * gru_0_out_t1_22 + (0.28007775545120239) * gru_0_out_t1_23 + (0.36722218990325928) * gru_0_out_t1_24 + (0.23995983600616455) * gru_0_out_t1_25 + (-0.38818418979644775) * gru_0_out_t1_26 + (-0.43615394830703735) * gru_0_out_t1_27 + (0.24126282334327698) * gru_0_out_t1_28 + (0.34801894426345825) * gru_0_out_t1_29 + (0.37655410170555115) * gru_0_out_t1_30 + (-0.84516745805740356) * gru_0_out_t1_31 + (0.58280473947525024) * gru_0_out_t1_32 + (-0.61177223920822144) * gru_0_out_t1_33 + (-0.41152641177177429) * gru_0_out_t1_34 + (-0.53671002388000488) * gru_0_out_t1_35 + (0.34637176990509033) * gru_0_out_t1_36 + (-0.065531842410564423) * gru_0_out_t1_37 + (0.1317916065454483) * gru_0_out_t1_38 + (-0.20242181420326233) * gru_0_out_t1_39 + (0.094229914247989655) * gru_0_out_t1_40 + (-0.89318108558654785) * gru_0_out_t1_41 + (0.62076389789581299) * gru_0_out_t1_42 + (-0.40476745367050171) * gru_0_out_t1_43 + (0.1014166846871376) * gru_0_out_t1_44 + (-0.30219507217407227) * gru_0_out_t1_45 + (-0.23410157859325409) * gru_0_out_t1_46 + (-0.40368464589118958) * gru_0_out_t1_47 + (-0.082179918885231018) * gru_0_out_t1_48 + (0.19890296459197998) * gru_0_out_t1_49 + (0.50316977500915527) * gru_0_out_t1_50 + (0.018120216205716133) * gru_0_out_t1_51 + (0.30786210298538208) * gru_0_out_t1_52 + (-0.22612935304641724) * gru_0_out_t1_53 + (-0.2711627185344696) * gru_0_out_t1_54 + (0.48368421196937561) * gru_0_out_t1_55 + (-0.58510655164718628) * gru_0_out_t1_56 + (0.06196778267621994) * gru_0_out_t1_57 + (-0.29741990566253662) * gru_0_out_t1_58 + (-0.26598015427589417) * gru_0_out_t1_59 + (-0.62684965133666992) * gru_0_out_t1_60 + (-0.46356514096260071) * gru_0_out_t1_61 + (-0.77833431959152222) * gru_0_out_t1_62 + (0.42090794444084167) * gru_0_out_t1_63 + gate_r * ((-0.12716244161128998) + (-0.50767791271209717) * gru_1_rev_t2_h_0 + (-0.045751091092824936) * gru_1_rev_t2_h_1 + (1.0142762660980225) * gru_1_rev_t2_h_2 + (-0.53044146299362183) * gru_1_rev_t2_h_3 + (-0.099377691745758057) * gru_1_rev_t2_h_4 + (0.14739063382148743) * gru_1_rev_t2_h_5 + (0.1935545802116394) * gru_1_rev_t2_h_6 + (-0.033105514943599701) * gru_1_rev_t2_h_7 + (-0.11854406446218491) * gru_1_rev_t2_h_8 + (-0.52346479892730713) * gru_1_rev_t2_h_9 + (-0.0042983214370906353) * gru_1_rev_t2_h_10 + (0.093348026275634766) * gru_1_rev_t2_h_11 + (0.47405683994293213) * gru_1_rev_t2_h_12 + (1.4858615398406982) * gru_1_rev_t2_h_13 + (0.25885635614395142) * gru_1_rev_t2_h_14 + (-0.81367069482803345) * gru_1_rev_t2_h_15 + (-0.55401885509490967) * gru_1_rev_t2_h_16 + (-0.18721428513526917) * gru_1_rev_t2_h_17 + (0.057779837399721146) * gru_1_rev_t2_h_18 + (0.15176242589950562) * gru_1_rev_t2_h_19 + (1.2920783758163452) * gru_1_rev_t2_h_20 + (-0.36697971820831299) * gru_1_rev_t2_h_21 + (0.19116158783435822) * gru_1_rev_t2_h_22 + (-0.52217614650726318) * gru_1_rev_t2_h_23 + (1.4250432252883911) * gru_1_rev_t2_h_24 + (-0.92895668745040894) * gru_1_rev_t2_h_25 + (0.27153488993644714) * gru_1_rev_t2_h_26 + (1.8092880249023438) * gru_1_rev_t2_h_27 + (-0.43880137801170349) * gru_1_rev_t2_h_28 + (1.0088309049606323) * gru_1_rev_t2_h_29 + (-1.3579831123352051) * gru_1_rev_t2_h_30 + (-0.76464974880218506) * gru_1_rev_t2_h_31));
    gru_1_rev_t1_h_23 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t2_h_23;
    // h=24
    gate_r = sigmoid((0.67716670036315918) + (0.12755954265594482) * gru_0_out_t1_0 + (-0.77821284532546997) * gru_0_out_t1_1 + (0.35458076000213623) * gru_0_out_t1_2 + (0.89700609445571899) * gru_0_out_t1_3 + (-0.40275734663009644) * gru_0_out_t1_4 + (0.83693277835845947) * gru_0_out_t1_5 + (0.67218101024627686) * gru_0_out_t1_6 + (-0.89414405822753906) * gru_0_out_t1_7 + (-0.94244480133056641) * gru_0_out_t1_8 + (0.21779540181159973) * gru_0_out_t1_9 + (-0.48200792074203491) * gru_0_out_t1_10 + (-0.482177734375) * gru_0_out_t1_11 + (0.42294710874557495) * gru_0_out_t1_12 + (-0.5128900408744812) * gru_0_out_t1_13 + (0.098782598972320557) * gru_0_out_t1_14 + (0.412679523229599) * gru_0_out_t1_15 + (-1.1664198637008667) * gru_0_out_t1_16 + (-0.066619187593460083) * gru_0_out_t1_17 + (1.0720069408416748) * gru_0_out_t1_18 + (0.62158501148223877) * gru_0_out_t1_19 + (0.52933382987976074) * gru_0_out_t1_20 + (-2.0011000633239746) * gru_0_out_t1_21 + (0.71812653541564941) * gru_0_out_t1_22 + (0.27037239074707031) * gru_0_out_t1_23 + (-1.4750754833221436) * gru_0_out_t1_24 + (0.04219253733754158) * gru_0_out_t1_25 + (0.3134789764881134) * gru_0_out_t1_26 + (1.1332876682281494) * gru_0_out_t1_27 + (1.0728960037231445) * gru_0_out_t1_28 + (0.32814356684684753) * gru_0_out_t1_29 + (0.13439776003360748) * gru_0_out_t1_30 + (0.47268301248550415) * gru_0_out_t1_31 + (2.1907854080200195) * gru_0_out_t1_32 + (-0.68154841661453247) * gru_0_out_t1_33 + (0.088571369647979736) * gru_0_out_t1_34 + (0.049184300005435944) * gru_0_out_t1_35 + (-0.28088828921318054) * gru_0_out_t1_36 + (-0.1946321576833725) * gru_0_out_t1_37 + (0.38633981347084045) * gru_0_out_t1_38 + (0.72349256277084351) * gru_0_out_t1_39 + (2.5432002544403076) * gru_0_out_t1_40 + (0.50516700744628906) * gru_0_out_t1_41 + (0.034253686666488647) * gru_0_out_t1_42 + (0.39487126469612122) * gru_0_out_t1_43 + (0.23286689817905426) * gru_0_out_t1_44 + (0.45215418934822083) * gru_0_out_t1_45 + (-0.44765502214431763) * gru_0_out_t1_46 + (-1.0132352113723755) * gru_0_out_t1_47 + (-0.9002271294593811) * gru_0_out_t1_48 + (1.0863083600997925) * gru_0_out_t1_49 + (0.72558313608169556) * gru_0_out_t1_50 + (-0.9536902904510498) * gru_0_out_t1_51 + (0.12993490695953369) * gru_0_out_t1_52 + (0.44029876589775085) * gru_0_out_t1_53 + (0.14091245830059052) * gru_0_out_t1_54 + (1.0717428922653198) * gru_0_out_t1_55 + (-0.028489610180258751) * gru_0_out_t1_56 + (0.93480628728866577) * gru_0_out_t1_57 + (-0.20069779455661774) * gru_0_out_t1_58 + (-0.23850759863853455) * gru_0_out_t1_59 + (0.17925733327865601) * gru_0_out_t1_60 + (0.90062069892883301) * gru_0_out_t1_61 + (-1.8585528135299683) * gru_0_out_t1_62 + (1.2682526111602783) * gru_0_out_t1_63 + (-0.40378004312515259) * gru_1_rev_t2_h_0 + (0.71817255020141602) * gru_1_rev_t2_h_1 + (-1.4584076404571533) * gru_1_rev_t2_h_2 + (0.088912248611450195) * gru_1_rev_t2_h_3 + (0.8418547511100769) * gru_1_rev_t2_h_4 + (-0.76983118057250977) * gru_1_rev_t2_h_5 + (-0.20257408916950226) * gru_1_rev_t2_h_6 + (0.099691852927207947) * gru_1_rev_t2_h_7 + (-0.48936834931373596) * gru_1_rev_t2_h_8 + (-1.0069247484207153) * gru_1_rev_t2_h_9 + (1.260507345199585) * gru_1_rev_t2_h_10 + (-0.67223137617111206) * gru_1_rev_t2_h_11 + (0.93055087327957153) * gru_1_rev_t2_h_12 + (-0.25944957137107849) * gru_1_rev_t2_h_13 + (-1.1124926805496216) * gru_1_rev_t2_h_14 + (0.59317284822463989) * gru_1_rev_t2_h_15 + (0.37545964121818542) * gru_1_rev_t2_h_16 + (-0.29388353228569031) * gru_1_rev_t2_h_17 + (-0.31289893388748169) * gru_1_rev_t2_h_18 + (0.90587508678436279) * gru_1_rev_t2_h_19 + (-0.49410936236381531) * gru_1_rev_t2_h_20 + (1.3558758497238159) * gru_1_rev_t2_h_21 + (0.28516417741775513) * gru_1_rev_t2_h_22 + (0.68772017955780029) * gru_1_rev_t2_h_23 + (-0.65662240982055664) * gru_1_rev_t2_h_24 + (0.56361442804336548) * gru_1_rev_t2_h_25 + (0.22395345568656921) * gru_1_rev_t2_h_26 + (0.47641894221305847) * gru_1_rev_t2_h_27 + (-0.8307909369468689) * gru_1_rev_t2_h_28 + (-0.41557213664054871) * gru_1_rev_t2_h_29 + (-2.0979766845703125) * gru_1_rev_t2_h_30 + (0.56947797536849976) * gru_1_rev_t2_h_31);
    gate_z = sigmoid((-0.064756311476230621) + (0.30718889832496643) * gru_0_out_t1_0 + (-0.095930680632591248) * gru_0_out_t1_1 + (0.78129267692565918) * gru_0_out_t1_2 + (-0.21648788452148438) * gru_0_out_t1_3 + (-0.50453841686248779) * gru_0_out_t1_4 + (1.4477152824401855) * gru_0_out_t1_5 + (0.613761305809021) * gru_0_out_t1_6 + (1.0879737138748169) * gru_0_out_t1_7 + (0.012940666638314724) * gru_0_out_t1_8 + (-0.27601796388626099) * gru_0_out_t1_9 + (0.30376529693603516) * gru_0_out_t1_10 + (0.98931366205215454) * gru_0_out_t1_11 + (0.52886468172073364) * gru_0_out_t1_12 + (0.77672839164733887) * gru_0_out_t1_13 + (-0.48119845986366272) * gru_0_out_t1_14 + (0.50836753845214844) * gru_0_out_t1_15 + (0.050744246691465378) * gru_0_out_t1_16 + (0.20092304050922394) * gru_0_out_t1_17 + (-0.59187215566635132) * gru_0_out_t1_18 + (-0.46986159682273865) * gru_0_out_t1_19 + (-0.5086822509765625) * gru_0_out_t1_20 + (-0.14866407215595245) * gru_0_out_t1_21 + (0.97529011964797974) * gru_0_out_t1_22 + (-0.19943630695343018) * gru_0_out_t1_23 + (-0.14562016725540161) * gru_0_out_t1_24 + (-0.62057745456695557) * gru_0_out_t1_25 + (0.69045603275299072) * gru_0_out_t1_26 + (0.29122290015220642) * gru_0_out_t1_27 + (1.5295441150665283) * gru_0_out_t1_28 + (0.16073994338512421) * gru_0_out_t1_29 + (-0.34573107957839966) * gru_0_out_t1_30 + (0.31544411182403564) * gru_0_out_t1_31 + (-2.0298264026641846) * gru_0_out_t1_32 + (0.829600989818573) * gru_0_out_t1_33 + (-0.10943248122930527) * gru_0_out_t1_34 + (-0.066457509994506836) * gru_0_out_t1_35 + (0.066131830215454102) * gru_0_out_t1_36 + (0.13418391346931458) * gru_0_out_t1_37 + (-0.54315352439880371) * gru_0_out_t1_38 + (0.75348025560379028) * gru_0_out_t1_39 + (-1.5707815885543823) * gru_0_out_t1_40 + (0.10500741750001907) * gru_0_out_t1_41 + (-0.24067328870296478) * gru_0_out_t1_42 + (0.4787280261516571) * gru_0_out_t1_43 + (-0.28987538814544678) * gru_0_out_t1_44 + (-0.41288614273071289) * gru_0_out_t1_45 + (-1.0574361085891724) * gru_0_out_t1_46 + (0.73015326261520386) * gru_0_out_t1_47 + (0.23295488953590393) * gru_0_out_t1_48 + (-0.084627613425254822) * gru_0_out_t1_49 + (-0.43914982676506042) * gru_0_out_t1_50 + (0.80177938938140869) * gru_0_out_t1_51 + (-0.29905039072036743) * gru_0_out_t1_52 + (-0.020908843725919724) * gru_0_out_t1_53 + (0.30011624097824097) * gru_0_out_t1_54 + (1.5771631002426147) * gru_0_out_t1_55 + (-0.18286755681037903) * gru_0_out_t1_56 + (0.13204255700111389) * gru_0_out_t1_57 + (0.63538879156112671) * gru_0_out_t1_58 + (0.29766595363616943) * gru_0_out_t1_59 + (1.3448009490966797) * gru_0_out_t1_60 + (1.3223707675933838) * gru_0_out_t1_61 + (-0.83467471599578857) * gru_0_out_t1_62 + (-0.71177250146865845) * gru_0_out_t1_63 + (-0.34289127588272095) * gru_1_rev_t2_h_0 + (-0.91829508543014526) * gru_1_rev_t2_h_1 + (0.063749879598617554) * gru_1_rev_t2_h_2 + (0.24851012229919434) * gru_1_rev_t2_h_3 + (-0.99244320392608643) * gru_1_rev_t2_h_4 + (-0.76070690155029297) * gru_1_rev_t2_h_5 + (0.3613036572933197) * gru_1_rev_t2_h_6 + (-0.42517724633216858) * gru_1_rev_t2_h_7 + (-0.056558001786470413) * gru_1_rev_t2_h_8 + (-0.46931847929954529) * gru_1_rev_t2_h_9 + (0.12886594235897064) * gru_1_rev_t2_h_10 + (0.21237972378730774) * gru_1_rev_t2_h_11 + (-0.93901097774505615) * gru_1_rev_t2_h_12 + (-0.17291033267974854) * gru_1_rev_t2_h_13 + (-0.14613461494445801) * gru_1_rev_t2_h_14 + (-0.22833357751369476) * gru_1_rev_t2_h_15 + (0.80675393342971802) * gru_1_rev_t2_h_16 + (0.58238792419433594) * gru_1_rev_t2_h_17 + (0.15494728088378906) * gru_1_rev_t2_h_18 + (0.36121031641960144) * gru_1_rev_t2_h_19 + (0.51009625196456909) * gru_1_rev_t2_h_20 + (-0.99438661336898804) * gru_1_rev_t2_h_21 + (-0.49125656485557556) * gru_1_rev_t2_h_22 + (0.57548278570175171) * gru_1_rev_t2_h_23 + (-0.46654817461967468) * gru_1_rev_t2_h_24 + (-0.29409918189048767) * gru_1_rev_t2_h_25 + (-0.099743455648422241) * gru_1_rev_t2_h_26 + (1.3910070657730103) * gru_1_rev_t2_h_27 + (-1.5768228769302368) * gru_1_rev_t2_h_28 + (-0.38987442851066589) * gru_1_rev_t2_h_29 + (1.1536402702331543) * gru_1_rev_t2_h_30 + (-0.060362204909324646) * gru_1_rev_t2_h_31);
    gate_n = tanh((0.047642260789871216) + (-0.8390384316444397) * gru_0_out_t1_0 + (0.38486915826797485) * gru_0_out_t1_1 + (-0.68896925449371338) * gru_0_out_t1_2 + (0.21516774594783783) * gru_0_out_t1_3 + (0.31702506542205811) * gru_0_out_t1_4 + (-0.53984808921813965) * gru_0_out_t1_5 + (0.3868410587310791) * gru_0_out_t1_6 + (-0.079134516417980194) * gru_0_out_t1_7 + (-0.1364014595746994) * gru_0_out_t1_8 + (-0.41994443535804749) * gru_0_out_t1_9 + (0.87232917547225952) * gru_0_out_t1_10 + (-0.50202840566635132) * gru_0_out_t1_11 + (-0.54522877931594849) * gru_0_out_t1_12 + (-0.65830183029174805) * gru_0_out_t1_13 + (0.2742314338684082) * gru_0_out_t1_14 + (-0.71831399202346802) * gru_0_out_t1_15 + (-0.46435487270355225) * gru_0_out_t1_16 + (-0.27805733680725098) * gru_0_out_t1_17 + (0.46553215384483337) * gru_0_out_t1_18 + (-0.71487146615982056) * gru_0_out_t1_19 + (0.015688169747591019) * gru_0_out_t1_20 + (-0.21254284679889679) * gru_0_out_t1_21 + (-0.1592562347650528) * gru_0_out_t1_22 + (0.51560968160629272) * gru_0_out_t1_23 + (1.200957179069519) * gru_0_out_t1_24 + (-0.23085834085941315) * gru_0_out_t1_25 + (-0.12868762016296387) * gru_0_out_t1_26 + (-0.12676739692687988) * gru_0_out_t1_27 + (-0.56767183542251587) * gru_0_out_t1_28 + (0.13375023007392883) * gru_0_out_t1_29 + (-0.12488507479429245) * gru_0_out_t1_30 + (0.33940032124519348) * gru_0_out_t1_31 + (0.95893466472625732) * gru_0_out_t1_32 + (-0.40778130292892456) * gru_0_out_t1_33 + (0.16722163558006287) * gru_0_out_t1_34 + (-0.34943893551826477) * gru_0_out_t1_35 + (-0.3026462197303772) * gru_0_out_t1_36 + (-0.13663609325885773) * gru_0_out_t1_37 + (0.7228473424911499) * gru_0_out_t1_38 + (1.0917237997055054) * gru_0_out_t1_39 + (-0.47965303063392639) * gru_0_out_t1_40 + (0.50533038377761841) * gru_0_out_t1_41 + (-0.38380688428878784) * gru_0_out_t1_42 + (-0.21269214153289795) * gru_0_out_t1_43 + (-0.37573185563087463) * gru_0_out_t1_44 + (0.29142099618911743) * gru_0_out_t1_45 + (-0.36884379386901855) * gru_0_out_t1_46 + (-0.10382306575775146) * gru_0_out_t1_47 + (0.061545334756374359) * gru_0_out_t1_48 + (-0.039712242782115936) * gru_0_out_t1_49 + (0.36601433157920837) * gru_0_out_t1_50 + (0.10713274776935577) * gru_0_out_t1_51 + (0.72829419374465942) * gru_0_out_t1_52 + (0.39498558640480042) * gru_0_out_t1_53 + (0.20543679594993591) * gru_0_out_t1_54 + (-0.10963305830955505) * gru_0_out_t1_55 + (-1.2933933734893799) * gru_0_out_t1_56 + (-0.037884030491113663) * gru_0_out_t1_57 + (-0.011826789006590843) * gru_0_out_t1_58 + (-1.528321385383606) * gru_0_out_t1_59 + (-0.26187777519226074) * gru_0_out_t1_60 + (0.44501194357872009) * gru_0_out_t1_61 + (0.58552044630050659) * gru_0_out_t1_62 + (-0.26960897445678711) * gru_0_out_t1_63 + gate_r * ((-0.18040646612644196) + (-0.26277837157249451) * gru_1_rev_t2_h_0 + (0.48694694042205811) * gru_1_rev_t2_h_1 + (-0.99450784921646118) * gru_1_rev_t2_h_2 + (0.52640587091445923) * gru_1_rev_t2_h_3 + (0.95334523916244507) * gru_1_rev_t2_h_4 + (0.4776187539100647) * gru_1_rev_t2_h_5 + (-1.2680472135543823) * gru_1_rev_t2_h_6 + (0.049339190125465393) * gru_1_rev_t2_h_7 + (-0.35120463371276855) * gru_1_rev_t2_h_8 + (0.47614026069641113) * gru_1_rev_t2_h_9 + (-1.075276255607605) * gru_1_rev_t2_h_10 + (0.074330717325210571) * gru_1_rev_t2_h_11 + (-1.0357192754745483) * gru_1_rev_t2_h_12 + (0.19469013810157776) * gru_1_rev_t2_h_13 + (-0.47360867261886597) * gru_1_rev_t2_h_14 + (-0.50178152322769165) * gru_1_rev_t2_h_15 + (-0.075868278741836548) * gru_1_rev_t2_h_16 + (1.1177390813827515) * gru_1_rev_t2_h_17 + (-1.0828514099121094) * gru_1_rev_t2_h_18 + (2.2804548740386963) * gru_1_rev_t2_h_19 + (-0.23992703855037689) * gru_1_rev_t2_h_20 + (0.4726739227771759) * gru_1_rev_t2_h_21 + (-0.18442513048648834) * gru_1_rev_t2_h_22 + (0.088708974421024323) * gru_1_rev_t2_h_23 + (-0.25001037120819092) * gru_1_rev_t2_h_24 + (0.86952996253967285) * gru_1_rev_t2_h_25 + (-0.47891974449157715) * gru_1_rev_t2_h_26 + (0.17702697217464447) * gru_1_rev_t2_h_27 + (0.50373721122741699) * gru_1_rev_t2_h_28 + (-0.24426186084747314) * gru_1_rev_t2_h_29 + (-0.037016607820987701) * gru_1_rev_t2_h_30 + (1.5139617919921875) * gru_1_rev_t2_h_31));
    gru_1_rev_t1_h_24 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t2_h_24;
    // h=25
    gate_r = sigmoid((-0.68872278928756714) + (0.36069002747535706) * gru_0_out_t1_0 + (0.71517562866210938) * gru_0_out_t1_1 + (-0.99392968416213989) * gru_0_out_t1_2 + (0.38534748554229736) * gru_0_out_t1_3 + (-0.19741858541965485) * gru_0_out_t1_4 + (0.043304946273565292) * gru_0_out_t1_5 + (1.1694974899291992) * gru_0_out_t1_6 + (0.11177445948123932) * gru_0_out_t1_7 + (-0.20850341022014618) * gru_0_out_t1_8 + (-0.17900639772415161) * gru_0_out_t1_9 + (0.39058849215507507) * gru_0_out_t1_10 + (-0.37520793080329895) * gru_0_out_t1_11 + (0.56499123573303223) * gru_0_out_t1_12 + (0.60227823257446289) * gru_0_out_t1_13 + (-0.37562569975852966) * gru_0_out_t1_14 + (0.37927168607711792) * gru_0_out_t1_15 + (0.92597073316574097) * gru_0_out_t1_16 + (-0.06651720404624939) * gru_0_out_t1_17 + (0.33824589848518372) * gru_0_out_t1_18 + (1.0773898363113403) * gru_0_out_t1_19 + (-0.16736890375614166) * gru_0_out_t1_20 + (0.52859139442443848) * gru_0_out_t1_21 + (0.60521113872528076) * gru_0_out_t1_22 + (-0.42439541220664978) * gru_0_out_t1_23 + (0.20992039144039154) * gru_0_out_t1_24 + (0.90285736322402954) * gru_0_out_t1_25 + (0.52016681432723999) * gru_0_out_t1_26 + (0.13756980001926422) * gru_0_out_t1_27 + (-1.0828664302825928) * gru_0_out_t1_28 + (0.15396140515804291) * gru_0_out_t1_29 + (-0.091489166021347046) * gru_0_out_t1_30 + (0.6299583911895752) * gru_0_out_t1_31 + (0.45895460247993469) * gru_0_out_t1_32 + (-0.32255271077156067) * gru_0_out_t1_33 + (-1.1023681163787842) * gru_0_out_t1_34 + (1.0012598037719727) * gru_0_out_t1_35 + (1.1804112195968628) * gru_0_out_t1_36 + (-1.0099633932113647) * gru_0_out_t1_37 + (0.74185484647750854) * gru_0_out_t1_38 + (-1.3310835361480713) * gru_0_out_t1_39 + (-2.2966156005859375) * gru_0_out_t1_40 + (1.432637095451355) * gru_0_out_t1_41 + (-0.66869258880615234) * gru_0_out_t1_42 + (0.32025089859962463) * gru_0_out_t1_43 + (0.33058920502662659) * gru_0_out_t1_44 + (-0.07027098536491394) * gru_0_out_t1_45 + (0.17212650179862976) * gru_0_out_t1_46 + (-0.37059327960014343) * gru_0_out_t1_47 + (0.084893472492694855) * gru_0_out_t1_48 + (-0.32169178128242493) * gru_0_out_t1_49 + (1.0965685844421387) * gru_0_out_t1_50 + (1.1026610136032104) * gru_0_out_t1_51 + (0.5448920726776123) * gru_0_out_t1_52 + (-0.54577904939651489) * gru_0_out_t1_53 + (-0.025114711374044418) * gru_0_out_t1_54 + (0.84211868047714233) * gru_0_out_t1_55 + (-1.6047921180725098) * gru_0_out_t1_56 + (0.78105896711349487) * gru_0_out_t1_57 + (-0.52728748321533203) * gru_0_out_t1_58 + (-0.5426490306854248) * gru_0_out_t1_59 + (0.058411728590726852) * gru_0_out_t1_60 + (0.31183773279190063) * gru_0_out_t1_61 + (-0.21657763421535492) * gru_0_out_t1_62 + (-1.1230523586273193) * gru_0_out_t1_63 + (1.1993770599365234) * gru_1_rev_t2_h_0 + (-0.33510327339172363) * gru_1_rev_t2_h_1 + (-1.225332498550415) * gru_1_rev_t2_h_2 + (3.3180224895477295) * gru_1_rev_t2_h_3 + (-0.11117099970579147) * gru_1_rev_t2_h_4 + (0.59104150533676147) * gru_1_rev_t2_h_5 + (1.4880579710006714) * gru_1_rev_t2_h_6 + (-0.02300756610929966) * gru_1_rev_t2_h_7 + (0.72380596399307251) * gru_1_rev_t2_h_8 + (-0.24485540390014648) * gru_1_rev_t2_h_9 + (-0.94089603424072266) * gru_1_rev_t2_h_10 + (-0.39606964588165283) * gru_1_rev_t2_h_11 + (2.6677491664886475) * gru_1_rev_t2_h_12 + (1.1836587190628052) * gru_1_rev_t2_h_13 + (0.84342306852340698) * gru_1_rev_t2_h_14 + (0.21934781968593597) * gru_1_rev_t2_h_15 + (0.040235843509435654) * gru_1_rev_t2_h_16 + (-0.81046819686889648) * gru_1_rev_t2_h_17 + (-0.27802133560180664) * gru_1_rev_t2_h_18 + (1.5077669620513916) * gru_1_rev_t2_h_19 + (-1.2212316989898682) * gru_1_rev_t2_h_20 + (-1.2865390777587891) * gru_1_rev_t2_h_21 + (-1.0127407312393188) * gru_1_rev_t2_h_22 + (-0.33258774876594543) * gru_1_rev_t2_h_23 + (0.57150888442993164) * gru_1_rev_t2_h_24 + (-0.41477862000465393) * gru_1_rev_t2_h_25 + (-0.71880102157592773) * gru_1_rev_t2_h_26 + (1.4207507371902466) * gru_1_rev_t2_h_27 + (4.4697318077087402) * gru_1_rev_t2_h_28 + (-0.62855976819992065) * gru_1_rev_t2_h_29 + (-1.43726646900177) * gru_1_rev_t2_h_30 + (-1.3448024988174438) * gru_1_rev_t2_h_31);
    gate_z = sigmoid((-1.3806666135787964) + (-0.58700364828109741) * gru_0_out_t1_0 + (0.26571473479270935) * gru_0_out_t1_1 + (-0.32685825228691101) * gru_0_out_t1_2 + (-0.90101999044418335) * gru_0_out_t1_3 + (0.35757860541343689) * gru_0_out_t1_4 + (-0.54397678375244141) * gru_0_out_t1_5 + (0.28882408142089844) * gru_0_out_t1_6 + (-0.42557385563850403) * gru_0_out_t1_7 + (0.40694007277488708) * gru_0_out_t1_8 + (-0.99995297193527222) * gru_0_out_t1_9 + (0.096525333821773529) * gru_0_out_t1_10 + (0.17275959253311157) * gru_0_out_t1_11 + (-0.22417077422142029) * gru_0_out_t1_12 + (-0.22835682332515717) * gru_0_out_t1_13 + (-0.28330114483833313) * gru_0_out_t1_14 + (-0.4054696261882782) * gru_0_out_t1_15 + (0.72596818208694458) * gru_0_out_t1_16 + (0.52691817283630371) * gru_0_out_t1_17 + (-0.14814548194408417) * gru_0_out_t1_18 + (-1.0273617506027222) * gru_0_out_t1_19 + (-0.63775330781936646) * gru_0_out_t1_20 + (2.1266162395477295) * gru_0_out_t1_21 + (-0.61278611421585083) * gru_0_out_t1_22 + (-0.53326821327209473) * gru_0_out_t1_23 + (0.1020834669470787) * gru_0_out_t1_24 + (0.68824303150177002) * gru_0_out_t1_25 + (0.39001506567001343) * gru_0_out_t1_26 + (-0.46168527007102966) * gru_0_out_t1_27 + (-1.2828541994094849) * gru_0_out_t1_28 + (-0.56002676486968994) * gru_0_out_t1_29 + (-1.0278382301330566) * gru_0_out_t1_30 + (0.65274471044540405) * gru_0_out_t1_31 + (-0.21438898146152496) * gru_0_out_t1_32 + (-0.34641027450561523) * gru_0_out_t1_33 + (0.0032906208653002977) * gru_0_out_t1_34 + (0.29625648260116577) * gru_0_out_t1_35 + (0.39076119661331177) * gru_0_out_t1_36 + (0.17421466112136841) * gru_0_out_t1_37 + (0.66873526573181152) * gru_0_out_t1_38 + (-1.2488648891448975) * gru_0_out_t1_39 + (1.4559496641159058) * gru_0_out_t1_40 + (-0.040352210402488708) * gru_0_out_t1_41 + (-1.4171470403671265) * gru_0_out_t1_42 + (0.26955947279930115) * gru_0_out_t1_43 + (0.55390739440917969) * gru_0_out_t1_44 + (0.23300084471702576) * gru_0_out_t1_45 + (-0.11313316971063614) * gru_0_out_t1_46 + (0.013845196925103664) * gru_0_out_t1_47 + (-0.61378484964370728) * gru_0_out_t1_48 + (0.92378604412078857) * gru_0_out_t1_49 + (-0.16182556748390198) * gru_0_out_t1_50 + (0.47823807597160339) * gru_0_out_t1_51 + (0.33600771427154541) * gru_0_out_t1_52 + (-0.24655236303806305) * gru_0_out_t1_53 + (2.9110496044158936) * gru_0_out_t1_54 + (-0.052052333950996399) * gru_0_out_t1_55 + (-1.0303739309310913) * gru_0_out_t1_56 + (1.5366804599761963) * gru_0_out_t1_57 + (-0.50297069549560547) * gru_0_out_t1_58 + (-2.1096131801605225) * gru_0_out_t1_59 + (-0.37937512993812561) * gru_0_out_t1_60 + (-0.64973890781402588) * gru_0_out_t1_61 + (-0.053456485271453857) * gru_0_out_t1_62 + (2.8340628147125244) * gru_0_out_t1_63 + (1.3118062019348145) * gru_1_rev_t2_h_0 + (0.72601211071014404) * gru_1_rev_t2_h_1 + (0.8403896689414978) * gru_1_rev_t2_h_2 + (0.9631306529045105) * gru_1_rev_t2_h_3 + (-1.3059902191162109) * gru_1_rev_t2_h_4 + (0.39217755198478699) * gru_1_rev_t2_h_5 + (0.22251453995704651) * gru_1_rev_t2_h_6 + (-0.38418540358543396) * gru_1_rev_t2_h_7 + (0.17794956266880035) * gru_1_rev_t2_h_8 + (-1.3219239711761475) * gru_1_rev_t2_h_9 + (0.030402036383748055) * gru_1_rev_t2_h_10 + (-0.94055426120758057) * gru_1_rev_t2_h_11 + (-1.0486565828323364) * gru_1_rev_t2_h_12 + (0.48371332883834839) * gru_1_rev_t2_h_13 + (0.64712578058242798) * gru_1_rev_t2_h_14 + (0.082876898348331451) * gru_1_rev_t2_h_15 + (0.64624106884002686) * gru_1_rev_t2_h_16 + (-0.6692662239074707) * gru_1_rev_t2_h_17 + (0.76401370763778687) * gru_1_rev_t2_h_18 + (-3.9688270092010498) * gru_1_rev_t2_h_19 + (0.34651711583137512) * gru_1_rev_t2_h_20 + (0.35951527953147888) * gru_1_rev_t2_h_21 + (-1.71735680103302) * gru_1_rev_t2_h_22 + (0.66552460193634033) * gru_1_rev_t2_h_23 + (-0.23552107810974121) * gru_1_rev_t2_h_24 + (-0.39188441634178162) * gru_1_rev_t2_h_25 + (-0.37041723728179932) * gru_1_rev_t2_h_26 + (0.74386674165725708) * gru_1_rev_t2_h_27 + (-2.8867461681365967) * gru_1_rev_t2_h_28 + (0.41335520148277283) * gru_1_rev_t2_h_29 + (-0.70892912149429321) * gru_1_rev_t2_h_30 + (0.64873170852661133) * gru_1_rev_t2_h_31);
    gate_n = tanh((0.42075583338737488) + (0.29455700516700745) * gru_0_out_t1_0 + (-1.2316609621047974) * gru_0_out_t1_1 + (-0.24127385020256042) * gru_0_out_t1_2 + (0.12402823567390442) * gru_0_out_t1_3 + (-0.92426884174346924) * gru_0_out_t1_4 + (0.6823958158493042) * gru_0_out_t1_5 + (1.3001562356948853) * gru_0_out_t1_6 + (-0.021451219916343689) * gru_0_out_t1_7 + (-0.14869573712348938) * gru_0_out_t1_8 + (0.63034754991531372) * gru_0_out_t1_9 + (0.24176689982414246) * gru_0_out_t1_10 + (0.016120696440339088) * gru_0_out_t1_11 + (1.0096893310546875) * gru_0_out_t1_12 + (0.18879173696041107) * gru_0_out_t1_13 + (0.31400904059410095) * gru_0_out_t1_14 + (0.50824850797653198) * gru_0_out_t1_15 + (-1.5484104156494141) * gru_0_out_t1_16 + (-0.10726187378168106) * gru_0_out_t1_17 + (-0.29704809188842773) * gru_0_out_t1_18 + (-0.36398449540138245) * gru_0_out_t1_19 + (0.61971956491470337) * gru_0_out_t1_20 + (-1.6753532886505127) * gru_0_out_t1_21 + (-0.035529263317584991) * gru_0_out_t1_22 + (0.22071681916713715) * gru_0_out_t1_23 + (-1.3711931705474854) * gru_0_out_t1_24 + (-0.55373275279998779) * gru_0_out_t1_25 + (0.17192965745925903) * gru_0_out_t1_26 + (-0.28454670310020447) * gru_0_out_t1_27 + (-1.871662974357605) * gru_0_out_t1_28 + (0.21489638090133667) * gru_0_out_t1_29 + (-0.5381094217300415) * gru_0_out_t1_30 + (0.88996607065200806) * gru_0_out_t1_31 + (1.5324912071228027) * gru_0_out_t1_32 + (-0.66878044605255127) * gru_0_out_t1_33 + (-0.99872201681137085) * gru_0_out_t1_34 + (0.59640860557556152) * gru_0_out_t1_35 + (-0.24413782358169556) * gru_0_out_t1_36 + (-0.73545742034912109) * gru_0_out_t1_37 + (0.8918454647064209) * gru_0_out_t1_38 + (-1.8465534448623657) * gru_0_out_t1_39 + (2.1779768466949463) * gru_0_out_t1_40 + (0.71242803335189819) * gru_0_out_t1_41 + (-0.29210388660430908) * gru_0_out_t1_42 + (0.022092429921030998) * gru_0_out_t1_43 + (-0.0057449727319180965) * gru_0_out_t1_44 + (-0.5264696478843689) * gru_0_out_t1_45 + (-0.91483044624328613) * gru_0_out_t1_46 + (-0.92364460229873657) * gru_0_out_t1_47 + (-0.80660921335220337) * gru_0_out_t1_48 + (0.12668250501155853) * gru_0_out_t1_49 + (0.6585925817489624) * gru_0_out_t1_50 + (-0.044622279703617096) * gru_0_out_t1_51 + (0.50692439079284668) * gru_0_out_t1_52 + (0.60111653804779053) * gru_0_out_t1_53 + (-0.28614088892936707) * gru_0_out_t1_54 + (-0.51850801706314087) * gru_0_out_t1_55 + (-0.37587946653366089) * gru_0_out_t1_56 + (0.14975480735301971) * gru_0_out_t1_57 + (-0.41916921734809875) * gru_0_out_t1_58 + (0.61755919456481934) * gru_0_out_t1_59 + (-0.53422755002975464) * gru_0_out_t1_60 + (1.0413503646850586) * gru_0_out_t1_61 + (0.43674063682556152) * gru_0_out_t1_62 + (0.2721983790397644) * gru_0_out_t1_63 + gate_r * ((0.38431325554847717) + (-0.41206768155097961) * gru_1_rev_t2_h_0 + (-0.27722847461700439) * gru_1_rev_t2_h_1 + (-0.74833011627197266) * gru_1_rev_t2_h_2 + (1.8245695829391479) * gru_1_rev_t2_h_3 + (1.2125097513198853) * gru_1_rev_t2_h_4 + (0.49687474966049194) * gru_1_rev_t2_h_5 + (-0.13226146996021271) * gru_1_rev_t2_h_6 + (0.47737330198287964) * gru_1_rev_t2_h_7 + (0.30610096454620361) * gru_1_rev_t2_h_8 + (0.92558646202087402) * gru_1_rev_t2_h_9 + (-0.4937383234500885) * gru_1_rev_t2_h_10 + (-0.26371854543685913) * gru_1_rev_t2_h_11 + (1.5507224798202515) * gru_1_rev_t2_h_12 + (-2.4346861839294434) * gru_1_rev_t2_h_13 + (-1.0647842884063721) * gru_1_rev_t2_h_14 + (0.48473095893859863) * gru_1_rev_t2_h_15 + (-0.14139547944068909) * gru_1_rev_t2_h_16 + (0.050848450511693954) * gru_1_rev_t2_h_17 + (-0.088865429162979126) * gru_1_rev_t2_h_18 + (0.49576026201248169) * gru_1_rev_t2_h_19 + (0.33802276849746704) * gru_1_rev_t2_h_20 + (0.41915205121040344) * gru_1_rev_t2_h_21 + (1.341840386390686) * gru_1_rev_t2_h_22 + (-0.011196828447282314) * gru_1_rev_t2_h_23 + (-1.2566180229187012) * gru_1_rev_t2_h_24 + (-0.14192281663417816) * gru_1_rev_t2_h_25 + (0.49107468128204346) * gru_1_rev_t2_h_26 + (-0.68868738412857056) * gru_1_rev_t2_h_27 + (0.22797045111656189) * gru_1_rev_t2_h_28 + (-0.006672966293990612) * gru_1_rev_t2_h_29 + (-0.95045918226242065) * gru_1_rev_t2_h_30 + (1.1420725584030151) * gru_1_rev_t2_h_31));
    gru_1_rev_t1_h_25 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t2_h_25;
    // h=26
    gate_r = sigmoid((-1.3849070072174072) + (0.2035602331161499) * gru_0_out_t1_0 + (-0.040443520992994308) * gru_0_out_t1_1 + (0.90126663446426392) * gru_0_out_t1_2 + (3.7027628421783447) * gru_0_out_t1_3 + (-0.94711905717849731) * gru_0_out_t1_4 + (-1.0484776496887207) * gru_0_out_t1_5 + (-1.182924747467041) * gru_0_out_t1_6 + (-1.0356642007827759) * gru_0_out_t1_7 + (-0.54311269521713257) * gru_0_out_t1_8 + (1.3705152273178101) * gru_0_out_t1_9 + (-0.43722140789031982) * gru_0_out_t1_10 + (-0.41263672709465027) * gru_0_out_t1_11 + (1.029377818107605) * gru_0_out_t1_12 + (-0.24379687011241913) * gru_0_out_t1_13 + (-0.10094958543777466) * gru_0_out_t1_14 + (1.8372827768325806) * gru_0_out_t1_15 + (0.84937864542007446) * gru_0_out_t1_16 + (0.098124809563159943) * gru_0_out_t1_17 + (0.84803563356399536) * gru_0_out_t1_18 + (3.8540334701538086) * gru_0_out_t1_19 + (1.5363163948059082) * gru_0_out_t1_20 + (0.0037667234428226948) * gru_0_out_t1_21 + (2.4095726013183594) * gru_0_out_t1_22 + (1.0084015130996704) * gru_0_out_t1_23 + (-2.4194860458374023) * gru_0_out_t1_24 + (-0.37978023290634155) * gru_0_out_t1_25 + (1.0542058944702148) * gru_0_out_t1_26 + (-0.32768318057060242) * gru_0_out_t1_27 + (0.68030530214309692) * gru_0_out_t1_28 + (-0.64886075258255005) * gru_0_out_t1_29 + (-3.4111189842224121) * gru_0_out_t1_30 + (2.2584981918334961) * gru_0_out_t1_31 + (-0.79855525493621826) * gru_0_out_t1_32 + (0.28479057550430298) * gru_0_out_t1_33 + (-0.38185584545135498) * gru_0_out_t1_34 + (0.78153342008590698) * gru_0_out_t1_35 + (0.89593559503555298) * gru_0_out_t1_36 + (-0.35564634203910828) * gru_0_out_t1_37 + (-0.13578081130981445) * gru_0_out_t1_38 + (-0.81159037351608276) * gru_0_out_t1_39 + (-2.0690281391143799) * gru_0_out_t1_40 + (0.76316094398498535) * gru_0_out_t1_41 + (-2.7663488388061523) * gru_0_out_t1_42 + (0.22821745276451111) * gru_0_out_t1_43 + (0.59312111139297485) * gru_0_out_t1_44 + (0.44644013047218323) * gru_0_out_t1_45 + (0.97447651624679565) * gru_0_out_t1_46 + (0.67504113912582397) * gru_0_out_t1_47 + (0.55783563852310181) * gru_0_out_t1_48 + (-0.56568372249603271) * gru_0_out_t1_49 + (-2.0430543422698975) * gru_0_out_t1_50 + (-0.58569294214248657) * gru_0_out_t1_51 + (0.58834236860275269) * gru_0_out_t1_52 + (-1.1708426475524902) * gru_0_out_t1_53 + (0.11008942872285843) * gru_0_out_t1_54 + (-0.032929278910160065) * gru_0_out_t1_55 + (-0.050686139613389969) * gru_0_out_t1_56 + (-1.3835775852203369) * gru_0_out_t1_57 + (-0.86650913953781128) * gru_0_out_t1_58 + (0.019592069089412689) * gru_0_out_t1_59 + (0.080178983509540558) * gru_0_out_t1_60 + (-1.3714538812637329) * gru_0_out_t1_61 + (-0.070283360779285431) * gru_0_out_t1_62 + (-0.35907617211341858) * gru_0_out_t1_63 + (-1.3266624212265015) * gru_1_rev_t2_h_0 + (-0.59424960613250732) * gru_1_rev_t2_h_1 + (0.031020978465676308) * gru_1_rev_t2_h_2 + (-0.39354684948921204) * gru_1_rev_t2_h_3 + (-0.50971841812133789) * gru_1_rev_t2_h_4 + (-0.48355755209922791) * gru_1_rev_t2_h_5 + (0.538482666015625) * gru_1_rev_t2_h_6 + (0.72413349151611328) * gru_1_rev_t2_h_7 + (-0.89606177806854248) * gru_1_rev_t2_h_8 + (0.053694963455200195) * gru_1_rev_t2_h_9 + (-0.91725605726242065) * gru_1_rev_t2_h_10 + (1.8685430288314819) * gru_1_rev_t2_h_11 + (0.10486017912626266) * gru_1_rev_t2_h_12 + (0.017982715740799904) * gru_1_rev_t2_h_13 + (0.57254713773727417) * gru_1_rev_t2_h_14 + (-0.97832280397415161) * gru_1_rev_t2_h_15 + (0.89050012826919556) * gru_1_rev_t2_h_16 + (-1.5839756727218628) * gru_1_rev_t2_h_17 + (0.1805608868598938) * gru_1_rev_t2_h_18 + (-2.5272164344787598) * gru_1_rev_t2_h_19 + (0.66472572088241577) * gru_1_rev_t2_h_20 + (-0.066327854990959167) * gru_1_rev_t2_h_21 + (-0.13813367486000061) * gru_1_rev_t2_h_22 + (-0.11463271826505661) * gru_1_rev_t2_h_23 + (0.38933312892913818) * gru_1_rev_t2_h_24 + (-0.21292941272258759) * gru_1_rev_t2_h_25 + (0.83010673522949219) * gru_1_rev_t2_h_26 + (0.50835114717483521) * gru_1_rev_t2_h_27 + (-1.3303238153457642) * gru_1_rev_t2_h_28 + (0.14575265347957611) * gru_1_rev_t2_h_29 + (-3.2273106575012207) * gru_1_rev_t2_h_30 + (0.10206147283315659) * gru_1_rev_t2_h_31);
    gate_z = sigmoid((-0.14969632029533386) + (0.098499134182929993) * gru_0_out_t1_0 + (-0.058121107518672943) * gru_0_out_t1_1 + (-0.020033961161971092) * gru_0_out_t1_2 + (0.36861327290534973) * gru_0_out_t1_3 + (-0.050071202218532562) * gru_0_out_t1_4 + (0.30397269129753113) * gru_0_out_t1_5 + (0.43292230367660522) * gru_0_out_t1_6 + (-0.87640184164047241) * gru_0_out_t1_7 + (0.2692071795463562) * gru_0_out_t1_8 + (0.40779668092727661) * gru_0_out_t1_9 + (0.38683417439460754) * gru_0_out_t1_10 + (0.57386118173599243) * gru_0_out_t1_11 + (0.41480997204780579) * gru_0_out_t1_12 + (0.38796854019165039) * gru_0_out_t1_13 + (-0.33451014757156372) * gru_0_out_t1_14 + (-0.14412827789783478) * gru_0_out_t1_15 + (-0.041270174086093903) * gru_0_out_t1_16 + (0.19578152894973755) * gru_0_out_t1_17 + (-0.32512015104293823) * gru_0_out_t1_18 + (0.047837506979703903) * gru_0_out_t1_19 + (0.37509843707084656) * gru_0_out_t1_20 + (-0.005351304542273283) * gru_0_out_t1_21 + (0.38668501377105713) * gru_0_out_t1_22 + (-0.44822195172309875) * gru_0_out_t1_23 + (0.46944025158882141) * gru_0_out_t1_24 + (-0.0082537569105625153) * gru_0_out_t1_25 + (-0.18922829627990723) * gru_0_out_t1_26 + (-0.0075922147370874882) * gru_0_out_t1_27 + (-0.022318162024021149) * gru_0_out_t1_28 + (1.995606541633606) * gru_0_out_t1_29 + (0.1362847238779068) * gru_0_out_t1_30 + (0.21843306720256805) * gru_0_out_t1_31 + (0.10659537464380264) * gru_0_out_t1_32 + (-0.99396711587905884) * gru_0_out_t1_33 + (-0.41160410642623901) * gru_0_out_t1_34 + (-0.50163859128952026) * gru_0_out_t1_35 + (-0.58482944965362549) * gru_0_out_t1_36 + (0.28164824843406677) * gru_0_out_t1_37 + (0.097125247120857239) * gru_0_out_t1_38 + (0.035281296819448471) * gru_0_out_t1_39 + (-1.2833260297775269) * gru_0_out_t1_40 + (0.06861598789691925) * gru_0_out_t1_41 + (0.019984792917966843) * gru_0_out_t1_42 + (0.23431785404682159) * gru_0_out_t1_43 + (0.13151144981384277) * gru_0_out_t1_44 + (-0.14272071421146393) * gru_0_out_t1_45 + (0.4253203272819519) * gru_0_out_t1_46 + (-0.41288486123085022) * gru_0_out_t1_47 + (0.088689051568508148) * gru_0_out_t1_48 + (0.35712751746177673) * gru_0_out_t1_49 + (0.25982645153999329) * gru_0_out_t1_50 + (-0.51312887668609619) * gru_0_out_t1_51 + (0.3521881103515625) * gru_0_out_t1_52 + (0.12718643248081207) * gru_0_out_t1_53 + (0.34499099850654602) * gru_0_out_t1_54 + (-0.27264934778213501) * gru_0_out_t1_55 + (0.03059670515358448) * gru_0_out_t1_56 + (0.35458385944366455) * gru_0_out_t1_57 + (-0.13553923368453979) * gru_0_out_t1_58 + (-1.1489249467849731) * gru_0_out_t1_59 + (-0.45713049173355103) * gru_0_out_t1_60 + (0.097685150802135468) * gru_0_out_t1_61 + (-0.19748847186565399) * gru_0_out_t1_62 + (0.56220328807830811) * gru_0_out_t1_63 + (0.25940781831741333) * gru_1_rev_t2_h_0 + (-0.23720091581344604) * gru_1_rev_t2_h_1 + (-0.61685347557067871) * gru_1_rev_t2_h_2 + (-1.0932610034942627) * gru_1_rev_t2_h_3 + (-0.80595147609710693) * gru_1_rev_t2_h_4 + (-0.72378283739089966) * gru_1_rev_t2_h_5 + (0.22080934047698975) * gru_1_rev_t2_h_6 + (-0.39638310670852661) * gru_1_rev_t2_h_7 + (0.13694871962070465) * gru_1_rev_t2_h_8 + (-1.1780130863189697) * gru_1_rev_t2_h_9 + (0.60650289058685303) * gru_1_rev_t2_h_10 + (0.35453850030899048) * gru_1_rev_t2_h_11 + (0.76122367382049561) * gru_1_rev_t2_h_12 + (-0.57087409496307373) * gru_1_rev_t2_h_13 + (0.37808296084403992) * gru_1_rev_t2_h_14 + (-0.016317769885063171) * gru_1_rev_t2_h_15 + (-1.3718936443328857) * gru_1_rev_t2_h_16 + (1.5174386501312256) * gru_1_rev_t2_h_17 + (0.80149561166763306) * gru_1_rev_t2_h_18 + (-1.3558560609817505) * gru_1_rev_t2_h_19 + (-0.022964000701904297) * gru_1_rev_t2_h_20 + (0.7291749119758606) * gru_1_rev_t2_h_21 + (-0.55455338954925537) * gru_1_rev_t2_h_22 + (0.23619359731674194) * gru_1_rev_t2_h_23 + (-0.17507891356945038) * gru_1_rev_t2_h_24 + (-0.82050329446792603) * gru_1_rev_t2_h_25 + (0.078206591308116913) * gru_1_rev_t2_h_26 + (0.10018184781074524) * gru_1_rev_t2_h_27 + (-1.9592317342758179) * gru_1_rev_t2_h_28 + (0.44502219557762146) * gru_1_rev_t2_h_29 + (-0.30903509259223938) * gru_1_rev_t2_h_30 + (0.28640913963317871) * gru_1_rev_t2_h_31);
    gate_n = tanh((0.28438782691955566) + (0.03224225714802742) * gru_0_out_t1_0 + (-0.22251491248607635) * gru_0_out_t1_1 + (0.24897474050521851) * gru_0_out_t1_2 + (0.51020926237106323) * gru_0_out_t1_3 + (-0.3331902027130127) * gru_0_out_t1_4 + (-0.12126055359840393) * gru_0_out_t1_5 + (0.89374619722366333) * gru_0_out_t1_6 + (-2.0917167663574219) * gru_0_out_t1_7 + (-0.6761174201965332) * gru_0_out_t1_8 + (-1.068554162979126) * gru_0_out_t1_9 + (0.25473994016647339) * gru_0_out_t1_10 + (0.12363075464963913) * gru_0_out_t1_11 + (0.11133992671966553) * gru_0_out_t1_12 + (0.35330888628959656) * gru_0_out_t1_13 + (-0.064566835761070251) * gru_0_out_t1_14 + (0.24817520380020142) * gru_0_out_t1_15 + (-0.95763415098190308) * gru_0_out_t1_16 + (-0.45638585090637207) * gru_0_out_t1_17 + (0.045507695525884628) * gru_0_out_t1_18 + (-1.0613921880722046) * gru_0_out_t1_19 + (0.25074699521064758) * gru_0_out_t1_20 + (-1.3195301294326782) * gru_0_out_t1_21 + (-0.15837457776069641) * gru_0_out_t1_22 + (0.98696291446685791) * gru_0_out_t1_23 + (0.022206159308552742) * gru_0_out_t1_24 + (-0.31491154432296753) * gru_0_out_t1_25 + (-0.035650786012411118) * gru_0_out_t1_26 + (0.30069461464881897) * gru_0_out_t1_27 + (0.93242067098617554) * gru_0_out_t1_28 + (-0.33105766773223877) * gru_0_out_t1_29 + (0.41289466619491577) * gru_0_out_t1_30 + (0.3467043936252594) * gru_0_out_t1_31 + (1.0731692314147949) * gru_0_out_t1_32 + (-0.29181236028671265) * gru_0_out_t1_33 + (0.25750330090522766) * gru_0_out_t1_34 + (0.35239326953887939) * gru_0_out_t1_35 + (-0.21127203106880188) * gru_0_out_t1_36 + (-0.20493632555007935) * gru_0_out_t1_37 + (0.17752508819103241) * gru_0_out_t1_38 + (0.39301154017448425) * gru_0_out_t1_39 + (-1.4752867221832275) * gru_0_out_t1_40 + (-0.16636273264884949) * gru_0_out_t1_41 + (-0.23854056000709534) * gru_0_out_t1_42 + (0.046220947057008743) * gru_0_out_t1_43 + (0.018332194536924362) * gru_0_out_t1_44 + (0.29956617951393127) * gru_0_out_t1_45 + (0.13400860130786896) * gru_0_out_t1_46 + (-0.81807136535644531) * gru_0_out_t1_47 + (-0.02093847468495369) * gru_0_out_t1_48 + (0.32666090130805969) * gru_0_out_t1_49 + (0.3327580988407135) * gru_0_out_t1_50 + (0.095665670931339264) * gru_0_out_t1_51 + (0.093630507588386536) * gru_0_out_t1_52 + (0.68123269081115723) * gru_0_out_t1_53 + (-0.28688549995422363) * gru_0_out_t1_54 + (-0.17934301495552063) * gru_0_out_t1_55 + (-0.095353804528713226) * gru_0_out_t1_56 + (-0.035506121814250946) * gru_0_out_t1_57 + (-0.0085240649059414864) * gru_0_out_t1_58 + (-0.85637521743774414) * gru_0_out_t1_59 + (-1.0530228614807129) * gru_0_out_t1_60 + (-0.14414586126804352) * gru_0_out_t1_61 + (0.99007993936538696) * gru_0_out_t1_62 + (-1.0537717342376709) * gru_0_out_t1_63 + gate_r * ((-0.42977431416511536) + (-0.087007559835910797) * gru_1_rev_t2_h_0 + (-0.14809881150722504) * gru_1_rev_t2_h_1 + (-0.5050385594367981) * gru_1_rev_t2_h_2 + (1.054185152053833) * gru_1_rev_t2_h_3 + (-0.14374500513076782) * gru_1_rev_t2_h_4 + (0.85547411441802979) * gru_1_rev_t2_h_5 + (-0.73488253355026245) * gru_1_rev_t2_h_6 + (0.012056845240294933) * gru_1_rev_t2_h_7 + (0.4540073573589325) * gru_1_rev_t2_h_8 + (-0.45818799734115601) * gru_1_rev_t2_h_9 + (0.15304900705814362) * gru_1_rev_t2_h_10 + (-1.5027923583984375) * gru_1_rev_t2_h_11 + (1.0831973552703857) * gru_1_rev_t2_h_12 + (0.83801233768463135) * gru_1_rev_t2_h_13 + (-0.25330975651741028) * gru_1_rev_t2_h_14 + (0.35657611489295959) * gru_1_rev_t2_h_15 + (0.27194392681121826) * gru_1_rev_t2_h_16 + (-0.27401778101921082) * gru_1_rev_t2_h_17 + (-0.43792930245399475) * gru_1_rev_t2_h_18 + (1.6203814744949341) * gru_1_rev_t2_h_19 + (-0.29565960168838501) * gru_1_rev_t2_h_20 + (-0.70135390758514404) * gru_1_rev_t2_h_21 + (0.14205916225910187) * gru_1_rev_t2_h_22 + (0.30389034748077393) * gru_1_rev_t2_h_23 + (0.2330603301525116) * gru_1_rev_t2_h_24 + (0.11077108979225159) * gru_1_rev_t2_h_25 + (-0.1046941950917244) * gru_1_rev_t2_h_26 + (-0.29495805501937866) * gru_1_rev_t2_h_27 + (0.9245685338973999) * gru_1_rev_t2_h_28 + (-0.26904049515724182) * gru_1_rev_t2_h_29 + (1.4777230024337769) * gru_1_rev_t2_h_30 + (0.10978471487760544) * gru_1_rev_t2_h_31));
    gru_1_rev_t1_h_26 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t2_h_26;
    // h=27
    gate_r = sigmoid((-0.28831538558006287) + (0.19522950053215027) * gru_0_out_t1_0 + (0.063962951302528381) * gru_0_out_t1_1 + (-0.033160276710987091) * gru_0_out_t1_2 + (-0.65896791219711304) * gru_0_out_t1_3 + (0.31294536590576172) * gru_0_out_t1_4 + (-3.345921516418457) * gru_0_out_t1_5 + (-1.2133930921554565) * gru_0_out_t1_6 + (0.72442775964736938) * gru_0_out_t1_7 + (0.10570076107978821) * gru_0_out_t1_8 + (-0.035752445459365845) * gru_0_out_t1_9 + (0.34319251775741577) * gru_0_out_t1_10 + (-0.070207789540290833) * gru_0_out_t1_11 + (-0.031761173158884048) * gru_0_out_t1_12 + (-0.15376977622509003) * gru_0_out_t1_13 + (0.14712102711200714) * gru_0_out_t1_14 + (-0.10423563420772552) * gru_0_out_t1_15 + (0.2049870640039444) * gru_0_out_t1_16 + (-0.5251421332359314) * gru_0_out_t1_17 + (-0.94625335931777954) * gru_0_out_t1_18 + (-1.2454417943954468) * gru_0_out_t1_19 + (-0.56189048290252686) * gru_0_out_t1_20 + (1.4805910587310791) * gru_0_out_t1_21 + (0.22788353264331818) * gru_0_out_t1_22 + (3.294156551361084) * gru_0_out_t1_23 + (0.52854269742965698) * gru_0_out_t1_24 + (0.20716136693954468) * gru_0_out_t1_25 + (-1.0457937717437744) * gru_0_out_t1_26 + (-0.53028279542922974) * gru_0_out_t1_27 + (0.27535593509674072) * gru_0_out_t1_28 + (-0.43526044487953186) * gru_0_out_t1_29 + (0.089854590594768524) * gru_0_out_t1_30 + (-2.311762809753418) * gru_0_out_t1_31 + (-0.33743578195571899) * gru_0_out_t1_32 + (0.28387072682380676) * gru_0_out_t1_33 + (-0.63422125577926636) * gru_0_out_t1_34 + (0.52689993381500244) * gru_0_out_t1_35 + (0.028313731774687767) * gru_0_out_t1_36 + (0.27350506186485291) * gru_0_out_t1_37 + (-0.17585311830043793) * gru_0_out_t1_38 + (0.40815377235412598) * gru_0_out_t1_39 + (-1.0963338613510132) * gru_0_out_t1_40 + (0.16626718640327454) * gru_0_out_t1_41 + (1.612789511680603) * gru_0_out_t1_42 + (0.22638307511806488) * gru_0_out_t1_43 + (-0.9733847975730896) * gru_0_out_t1_44 + (0.87267422676086426) * gru_0_out_t1_45 + (1.0673621892929077) * gru_0_out_t1_46 + (0.23525483906269073) * gru_0_out_t1_47 + (0.99385583400726318) * gru_0_out_t1_48 + (-0.943767249584198) * gru_0_out_t1_49 + (-0.26808366179466248) * gru_0_out_t1_50 + (0.33952417969703674) * gru_0_out_t1_51 + (-0.26812741160392761) * gru_0_out_t1_52 + (-0.27410963177680969) * gru_0_out_t1_53 + (-2.7675399780273438) * gru_0_out_t1_54 + (-0.16688139736652374) * gru_0_out_t1_55 + (0.35239323973655701) * gru_0_out_t1_56 + (-0.12228724360466003) * gru_0_out_t1_57 + (-0.41591536998748779) * gru_0_out_t1_58 + (0.32379776239395142) * gru_0_out_t1_59 + (0.079443186521530151) * gru_0_out_t1_60 + (-3.0097000598907471) * gru_0_out_t1_61 + (0.19968399405479431) * gru_0_out_t1_62 + (0.40376776456832886) * gru_0_out_t1_63 + (0.54741442203521729) * gru_1_rev_t2_h_0 + (0.43920531868934631) * gru_1_rev_t2_h_1 + (-0.44236555695533752) * gru_1_rev_t2_h_2 + (-0.12652997672557831) * gru_1_rev_t2_h_3 + (-0.12488659471273422) * gru_1_rev_t2_h_4 + (0.67693424224853516) * gru_1_rev_t2_h_5 + (-0.22922204434871674) * gru_1_rev_t2_h_6 + (-0.17010068893432617) * gru_1_rev_t2_h_7 + (-0.952892005443573) * gru_1_rev_t2_h_8 + (-0.25607973337173462) * gru_1_rev_t2_h_9 + (-1.0971106290817261) * gru_1_rev_t2_h_10 + (0.56143462657928467) * gru_1_rev_t2_h_11 + (0.20169998705387115) * gru_1_rev_t2_h_12 + (-0.52232694625854492) * gru_1_rev_t2_h_13 + (-0.057153023779392242) * gru_1_rev_t2_h_14 + (-0.86585336923599243) * gru_1_rev_t2_h_15 + (-1.182182788848877) * gru_1_rev_t2_h_16 + (-0.53353589773178101) * gru_1_rev_t2_h_17 + (0.50066030025482178) * gru_1_rev_t2_h_18 + (0.017651580274105072) * gru_1_rev_t2_h_19 + (-0.39345145225524902) * gru_1_rev_t2_h_20 + (-0.12052380293607712) * gru_1_rev_t2_h_21 + (0.13550804555416107) * gru_1_rev_t2_h_22 + (-0.5383266806602478) * gru_1_rev_t2_h_23 + (-0.33238360285758972) * gru_1_rev_t2_h_24 + (0.30329662561416626) * gru_1_rev_t2_h_25 + (0.41191715002059937) * gru_1_rev_t2_h_26 + (-0.21781088411808014) * gru_1_rev_t2_h_27 + (0.083599120378494263) * gru_1_rev_t2_h_28 + (-0.054715558886528015) * gru_1_rev_t2_h_29 + (-0.58357119560241699) * gru_1_rev_t2_h_30 + (0.30187490582466125) * gru_1_rev_t2_h_31);
    gate_z = sigmoid((-0.061054226011037827) + (-0.41728505492210388) * gru_0_out_t1_0 + (-0.023665005341172218) * gru_0_out_t1_1 + (0.1132797971367836) * gru_0_out_t1_2 + (0.13780045509338379) * gru_0_out_t1_3 + (0.010538240894675255) * gru_0_out_t1_4 + (-0.18486326932907104) * gru_0_out_t1_5 + (-0.6363336443901062) * gru_0_out_t1_6 + (-0.053916025906801224) * gru_0_out_t1_7 + (-0.22441484034061432) * gru_0_out_t1_8 + (0.25992301106452942) * gru_0_out_t1_9 + (0.10673618316650391) * gru_0_out_t1_10 + (-0.5913550853729248) * gru_0_out_t1_11 + (-0.03510839119553566) * gru_0_out_t1_12 + (-0.16584886610507965) * gru_0_out_t1_13 + (-0.2089548259973526) * gru_0_out_t1_14 + (-0.095754854381084442) * gru_0_out_t1_15 + (0.15267075598239899) * gru_0_out_t1_16 + (-0.12822359800338745) * gru_0_out_t1_17 + (0.14956201612949371) * gru_0_out_t1_18 + (-0.92975836992263794) * gru_0_out_t1_19 + (0.90978986024856567) * gru_0_out_t1_20 + (0.08058534562587738) * gru_0_out_t1_21 + (-0.5122484564781189) * gru_0_out_t1_22 + (0.13374724984169006) * gru_0_out_t1_23 + (0.15319502353668213) * gru_0_out_t1_24 + (0.0038195198867470026) * gru_0_out_t1_25 + (-0.075328484177589417) * gru_0_out_t1_26 + (0.12666705250740051) * gru_0_out_t1_27 + (0.92413479089736938) * gru_0_out_t1_28 + (-1.5491005182266235) * gru_0_out_t1_29 + (-0.057907138019800186) * gru_0_out_t1_30 + (-0.63088202476501465) * gru_0_out_t1_31 + (0.075930967926979065) * gru_0_out_t1_32 + (-0.33337599039077759) * gru_0_out_t1_33 + (0.10941644012928009) * gru_0_out_t1_34 + (-0.091142937541007996) * gru_0_out_t1_35 + (-0.95818966627120972) * gru_0_out_t1_36 + (0.065427981317043304) * gru_0_out_t1_37 + (0.23410408198833466) * gru_0_out_t1_38 + (0.55235308408737183) * gru_0_out_t1_39 + (0.91209077835083008) * gru_0_out_t1_40 + (0.051325671374797821) * gru_0_out_t1_41 + (-0.38183653354644775) * gru_0_out_t1_42 + (-0.53851932287216187) * gru_0_out_t1_43 + (0.15073877573013306) * gru_0_out_t1_44 + (0.11819285899400711) * gru_0_out_t1_45 + (-0.2157491147518158) * gru_0_out_t1_46 + (0.50161665678024292) * gru_0_out_t1_47 + (0.34651455283164978) * gru_0_out_t1_48 + (-0.49277818202972412) * gru_0_out_t1_49 + (0.020954851061105728) * gru_0_out_t1_50 + (0.020804468542337418) * gru_0_out_t1_51 + (-0.049971658736467361) * gru_0_out_t1_52 + (-0.0059814448468387127) * gru_0_out_t1_53 + (0.17260503768920898) * gru_0_out_t1_54 + (-0.1163136214017868) * gru_0_out_t1_55 + (0.48281118273735046) * gru_0_out_t1_56 + (-0.31399655342102051) * gru_0_out_t1_57 + (0.32108935713768005) * gru_0_out_t1_58 + (0.39556977152824402) * gru_0_out_t1_59 + (0.13550055027008057) * gru_0_out_t1_60 + (0.26093286275863647) * gru_0_out_t1_61 + (-0.047188568860292435) * gru_0_out_t1_62 + (-0.43597352504730225) * gru_0_out_t1_63 + (0.63402175903320312) * gru_1_rev_t2_h_0 + (-0.75626897811889648) * gru_1_rev_t2_h_1 + (0.47654172778129578) * gru_1_rev_t2_h_2 + (0.20966456830501556) * gru_1_rev_t2_h_3 + (-0.46073612570762634) * gru_1_rev_t2_h_4 + (0.82701760530471802) * gru_1_rev_t2_h_5 + (0.68125182390213013) * gru_1_rev_t2_h_6 + (-0.13182029128074646) * gru_1_rev_t2_h_7 + (0.66373544931411743) * gru_1_rev_t2_h_8 + (0.44698655605316162) * gru_1_rev_t2_h_9 + (1.0451512336730957) * gru_1_rev_t2_h_10 + (-1.4969738721847534) * gru_1_rev_t2_h_11 + (-0.23423154652118683) * gru_1_rev_t2_h_12 + (0.18541623651981354) * gru_1_rev_t2_h_13 + (0.044841296970844269) * gru_1_rev_t2_h_14 + (1.4394901990890503) * gru_1_rev_t2_h_15 + (0.96798050403594971) * gru_1_rev_t2_h_16 + (0.3353537917137146) * gru_1_rev_t2_h_17 + (-0.018812963739037514) * gru_1_rev_t2_h_18 + (-0.30800029635429382) * gru_1_rev_t2_h_19 + (0.60540133714675903) * gru_1_rev_t2_h_20 + (-0.42648041248321533) * gru_1_rev_t2_h_21 + (-1.2718510627746582) * gru_1_rev_t2_h_22 + (0.66983062028884888) * gru_1_rev_t2_h_23 + (-0.36984339356422424) * gru_1_rev_t2_h_24 + (-0.6824108362197876) * gru_1_rev_t2_h_25 + (-0.17256252467632294) * gru_1_rev_t2_h_26 + (-0.19305828213691711) * gru_1_rev_t2_h_27 + (-0.83201181888580322) * gru_1_rev_t2_h_28 + (-0.5386207103729248) * gru_1_rev_t2_h_29 + (0.045245654881000519) * gru_1_rev_t2_h_30 + (-0.20905523002147675) * gru_1_rev_t2_h_31);
    gate_n = tanh((-0.055888228118419647) + (0.23970018327236176) * gru_0_out_t1_0 + (0.72848016023635864) * gru_0_out_t1_1 + (-0.29254448413848877) * gru_0_out_t1_2 + (-0.23698987066745758) * gru_0_out_t1_3 + (0.425127774477005) * gru_0_out_t1_4 + (0.25611427426338196) * gru_0_out_t1_5 + (-0.67846304178237915) * gru_0_out_t1_6 + (0.97954642772674561) * gru_0_out_t1_7 + (-0.054137270897626877) * gru_0_out_t1_8 + (0.0038908200804144144) * gru_0_out_t1_9 + (0.13408327102661133) * gru_0_out_t1_10 + (-0.083344228565692902) * gru_0_out_t1_11 + (-0.70605957508087158) * gru_0_out_t1_12 + (-0.47657063603401184) * gru_0_out_t1_13 + (0.063094824552536011) * gru_0_out_t1_14 + (-0.19434286653995514) * gru_0_out_t1_15 + (0.40125066041946411) * gru_0_out_t1_16 + (0.084499813616275787) * gru_0_out_t1_17 + (0.28462466597557068) * gru_0_out_t1_18 + (-0.038473214954137802) * gru_0_out_t1_19 + (0.32616430521011353) * gru_0_out_t1_20 + (1.8178490400314331) * gru_0_out_t1_21 + (-0.74116021394729614) * gru_0_out_t1_22 + (-0.76459687948226929) * gru_0_out_t1_23 + (-0.20578932762145996) * gru_0_out_t1_24 + (-0.25766286253929138) * gru_0_out_t1_25 + (0.076891243457794189) * gru_0_out_t1_26 + (-0.42391479015350342) * gru_0_out_t1_27 + (0.28550750017166138) * gru_0_out_t1_28 + (0.53601294755935669) * gru_0_out_t1_29 + (-0.53732484579086304) * gru_0_out_t1_30 + (-0.37314251065254211) * gru_0_out_t1_31 + (-0.22411236166954041) * gru_0_out_t1_32 + (-0.089037522673606873) * gru_0_out_t1_33 + (0.19442380964756012) * gru_0_out_t1_34 + (-0.5298306941986084) * gru_0_out_t1_35 + (-0.059884153306484222) * gru_0_out_t1_36 + (-0.093729913234710693) * gru_0_out_t1_37 + (0.45952439308166504) * gru_0_out_t1_38 + (-1.5024527311325073) * gru_0_out_t1_39 + (1.6420607566833496) * gru_0_out_t1_40 + (-0.54342484474182129) * gru_0_out_t1_41 + (-1.8958513736724854) * gru_0_out_t1_42 + (-0.29252675175666809) * gru_0_out_t1_43 + (-0.43946880102157593) * gru_0_out_t1_44 + (-0.13999417424201965) * gru_0_out_t1_45 + (-0.44499897956848145) * gru_0_out_t1_46 + (0.056745186448097229) * gru_0_out_t1_47 + (-0.15355624258518219) * gru_0_out_t1_48 + (0.30705609917640686) * gru_0_out_t1_49 + (0.24390937387943268) * gru_0_out_t1_50 + (-0.056140400469303131) * gru_0_out_t1_51 + (0.38696497678756714) * gru_0_out_t1_52 + (0.058019809424877167) * gru_0_out_t1_53 + (0.89175838232040405) * gru_0_out_t1_54 + (-0.43426719307899475) * gru_0_out_t1_55 + (0.0070846611633896828) * gru_0_out_t1_56 + (0.2888144850730896) * gru_0_out_t1_57 + (0.11952608823776245) * gru_0_out_t1_58 + (0.49300023913383484) * gru_0_out_t1_59 + (0.030797075480222702) * gru_0_out_t1_60 + (0.71325129270553589) * gru_0_out_t1_61 + (0.18240049481391907) * gru_0_out_t1_62 + (0.68815410137176514) * gru_0_out_t1_63 + gate_r * ((0.1124502569437027) + (0.91907906532287598) * gru_1_rev_t2_h_0 + (0.079965531826019287) * gru_1_rev_t2_h_1 + (-0.13280303776264191) * gru_1_rev_t2_h_2 + (-0.12755826115608215) * gru_1_rev_t2_h_3 + (0.039959870278835297) * gru_1_rev_t2_h_4 + (0.38225078582763672) * gru_1_rev_t2_h_5 + (-0.31974899768829346) * gru_1_rev_t2_h_6 + (0.33341753482818604) * gru_1_rev_t2_h_7 + (0.79510176181793213) * gru_1_rev_t2_h_8 + (-0.20803791284561157) * gru_1_rev_t2_h_9 + (0.14263549447059631) * gru_1_rev_t2_h_10 + (-0.72649663686752319) * gru_1_rev_t2_h_11 + (0.16472034156322479) * gru_1_rev_t2_h_12 + (0.71067821979522705) * gru_1_rev_t2_h_13 + (-0.15214067697525024) * gru_1_rev_t2_h_14 + (-0.52577924728393555) * gru_1_rev_t2_h_15 + (0.17004294693470001) * gru_1_rev_t2_h_16 + (-0.10250711441040039) * gru_1_rev_t2_h_17 + (-0.93992489576339722) * gru_1_rev_t2_h_18 + (0.35368472337722778) * gru_1_rev_t2_h_19 + (-0.72099339962005615) * gru_1_rev_t2_h_20 + (0.015863260254263878) * gru_1_rev_t2_h_21 + (-0.92760348320007324) * gru_1_rev_t2_h_22 + (-1.0257201194763184) * gru_1_rev_t2_h_23 + (0.47216174006462097) * gru_1_rev_t2_h_24 + (-0.19633348286151886) * gru_1_rev_t2_h_25 + (-0.7544480562210083) * gru_1_rev_t2_h_26 + (-0.29674288630485535) * gru_1_rev_t2_h_27 + (0.7170296311378479) * gru_1_rev_t2_h_28 + (-0.14809201657772064) * gru_1_rev_t2_h_29 + (0.3736051619052887) * gru_1_rev_t2_h_30 + (0.32075369358062744) * gru_1_rev_t2_h_31));
    gru_1_rev_t1_h_27 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t2_h_27;
    // h=28
    gate_r = sigmoid((0.38495266437530518) + (0.24517485499382019) * gru_0_out_t1_0 + (0.43384209275245667) * gru_0_out_t1_1 + (-0.34521183371543884) * gru_0_out_t1_2 + (-1.2785024642944336) * gru_0_out_t1_3 + (0.035775329917669296) * gru_0_out_t1_4 + (1.533103346824646) * gru_0_out_t1_5 + (0.8216392993927002) * gru_0_out_t1_6 + (1.3818939924240112) * gru_0_out_t1_7 + (0.062483824789524078) * gru_0_out_t1_8 + (2.6988174915313721) * gru_0_out_t1_9 + (0.17467106878757477) * gru_0_out_t1_10 + (0.012607855722308159) * gru_0_out_t1_11 + (-0.37592044472694397) * gru_0_out_t1_12 + (0.67778301239013672) * gru_0_out_t1_13 + (0.22810263931751251) * gru_0_out_t1_14 + (0.020402560010552406) * gru_0_out_t1_15 + (-0.080984756350517273) * gru_0_out_t1_16 + (0.36288097500801086) * gru_0_out_t1_17 + (-1.7684946060180664) * gru_0_out_t1_18 + (0.98190796375274658) * gru_0_out_t1_19 + (6.2056088447570801) * gru_0_out_t1_20 + (-0.059406399726867676) * gru_0_out_t1_21 + (-1.1386468410491943) * gru_0_out_t1_22 + (-0.16445112228393555) * gru_0_out_t1_23 + (7.9238858222961426) * gru_0_out_t1_24 + (0.38441357016563416) * gru_0_out_t1_25 + (-1.3391866683959961) * gru_0_out_t1_26 + (-0.23772802948951721) * gru_0_out_t1_27 + (-1.93971848487854) * gru_0_out_t1_28 + (2.1419475078582764) * gru_0_out_t1_29 + (0.1390129029750824) * gru_0_out_t1_30 + (-3.8627009391784668) * gru_0_out_t1_31 + (-0.67508494853973389) * gru_0_out_t1_32 + (-0.61689096689224243) * gru_0_out_t1_33 + (-0.76469635963439941) * gru_0_out_t1_34 + (0.73646599054336548) * gru_0_out_t1_35 + (-1.7570983171463013) * gru_0_out_t1_36 + (0.4429442286491394) * gru_0_out_t1_37 + (1.2157485485076904) * gru_0_out_t1_38 + (-0.48993882536888123) * gru_0_out_t1_39 + (-0.52398854494094849) * gru_0_out_t1_40 + (-0.1198851466178894) * gru_0_out_t1_41 + (1.7073931694030762) * gru_0_out_t1_42 + (-2.0276443958282471) * gru_0_out_t1_43 + (0.48097479343414307) * gru_0_out_t1_44 + (0.78069180250167847) * gru_0_out_t1_45 + (-0.82747107744216919) * gru_0_out_t1_46 + (0.52049124240875244) * gru_0_out_t1_47 + (1.7230833768844604) * gru_0_out_t1_48 + (-2.0977826118469238) * gru_0_out_t1_49 + (-0.58418577909469604) * gru_0_out_t1_50 + (2.037954568862915) * gru_0_out_t1_51 + (1.6894580125808716) * gru_0_out_t1_52 + (-0.11226963996887207) * gru_0_out_t1_53 + (-0.389029860496521) * gru_0_out_t1_54 + (-1.1335253715515137) * gru_0_out_t1_55 + (1.8562434911727905) * gru_0_out_t1_56 + (-1.3597702980041504) * gru_0_out_t1_57 + (-0.42686748504638672) * gru_0_out_t1_58 + (1.4028137922286987) * gru_0_out_t1_59 + (0.056015219539403915) * gru_0_out_t1_60 + (-0.085880830883979797) * gru_0_out_t1_61 + (0.036875121295452118) * gru_0_out_t1_62 + (-0.16856873035430908) * gru_0_out_t1_63 + (-0.58184975385665894) * gru_1_rev_t2_h_0 + (-0.24159583449363708) * gru_1_rev_t2_h_1 + (-0.10429973155260086) * gru_1_rev_t2_h_2 + (1.1584887504577637) * gru_1_rev_t2_h_3 + (-0.041181370615959167) * gru_1_rev_t2_h_4 + (-0.94562143087387085) * gru_1_rev_t2_h_5 + (-0.28043583035469055) * gru_1_rev_t2_h_6 + (0.60273563861846924) * gru_1_rev_t2_h_7 + (0.040203079581260681) * gru_1_rev_t2_h_8 + (0.13992607593536377) * gru_1_rev_t2_h_9 + (-0.52868258953094482) * gru_1_rev_t2_h_10 + (-3.9927210807800293) * gru_1_rev_t2_h_11 + (0.10332739353179932) * gru_1_rev_t2_h_12 + (-3.7586183547973633) * gru_1_rev_t2_h_13 + (2.1682198047637939) * gru_1_rev_t2_h_14 + (0.70560294389724731) * gru_1_rev_t2_h_15 + (1.6283551454544067) * gru_1_rev_t2_h_16 + (-2.4343774318695068) * gru_1_rev_t2_h_17 + (0.98010694980621338) * gru_1_rev_t2_h_18 + (-0.40035763382911682) * gru_1_rev_t2_h_19 + (-0.51121455430984497) * gru_1_rev_t2_h_20 + (0.33723956346511841) * gru_1_rev_t2_h_21 + (-0.74957460165023804) * gru_1_rev_t2_h_22 + (-0.82415205240249634) * gru_1_rev_t2_h_23 + (-1.5612708330154419) * gru_1_rev_t2_h_24 + (-0.066470667719841003) * gru_1_rev_t2_h_25 + (-0.27123963832855225) * gru_1_rev_t2_h_26 + (-1.5565893650054932) * gru_1_rev_t2_h_27 + (-3.0803158283233643) * gru_1_rev_t2_h_28 + (-0.22295172512531281) * gru_1_rev_t2_h_29 + (-1.6278361082077026) * gru_1_rev_t2_h_30 + (-0.10600800067186356) * gru_1_rev_t2_h_31);
    gate_z = sigmoid((1.1635242700576782) + (0.46526461839675903) * gru_0_out_t1_0 + (-0.77334088087081909) * gru_0_out_t1_1 + (0.2253769189119339) * gru_0_out_t1_2 + (0.21902711689472198) * gru_0_out_t1_3 + (-0.0098206829279661179) * gru_0_out_t1_4 + (0.67492413520812988) * gru_0_out_t1_5 + (2.2120251655578613) * gru_0_out_t1_6 + (0.39467531442642212) * gru_0_out_t1_7 + (-0.092816315591335297) * gru_0_out_t1_8 + (0.16426098346710205) * gru_0_out_t1_9 + (0.81289893388748169) * gru_0_out_t1_10 + (0.79923534393310547) * gru_0_out_t1_11 + (-0.30268985033035278) * gru_0_out_t1_12 + (0.8558616042137146) * gru_0_out_t1_13 + (0.024393109604716301) * gru_0_out_t1_14 + (0.33802351355552673) * gru_0_out_t1_15 + (-0.30856144428253174) * gru_0_out_t1_16 + (-0.042766209691762924) * gru_0_out_t1_17 + (0.42629185318946838) * gru_0_out_t1_18 + (-3.1004993915557861) * gru_0_out_t1_19 + (0.02336634136736393) * gru_0_out_t1_20 + (-0.28578871488571167) * gru_0_out_t1_21 + (-0.22589519619941711) * gru_0_out_t1_22 + (-0.51130688190460205) * gru_0_out_t1_23 + (-0.4282987117767334) * gru_0_out_t1_24 + (0.39199721813201904) * gru_0_out_t1_25 + (0.18464250862598419) * gru_0_out_t1_26 + (-0.3822171688079834) * gru_0_out_t1_27 + (-0.79789787530899048) * gru_0_out_t1_28 + (-0.090598195791244507) * gru_0_out_t1_29 + (0.049423504620790482) * gru_0_out_t1_30 + (0.48325544595718384) * gru_0_out_t1_31 + (-0.071516074240207672) * gru_0_out_t1_32 + (0.8024824857711792) * gru_0_out_t1_33 + (0.29999503493309021) * gru_0_out_t1_34 + (0.32240206003189087) * gru_0_out_t1_35 + (0.11254841834306717) * gru_0_out_t1_36 + (0.74355006217956543) * gru_0_out_t1_37 + (-0.84019660949707031) * gru_0_out_t1_38 + (-0.10382818430662155) * gru_0_out_t1_39 + (0.19603891670703888) * gru_0_out_t1_40 + (-0.55069816112518311) * gru_0_out_t1_41 + (0.85013920068740845) * gru_0_out_t1_42 + (-0.67944049835205078) * gru_0_out_t1_43 + (0.49380853772163391) * gru_0_out_t1_44 + (0.14678692817687988) * gru_0_out_t1_45 + (0.40708866715431213) * gru_0_out_t1_46 + (-0.53360497951507568) * gru_0_out_t1_47 + (0.56696707010269165) * gru_0_out_t1_48 + (-0.75680959224700928) * gru_0_out_t1_49 + (-0.41956266760826111) * gru_0_out_t1_50 + (-0.10296233743429184) * gru_0_out_t1_51 + (0.65534496307373047) * gru_0_out_t1_52 + (0.19792743027210236) * gru_0_out_t1_53 + (-2.5934839248657227) * gru_0_out_t1_54 + (0.67565196752548218) * gru_0_out_t1_55 + (1.0444697141647339) * gru_0_out_t1_56 + (-0.78978055715560913) * gru_0_out_t1_57 + (1.1348870992660522) * gru_0_out_t1_58 + (1.1408712863922119) * gru_0_out_t1_59 + (0.0054184896871447563) * gru_0_out_t1_60 + (0.4826195240020752) * gru_0_out_t1_61 + (0.55679649114608765) * gru_0_out_t1_62 + (-0.30835694074630737) * gru_0_out_t1_63 + (-0.7360953688621521) * gru_1_rev_t2_h_0 + (-0.97027468681335449) * gru_1_rev_t2_h_1 + (1.4197783470153809) * gru_1_rev_t2_h_2 + (-1.1104809045791626) * gru_1_rev_t2_h_3 + (-0.11571197211742401) * gru_1_rev_t2_h_4 + (-1.0672018527984619) * gru_1_rev_t2_h_5 + (0.43117493391036987) * gru_1_rev_t2_h_6 + (0.019311966374516487) * gru_1_rev_t2_h_7 + (0.32989013195037842) * gru_1_rev_t2_h_8 + (-0.024389205500483513) * gru_1_rev_t2_h_9 + (-0.58137071132659912) * gru_1_rev_t2_h_10 + (-0.064952842891216278) * gru_1_rev_t2_h_11 + (0.16863101720809937) * gru_1_rev_t2_h_12 + (-1.7389678955078125) * gru_1_rev_t2_h_13 + (0.40751448273658752) * gru_1_rev_t2_h_14 + (0.90026932954788208) * gru_1_rev_t2_h_15 + (0.37842351198196411) * gru_1_rev_t2_h_16 + (-0.71322733163833618) * gru_1_rev_t2_h_17 + (-0.12247438728809357) * gru_1_rev_t2_h_18 + (0.65992963314056396) * gru_1_rev_t2_h_19 + (-0.28519454598426819) * gru_1_rev_t2_h_20 + (-0.34817719459533691) * gru_1_rev_t2_h_21 + (0.58168977499008179) * gru_1_rev_t2_h_22 + (-0.26330697536468506) * gru_1_rev_t2_h_23 + (-0.72273576259613037) * gru_1_rev_t2_h_24 + (-0.49771633744239807) * gru_1_rev_t2_h_25 + (-0.14488427340984344) * gru_1_rev_t2_h_26 + (-1.3244274854660034) * gru_1_rev_t2_h_27 + (-0.033292792737483978) * gru_1_rev_t2_h_28 + (-0.33947205543518066) * gru_1_rev_t2_h_29 + (-1.0981553792953491) * gru_1_rev_t2_h_30 + (-0.48396068811416626) * gru_1_rev_t2_h_31);
    gate_n = tanh((-0.14081251621246338) + (-0.47017627954483032) * gru_0_out_t1_0 + (0.28686550259590149) * gru_0_out_t1_1 + (0.19199033081531525) * gru_0_out_t1_2 + (0.28524833917617798) * gru_0_out_t1_3 + (0.20275498926639557) * gru_0_out_t1_4 + (0.30021563172340393) * gru_0_out_t1_5 + (-0.21653261780738831) * gru_0_out_t1_6 + (-0.15130066871643066) * gru_0_out_t1_7 + (0.089408949017524719) * gru_0_out_t1_8 + (-0.12699039280414581) * gru_0_out_t1_9 + (-0.98048233985900879) * gru_0_out_t1_10 + (-0.69065117835998535) * gru_0_out_t1_11 + (0.022636350244283676) * gru_0_out_t1_12 + (0.32052695751190186) * gru_0_out_t1_13 + (0.12180080264806747) * gru_0_out_t1_14 + (-0.035740692168474197) * gru_0_out_t1_15 + (0.12505139410495758) * gru_0_out_t1_16 + (0.051997914910316467) * gru_0_out_t1_17 + (0.52506595849990845) * gru_0_out_t1_18 + (0.56566125154495239) * gru_0_out_t1_19 + (0.015629788860678673) * gru_0_out_t1_20 + (0.053177043795585632) * gru_0_out_t1_21 + (-0.71265530586242676) * gru_0_out_t1_22 + (0.068835131824016571) * gru_0_out_t1_23 + (-0.18199162185192108) * gru_0_out_t1_24 + (-0.34626057744026184) * gru_0_out_t1_25 + (0.99873358011245728) * gru_0_out_t1_26 + (1.1697840690612793) * gru_0_out_t1_27 + (-0.42925849556922913) * gru_0_out_t1_28 + (-0.52829694747924805) * gru_0_out_t1_29 + (0.15616248548030853) * gru_0_out_t1_30 + (3.4068710803985596) * gru_0_out_t1_31 + (-0.41775748133659363) * gru_0_out_t1_32 + (-0.03997354581952095) * gru_0_out_t1_33 + (-0.48278787732124329) * gru_0_out_t1_34 + (-0.001750736148096621) * gru_0_out_t1_35 + (0.099546864628791809) * gru_0_out_t1_36 + (-0.054956115782260895) * gru_0_out_t1_37 + (0.50001817941665649) * gru_0_out_t1_38 + (0.38631236553192139) * gru_0_out_t1_39 + (-0.71737629175186157) * gru_0_out_t1_40 + (-0.04780496284365654) * gru_0_out_t1_41 + (1.1841582059860229) * gru_0_out_t1_42 + (0.25365343689918518) * gru_0_out_t1_43 + (-0.34332820773124695) * gru_0_out_t1_44 + (-0.16847324371337891) * gru_0_out_t1_45 + (0.73368000984191895) * gru_0_out_t1_46 + (-0.043232418596744537) * gru_0_out_t1_47 + (0.11815484613180161) * gru_0_out_t1_48 + (0.089505836367607117) * gru_0_out_t1_49 + (-0.24156701564788818) * gru_0_out_t1_50 + (-0.71883511543273926) * gru_0_out_t1_51 + (0.18286909162998199) * gru_0_out_t1_52 + (0.32831746339797974) * gru_0_out_t1_53 + (0.48485705256462097) * gru_0_out_t1_54 + (0.35323235392570496) * gru_0_out_t1_55 + (0.34469249844551086) * gru_0_out_t1_56 + (0.0038158309180289507) * gru_0_out_t1_57 + (0.84813112020492554) * gru_0_out_t1_58 + (-0.16826142370700836) * gru_0_out_t1_59 + (-0.51322788000106812) * gru_0_out_t1_60 + (0.12121559679508209) * gru_0_out_t1_61 + (-0.12166905403137207) * gru_0_out_t1_62 + (-0.33865022659301758) * gru_0_out_t1_63 + gate_r * ((-0.2034243643283844) + (-1.1063227653503418) * gru_1_rev_t2_h_0 + (-0.32183822989463806) * gru_1_rev_t2_h_1 + (-1.2291498184204102) * gru_1_rev_t2_h_2 + (1.8931022882461548) * gru_1_rev_t2_h_3 + (0.20090490579605103) * gru_1_rev_t2_h_4 + (-0.085786297917366028) * gru_1_rev_t2_h_5 + (0.16120660305023193) * gru_1_rev_t2_h_6 + (-0.10673391073942184) * gru_1_rev_t2_h_7 + (0.60725301504135132) * gru_1_rev_t2_h_8 + (-0.17193767428398132) * gru_1_rev_t2_h_9 + (1.3786369562149048) * gru_1_rev_t2_h_10 + (0.024405146017670631) * gru_1_rev_t2_h_11 + (0.69248580932617188) * gru_1_rev_t2_h_12 + (2.2421188354492188) * gru_1_rev_t2_h_13 + (-0.037626076489686966) * gru_1_rev_t2_h_14 + (1.1333873271942139) * gru_1_rev_t2_h_15 + (1.3318691253662109) * gru_1_rev_t2_h_16 + (-0.57494169473648071) * gru_1_rev_t2_h_17 + (0.4663064181804657) * gru_1_rev_t2_h_18 + (-0.91170614957809448) * gru_1_rev_t2_h_19 + (-0.10510260611772537) * gru_1_rev_t2_h_20 + (-0.18323059380054474) * gru_1_rev_t2_h_21 + (1.025905966758728) * gru_1_rev_t2_h_22 + (-0.37681496143341064) * gru_1_rev_t2_h_23 + (-2.5587248802185059) * gru_1_rev_t2_h_24 + (0.60318535566329956) * gru_1_rev_t2_h_25 + (0.090684302151203156) * gru_1_rev_t2_h_26 + (-0.81764441728591919) * gru_1_rev_t2_h_27 + (-0.75473809242248535) * gru_1_rev_t2_h_28 + (-0.4670332670211792) * gru_1_rev_t2_h_29 + (0.08533032238483429) * gru_1_rev_t2_h_30 + (-1.1759481430053711) * gru_1_rev_t2_h_31));
    gru_1_rev_t1_h_28 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t2_h_28;
    // h=29
    gate_r = sigmoid((0.21502673625946045) + (-0.40601328015327454) * gru_0_out_t1_0 + (-0.097969777882099152) * gru_0_out_t1_1 + (0.85871726274490356) * gru_0_out_t1_2 + (-0.92955589294433594) * gru_0_out_t1_3 + (0.29914548993110657) * gru_0_out_t1_4 + (-0.57047760486602783) * gru_0_out_t1_5 + (-0.28610458970069885) * gru_0_out_t1_6 + (0.14064958691596985) * gru_0_out_t1_7 + (-1.1372116804122925) * gru_0_out_t1_8 + (1.0613241195678711) * gru_0_out_t1_9 + (-0.35227525234222412) * gru_0_out_t1_10 + (0.057069137692451477) * gru_0_out_t1_11 + (-0.25985458493232727) * gru_0_out_t1_12 + (0.079464465379714966) * gru_0_out_t1_13 + (-0.18415048718452454) * gru_0_out_t1_14 + (0.25093847513198853) * gru_0_out_t1_15 + (0.25747931003570557) * gru_0_out_t1_16 + (0.47546640038490295) * gru_0_out_t1_17 + (-0.31340852379798889) * gru_0_out_t1_18 + (1.1860820055007935) * gru_0_out_t1_19 + (0.44891336560249329) * gru_0_out_t1_20 + (-1.8879481554031372) * gru_0_out_t1_21 + (0.48409256339073181) * gru_0_out_t1_22 + (1.247367262840271) * gru_0_out_t1_23 + (0.029521184042096138) * gru_0_out_t1_24 + (0.15670068562030792) * gru_0_out_t1_25 + (-0.60761308670043945) * gru_0_out_t1_26 + (0.071603260934352875) * gru_0_out_t1_27 + (0.00053122371900826693) * gru_0_out_t1_28 + (0.42420899868011475) * gru_0_out_t1_29 + (0.20991963148117065) * gru_0_out_t1_30 + (0.049920126795768738) * gru_0_out_t1_31 + (-0.46352711319923401) * gru_0_out_t1_32 + (0.056479267776012421) * gru_0_out_t1_33 + (-0.10843802988529205) * gru_0_out_t1_34 + (0.21591271460056305) * gru_0_out_t1_35 + (0.073450095951557159) * gru_0_out_t1_36 + (-0.099546909332275391) * gru_0_out_t1_37 + (0.70637184381484985) * gru_0_out_t1_38 + (1.2784665822982788) * gru_0_out_t1_39 + (-2.2752499580383301) * gru_0_out_t1_40 + (0.33130553364753723) * gru_0_out_t1_41 + (0.79199206829071045) * gru_0_out_t1_42 + (0.23844544589519501) * gru_0_out_t1_43 + (-0.33926782011985779) * gru_0_out_t1_44 + (-0.22002914547920227) * gru_0_out_t1_45 + (1.2905511856079102) * gru_0_out_t1_46 + (-0.0076114586554467678) * gru_0_out_t1_47 + (0.057363107800483704) * gru_0_out_t1_48 + (-0.091546513140201569) * gru_0_out_t1_49 + (-1.2490360736846924) * gru_0_out_t1_50 + (0.50319486856460571) * gru_0_out_t1_51 + (0.51193273067474365) * gru_0_out_t1_52 + (-0.16754555702209473) * gru_0_out_t1_53 + (-0.49089622497558594) * gru_0_out_t1_54 + (0.63296902179718018) * gru_0_out_t1_55 + (1.4065903425216675) * gru_0_out_t1_56 + (-0.23820261657238007) * gru_0_out_t1_57 + (0.92519271373748779) * gru_0_out_t1_58 + (-0.59376132488250732) * gru_0_out_t1_59 + (1.3284118175506592) * gru_0_out_t1_60 + (-0.0095832860097289085) * gru_0_out_t1_61 + (0.7741013765335083) * gru_0_out_t1_62 + (-0.98127859830856323) * gru_0_out_t1_63 + (-0.49192506074905396) * gru_1_rev_t2_h_0 + (-2.0870704650878906) * gru_1_rev_t2_h_1 + (1.6191780567169189) * gru_1_rev_t2_h_2 + (-0.39195474982261658) * gru_1_rev_t2_h_3 + (0.74324136972427368) * gru_1_rev_t2_h_4 + (-0.050907514989376068) * gru_1_rev_t2_h_5 + (2.1409423351287842) * gru_1_rev_t2_h_6 + (0.7336389422416687) * gru_1_rev_t2_h_7 + (-0.48771172761917114) * gru_1_rev_t2_h_8 + (1.1810534000396729) * gru_1_rev_t2_h_9 + (-1.9674804210662842) * gru_1_rev_t2_h_10 + (-0.34298443794250488) * gru_1_rev_t2_h_11 + (-0.70673763751983643) * gru_1_rev_t2_h_12 + (-1.1082148551940918) * gru_1_rev_t2_h_13 + (-0.52169942855834961) * gru_1_rev_t2_h_14 + (0.35327443480491638) * gru_1_rev_t2_h_15 + (-0.30773234367370605) * gru_1_rev_t2_h_16 + (0.90633076429367065) * gru_1_rev_t2_h_17 + (-0.45464670658111572) * gru_1_rev_t2_h_18 + (1.9996049404144287) * gru_1_rev_t2_h_19 + (0.74124324321746826) * gru_1_rev_t2_h_20 + (0.42983216047286987) * gru_1_rev_t2_h_21 + (-0.067735128104686737) * gru_1_rev_t2_h_22 + (-1.5534031391143799) * gru_1_rev_t2_h_23 + (-1.7254632711410522) * gru_1_rev_t2_h_24 + (0.20811846852302551) * gru_1_rev_t2_h_25 + (-1.3834332227706909) * gru_1_rev_t2_h_26 + (-1.0439707040786743) * gru_1_rev_t2_h_27 + (-1.970583438873291) * gru_1_rev_t2_h_28 + (-0.14200207591056824) * gru_1_rev_t2_h_29 + (-0.06939367949962616) * gru_1_rev_t2_h_30 + (-0.74878323078155518) * gru_1_rev_t2_h_31);
    gate_z = sigmoid((0.67309153079986572) + (0.10259202122688293) * gru_0_out_t1_0 + (-1.2646406888961792) * gru_0_out_t1_1 + (-2.1121339797973633) * gru_0_out_t1_2 + (-0.94939643144607544) * gru_0_out_t1_3 + (-0.49155789613723755) * gru_0_out_t1_4 + (-0.36567530035972595) * gru_0_out_t1_5 + (1.8015072345733643) * gru_0_out_t1_6 + (1.9041053056716919) * gru_0_out_t1_7 + (-0.20589712262153625) * gru_0_out_t1_8 + (-0.35524085164070129) * gru_0_out_t1_9 + (1.8606294393539429) * gru_0_out_t1_10 + (0.27462002635002136) * gru_0_out_t1_11 + (0.2128472775220871) * gru_0_out_t1_12 + (1.4536436796188354) * gru_0_out_t1_13 + (0.19666635990142822) * gru_0_out_t1_14 + (-0.38700997829437256) * gru_0_out_t1_15 + (-0.58077657222747803) * gru_0_out_t1_16 + (0.20213723182678223) * gru_0_out_t1_17 + (0.18831619620323181) * gru_0_out_t1_18 + (-1.2360872030258179) * gru_0_out_t1_19 + (-0.6745726466178894) * gru_0_out_t1_20 + (-1.1088112592697144) * gru_0_out_t1_21 + (0.51919955015182495) * gru_0_out_t1_22 + (1.437946081161499) * gru_0_out_t1_23 + (1.045720100402832) * gru_0_out_t1_24 + (-0.91910123825073242) * gru_0_out_t1_25 + (0.36706012487411499) * gru_0_out_t1_26 + (-0.27880692481994629) * gru_0_out_t1_27 + (-1.3676548004150391) * gru_0_out_t1_28 + (0.050083544105291367) * gru_0_out_t1_29 + (0.37140136957168579) * gru_0_out_t1_30 + (-1.6930934190750122) * gru_0_out_t1_31 + (0.23962110280990601) * gru_0_out_t1_32 + (0.25832691788673401) * gru_0_out_t1_33 + (-0.18632183969020844) * gru_0_out_t1_34 + (0.61712646484375) * gru_0_out_t1_35 + (0.19554808735847473) * gru_0_out_t1_36 + (-0.3100319504737854) * gru_0_out_t1_37 + (-0.19524195790290833) * gru_0_out_t1_38 + (0.33865600824356079) * gru_0_out_t1_39 + (2.5612778663635254) * gru_0_out_t1_40 + (0.061614066362380981) * gru_0_out_t1_41 + (-0.88045042753219604) * gru_0_out_t1_42 + (-0.196710005402565) * gru_0_out_t1_43 + (0.28933924436569214) * gru_0_out_t1_44 + (0.35075095295906067) * gru_0_out_t1_45 + (1.2756835222244263) * gru_0_out_t1_46 + (-0.35066723823547363) * gru_0_out_t1_47 + (0.27180531620979309) * gru_0_out_t1_48 + (0.099044241011142731) * gru_0_out_t1_49 + (-0.30049580335617065) * gru_0_out_t1_50 + (-0.20073506236076355) * gru_0_out_t1_51 + (-0.0014667947543784976) * gru_0_out_t1_52 + (0.58066356182098389) * gru_0_out_t1_53 + (0.22076267004013062) * gru_0_out_t1_54 + (0.90588110685348511) * gru_0_out_t1_55 + (0.62073498964309692) * gru_0_out_t1_56 + (-0.21829333901405334) * gru_0_out_t1_57 + (-0.42463773488998413) * gru_0_out_t1_58 + (0.11085380613803864) * gru_0_out_t1_59 + (0.17097228765487671) * gru_0_out_t1_60 + (1.7246203422546387) * gru_0_out_t1_61 + (0.87537813186645508) * gru_0_out_t1_62 + (1.7468832731246948) * gru_0_out_t1_63 + (0.19721262156963348) * gru_1_rev_t2_h_0 + (0.027827989310026169) * gru_1_rev_t2_h_1 + (-0.42645111680030823) * gru_1_rev_t2_h_2 + (0.79313915967941284) * gru_1_rev_t2_h_3 + (-0.6901431679725647) * gru_1_rev_t2_h_4 + (-0.62386375665664673) * gru_1_rev_t2_h_5 + (-0.073467567563056946) * gru_1_rev_t2_h_6 + (-0.46225538849830627) * gru_1_rev_t2_h_7 + (-0.29394426941871643) * gru_1_rev_t2_h_8 + (-0.14954963326454163) * gru_1_rev_t2_h_9 + (0.15387395024299622) * gru_1_rev_t2_h_10 + (0.50252634286880493) * gru_1_rev_t2_h_11 + (0.038032669574022293) * gru_1_rev_t2_h_12 + (-0.24083791673183441) * gru_1_rev_t2_h_13 + (0.33005350828170776) * gru_1_rev_t2_h_14 + (0.61342418193817139) * gru_1_rev_t2_h_15 + (1.1136883497238159) * gru_1_rev_t2_h_16 + (1.0958858728408813) * gru_1_rev_t2_h_17 + (0.31268852949142456) * gru_1_rev_t2_h_18 + (0.36710923910140991) * gru_1_rev_t2_h_19 + (-0.63343602418899536) * gru_1_rev_t2_h_20 + (0.63686668872833252) * gru_1_rev_t2_h_21 + (-0.66493654251098633) * gru_1_rev_t2_h_22 + (0.20904426276683807) * gru_1_rev_t2_h_23 + (-0.42113149166107178) * gru_1_rev_t2_h_24 + (-0.093368187546730042) * gru_1_rev_t2_h_25 + (-0.67437690496444702) * gru_1_rev_t2_h_26 + (-0.16489262878894806) * gru_1_rev_t2_h_27 + (-1.8634204864501953) * gru_1_rev_t2_h_28 + (-0.12889435887336731) * gru_1_rev_t2_h_29 + (-0.06814468652009964) * gru_1_rev_t2_h_30 + (-0.46242597699165344) * gru_1_rev_t2_h_31);
    gate_n = tanh((0.13148400187492371) + (0.048074457794427872) * gru_0_out_t1_0 + (0.24856722354888916) * gru_0_out_t1_1 + (0.69820606708526611) * gru_0_out_t1_2 + (0.53871947526931763) * gru_0_out_t1_3 + (0.39280393719673157) * gru_0_out_t1_4 + (0.13331045210361481) * gru_0_out_t1_5 + (0.93594652414321899) * gru_0_out_t1_6 + (0.16193307936191559) * gru_0_out_t1_7 + (-1.2680048942565918) * gru_0_out_t1_8 + (-1.4774447679519653) * gru_0_out_t1_9 + (-0.52730667591094971) * gru_0_out_t1_10 + (0.13553179800510406) * gru_0_out_t1_11 + (-0.38394102454185486) * gru_0_out_t1_12 + (-0.36408752202987671) * gru_0_out_t1_13 + (0.29412955045700073) * gru_0_out_t1_14 + (0.086077392101287842) * gru_0_out_t1_15 + (-0.75713753700256348) * gru_0_out_t1_16 + (-0.22336678206920624) * gru_0_out_t1_17 + (-0.19519658386707306) * gru_0_out_t1_18 + (-0.40588206052780151) * gru_0_out_t1_19 + (0.71091991662979126) * gru_0_out_t1_20 + (-2.653040885925293) * gru_0_out_t1_21 + (0.14940784871578217) * gru_0_out_t1_22 + (0.90244674682617188) * gru_0_out_t1_23 + (-0.24565620720386505) * gru_0_out_t1_24 + (-0.11145949363708496) * gru_0_out_t1_25 + (-0.38311311602592468) * gru_0_out_t1_26 + (-0.16660372912883759) * gru_0_out_t1_27 + (0.23951300978660583) * gru_0_out_t1_28 + (-0.2302229106426239) * gru_0_out_t1_29 + (-0.10545958578586578) * gru_0_out_t1_30 + (-0.21753415465354919) * gru_0_out_t1_31 + (2.3672904968261719) * gru_0_out_t1_32 + (0.56052380800247192) * gru_0_out_t1_33 + (0.41656377911567688) * gru_0_out_t1_34 + (0.40945255756378174) * gru_0_out_t1_35 + (-0.098318979144096375) * gru_0_out_t1_36 + (-0.029935693368315697) * gru_0_out_t1_37 + (-0.23717382550239563) * gru_0_out_t1_38 + (-0.72892212867736816) * gru_0_out_t1_39 + (-0.079842247068881989) * gru_0_out_t1_40 + (0.51842379570007324) * gru_0_out_t1_41 + (0.74698877334594727) * gru_0_out_t1_42 + (-0.10745317488908768) * gru_0_out_t1_43 + (0.2335120290517807) * gru_0_out_t1_44 + (0.75212275981903076) * gru_0_out_t1_45 + (-0.10143916308879852) * gru_0_out_t1_46 + (-0.89907008409500122) * gru_0_out_t1_47 + (-0.20477205514907837) * gru_0_out_t1_48 + (0.2170599102973938) * gru_0_out_t1_49 + (1.6260881423950195) * gru_0_out_t1_50 + (0.07426055520772934) * gru_0_out_t1_51 + (0.071226753294467926) * gru_0_out_t1_52 + (0.7151983380317688) * gru_0_out_t1_53 + (-0.14541825652122498) * gru_0_out_t1_54 + (-0.53475254774093628) * gru_0_out_t1_55 + (-0.46197584271430969) * gru_0_out_t1_56 + (0.022221805527806282) * gru_0_out_t1_57 + (0.13503828644752502) * gru_0_out_t1_58 + (-0.18979109823703766) * gru_0_out_t1_59 + (-0.52279984951019287) * gru_0_out_t1_60 + (-0.36309480667114258) * gru_0_out_t1_61 + (-0.012288399040699005) * gru_0_out_t1_62 + (0.51911723613739014) * gru_0_out_t1_63 + gate_r * ((0.0013588299043476582) + (0.41391938924789429) * gru_1_rev_t2_h_0 + (1.373509407043457) * gru_1_rev_t2_h_1 + (-0.75845503807067871) * gru_1_rev_t2_h_2 + (-0.95289337635040283) * gru_1_rev_t2_h_3 + (1.6584351062774658) * gru_1_rev_t2_h_4 + (0.87250512838363647) * gru_1_rev_t2_h_5 + (-2.197955846786499) * gru_1_rev_t2_h_6 + (1.0226624011993408) * gru_1_rev_t2_h_7 + (-0.26242294907569885) * gru_1_rev_t2_h_8 + (0.54375976324081421) * gru_1_rev_t2_h_9 + (-1.1838041543960571) * gru_1_rev_t2_h_10 + (0.15622860193252563) * gru_1_rev_t2_h_11 + (0.14125631749629974) * gru_1_rev_t2_h_12 + (-0.072216205298900604) * gru_1_rev_t2_h_13 + (-0.66192048788070679) * gru_1_rev_t2_h_14 + (0.27665677666664124) * gru_1_rev_t2_h_15 + (-0.73894733190536499) * gru_1_rev_t2_h_16 + (-2.0791699886322021) * gru_1_rev_t2_h_17 + (0.22185227274894714) * gru_1_rev_t2_h_18 + (-1.0337995290756226) * gru_1_rev_t2_h_19 + (-0.86358082294464111) * gru_1_rev_t2_h_20 + (2.2028462886810303) * gru_1_rev_t2_h_21 + (-0.84903222322463989) * gru_1_rev_t2_h_22 + (-0.10651569068431854) * gru_1_rev_t2_h_23 + (2.3026671409606934) * gru_1_rev_t2_h_24 + (1.8932507038116455) * gru_1_rev_t2_h_25 + (0.99576646089553833) * gru_1_rev_t2_h_26 + (0.039755295962095261) * gru_1_rev_t2_h_27 + (0.13516265153884888) * gru_1_rev_t2_h_28 + (2.1378803253173828) * gru_1_rev_t2_h_29 + (-0.48830917477607727) * gru_1_rev_t2_h_30 + (3.7675611972808838) * gru_1_rev_t2_h_31));
    gru_1_rev_t1_h_29 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t2_h_29;
    // h=30
    gate_r = sigmoid((0.85716193914413452) + (1.649543285369873) * gru_0_out_t1_0 + (0.45088303089141846) * gru_0_out_t1_1 + (-0.27718445658683777) * gru_0_out_t1_2 + (-0.61998218297958374) * gru_0_out_t1_3 + (-0.13106164336204529) * gru_0_out_t1_4 + (-0.97619658708572388) * gru_0_out_t1_5 + (3.111882209777832) * gru_0_out_t1_6 + (-0.87532556056976318) * gru_0_out_t1_7 + (-1.0475249290466309) * gru_0_out_t1_8 + (-1.3397421836853027) * gru_0_out_t1_9 + (-0.87532985210418701) * gru_0_out_t1_10 + (-0.025833267718553543) * gru_0_out_t1_11 + (1.002227783203125) * gru_0_out_t1_12 + (-2.5184757709503174) * gru_0_out_t1_13 + (1.9034723043441772) * gru_0_out_t1_14 + (-0.50497263669967651) * gru_0_out_t1_15 + (-2.0610408782958984) * gru_0_out_t1_16 + (-1.7017092704772949) * gru_0_out_t1_17 + (-0.87417680025100708) * gru_0_out_t1_18 + (1.6391714811325073) * gru_0_out_t1_19 + (0.49758973717689514) * gru_0_out_t1_20 + (-1.2953470945358276) * gru_0_out_t1_21 + (1.9915512800216675) * gru_0_out_t1_22 + (1.0057895183563232) * gru_0_out_t1_23 + (-1.0814905166625977) * gru_0_out_t1_24 + (0.17584118247032166) * gru_0_out_t1_25 + (2.9850382804870605) * gru_0_out_t1_26 + (-0.98339742422103882) * gru_0_out_t1_27 + (-1.4995357990264893) * gru_0_out_t1_28 + (1.9734455347061157) * gru_0_out_t1_29 + (0.28934454917907715) * gru_0_out_t1_30 + (6.8582983016967773) * gru_0_out_t1_31 + (-0.52590477466583252) * gru_0_out_t1_32 + (0.85930860042572021) * gru_0_out_t1_33 + (0.74450284242630005) * gru_0_out_t1_34 + (0.12054198980331421) * gru_0_out_t1_35 + (-1.8244819641113281) * gru_0_out_t1_36 + (2.277951717376709) * gru_0_out_t1_37 + (-0.68496119976043701) * gru_0_out_t1_38 + (-0.44774267077445984) * gru_0_out_t1_39 + (0.38161402940750122) * gru_0_out_t1_40 + (-0.1457248330116272) * gru_0_out_t1_41 + (-0.47726765275001526) * gru_0_out_t1_42 + (-0.96286976337432861) * gru_0_out_t1_43 + (-0.013196425512433052) * gru_0_out_t1_44 + (0.39577049016952515) * gru_0_out_t1_45 + (0.81023192405700684) * gru_0_out_t1_46 + (0.24970746040344238) * gru_0_out_t1_47 + (0.19124722480773926) * gru_0_out_t1_48 + (-0.10159099102020264) * gru_0_out_t1_49 + (-0.4481607973575592) * gru_0_out_t1_50 + (-0.62269479036331177) * gru_0_out_t1_51 + (-3.7736556529998779) * gru_0_out_t1_52 + (0.31949040293693542) * gru_0_out_t1_53 + (-0.70763826370239258) * gru_0_out_t1_54 + (-0.62920057773590088) * gru_0_out_t1_55 + (0.35399478673934937) * gru_0_out_t1_56 + (-0.0058800708502531052) * gru_0_out_t1_57 + (-0.32260569930076599) * gru_0_out_t1_58 + (0.65387481451034546) * gru_0_out_t1_59 + (-0.63343489170074463) * gru_0_out_t1_60 + (0.14838977158069611) * gru_0_out_t1_61 + (0.50209051370620728) * gru_0_out_t1_62 + (0.10247036814689636) * gru_0_out_t1_63 + (-1.8289417028427124) * gru_1_rev_t2_h_0 + (-0.13336770236492157) * gru_1_rev_t2_h_1 + (-0.13270542025566101) * gru_1_rev_t2_h_2 + (-0.65469801425933838) * gru_1_rev_t2_h_3 + (-0.85020792484283447) * gru_1_rev_t2_h_4 + (0.73639160394668579) * gru_1_rev_t2_h_5 + (0.014218850061297417) * gru_1_rev_t2_h_6 + (-0.60430967807769775) * gru_1_rev_t2_h_7 + (-0.88245111703872681) * gru_1_rev_t2_h_8 + (-0.68215394020080566) * gru_1_rev_t2_h_9 + (1.2907422780990601) * gru_1_rev_t2_h_10 + (-0.15736304223537445) * gru_1_rev_t2_h_11 + (0.41801920533180237) * gru_1_rev_t2_h_12 + (-0.63561326265335083) * gru_1_rev_t2_h_13 + (0.4857533872127533) * gru_1_rev_t2_h_14 + (-1.8187881708145142) * gru_1_rev_t2_h_15 + (0.38682323694229126) * gru_1_rev_t2_h_16 + (-0.71859484910964966) * gru_1_rev_t2_h_17 + (0.18281854689121246) * gru_1_rev_t2_h_18 + (-1.9922438859939575) * gru_1_rev_t2_h_19 + (-1.3174217939376831) * gru_1_rev_t2_h_20 + (0.020464414730668068) * gru_1_rev_t2_h_21 + (0.19182814657688141) * gru_1_rev_t2_h_22 + (-0.25705412030220032) * gru_1_rev_t2_h_23 + (0.8793521523475647) * gru_1_rev_t2_h_24 + (-0.43747323751449585) * gru_1_rev_t2_h_25 + (0.49686223268508911) * gru_1_rev_t2_h_26 + (1.5138499736785889) * gru_1_rev_t2_h_27 + (-4.5687127113342285) * gru_1_rev_t2_h_28 + (-1.3887350559234619) * gru_1_rev_t2_h_29 + (0.73412388563156128) * gru_1_rev_t2_h_30 + (0.53007608652114868) * gru_1_rev_t2_h_31);
    gate_z = sigmoid((0.51611274480819702) + (0.22708803415298462) * gru_0_out_t1_0 + (0.036684650927782059) * gru_0_out_t1_1 + (0.31577715277671814) * gru_0_out_t1_2 + (-0.95264238119125366) * gru_0_out_t1_3 + (-0.7000727653503418) * gru_0_out_t1_4 + (0.16630235314369202) * gru_0_out_t1_5 + (2.0632691383361816) * gru_0_out_t1_6 + (2.0414032936096191) * gru_0_out_t1_7 + (0.72561746835708618) * gru_0_out_t1_8 + (0.32504880428314209) * gru_0_out_t1_9 + (-1.1182498931884766) * gru_0_out_t1_10 + (-0.64597666263580322) * gru_0_out_t1_11 + (0.18385662138462067) * gru_0_out_t1_12 + (-0.096333801746368408) * gru_0_out_t1_13 + (0.47771790623664856) * gru_0_out_t1_14 + (-0.19199702143669128) * gru_0_out_t1_15 + (-1.1163986921310425) * gru_0_out_t1_16 + (0.070315130054950714) * gru_0_out_t1_17 + (0.028666319325566292) * gru_0_out_t1_18 + (0.95718467235565186) * gru_0_out_t1_19 + (0.64090079069137573) * gru_0_out_t1_20 + (-1.8139890432357788) * gru_0_out_t1_21 + (0.48254719376564026) * gru_0_out_t1_22 + (0.46828603744506836) * gru_0_out_t1_23 + (-1.0449913740158081) * gru_0_out_t1_24 + (0.3517763614654541) * gru_0_out_t1_25 + (-0.42286396026611328) * gru_0_out_t1_26 + (-0.22348251938819885) * gru_0_out_t1_27 + (-0.29686412215232849) * gru_0_out_t1_28 + (0.87854999303817749) * gru_0_out_t1_29 + (0.41296565532684326) * gru_0_out_t1_30 + (-0.23116119205951691) * gru_0_out_t1_31 + (0.39755216240882874) * gru_0_out_t1_32 + (0.68386095762252808) * gru_0_out_t1_33 + (0.48814454674720764) * gru_0_out_t1_34 + (-0.09386858344078064) * gru_0_out_t1_35 + (0.33808150887489319) * gru_0_out_t1_36 + (-0.48398375511169434) * gru_0_out_t1_37 + (-0.23551404476165771) * gru_0_out_t1_38 + (0.42424923181533813) * gru_0_out_t1_39 + (0.087182268500328064) * gru_0_out_t1_40 + (-0.64929115772247314) * gru_0_out_t1_41 + (-0.89337903261184692) * gru_0_out_t1_42 + (-0.42241561412811279) * gru_0_out_t1_43 + (0.19373111426830292) * gru_0_out_t1_44 + (-0.36034497618675232) * gru_0_out_t1_45 + (0.81619042158126831) * gru_0_out_t1_46 + (-0.0015409109182655811) * gru_0_out_t1_47 + (0.54126572608947754) * gru_0_out_t1_48 + (-0.61879599094390869) * gru_0_out_t1_49 + (0.20354199409484863) * gru_0_out_t1_50 + (-0.2290412038564682) * gru_0_out_t1_51 + (-0.46708747744560242) * gru_0_out_t1_52 + (-0.33631902933120728) * gru_0_out_t1_53 + (0.033379718661308289) * gru_0_out_t1_54 + (0.72576892375946045) * gru_0_out_t1_55 + (0.78225451707839966) * gru_0_out_t1_56 + (-0.36133912205696106) * gru_0_out_t1_57 + (-0.23720811307430267) * gru_0_out_t1_58 + (2.6815047264099121) * gru_0_out_t1_59 + (0.47129055857658386) * gru_0_out_t1_60 + (0.70430088043212891) * gru_0_out_t1_61 + (0.16815133392810822) * gru_0_out_t1_62 + (-1.2784675359725952) * gru_0_out_t1_63 + (0.24068580567836761) * gru_1_rev_t2_h_0 + (0.13070201873779297) * gru_1_rev_t2_h_1 + (0.3264676034450531) * gru_1_rev_t2_h_2 + (-0.72935515642166138) * gru_1_rev_t2_h_3 + (0.38853806257247925) * gru_1_rev_t2_h_4 + (0.44815385341644287) * gru_1_rev_t2_h_5 + (-0.010806268081068993) * gru_1_rev_t2_h_6 + (-0.29390078783035278) * gru_1_rev_t2_h_7 + (0.1768365353345871) * gru_1_rev_t2_h_8 + (0.29849931597709656) * gru_1_rev_t2_h_9 + (0.58723509311676025) * gru_1_rev_t2_h_10 + (-0.7486303448677063) * gru_1_rev_t2_h_11 + (1.0636621713638306) * gru_1_rev_t2_h_12 + (1.1717221736907959) * gru_1_rev_t2_h_13 + (-0.04848029837012291) * gru_1_rev_t2_h_14 + (0.93759340047836304) * gru_1_rev_t2_h_15 + (-0.05463801696896553) * gru_1_rev_t2_h_16 + (-0.2824559211730957) * gru_1_rev_t2_h_17 + (-0.097557954490184784) * gru_1_rev_t2_h_18 + (0.84401881694793701) * gru_1_rev_t2_h_19 + (-1.0166242122650146) * gru_1_rev_t2_h_20 + (0.28890329599380493) * gru_1_rev_t2_h_21 + (-0.52912813425064087) * gru_1_rev_t2_h_22 + (0.2358674556016922) * gru_1_rev_t2_h_23 + (0.59409236907958984) * gru_1_rev_t2_h_24 + (0.14122110605239868) * gru_1_rev_t2_h_25 + (0.21271084249019623) * gru_1_rev_t2_h_26 + (0.78180390596389771) * gru_1_rev_t2_h_27 + (0.24963212013244629) * gru_1_rev_t2_h_28 + (0.20135380327701569) * gru_1_rev_t2_h_29 + (0.37729856371879578) * gru_1_rev_t2_h_30 + (-0.28824803233146667) * gru_1_rev_t2_h_31);
    gate_n = tanh((0.22924134135246277) + (-0.50451838970184326) * gru_0_out_t1_0 + (0.41936236619949341) * gru_0_out_t1_1 + (0.34150728583335876) * gru_0_out_t1_2 + (-0.55084729194641113) * gru_0_out_t1_3 + (0.51659774780273438) * gru_0_out_t1_4 + (0.10549452155828476) * gru_0_out_t1_5 + (1.3371551036834717) * gru_0_out_t1_6 + (0.42776045203208923) * gru_0_out_t1_7 + (0.16935791075229645) * gru_0_out_t1_8 + (-0.55441683530807495) * gru_0_out_t1_9 + (-0.60458344221115112) * gru_0_out_t1_10 + (-0.6806262731552124) * gru_0_out_t1_11 + (-0.19063223898410797) * gru_0_out_t1_12 + (0.79175388813018799) * gru_0_out_t1_13 + (-0.99972623586654663) * gru_0_out_t1_14 + (-0.65215492248535156) * gru_0_out_t1_15 + (-0.16905416548252106) * gru_0_out_t1_16 + (0.64884060621261597) * gru_0_out_t1_17 + (0.54012417793273926) * gru_0_out_t1_18 + (0.66570198535919189) * gru_0_out_t1_19 + (0.83383089303970337) * gru_0_out_t1_20 + (-0.19423441588878632) * gru_0_out_t1_21 + (-0.14872634410858154) * gru_0_out_t1_22 + (-0.68760639429092407) * gru_0_out_t1_23 + (-1.379716157913208) * gru_0_out_t1_24 + (0.33245748281478882) * gru_0_out_t1_25 + (1.096098780632019) * gru_0_out_t1_26 + (0.52990186214447021) * gru_0_out_t1_27 + (-0.27782538533210754) * gru_0_out_t1_28 + (1.8925288915634155) * gru_0_out_t1_29 + (0.29745826125144958) * gru_0_out_t1_30 + (2.100780725479126) * gru_0_out_t1_31 + (0.27353081107139587) * gru_0_out_t1_32 + (-1.2037590742111206) * gru_0_out_t1_33 + (1.3473719358444214) * gru_0_out_t1_34 + (-1.338196873664856) * gru_0_out_t1_35 + (0.30669856071472168) * gru_0_out_t1_36 + (-1.1278975009918213) * gru_0_out_t1_37 + (0.49111238121986389) * gru_0_out_t1_38 + (1.2978067398071289) * gru_0_out_t1_39 + (0.46374866366386414) * gru_0_out_t1_40 + (-0.031063802540302277) * gru_0_out_t1_41 + (0.74358993768692017) * gru_0_out_t1_42 + (-0.53793752193450928) * gru_0_out_t1_43 + (0.077134490013122559) * gru_0_out_t1_44 + (-0.55197131633758545) * gru_0_out_t1_45 + (0.98787254095077515) * gru_0_out_t1_46 + (0.15084029734134674) * gru_0_out_t1_47 + (1.8568637371063232) * gru_0_out_t1_48 + (-1.6271584033966064) * gru_0_out_t1_49 + (0.34656858444213867) * gru_0_out_t1_50 + (-0.86839616298675537) * gru_0_out_t1_51 + (2.5582304000854492) * gru_0_out_t1_52 + (-0.12308415770530701) * gru_0_out_t1_53 + (-1.0661908388137817) * gru_0_out_t1_54 + (0.20816525816917419) * gru_0_out_t1_55 + (-0.83389878273010254) * gru_0_out_t1_56 + (-1.5924750566482544) * gru_0_out_t1_57 + (0.19064168632030487) * gru_0_out_t1_58 + (-0.47059336304664612) * gru_0_out_t1_59 + (0.05270574614405632) * gru_0_out_t1_60 + (0.83878022432327271) * gru_0_out_t1_61 + (0.26361614465713501) * gru_0_out_t1_62 + (0.7258831262588501) * gru_0_out_t1_63 + gate_r * ((1.6797351837158203) + (0.11638128012418747) * gru_1_rev_t2_h_0 + (0.71694105863571167) * gru_1_rev_t2_h_1 + (0.43218377232551575) * gru_1_rev_t2_h_2 + (-0.35854855179786682) * gru_1_rev_t2_h_3 + (1.1292591094970703) * gru_1_rev_t2_h_4 + (0.27341580390930176) * gru_1_rev_t2_h_5 + (-0.46340605616569519) * gru_1_rev_t2_h_6 + (-0.25662636756896973) * gru_1_rev_t2_h_7 + (-0.07856190949678421) * gru_1_rev_t2_h_8 + (1.1454125642776489) * gru_1_rev_t2_h_9 + (1.2836399078369141) * gru_1_rev_t2_h_10 + (1.6576181650161743) * gru_1_rev_t2_h_11 + (-0.20489834249019623) * gru_1_rev_t2_h_12 + (-1.2995989322662354) * gru_1_rev_t2_h_13 + (-1.3280289173126221) * gru_1_rev_t2_h_14 + (1.8126654624938965) * gru_1_rev_t2_h_15 + (0.059173241257667542) * gru_1_rev_t2_h_16 + (0.33619499206542969) * gru_1_rev_t2_h_17 + (1.5496997833251953) * gru_1_rev_t2_h_18 + (-0.07145284116268158) * gru_1_rev_t2_h_19 + (0.3755013644695282) * gru_1_rev_t2_h_20 + (0.16703319549560547) * gru_1_rev_t2_h_21 + (-0.4955742359161377) * gru_1_rev_t2_h_22 + (0.3444492518901825) * gru_1_rev_t2_h_23 + (-1.2621994018554688) * gru_1_rev_t2_h_24 + (0.64551210403442383) * gru_1_rev_t2_h_25 + (0.32480499148368835) * gru_1_rev_t2_h_26 + (-0.61869096755981445) * gru_1_rev_t2_h_27 + (1.3689392805099487) * gru_1_rev_t2_h_28 + (-0.13345751166343689) * gru_1_rev_t2_h_29 + (-0.56539428234100342) * gru_1_rev_t2_h_30 + (-0.25875064730644226) * gru_1_rev_t2_h_31));
    gru_1_rev_t1_h_30 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t2_h_30;
    // h=31
    gate_r = sigmoid((-0.98557847738265991) + (-0.57001930475234985) * gru_0_out_t1_0 + (-0.35154679417610168) * gru_0_out_t1_1 + (0.10432462394237518) * gru_0_out_t1_2 + (0.35117658972740173) * gru_0_out_t1_3 + (-0.019616696983575821) * gru_0_out_t1_4 + (2.4098455905914307) * gru_0_out_t1_5 + (-0.77983909845352173) * gru_0_out_t1_6 + (-1.1174522638320923) * gru_0_out_t1_7 + (-0.78133088350296021) * gru_0_out_t1_8 + (-0.14760725200176239) * gru_0_out_t1_9 + (-0.024769900366663933) * gru_0_out_t1_10 + (0.240852952003479) * gru_0_out_t1_11 + (-0.16587091982364655) * gru_0_out_t1_12 + (0.11909255385398865) * gru_0_out_t1_13 + (-0.30178391933441162) * gru_0_out_t1_14 + (-0.17571985721588135) * gru_0_out_t1_15 + (-0.39979660511016846) * gru_0_out_t1_16 + (0.11788331717252731) * gru_0_out_t1_17 + (0.45817285776138306) * gru_0_out_t1_18 + (-0.97214162349700928) * gru_0_out_t1_19 + (-1.3138552904129028) * gru_0_out_t1_20 + (-3.144373893737793) * gru_0_out_t1_21 + (1.1638123989105225) * gru_0_out_t1_22 + (0.40527492761611938) * gru_0_out_t1_23 + (-1.349744439125061) * gru_0_out_t1_24 + (-0.29161128401756287) * gru_0_out_t1_25 + (0.9838789701461792) * gru_0_out_t1_26 + (0.40017032623291016) * gru_0_out_t1_27 + (1.0769093036651611) * gru_0_out_t1_28 + (-0.42304638028144836) * gru_0_out_t1_29 + (-0.039728749543428421) * gru_0_out_t1_30 + (0.65489012002944946) * gru_0_out_t1_31 + (0.41086083650588989) * gru_0_out_t1_32 + (-0.17747671902179718) * gru_0_out_t1_33 + (-0.26099306344985962) * gru_0_out_t1_34 + (-0.15206363797187805) * gru_0_out_t1_35 + (0.069185204803943634) * gru_0_out_t1_36 + (-0.12884795665740967) * gru_0_out_t1_37 + (0.17570154368877411) * gru_0_out_t1_38 + (-1.1146599054336548) * gru_0_out_t1_39 + (1.1497622728347778) * gru_0_out_t1_40 + (-0.17271503806114197) * gru_0_out_t1_41 + (-1.1614012718200684) * gru_0_out_t1_42 + (0.11741302162408829) * gru_0_out_t1_43 + (-0.62887835502624512) * gru_0_out_t1_44 + (0.33463692665100098) * gru_0_out_t1_45 + (1.28246009349823) * gru_0_out_t1_46 + (-0.33666315674781799) * gru_0_out_t1_47 + (-0.37943035364151001) * gru_0_out_t1_48 + (0.34155118465423584) * gru_0_out_t1_49 + (-0.26588797569274902) * gru_0_out_t1_50 + (0.0028470235411077738) * gru_0_out_t1_51 + (0.35706245899200439) * gru_0_out_t1_52 + (0.27461141347885132) * gru_0_out_t1_53 + (0.7130589485168457) * gru_0_out_t1_54 + (-0.2139023095369339) * gru_0_out_t1_55 + (0.90510344505310059) * gru_0_out_t1_56 + (0.43993806838989258) * gru_0_out_t1_57 + (0.591033935546875) * gru_0_out_t1_58 + (-0.36402034759521484) * gru_0_out_t1_59 + (0.4530339241027832) * gru_0_out_t1_60 + (3.1212844848632812) * gru_0_out_t1_61 + (0.24729430675506592) * gru_0_out_t1_62 + (0.61910051107406616) * gru_0_out_t1_63 + (-1.0665386915206909) * gru_1_rev_t2_h_0 + (-0.28836241364479065) * gru_1_rev_t2_h_1 + (0.65913307666778564) * gru_1_rev_t2_h_2 + (-0.46255064010620117) * gru_1_rev_t2_h_3 + (1.0547652244567871) * gru_1_rev_t2_h_4 + (-1.7123391628265381) * gru_1_rev_t2_h_5 + (0.19686447083950043) * gru_1_rev_t2_h_6 + (1.0052081346511841) * gru_1_rev_t2_h_7 + (0.28105196356773376) * gru_1_rev_t2_h_8 + (-0.81000250577926636) * gru_1_rev_t2_h_9 + (-2.408367395401001) * gru_1_rev_t2_h_10 + (1.5828473567962646) * gru_1_rev_t2_h_11 + (0.26879608631134033) * gru_1_rev_t2_h_12 + (0.44401097297668457) * gru_1_rev_t2_h_13 + (0.018761651590466499) * gru_1_rev_t2_h_14 + (-0.89160192012786865) * gru_1_rev_t2_h_15 + (1.4415880441665649) * gru_1_rev_t2_h_16 + (0.59578847885131836) * gru_1_rev_t2_h_17 + (-0.048765785992145538) * gru_1_rev_t2_h_18 + (0.98465847969055176) * gru_1_rev_t2_h_19 + (0.30099761486053467) * gru_1_rev_t2_h_20 + (-0.0095528606325387955) * gru_1_rev_t2_h_21 + (0.21286158263683319) * gru_1_rev_t2_h_22 + (-0.27618306875228882) * gru_1_rev_t2_h_23 + (1.1806737184524536) * gru_1_rev_t2_h_24 + (0.1493525505065918) * gru_1_rev_t2_h_25 + (-0.32428878545761108) * gru_1_rev_t2_h_26 + (0.47690919041633606) * gru_1_rev_t2_h_27 + (-3.3402020931243896) * gru_1_rev_t2_h_28 + (0.19403204321861267) * gru_1_rev_t2_h_29 + (-0.7463071346282959) * gru_1_rev_t2_h_30 + (0.35831201076507568) * gru_1_rev_t2_h_31);
    gate_z = sigmoid((-0.2909734845161438) + (0.32473564147949219) * gru_0_out_t1_0 + (-0.041842926293611526) * gru_0_out_t1_1 + (-0.05382344126701355) * gru_0_out_t1_2 + (0.39428138732910156) * gru_0_out_t1_3 + (0.32163208723068237) * gru_0_out_t1_4 + (-0.31057780981063843) * gru_0_out_t1_5 + (0.32698565721511841) * gru_0_out_t1_6 + (-0.18882457911968231) * gru_0_out_t1_7 + (0.68542063236236572) * gru_0_out_t1_8 + (0.92202413082122803) * gru_0_out_t1_9 + (-0.11150964349508286) * gru_0_out_t1_10 + (0.72921949625015259) * gru_0_out_t1_11 + (0.54567414522171021) * gru_0_out_t1_12 + (0.46798700094223022) * gru_0_out_t1_13 + (-1.3350894451141357) * gru_0_out_t1_14 + (0.3513941764831543) * gru_0_out_t1_15 + (0.94183695316314697) * gru_0_out_t1_16 + (1.3504635095596313) * gru_0_out_t1_17 + (-0.19672265648841858) * gru_0_out_t1_18 + (-0.83739352226257324) * gru_0_out_t1_19 + (0.027224553748965263) * gru_0_out_t1_20 + (-0.0093999719247221947) * gru_0_out_t1_21 + (0.95362061262130737) * gru_0_out_t1_22 + (-1.8471578359603882) * gru_0_out_t1_23 + (-0.3192552924156189) * gru_0_out_t1_24 + (0.00031467611552216113) * gru_0_out_t1_25 + (0.0054807355627417564) * gru_0_out_t1_26 + (0.37948691844940186) * gru_0_out_t1_27 + (-1.8738301992416382) * gru_0_out_t1_28 + (0.68953710794448853) * gru_0_out_t1_29 + (-0.12833678722381592) * gru_0_out_t1_30 + (0.51487106084823608) * gru_0_out_t1_31 + (0.3465462327003479) * gru_0_out_t1_32 + (-0.44558027386665344) * gru_0_out_t1_33 + (0.04008793830871582) * gru_0_out_t1_34 + (-0.10673493891954422) * gru_0_out_t1_35 + (-0.082206353545188904) * gru_0_out_t1_36 + (0.39172077178955078) * gru_0_out_t1_37 + (-0.1043899804353714) * gru_0_out_t1_38 + (0.74820905923843384) * gru_0_out_t1_39 + (1.4621125459671021) * gru_0_out_t1_40 + (0.068846963346004486) * gru_0_out_t1_41 + (0.17076753079891205) * gru_0_out_t1_42 + (-0.1556088775396347) * gru_0_out_t1_43 + (0.02686740830540657) * gru_0_out_t1_44 + (-0.61342614889144897) * gru_0_out_t1_45 + (0.34259906411170959) * gru_0_out_t1_46 + (-0.5014188289642334) * gru_0_out_t1_47 + (0.033381212502717972) * gru_0_out_t1_48 + (0.13173244893550873) * gru_0_out_t1_49 + (0.067189611494541168) * gru_0_out_t1_50 + (-0.69147717952728271) * gru_0_out_t1_51 + (0.26483070850372314) * gru_0_out_t1_52 + (0.69465166330337524) * gru_0_out_t1_53 + (0.15822289884090424) * gru_0_out_t1_54 + (0.5083349347114563) * gru_0_out_t1_55 + (-0.81061273813247681) * gru_0_out_t1_56 + (-0.20973744988441467) * gru_0_out_t1_57 + (1.3719931840896606) * gru_0_out_t1_58 + (-2.1541194915771484) * gru_0_out_t1_59 + (-0.44197630882263184) * gru_0_out_t1_60 + (-1.1619863510131836) * gru_0_out_t1_61 + (-0.99470162391662598) * gru_0_out_t1_62 + (-0.91743266582489014) * gru_0_out_t1_63 + (-0.19631260633468628) * gru_1_rev_t2_h_0 + (0.43105778098106384) * gru_1_rev_t2_h_1 + (-0.19833987951278687) * gru_1_rev_t2_h_2 + (0.081125907599925995) * gru_1_rev_t2_h_3 + (-0.50198847055435181) * gru_1_rev_t2_h_4 + (0.045934692025184631) * gru_1_rev_t2_h_5 + (0.40329831838607788) * gru_1_rev_t2_h_6 + (-0.1924348771572113) * gru_1_rev_t2_h_7 + (0.093145310878753662) * gru_1_rev_t2_h_8 + (-0.42420414090156555) * gru_1_rev_t2_h_9 + (-1.0381854772567749) * gru_1_rev_t2_h_10 + (0.66620093584060669) * gru_1_rev_t2_h_11 + (-0.21465878188610077) * gru_1_rev_t2_h_12 + (-0.27509391307830811) * gru_1_rev_t2_h_13 + (0.48978379368782043) * gru_1_rev_t2_h_14 + (0.94452959299087524) * gru_1_rev_t2_h_15 + (-0.9789193868637085) * gru_1_rev_t2_h_16 + (-0.51034855842590332) * gru_1_rev_t2_h_17 + (0.92878443002700806) * gru_1_rev_t2_h_18 + (2.8986659049987793) * gru_1_rev_t2_h_19 + (-0.82610905170440674) * gru_1_rev_t2_h_20 + (0.24784035980701447) * gru_1_rev_t2_h_21 + (-0.30891680717468262) * gru_1_rev_t2_h_22 + (-0.7636488676071167) * gru_1_rev_t2_h_23 + (-0.75402361154556274) * gru_1_rev_t2_h_24 + (-1.1052480936050415) * gru_1_rev_t2_h_25 + (0.61875826120376587) * gru_1_rev_t2_h_26 + (0.85503017902374268) * gru_1_rev_t2_h_27 + (-2.134047269821167) * gru_1_rev_t2_h_28 + (-0.71614706516265869) * gru_1_rev_t2_h_29 + (-1.1061947345733643) * gru_1_rev_t2_h_30 + (0.45499908924102783) * gru_1_rev_t2_h_31);
    gate_n = tanh((0.17665942013263702) + (0.01648641936480999) * gru_0_out_t1_0 + (-0.26165881752967834) * gru_0_out_t1_1 + (-0.66114318370819092) * gru_0_out_t1_2 + (0.5737336277961731) * gru_0_out_t1_3 + (-0.03213157132267952) * gru_0_out_t1_4 + (-1.1800439357757568) * gru_0_out_t1_5 + (0.41751754283905029) * gru_0_out_t1_6 + (-0.97069650888442993) * gru_0_out_t1_7 + (-0.86873745918273926) * gru_0_out_t1_8 + (-0.48883959650993347) * gru_0_out_t1_9 + (-0.26976341009140015) * gru_0_out_t1_10 + (-0.8067513108253479) * gru_0_out_t1_11 + (0.29970589280128479) * gru_0_out_t1_12 + (0.035179387778043747) * gru_0_out_t1_13 + (0.013108598068356514) * gru_0_out_t1_14 + (-0.26240602135658264) * gru_0_out_t1_15 + (-1.6582537889480591) * gru_0_out_t1_16 + (-1.0142879486083984) * gru_0_out_t1_17 + (0.071152396500110626) * gru_0_out_t1_18 + (-1.3084031343460083) * gru_0_out_t1_19 + (0.18800821900367737) * gru_0_out_t1_20 + (-0.79982244968414307) * gru_0_out_t1_21 + (0.016034698113799095) * gru_0_out_t1_22 + (1.7165931463241577) * gru_0_out_t1_23 + (0.339292973279953) * gru_0_out_t1_24 + (-0.90300899744033813) * gru_0_out_t1_25 + (-0.22457738220691681) * gru_0_out_t1_26 + (-0.11689282208681107) * gru_0_out_t1_27 + (-0.75630277395248413) * gru_0_out_t1_28 + (-0.46465310454368591) * gru_0_out_t1_29 + (0.28652399778366089) * gru_0_out_t1_30 + (0.4107556939125061) * gru_0_out_t1_31 + (0.94720196723937988) * gru_0_out_t1_32 + (-0.053141620010137558) * gru_0_out_t1_33 + (0.51892304420471191) * gru_0_out_t1_34 + (0.13718646764755249) * gru_0_out_t1_35 + (-0.16538721323013306) * gru_0_out_t1_36 + (0.20964382588863373) * gru_0_out_t1_37 + (-0.11333430558443069) * gru_0_out_t1_38 + (0.93258357048034668) * gru_0_out_t1_39 + (-1.2982161045074463) * gru_0_out_t1_40 + (0.87242937088012695) * gru_0_out_t1_41 + (-2.0130214691162109) * gru_0_out_t1_42 + (-0.12585063278675079) * gru_0_out_t1_43 + (0.5177839994430542) * gru_0_out_t1_44 + (0.26271334290504456) * gru_0_out_t1_45 + (-0.24234199523925781) * gru_0_out_t1_46 + (-0.25770381093025208) * gru_0_out_t1_47 + (-0.010344302281737328) * gru_0_out_t1_48 + (0.10489494353532791) * gru_0_out_t1_49 + (0.069803468883037567) * gru_0_out_t1_50 + (-0.051264781504869461) * gru_0_out_t1_51 + (-0.02555127814412117) * gru_0_out_t1_52 + (0.53907948732376099) * gru_0_out_t1_53 + (-0.33471527695655823) * gru_0_out_t1_54 + (0.77929776906967163) * gru_0_out_t1_55 + (-1.0024372339248657) * gru_0_out_t1_56 + (0.25550559163093567) * gru_0_out_t1_57 + (-0.019731847569346428) * gru_0_out_t1_58 + (-0.56956368684768677) * gru_0_out_t1_59 + (-0.18431814014911652) * gru_0_out_t1_60 + (-0.049358803778886795) * gru_0_out_t1_61 + (0.33418893814086914) * gru_0_out_t1_62 + (-0.15847030282020569) * gru_0_out_t1_63 + gate_r * ((-0.35027503967285156) + (0.12682047486305237) * gru_1_rev_t2_h_0 + (0.49305620789527893) * gru_1_rev_t2_h_1 + (-0.35291460156440735) * gru_1_rev_t2_h_2 + (0.19995740056037903) * gru_1_rev_t2_h_3 + (-0.062366444617509842) * gru_1_rev_t2_h_4 + (0.72309184074401855) * gru_1_rev_t2_h_5 + (0.2124248594045639) * gru_1_rev_t2_h_6 + (-0.34355464577674866) * gru_1_rev_t2_h_7 + (-0.15159454941749573) * gru_1_rev_t2_h_8 + (0.54663461446762085) * gru_1_rev_t2_h_9 + (-0.66338557004928589) * gru_1_rev_t2_h_10 + (-0.032460670918226242) * gru_1_rev_t2_h_11 + (-0.21329440176486969) * gru_1_rev_t2_h_12 + (0.32556816935539246) * gru_1_rev_t2_h_13 + (-0.22626769542694092) * gru_1_rev_t2_h_14 + (-0.95979189872741699) * gru_1_rev_t2_h_15 + (-0.10099168866872787) * gru_1_rev_t2_h_16 + (-0.20442976057529449) * gru_1_rev_t2_h_17 + (0.50563251972198486) * gru_1_rev_t2_h_18 + (1.7543375492095947) * gru_1_rev_t2_h_19 + (0.034563649445772171) * gru_1_rev_t2_h_20 + (-0.46983090043067932) * gru_1_rev_t2_h_21 + (-0.25320518016815186) * gru_1_rev_t2_h_22 + (-0.1592075526714325) * gru_1_rev_t2_h_23 + (-0.40631639957427979) * gru_1_rev_t2_h_24 + (0.81797534227371216) * gru_1_rev_t2_h_25 + (-0.25494658946990967) * gru_1_rev_t2_h_26 + (0.38209268450737) * gru_1_rev_t2_h_27 + (-0.89450091123580933) * gru_1_rev_t2_h_28 + (0.18882468342781067) * gru_1_rev_t2_h_29 + (0.37574642896652222) * gru_1_rev_t2_h_30 + (-1.1140655279159546) * gru_1_rev_t2_h_31));
    gru_1_rev_t1_h_31 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t2_h_31;

    // RV step t=0
    // h=0
    gate_r = sigmoid((0.58126628398895264) + (0.3461015522480011) * gru_0_out_t0_0 + (-0.2949959933757782) * gru_0_out_t0_1 + (0.42175370454788208) * gru_0_out_t0_2 + (0.62256276607513428) * gru_0_out_t0_3 + (0.23958523571491241) * gru_0_out_t0_4 + (-0.45301467180252075) * gru_0_out_t0_5 + (0.68952316045761108) * gru_0_out_t0_6 + (-0.49925786256790161) * gru_0_out_t0_7 + (-0.068710625171661377) * gru_0_out_t0_8 + (1.3800723552703857) * gru_0_out_t0_9 + (-0.89359819889068604) * gru_0_out_t0_10 + (0.43140432238578796) * gru_0_out_t0_11 + (0.031491909176111221) * gru_0_out_t0_12 + (-0.087643668055534363) * gru_0_out_t0_13 + (0.336295485496521) * gru_0_out_t0_14 + (0.19321420788764954) * gru_0_out_t0_15 + (0.00080590764991939068) * gru_0_out_t0_16 + (0.075453773140907288) * gru_0_out_t0_17 + (-0.41135543584823608) * gru_0_out_t0_18 + (2.0293476581573486) * gru_0_out_t0_19 + (0.72744262218475342) * gru_0_out_t0_20 + (0.53991758823394775) * gru_0_out_t0_21 + (0.31365412473678589) * gru_0_out_t0_22 + (0.68274176120758057) * gru_0_out_t0_23 + (0.10474167019128799) * gru_0_out_t0_24 + (0.62453806400299072) * gru_0_out_t0_25 + (0.41086536645889282) * gru_0_out_t0_26 + (-0.56289297342300415) * gru_0_out_t0_27 + (-0.82757002115249634) * gru_0_out_t0_28 + (1.1187382936477661) * gru_0_out_t0_29 + (0.54665815830230713) * gru_0_out_t0_30 + (-0.21825309097766876) * gru_0_out_t0_31 + (0.2940315306186676) * gru_0_out_t0_32 + (0.053931709378957748) * gru_0_out_t0_33 + (0.24624025821685791) * gru_0_out_t0_34 + (0.31730201840400696) * gru_0_out_t0_35 + (-0.0042199939489364624) * gru_0_out_t0_36 + (-0.099361449480056763) * gru_0_out_t0_37 + (0.32230666279792786) * gru_0_out_t0_38 + (-0.12619507312774658) * gru_0_out_t0_39 + (-1.3094536066055298) * gru_0_out_t0_40 + (1.0639116764068604) * gru_0_out_t0_41 + (-0.2831280529499054) * gru_0_out_t0_42 + (-0.12234871089458466) * gru_0_out_t0_43 + (0.097353234887123108) * gru_0_out_t0_44 + (0.37904301285743713) * gru_0_out_t0_45 + (0.70086753368377686) * gru_0_out_t0_46 + (0.034374512732028961) * gru_0_out_t0_47 + (0.84007364511489868) * gru_0_out_t0_48 + (-1.040581226348877) * gru_0_out_t0_49 + (-0.21705634891986847) * gru_0_out_t0_50 + (0.58707612752914429) * gru_0_out_t0_51 + (0.63053524494171143) * gru_0_out_t0_52 + (0.36505591869354248) * gru_0_out_t0_53 + (-0.49750047922134399) * gru_0_out_t0_54 + (0.17923566699028015) * gru_0_out_t0_55 + (0.89410495758056641) * gru_0_out_t0_56 + (0.0035052259918302298) * gru_0_out_t0_57 + (-0.16507460176944733) * gru_0_out_t0_58 + (0.9692615270614624) * gru_0_out_t0_59 + (-1.9698183536529541) * gru_0_out_t0_60 + (0.017860323190689087) * gru_0_out_t0_61 + (0.62139171361923218) * gru_0_out_t0_62 + (0.24609129130840302) * gru_0_out_t0_63 + (0.14864030480384827) * gru_1_rev_t1_h_0 + (-0.15750719606876373) * gru_1_rev_t1_h_1 + (-0.47075945138931274) * gru_1_rev_t1_h_2 + (0.068322144448757172) * gru_1_rev_t1_h_3 + (-0.10201981663703918) * gru_1_rev_t1_h_4 + (-0.137136310338974) * gru_1_rev_t1_h_5 + (-0.13364081084728241) * gru_1_rev_t1_h_6 + (-0.60472434759140015) * gru_1_rev_t1_h_7 + (0.34472453594207764) * gru_1_rev_t1_h_8 + (1.634030818939209) * gru_1_rev_t1_h_9 + (0.14629141986370087) * gru_1_rev_t1_h_10 + (-0.76001965999603271) * gru_1_rev_t1_h_11 + (0.29311755299568176) * gru_1_rev_t1_h_12 + (-1.7175664901733398) * gru_1_rev_t1_h_13 + (0.079696156084537506) * gru_1_rev_t1_h_14 + (-0.030004503205418587) * gru_1_rev_t1_h_15 + (-0.67139732837677002) * gru_1_rev_t1_h_16 + (-0.41371950507164001) * gru_1_rev_t1_h_17 + (-0.72889882326126099) * gru_1_rev_t1_h_18 + (-0.01909981295466423) * gru_1_rev_t1_h_19 + (-0.67588406801223755) * gru_1_rev_t1_h_20 + (0.044362425804138184) * gru_1_rev_t1_h_21 + (1.1402187347412109) * gru_1_rev_t1_h_22 + (-0.97483623027801514) * gru_1_rev_t1_h_23 + (-0.29417246580123901) * gru_1_rev_t1_h_24 + (1.6576207876205444) * gru_1_rev_t1_h_25 + (0.096272088587284088) * gru_1_rev_t1_h_26 + (-1.1318717002868652) * gru_1_rev_t1_h_27 + (0.92297852039337158) * gru_1_rev_t1_h_28 + (-0.25924003124237061) * gru_1_rev_t1_h_29 + (-0.90933418273925781) * gru_1_rev_t1_h_30 + (0.61248242855072021) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.92658507823944092) + (0.3031025230884552) * gru_0_out_t0_0 + (-1.0290640592575073) * gru_0_out_t0_1 + (1.9438254833221436) * gru_0_out_t0_2 + (0.039532888680696487) * gru_0_out_t0_3 + (-0.56961101293563843) * gru_0_out_t0_4 + (0.030088700354099274) * gru_0_out_t0_5 + (0.055256132036447525) * gru_0_out_t0_6 + (-1.3125280141830444) * gru_0_out_t0_7 + (0.11220762133598328) * gru_0_out_t0_8 + (0.21006862819194794) * gru_0_out_t0_9 + (-2.3677353858947754) * gru_0_out_t0_10 + (0.15025962889194489) * gru_0_out_t0_11 + (1.054884672164917) * gru_0_out_t0_12 + (0.8738444447517395) * gru_0_out_t0_13 + (0.18520714342594147) * gru_0_out_t0_14 + (1.6222653388977051) * gru_0_out_t0_15 + (0.57355082035064697) * gru_0_out_t0_16 + (0.793773353099823) * gru_0_out_t0_17 + (-0.345439612865448) * gru_0_out_t0_18 + (0.026623686775565147) * gru_0_out_t0_19 + (0.82493579387664795) * gru_0_out_t0_20 + (-0.37602835893630981) * gru_0_out_t0_21 + (-0.11914751678705215) * gru_0_out_t0_22 + (-0.67521286010742188) * gru_0_out_t0_23 + (-1.3429644107818604) * gru_0_out_t0_24 + (-0.5212562084197998) * gru_0_out_t0_25 + (0.70230227708816528) * gru_0_out_t0_26 + (0.9508126974105835) * gru_0_out_t0_27 + (-1.569488525390625) * gru_0_out_t0_28 + (0.020253580063581467) * gru_0_out_t0_29 + (0.050608079880475998) * gru_0_out_t0_30 + (0.46613603830337524) * gru_0_out_t0_31 + (-0.40216577053070068) * gru_0_out_t0_32 + (0.34979802370071411) * gru_0_out_t0_33 + (-0.20113091170787811) * gru_0_out_t0_34 + (1.0137882232666016) * gru_0_out_t0_35 + (0.14480744302272797) * gru_0_out_t0_36 + (-0.16547851264476776) * gru_0_out_t0_37 + (-0.24511897563934326) * gru_0_out_t0_38 + (1.006535530090332) * gru_0_out_t0_39 + (0.57186049222946167) * gru_0_out_t0_40 + (1.3397485017776489) * gru_0_out_t0_41 + (0.98700827360153198) * gru_0_out_t0_42 + (-0.24130327999591827) * gru_0_out_t0_43 + (0.65854847431182861) * gru_0_out_t0_44 + (0.47380965948104858) * gru_0_out_t0_45 + (-0.16745896637439728) * gru_0_out_t0_46 + (-0.045964758843183517) * gru_0_out_t0_47 + (-0.25303694605827332) * gru_0_out_t0_48 + (-0.051693916320800781) * gru_0_out_t0_49 + (-0.18152262270450592) * gru_0_out_t0_50 + (-0.23376059532165527) * gru_0_out_t0_51 + (-0.35757845640182495) * gru_0_out_t0_52 + (-0.0040349569171667099) * gru_0_out_t0_53 + (-0.40543285012245178) * gru_0_out_t0_54 + (-0.0019529624842107296) * gru_0_out_t0_55 + (0.46795263886451721) * gru_0_out_t0_56 + (0.17968311905860901) * gru_0_out_t0_57 + (0.11411868035793304) * gru_0_out_t0_58 + (-0.63490390777587891) * gru_0_out_t0_59 + (0.061035852879285812) * gru_0_out_t0_60 + (0.043291643261909485) * gru_0_out_t0_61 + (0.54315197467803955) * gru_0_out_t0_62 + (-1.2224456071853638) * gru_0_out_t0_63 + (-0.83274197578430176) * gru_1_rev_t1_h_0 + (0.59296143054962158) * gru_1_rev_t1_h_1 + (-0.98576176166534424) * gru_1_rev_t1_h_2 + (1.022352933883667) * gru_1_rev_t1_h_3 + (-0.39523115754127502) * gru_1_rev_t1_h_4 + (0.034930374473333359) * gru_1_rev_t1_h_5 + (-0.041706953197717667) * gru_1_rev_t1_h_6 + (-0.60003703832626343) * gru_1_rev_t1_h_7 + (0.0498000867664814) * gru_1_rev_t1_h_8 + (-0.11168863624334335) * gru_1_rev_t1_h_9 + (0.56408816576004028) * gru_1_rev_t1_h_10 + (0.34469941258430481) * gru_1_rev_t1_h_11 + (0.44151723384857178) * gru_1_rev_t1_h_12 + (-2.5328404903411865) * gru_1_rev_t1_h_13 + (0.023146072402596474) * gru_1_rev_t1_h_14 + (0.36669471859931946) * gru_1_rev_t1_h_15 + (-0.22694644331932068) * gru_1_rev_t1_h_16 + (0.041660897433757782) * gru_1_rev_t1_h_17 + (0.26842394471168518) * gru_1_rev_t1_h_18 + (-0.67282003164291382) * gru_1_rev_t1_h_19 + (-0.4502221941947937) * gru_1_rev_t1_h_20 + (-1.0531136989593506) * gru_1_rev_t1_h_21 + (0.91989147663116455) * gru_1_rev_t1_h_22 + (-0.24896983802318573) * gru_1_rev_t1_h_23 + (-1.6267088651657104) * gru_1_rev_t1_h_24 + (0.15558704733848572) * gru_1_rev_t1_h_25 + (0.3384888768196106) * gru_1_rev_t1_h_26 + (-1.2046065330505371) * gru_1_rev_t1_h_27 + (-1.6663806438446045) * gru_1_rev_t1_h_28 + (0.1776728630065918) * gru_1_rev_t1_h_29 + (-0.84148705005645752) * gru_1_rev_t1_h_30 + (-0.15535357594490051) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.17712901532649994) + (-0.19911818206310272) * gru_0_out_t0_0 + (0.071633517742156982) * gru_0_out_t0_1 + (-1.2292951345443726) * gru_0_out_t0_2 + (-0.14776083827018738) * gru_0_out_t0_3 + (0.33671331405639648) * gru_0_out_t0_4 + (1.1010667085647583) * gru_0_out_t0_5 + (-0.6213991641998291) * gru_0_out_t0_6 + (-1.0614986419677734) * gru_0_out_t0_7 + (-0.22221857309341431) * gru_0_out_t0_8 + (-0.51339191198348999) * gru_0_out_t0_9 + (1.3227903842926025) * gru_0_out_t0_10 + (0.26794177293777466) * gru_0_out_t0_11 + (-0.31339377164840698) * gru_0_out_t0_12 + (-0.069509446620941162) * gru_0_out_t0_13 + (-0.65909695625305176) * gru_0_out_t0_14 + (0.29469594359397888) * gru_0_out_t0_15 + (-0.13114316761493683) * gru_0_out_t0_16 + (0.064992554485797882) * gru_0_out_t0_17 + (0.18779313564300537) * gru_0_out_t0_18 + (-2.077904224395752) * gru_0_out_t0_19 + (-0.28640463948249817) * gru_0_out_t0_20 + (-0.26710081100463867) * gru_0_out_t0_21 + (0.54704087972640991) * gru_0_out_t0_22 + (-1.3856691122055054) * gru_0_out_t0_23 + (1.2855089902877808) * gru_0_out_t0_24 + (-0.37560603022575378) * gru_0_out_t0_25 + (-0.16082859039306641) * gru_0_out_t0_26 + (-0.58927625417709351) * gru_0_out_t0_27 + (1.2076035737991333) * gru_0_out_t0_28 + (-0.027270674705505371) * gru_0_out_t0_29 + (-0.35477718710899353) * gru_0_out_t0_30 + (-0.7819594144821167) * gru_0_out_t0_31 + (0.61380308866500854) * gru_0_out_t0_32 + (-0.12947762012481689) * gru_0_out_t0_33 + (-0.13859930634498596) * gru_0_out_t0_34 + (0.30669164657592773) * gru_0_out_t0_35 + (0.21221533417701721) * gru_0_out_t0_36 + (0.073815904557704926) * gru_0_out_t0_37 + (0.0020874117035418749) * gru_0_out_t0_38 + (-0.46144667267799377) * gru_0_out_t0_39 + (2.1233847141265869) * gru_0_out_t0_40 + (-0.27828532457351685) * gru_0_out_t0_41 + (2.5182802677154541) * gru_0_out_t0_42 + (0.067871846258640289) * gru_0_out_t0_43 + (-0.40057769417762756) * gru_0_out_t0_44 + (-0.13372674584388733) * gru_0_out_t0_45 + (0.06801750510931015) * gru_0_out_t0_46 + (-0.69326484203338623) * gru_0_out_t0_47 + (0.30723923444747925) * gru_0_out_t0_48 + (0.25171956419944763) * gru_0_out_t0_49 + (0.067896425724029541) * gru_0_out_t0_50 + (0.015187440440058708) * gru_0_out_t0_51 + (-0.01062028668820858) * gru_0_out_t0_52 + (0.40402901172637939) * gru_0_out_t0_53 + (-0.14724063873291016) * gru_0_out_t0_54 + (0.0067734434269368649) * gru_0_out_t0_55 + (0.87118464708328247) * gru_0_out_t0_56 + (-0.37395113706588745) * gru_0_out_t0_57 + (0.093851692974567413) * gru_0_out_t0_58 + (-0.54271560907363892) * gru_0_out_t0_59 + (2.9927453994750977) * gru_0_out_t0_60 + (1.5603146553039551) * gru_0_out_t0_61 + (-0.023856762796640396) * gru_0_out_t0_62 + (0.12609013915061951) * gru_0_out_t0_63 + gate_r * ((-0.58328002691268921) + (-1.3517909049987793) * gru_1_rev_t1_h_0 + (0.63927245140075684) * gru_1_rev_t1_h_1 + (-1.1232514381408691) * gru_1_rev_t1_h_2 + (0.43054747581481934) * gru_1_rev_t1_h_3 + (-0.20211561024188995) * gru_1_rev_t1_h_4 + (-0.63455706834793091) * gru_1_rev_t1_h_5 + (1.5356982946395874) * gru_1_rev_t1_h_6 + (-0.7864372730255127) * gru_1_rev_t1_h_7 + (0.59914445877075195) * gru_1_rev_t1_h_8 + (0.036764491349458694) * gru_1_rev_t1_h_9 + (-0.45728763937950134) * gru_1_rev_t1_h_10 + (-0.99114346504211426) * gru_1_rev_t1_h_11 + (0.36095750331878662) * gru_1_rev_t1_h_12 + (0.17599937319755554) * gru_1_rev_t1_h_13 + (-0.23462289571762085) * gru_1_rev_t1_h_14 + (0.55971390008926392) * gru_1_rev_t1_h_15 + (-0.32236543297767639) * gru_1_rev_t1_h_16 + (-0.60134202241897583) * gru_1_rev_t1_h_17 + (-0.18101832270622253) * gru_1_rev_t1_h_18 + (0.11181644350290298) * gru_1_rev_t1_h_19 + (0.53572326898574829) * gru_1_rev_t1_h_20 + (-0.038441203534603119) * gru_1_rev_t1_h_21 + (0.97531086206436157) * gru_1_rev_t1_h_22 + (-0.4231114387512207) * gru_1_rev_t1_h_23 + (-0.13136069476604462) * gru_1_rev_t1_h_24 + (-0.2886786162853241) * gru_1_rev_t1_h_25 + (-0.35735616087913513) * gru_1_rev_t1_h_26 + (0.35444068908691406) * gru_1_rev_t1_h_27 + (-0.41141787171363831) * gru_1_rev_t1_h_28 + (-0.25135406851768494) * gru_1_rev_t1_h_29 + (-1.3673070669174194) * gru_1_rev_t1_h_30 + (-0.4010501503944397) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_0 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_0;
    // h=1
    gate_r = sigmoid((-0.20903995633125305) + (0.30925112962722778) * gru_0_out_t0_0 + (-0.015742391347885132) * gru_0_out_t0_1 + (-0.2368304580450058) * gru_0_out_t0_2 + (-1.1588512659072876) * gru_0_out_t0_3 + (-0.17164070904254913) * gru_0_out_t0_4 + (0.02564871683716774) * gru_0_out_t0_5 + (-1.4705148935317993) * gru_0_out_t0_6 + (-0.61768084764480591) * gru_0_out_t0_7 + (0.079003781080245972) * gru_0_out_t0_8 + (-0.028004871681332588) * gru_0_out_t0_9 + (0.57926177978515625) * gru_0_out_t0_10 + (0.62611490488052368) * gru_0_out_t0_11 + (-0.71592998504638672) * gru_0_out_t0_12 + (-0.28013396263122559) * gru_0_out_t0_13 + (0.64424937963485718) * gru_0_out_t0_14 + (-1.1557599306106567) * gru_0_out_t0_15 + (0.64116787910461426) * gru_0_out_t0_16 + (-0.54434990882873535) * gru_0_out_t0_17 + (0.19131892919540405) * gru_0_out_t0_18 + (1.2721389532089233) * gru_0_out_t0_19 + (-0.19331479072570801) * gru_0_out_t0_20 + (1.0641202926635742) * gru_0_out_t0_21 + (0.40934953093528748) * gru_0_out_t0_22 + (-0.3040870726108551) * gru_0_out_t0_23 + (-0.76493173837661743) * gru_0_out_t0_24 + (-1.6161586046218872) * gru_0_out_t0_25 + (-0.45597133040428162) * gru_0_out_t0_26 + (0.89349943399429321) * gru_0_out_t0_27 + (0.24348098039627075) * gru_0_out_t0_28 + (-3.2238359451293945) * gru_0_out_t0_29 + (-0.26619812846183777) * gru_0_out_t0_30 + (-1.8762181997299194) * gru_0_out_t0_31 + (-0.13870754837989807) * gru_0_out_t0_32 + (0.39376085996627808) * gru_0_out_t0_33 + (0.12738075852394104) * gru_0_out_t0_34 + (-0.66587477922439575) * gru_0_out_t0_35 + (-0.22798031568527222) * gru_0_out_t0_36 + (0.42163008451461792) * gru_0_out_t0_37 + (-0.76521778106689453) * gru_0_out_t0_38 + (-0.83616834878921509) * gru_0_out_t0_39 + (0.48386898636817932) * gru_0_out_t0_40 + (-0.29284533858299255) * gru_0_out_t0_41 + (0.65458744764328003) * gru_0_out_t0_42 + (0.18632990121841431) * gru_0_out_t0_43 + (-0.029939791187644005) * gru_0_out_t0_44 + (-1.6301888227462769) * gru_0_out_t0_45 + (-1.1368800401687622) * gru_0_out_t0_46 + (-0.11000495404005051) * gru_0_out_t0_47 + (-1.2941906452178955) * gru_0_out_t0_48 + (1.0825592279434204) * gru_0_out_t0_49 + (0.64831972122192383) * gru_0_out_t0_50 + (-1.1520640850067139) * gru_0_out_t0_51 + (-0.96388977766036987) * gru_0_out_t0_52 + (0.26267817616462708) * gru_0_out_t0_53 + (0.28491249680519104) * gru_0_out_t0_54 + (0.1249992847442627) * gru_0_out_t0_55 + (-0.81087195873260498) * gru_0_out_t0_56 + (1.149482250213623) * gru_0_out_t0_57 + (-0.22046862542629242) * gru_0_out_t0_58 + (1.2936067581176758) * gru_0_out_t0_59 + (-0.57055181264877319) * gru_0_out_t0_60 + (0.75417762994766235) * gru_0_out_t0_61 + (-1.1933449506759644) * gru_0_out_t0_62 + (2.3391835689544678) * gru_0_out_t0_63 + (0.40303719043731689) * gru_1_rev_t1_h_0 + (-1.2077717781066895) * gru_1_rev_t1_h_1 + (1.583712100982666) * gru_1_rev_t1_h_2 + (0.37521818280220032) * gru_1_rev_t1_h_3 + (0.5753399133682251) * gru_1_rev_t1_h_4 + (-0.16197578608989716) * gru_1_rev_t1_h_5 + (-0.087297342717647552) * gru_1_rev_t1_h_6 + (-0.016816722229123116) * gru_1_rev_t1_h_7 + (-0.16015522181987762) * gru_1_rev_t1_h_8 + (-0.20441380143165588) * gru_1_rev_t1_h_9 + (1.5563437938690186) * gru_1_rev_t1_h_10 + (0.76425153017044067) * gru_1_rev_t1_h_11 + (-0.26583787798881531) * gru_1_rev_t1_h_12 + (-1.3522046804428101) * gru_1_rev_t1_h_13 + (-0.68187522888183594) * gru_1_rev_t1_h_14 + (-0.71504414081573486) * gru_1_rev_t1_h_15 + (0.57563221454620361) * gru_1_rev_t1_h_16 + (0.069927692413330078) * gru_1_rev_t1_h_17 + (-0.22839675843715668) * gru_1_rev_t1_h_18 + (0.53304517269134521) * gru_1_rev_t1_h_19 + (0.94785535335540771) * gru_1_rev_t1_h_20 + (0.53796678781509399) * gru_1_rev_t1_h_21 + (-1.4437532424926758) * gru_1_rev_t1_h_22 + (1.3672821521759033) * gru_1_rev_t1_h_23 + (0.018310785293579102) * gru_1_rev_t1_h_24 + (-0.15662123262882233) * gru_1_rev_t1_h_25 + (-0.87659215927124023) * gru_1_rev_t1_h_26 + (-1.2991909980773926) * gru_1_rev_t1_h_27 + (3.2223484516143799) * gru_1_rev_t1_h_28 + (0.63181602954864502) * gru_1_rev_t1_h_29 + (2.3474366664886475) * gru_1_rev_t1_h_30 + (-0.36722493171691895) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.44227322936058044) + (-0.21850600838661194) * gru_0_out_t0_0 + (-0.7310950756072998) * gru_0_out_t0_1 + (0.42367720603942871) * gru_0_out_t0_2 + (0.48620641231536865) * gru_0_out_t0_3 + (-0.67666035890579224) * gru_0_out_t0_4 + (-0.68617582321166992) * gru_0_out_t0_5 + (1.5264557600021362) * gru_0_out_t0_6 + (-1.455356240272522) * gru_0_out_t0_7 + (-0.6247294545173645) * gru_0_out_t0_8 + (-0.50455397367477417) * gru_0_out_t0_9 + (-1.1144506931304932) * gru_0_out_t0_10 + (-0.41711091995239258) * gru_0_out_t0_11 + (0.91959434747695923) * gru_0_out_t0_12 + (0.19608889520168304) * gru_0_out_t0_13 + (-0.18951871991157532) * gru_0_out_t0_14 + (-0.10637872666120529) * gru_0_out_t0_15 + (-0.3021526038646698) * gru_0_out_t0_16 + (-0.73989778757095337) * gru_0_out_t0_17 + (0.29301938414573669) * gru_0_out_t0_18 + (1.5125272274017334) * gru_0_out_t0_19 + (-0.23356017470359802) * gru_0_out_t0_20 + (-0.92266732454299927) * gru_0_out_t0_21 + (-0.3032691478729248) * gru_0_out_t0_22 + (0.75643694400787354) * gru_0_out_t0_23 + (-0.42981496453285217) * gru_0_out_t0_24 + (-0.80385547876358032) * gru_0_out_t0_25 + (-0.81996655464172363) * gru_0_out_t0_26 + (0.44457468390464783) * gru_0_out_t0_27 + (0.49909830093383789) * gru_0_out_t0_28 + (-0.9957730770111084) * gru_0_out_t0_29 + (0.2541067898273468) * gru_0_out_t0_30 + (0.65908408164978027) * gru_0_out_t0_31 + (-0.87052041292190552) * gru_0_out_t0_32 + (-0.33276680111885071) * gru_0_out_t0_33 + (0.4800797700881958) * gru_0_out_t0_34 + (0.54547256231307983) * gru_0_out_t0_35 + (0.38553181290626526) * gru_0_out_t0_36 + (-0.58588927984237671) * gru_0_out_t0_37 + (0.57059282064437866) * gru_0_out_t0_38 + (-0.62960571050643921) * gru_0_out_t0_39 + (1.4591929912567139) * gru_0_out_t0_40 + (0.67755550146102905) * gru_0_out_t0_41 + (-0.77732712030410767) * gru_0_out_t0_42 + (-0.073959782719612122) * gru_0_out_t0_43 + (-0.0013122587697580457) * gru_0_out_t0_44 + (0.28594070672988892) * gru_0_out_t0_45 + (-2.6861422061920166) * gru_0_out_t0_46 + (0.035561736673116684) * gru_0_out_t0_47 + (-0.75469881296157837) * gru_0_out_t0_48 + (-0.2337968498468399) * gru_0_out_t0_49 + (0.1939275711774826) * gru_0_out_t0_50 + (-0.33581367135047913) * gru_0_out_t0_51 + (0.31883317232131958) * gru_0_out_t0_52 + (-0.36054894328117371) * gru_0_out_t0_53 + (-1.1178292036056519) * gru_0_out_t0_54 + (-0.23496320843696594) * gru_0_out_t0_55 + (0.52693843841552734) * gru_0_out_t0_56 + (0.33940580487251282) * gru_0_out_t0_57 + (-0.15926779806613922) * gru_0_out_t0_58 + (1.7501543760299683) * gru_0_out_t0_59 + (0.32313439249992371) * gru_0_out_t0_60 + (-0.20621946454048157) * gru_0_out_t0_61 + (0.13146002590656281) * gru_0_out_t0_62 + (-0.017668968066573143) * gru_0_out_t0_63 + (1.299920916557312) * gru_1_rev_t1_h_0 + (0.28816479444503784) * gru_1_rev_t1_h_1 + (0.25450631976127625) * gru_1_rev_t1_h_2 + (-0.69665884971618652) * gru_1_rev_t1_h_3 + (-0.74128979444503784) * gru_1_rev_t1_h_4 + (0.65804886817932129) * gru_1_rev_t1_h_5 + (-0.70485895872116089) * gru_1_rev_t1_h_6 + (0.27145007252693176) * gru_1_rev_t1_h_7 + (-0.2010025680065155) * gru_1_rev_t1_h_8 + (-0.34721091389656067) * gru_1_rev_t1_h_9 + (-0.7082182765007019) * gru_1_rev_t1_h_10 + (0.027230614796280861) * gru_1_rev_t1_h_11 + (0.59352654218673706) * gru_1_rev_t1_h_12 + (0.72958862781524658) * gru_1_rev_t1_h_13 + (0.047824457287788391) * gru_1_rev_t1_h_14 + (-1.5103543996810913) * gru_1_rev_t1_h_15 + (-0.022831697016954422) * gru_1_rev_t1_h_16 + (-0.5142483115196228) * gru_1_rev_t1_h_17 + (-0.33398729562759399) * gru_1_rev_t1_h_18 + (-0.086465522646903992) * gru_1_rev_t1_h_19 + (-0.40240710973739624) * gru_1_rev_t1_h_20 + (0.43961226940155029) * gru_1_rev_t1_h_21 + (-0.34033855795860291) * gru_1_rev_t1_h_22 + (1.2316315174102783) * gru_1_rev_t1_h_23 + (-0.3097844123840332) * gru_1_rev_t1_h_24 + (-0.026938857510685921) * gru_1_rev_t1_h_25 + (0.30688565969467163) * gru_1_rev_t1_h_26 + (0.26818600296974182) * gru_1_rev_t1_h_27 + (-2.3415427207946777) * gru_1_rev_t1_h_28 + (-0.59448349475860596) * gru_1_rev_t1_h_29 + (0.34691375494003296) * gru_1_rev_t1_h_30 + (-0.24157185852527618) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.012219520285725594) + (-0.20780402421951294) * gru_0_out_t0_0 + (-0.0026832965668290854) * gru_0_out_t0_1 + (0.45621770620346069) * gru_0_out_t0_2 + (0.22725893557071686) * gru_0_out_t0_3 + (-0.38065177202224731) * gru_0_out_t0_4 + (-0.087196126580238342) * gru_0_out_t0_5 + (0.34167280793190002) * gru_0_out_t0_6 + (-0.21362018585205078) * gru_0_out_t0_7 + (0.28855735063552856) * gru_0_out_t0_8 + (-0.19377273321151733) * gru_0_out_t0_9 + (-0.87108749151229858) * gru_0_out_t0_10 + (-0.47549352049827576) * gru_0_out_t0_11 + (-0.23855489492416382) * gru_0_out_t0_12 + (0.25526523590087891) * gru_0_out_t0_13 + (-0.66180497407913208) * gru_0_out_t0_14 + (0.5743098258972168) * gru_0_out_t0_15 + (-0.58508223295211792) * gru_0_out_t0_16 + (-0.24840687215328217) * gru_0_out_t0_17 + (0.29912793636322021) * gru_0_out_t0_18 + (-0.012425573542714119) * gru_0_out_t0_19 + (0.25449204444885254) * gru_0_out_t0_20 + (-1.8550071716308594) * gru_0_out_t0_21 + (0.2841765284538269) * gru_0_out_t0_22 + (0.25805601477622986) * gru_0_out_t0_23 + (-0.5748213529586792) * gru_0_out_t0_24 + (-0.45939794182777405) * gru_0_out_t0_25 + (-0.0074814409017562866) * gru_0_out_t0_26 + (0.51099127531051636) * gru_0_out_t0_27 + (-0.25700733065605164) * gru_0_out_t0_28 + (0.25135305523872375) * gru_0_out_t0_29 + (-0.18593892455101013) * gru_0_out_t0_30 + (0.76798194646835327) * gru_0_out_t0_31 + (-0.73348087072372437) * gru_0_out_t0_32 + (-0.98755848407745361) * gru_0_out_t0_33 + (-0.1546047031879425) * gru_0_out_t0_34 + (0.30265974998474121) * gru_0_out_t0_35 + (0.4441315233707428) * gru_0_out_t0_36 + (-0.20875450968742371) * gru_0_out_t0_37 + (0.77092307806015015) * gru_0_out_t0_38 + (0.58746165037155151) * gru_0_out_t0_39 + (-1.1697883605957031) * gru_0_out_t0_40 + (0.27910000085830688) * gru_0_out_t0_41 + (-0.16143356263637543) * gru_0_out_t0_42 + (0.2880476713180542) * gru_0_out_t0_43 + (0.48523822426795959) * gru_0_out_t0_44 + (0.32786557078361511) * gru_0_out_t0_45 + (-0.82991600036621094) * gru_0_out_t0_46 + (0.85194498300552368) * gru_0_out_t0_47 + (0.85600399971008301) * gru_0_out_t0_48 + (-0.59633147716522217) * gru_0_out_t0_49 + (-0.94536548852920532) * gru_0_out_t0_50 + (-0.29678067564964294) * gru_0_out_t0_51 + (0.3879534900188446) * gru_0_out_t0_52 + (-0.543770432472229) * gru_0_out_t0_53 + (-0.20589473843574524) * gru_0_out_t0_54 + (0.085477903485298157) * gru_0_out_t0_55 + (0.61352998018264771) * gru_0_out_t0_56 + (-0.57839703559875488) * gru_0_out_t0_57 + (-0.58938181400299072) * gru_0_out_t0_58 + (0.125187948346138) * gru_0_out_t0_59 + (0.70047521591186523) * gru_0_out_t0_60 + (-0.11797461658716202) * gru_0_out_t0_61 + (0.95170670747756958) * gru_0_out_t0_62 + (-0.53871250152587891) * gru_0_out_t0_63 + gate_r * ((-0.1497119814157486) + (0.49774333834648132) * gru_1_rev_t1_h_0 + (0.078125707805156708) * gru_1_rev_t1_h_1 + (0.15018138289451599) * gru_1_rev_t1_h_2 + (0.48130506277084351) * gru_1_rev_t1_h_3 + (-0.96374291181564331) * gru_1_rev_t1_h_4 + (-0.26431038975715637) * gru_1_rev_t1_h_5 + (-0.2318902313709259) * gru_1_rev_t1_h_6 + (0.16501238942146301) * gru_1_rev_t1_h_7 + (0.33484542369842529) * gru_1_rev_t1_h_8 + (-0.26676395535469055) * gru_1_rev_t1_h_9 + (0.71060198545455933) * gru_1_rev_t1_h_10 + (0.12320603430271149) * gru_1_rev_t1_h_11 + (-1.2173291444778442) * gru_1_rev_t1_h_12 + (0.82299745082855225) * gru_1_rev_t1_h_13 + (-0.53584504127502441) * gru_1_rev_t1_h_14 + (0.28913107514381409) * gru_1_rev_t1_h_15 + (-0.954154372215271) * gru_1_rev_t1_h_16 + (0.72333693504333496) * gru_1_rev_t1_h_17 + (0.40067127346992493) * gru_1_rev_t1_h_18 + (0.048737909644842148) * gru_1_rev_t1_h_19 + (-0.33992832899093628) * gru_1_rev_t1_h_20 + (-0.76566272974014282) * gru_1_rev_t1_h_21 + (0.12135640531778336) * gru_1_rev_t1_h_22 + (-0.12922905385494232) * gru_1_rev_t1_h_23 + (-0.65529811382293701) * gru_1_rev_t1_h_24 + (-0.69225847721099854) * gru_1_rev_t1_h_25 + (0.2011922150850296) * gru_1_rev_t1_h_26 + (0.49846398830413818) * gru_1_rev_t1_h_27 + (0.75606369972229004) * gru_1_rev_t1_h_28 + (-0.77764654159545898) * gru_1_rev_t1_h_29 + (0.88152611255645752) * gru_1_rev_t1_h_30 + (-0.52552968263626099) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_1 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_1;
    // h=2
    gate_r = sigmoid((-0.29359552264213562) + (-0.30851709842681885) * gru_0_out_t0_0 + (0.10630916059017181) * gru_0_out_t0_1 + (-0.52118217945098877) * gru_0_out_t0_2 + (1.0581414699554443) * gru_0_out_t0_3 + (-0.021844638511538506) * gru_0_out_t0_4 + (1.0310388803482056) * gru_0_out_t0_5 + (4.1587996482849121) * gru_0_out_t0_6 + (0.46692392230033875) * gru_0_out_t0_7 + (0.32975688576698303) * gru_0_out_t0_8 + (-2.77455735206604) * gru_0_out_t0_9 + (1.1535125970840454) * gru_0_out_t0_10 + (0.31193983554840088) * gru_0_out_t0_11 + (0.29254361987113953) * gru_0_out_t0_12 + (0.51572608947753906) * gru_0_out_t0_13 + (-0.22981269657611847) * gru_0_out_t0_14 + (0.26099058985710144) * gru_0_out_t0_15 + (-0.14098379015922546) * gru_0_out_t0_16 + (-0.11069414764642715) * gru_0_out_t0_17 + (-0.34626680612564087) * gru_0_out_t0_18 + (0.99610620737075806) * gru_0_out_t0_19 + (-0.52057719230651855) * gru_0_out_t0_20 + (-1.9270204305648804) * gru_0_out_t0_21 + (2.3346488475799561) * gru_0_out_t0_22 + (-0.0057712085545063019) * gru_0_out_t0_23 + (0.71812915802001953) * gru_0_out_t0_24 + (0.0057410052977502346) * gru_0_out_t0_25 + (-0.29757252335548401) * gru_0_out_t0_26 + (1.0797752141952515) * gru_0_out_t0_27 + (-1.2741584777832031) * gru_0_out_t0_28 + (-1.4562393426895142) * gru_0_out_t0_29 + (-0.065648555755615234) * gru_0_out_t0_30 + (-0.84069466590881348) * gru_0_out_t0_31 + (-0.9378388524055481) * gru_0_out_t0_32 + (0.16944015026092529) * gru_0_out_t0_33 + (0.030433623120188713) * gru_0_out_t0_34 + (0.16765798628330231) * gru_0_out_t0_35 + (0.36457657814025879) * gru_0_out_t0_36 + (0.07195708155632019) * gru_0_out_t0_37 + (-0.12130691111087799) * gru_0_out_t0_38 + (-2.2531247138977051) * gru_0_out_t0_39 + (-6.230186939239502) * gru_0_out_t0_40 + (0.12616020441055298) * gru_0_out_t0_41 + (-0.4558638334274292) * gru_0_out_t0_42 + (0.069745369255542755) * gru_0_out_t0_43 + (-0.11587700247764587) * gru_0_out_t0_44 + (-0.76109570264816284) * gru_0_out_t0_45 + (-2.4116475582122803) * gru_0_out_t0_46 + (0.014376847073435783) * gru_0_out_t0_47 + (-0.15219645202159882) * gru_0_out_t0_48 + (-0.18007808923721313) * gru_0_out_t0_49 + (0.78601598739624023) * gru_0_out_t0_50 + (-0.09346858412027359) * gru_0_out_t0_51 + (0.037853322923183441) * gru_0_out_t0_52 + (0.2071223258972168) * gru_0_out_t0_53 + (-0.56144142150878906) * gru_0_out_t0_54 + (-0.47393777966499329) * gru_0_out_t0_55 + (-0.30988287925720215) * gru_0_out_t0_56 + (0.39365428686141968) * gru_0_out_t0_57 + (-0.36413618922233582) * gru_0_out_t0_58 + (1.4322688579559326) * gru_0_out_t0_59 + (0.55603688955307007) * gru_0_out_t0_60 + (-0.22911778092384338) * gru_0_out_t0_61 + (0.16704843938350677) * gru_0_out_t0_62 + (-0.43199557065963745) * gru_0_out_t0_63 + (-2.0993752479553223) * gru_1_rev_t1_h_0 + (-0.22694727778434753) * gru_1_rev_t1_h_1 + (0.87581753730773926) * gru_1_rev_t1_h_2 + (1.187531590461731) * gru_1_rev_t1_h_3 + (-0.16048520803451538) * gru_1_rev_t1_h_4 + (-0.41321611404418945) * gru_1_rev_t1_h_5 + (0.20659849047660828) * gru_1_rev_t1_h_6 + (-0.10270600020885468) * gru_1_rev_t1_h_7 + (0.44459480047225952) * gru_1_rev_t1_h_8 + (1.1629283428192139) * gru_1_rev_t1_h_9 + (-0.214214026927948) * gru_1_rev_t1_h_10 + (-0.37804627418518066) * gru_1_rev_t1_h_11 + (-0.052704166620969772) * gru_1_rev_t1_h_12 + (-0.54979461431503296) * gru_1_rev_t1_h_13 + (-0.84141039848327637) * gru_1_rev_t1_h_14 + (0.4832378625869751) * gru_1_rev_t1_h_15 + (-0.38649716973304749) * gru_1_rev_t1_h_16 + (0.74789333343505859) * gru_1_rev_t1_h_17 + (1.7124238014221191) * gru_1_rev_t1_h_18 + (1.9276484251022339) * gru_1_rev_t1_h_19 + (0.41676181554794312) * gru_1_rev_t1_h_20 + (-0.43321910500526428) * gru_1_rev_t1_h_21 + (0.44823488593101501) * gru_1_rev_t1_h_22 + (-0.29335722327232361) * gru_1_rev_t1_h_23 + (0.91846072673797607) * gru_1_rev_t1_h_24 + (0.81710702180862427) * gru_1_rev_t1_h_25 + (0.29132866859436035) * gru_1_rev_t1_h_26 + (1.1272709369659424) * gru_1_rev_t1_h_27 + (-1.5756014585494995) * gru_1_rev_t1_h_28 + (0.3834226131439209) * gru_1_rev_t1_h_29 + (0.38600006699562073) * gru_1_rev_t1_h_30 + (-0.54183357954025269) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.43784698843955994) + (-0.018855109810829163) * gru_0_out_t0_0 + (-0.58723640441894531) * gru_0_out_t0_1 + (0.058743558824062347) * gru_0_out_t0_2 + (0.53357982635498047) * gru_0_out_t0_3 + (-0.428518146276474) * gru_0_out_t0_4 + (-0.3275763988494873) * gru_0_out_t0_5 + (0.68564492464065552) * gru_0_out_t0_6 + (-0.39698010683059692) * gru_0_out_t0_7 + (0.15838627517223358) * gru_0_out_t0_8 + (-1.0199624300003052) * gru_0_out_t0_9 + (-0.38474291563034058) * gru_0_out_t0_10 + (-0.55515635013580322) * gru_0_out_t0_11 + (0.39176470041275024) * gru_0_out_t0_12 + (-0.027490871027112007) * gru_0_out_t0_13 + (0.73575741052627563) * gru_0_out_t0_14 + (0.50056916475296021) * gru_0_out_t0_15 + (-1.2056490182876587) * gru_0_out_t0_16 + (-0.040703266859054565) * gru_0_out_t0_17 + (-0.038887947797775269) * gru_0_out_t0_18 + (0.43591615557670593) * gru_0_out_t0_19 + (-0.0099730277433991432) * gru_0_out_t0_20 + (-1.3062015771865845) * gru_0_out_t0_21 + (0.058146044611930847) * gru_0_out_t0_22 + (0.047639269381761551) * gru_0_out_t0_23 + (0.37951111793518066) * gru_0_out_t0_24 + (-0.25028958916664124) * gru_0_out_t0_25 + (0.80443602800369263) * gru_0_out_t0_26 + (0.28285908699035645) * gru_0_out_t0_27 + (-1.7759672403335571) * gru_0_out_t0_28 + (-0.15853141248226166) * gru_0_out_t0_29 + (-0.36927178502082825) * gru_0_out_t0_30 + (1.172264575958252) * gru_0_out_t0_31 + (0.31176963448524475) * gru_0_out_t0_32 + (0.11376465111970901) * gru_0_out_t0_33 + (0.28411510586738586) * gru_0_out_t0_34 + (0.46776485443115234) * gru_0_out_t0_35 + (0.20641888678073883) * gru_0_out_t0_36 + (-0.46705728769302368) * gru_0_out_t0_37 + (-0.11918076872825623) * gru_0_out_t0_38 + (0.4385235607624054) * gru_0_out_t0_39 + (-1.9194539785385132) * gru_0_out_t0_40 + (0.69094270467758179) * gru_0_out_t0_41 + (0.59324854612350464) * gru_0_out_t0_42 + (0.084542065858840942) * gru_0_out_t0_43 + (0.38348358869552612) * gru_0_out_t0_44 + (0.5126233696937561) * gru_0_out_t0_45 + (0.17638643085956573) * gru_0_out_t0_46 + (0.10237032175064087) * gru_0_out_t0_47 + (-0.50119763612747192) * gru_0_out_t0_48 + (0.59258264303207397) * gru_0_out_t0_49 + (0.064152315258979797) * gru_0_out_t0_50 + (-0.29318258166313171) * gru_0_out_t0_51 + (0.034756578505039215) * gru_0_out_t0_52 + (-0.072132214903831482) * gru_0_out_t0_53 + (1.3972070217132568) * gru_0_out_t0_54 + (1.1079283952713013) * gru_0_out_t0_55 + (0.099384427070617676) * gru_0_out_t0_56 + (0.2537473738193512) * gru_0_out_t0_57 + (-0.59472364187240601) * gru_0_out_t0_58 + (-0.78708744049072266) * gru_0_out_t0_59 + (-0.16626006364822388) * gru_0_out_t0_60 + (0.61122870445251465) * gru_0_out_t0_61 + (0.67303657531738281) * gru_0_out_t0_62 + (0.40167546272277832) * gru_0_out_t0_63 + (0.48487779498100281) * gru_1_rev_t1_h_0 + (-0.36795413494110107) * gru_1_rev_t1_h_1 + (0.75819557905197144) * gru_1_rev_t1_h_2 + (-0.403220534324646) * gru_1_rev_t1_h_3 + (0.28814637660980225) * gru_1_rev_t1_h_4 + (-0.0036731052678078413) * gru_1_rev_t1_h_5 + (-0.4333760142326355) * gru_1_rev_t1_h_6 + (0.44037216901779175) * gru_1_rev_t1_h_7 + (-0.16652347147464752) * gru_1_rev_t1_h_8 + (-0.36442044377326965) * gru_1_rev_t1_h_9 + (0.38615012168884277) * gru_1_rev_t1_h_10 + (0.93189501762390137) * gru_1_rev_t1_h_11 + (-1.2922149896621704) * gru_1_rev_t1_h_12 + (-0.72717654705047607) * gru_1_rev_t1_h_13 + (0.16039265692234039) * gru_1_rev_t1_h_14 + (-0.34681978821754456) * gru_1_rev_t1_h_15 + (-0.25129231810569763) * gru_1_rev_t1_h_16 + (-0.62005156278610229) * gru_1_rev_t1_h_17 + (-0.54391366243362427) * gru_1_rev_t1_h_18 + (0.74952501058578491) * gru_1_rev_t1_h_19 + (0.90544033050537109) * gru_1_rev_t1_h_20 + (-0.50156527757644653) * gru_1_rev_t1_h_21 + (-0.88940131664276123) * gru_1_rev_t1_h_22 + (0.70264983177185059) * gru_1_rev_t1_h_23 + (-0.49386757612228394) * gru_1_rev_t1_h_24 + (0.093799814581871033) * gru_1_rev_t1_h_25 + (0.20935836434364319) * gru_1_rev_t1_h_26 + (-0.48495751619338989) * gru_1_rev_t1_h_27 + (-1.096301794052124) * gru_1_rev_t1_h_28 + (-0.32393267750740051) * gru_1_rev_t1_h_29 + (0.92878276109695435) * gru_1_rev_t1_h_30 + (0.30476319789886475) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.036338925361633301) + (0.15184362232685089) * gru_0_out_t0_0 + (0.074002064764499664) * gru_0_out_t0_1 + (-0.60322803258895874) * gru_0_out_t0_2 + (-0.49432352185249329) * gru_0_out_t0_3 + (0.13194677233695984) * gru_0_out_t0_4 + (0.15184587240219116) * gru_0_out_t0_5 + (-0.7278296947479248) * gru_0_out_t0_6 + (-0.22918656468391418) * gru_0_out_t0_7 + (0.15080161392688751) * gru_0_out_t0_8 + (0.32200855016708374) * gru_0_out_t0_9 + (1.1495007276535034) * gru_0_out_t0_10 + (0.41310107707977295) * gru_0_out_t0_11 + (-0.35486513376235962) * gru_0_out_t0_12 + (0.24678005278110504) * gru_0_out_t0_13 + (0.029497832059860229) * gru_0_out_t0_14 + (-0.34316501021385193) * gru_0_out_t0_15 + (0.11734772473573685) * gru_0_out_t0_16 + (0.19860650599002838) * gru_0_out_t0_17 + (-0.013839568011462688) * gru_0_out_t0_18 + (-0.25995168089866638) * gru_0_out_t0_19 + (0.85276490449905396) * gru_0_out_t0_20 + (0.56019854545593262) * gru_0_out_t0_21 + (0.057018883526325226) * gru_0_out_t0_22 + (0.056567691266536713) * gru_0_out_t0_23 + (0.84792256355285645) * gru_0_out_t0_24 + (0.35751515626907349) * gru_0_out_t0_25 + (0.12265323847532272) * gru_0_out_t0_26 + (-0.40500184893608093) * gru_0_out_t0_27 + (-0.048174962401390076) * gru_0_out_t0_28 + (-0.1416359543800354) * gru_0_out_t0_29 + (0.15839573740959167) * gru_0_out_t0_30 + (-1.6904621124267578) * gru_0_out_t0_31 + (0.94405484199523926) * gru_0_out_t0_32 + (0.50102978944778442) * gru_0_out_t0_33 + (0.078424066305160522) * gru_0_out_t0_34 + (-0.250348299741745) * gru_0_out_t0_35 + (-0.23872998356819153) * gru_0_out_t0_36 + (0.086814664304256439) * gru_0_out_t0_37 + (-0.36284878849983215) * gru_0_out_t0_38 + (0.34516936540603638) * gru_0_out_t0_39 + (-1.0351132154464722) * gru_0_out_t0_40 + (0.016523202881217003) * gru_0_out_t0_41 + (0.58652973175048828) * gru_0_out_t0_42 + (-0.29010611772537231) * gru_0_out_t0_43 + (-0.3234105110168457) * gru_0_out_t0_44 + (-0.20859168469905853) * gru_0_out_t0_45 + (1.0047365427017212) * gru_0_out_t0_46 + (-0.98380160331726074) * gru_0_out_t0_47 + (-0.77846169471740723) * gru_0_out_t0_48 + (0.79964578151702881) * gru_0_out_t0_49 + (0.47566342353820801) * gru_0_out_t0_50 + (-0.10172613710165024) * gru_0_out_t0_51 + (-0.30825012922286987) * gru_0_out_t0_52 + (0.73772144317626953) * gru_0_out_t0_53 + (0.11490385979413986) * gru_0_out_t0_54 + (0.1627524346113205) * gru_0_out_t0_55 + (-1.2375884056091309) * gru_0_out_t0_56 + (0.63083767890930176) * gru_0_out_t0_57 + (-0.025980975478887558) * gru_0_out_t0_58 + (-1.0682672262191772) * gru_0_out_t0_59 + (-1.1967281103134155) * gru_0_out_t0_60 + (-0.23492655158042908) * gru_0_out_t0_61 + (-0.47744584083557129) * gru_0_out_t0_62 + (-1.0851637125015259) * gru_0_out_t0_63 + gate_r * ((0.035252805799245834) + (-0.020339563488960266) * gru_1_rev_t1_h_0 + (0.015279458835721016) * gru_1_rev_t1_h_1 + (-0.37479671835899353) * gru_1_rev_t1_h_2 + (0.21169449388980865) * gru_1_rev_t1_h_3 + (-0.22726538777351379) * gru_1_rev_t1_h_4 + (0.34984847903251648) * gru_1_rev_t1_h_5 + (-1.2669180631637573) * gru_1_rev_t1_h_6 + (-0.41244286298751831) * gru_1_rev_t1_h_7 + (0.4675370454788208) * gru_1_rev_t1_h_8 + (0.21022117137908936) * gru_1_rev_t1_h_9 + (-0.067724481225013733) * gru_1_rev_t1_h_10 + (-1.5817868709564209) * gru_1_rev_t1_h_11 + (1.9594063758850098) * gru_1_rev_t1_h_12 + (1.677892804145813) * gru_1_rev_t1_h_13 + (-0.24803711473941803) * gru_1_rev_t1_h_14 + (0.40486383438110352) * gru_1_rev_t1_h_15 + (-0.6956285834312439) * gru_1_rev_t1_h_16 + (0.20579676330089569) * gru_1_rev_t1_h_17 + (-0.41395419836044312) * gru_1_rev_t1_h_18 + (-0.20070114731788635) * gru_1_rev_t1_h_19 + (0.50337624549865723) * gru_1_rev_t1_h_20 + (0.62259000539779663) * gru_1_rev_t1_h_21 + (-0.56309157609939575) * gru_1_rev_t1_h_22 + (-0.63929855823516846) * gru_1_rev_t1_h_23 + (0.40089982748031616) * gru_1_rev_t1_h_24 + (1.1522977352142334) * gru_1_rev_t1_h_25 + (0.36090049147605896) * gru_1_rev_t1_h_26 + (-0.42320054769515991) * gru_1_rev_t1_h_27 + (0.040643405169248581) * gru_1_rev_t1_h_28 + (-0.37114626169204712) * gru_1_rev_t1_h_29 + (-1.1277205944061279) * gru_1_rev_t1_h_30 + (-0.17881783843040466) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_2 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_2;
    // h=3
    gate_r = sigmoid((0.3057715892791748) + (0.28386944532394409) * gru_0_out_t0_0 + (0.48094919323921204) * gru_0_out_t0_1 + (-0.63467681407928467) * gru_0_out_t0_2 + (-0.67109549045562744) * gru_0_out_t0_3 + (0.30236199498176575) * gru_0_out_t0_4 + (1.1504365205764771) * gru_0_out_t0_5 + (-0.21222943067550659) * gru_0_out_t0_6 + (-0.2851472795009613) * gru_0_out_t0_7 + (0.97742176055908203) * gru_0_out_t0_8 + (-0.43844521045684814) * gru_0_out_t0_9 + (0.63239294290542603) * gru_0_out_t0_10 + (-0.15549629926681519) * gru_0_out_t0_11 + (-0.17926536500453949) * gru_0_out_t0_12 + (0.16486240923404694) * gru_0_out_t0_13 + (-0.031540501862764359) * gru_0_out_t0_14 + (1.069970965385437) * gru_0_out_t0_15 + (0.52673977613449097) * gru_0_out_t0_16 + (-0.0064126881770789623) * gru_0_out_t0_17 + (0.5992472767829895) * gru_0_out_t0_18 + (-0.18491768836975098) * gru_0_out_t0_19 + (-0.11631443351507187) * gru_0_out_t0_20 + (0.70930790901184082) * gru_0_out_t0_21 + (-0.14091587066650391) * gru_0_out_t0_22 + (0.013239732943475246) * gru_0_out_t0_23 + (2.0339243412017822) * gru_0_out_t0_24 + (0.48630067706108093) * gru_0_out_t0_25 + (0.44641673564910889) * gru_0_out_t0_26 + (-1.0603811740875244) * gru_0_out_t0_27 + (0.36119160056114197) * gru_0_out_t0_28 + (0.23778082430362701) * gru_0_out_t0_29 + (0.086604051291942596) * gru_0_out_t0_30 + (-3.326984167098999) * gru_0_out_t0_31 + (-0.34258529543876648) * gru_0_out_t0_32 + (2.2508060932159424) * gru_0_out_t0_33 + (0.71955138444900513) * gru_0_out_t0_34 + (-0.14840622246265411) * gru_0_out_t0_35 + (-0.06038583442568779) * gru_0_out_t0_36 + (0.42593801021575928) * gru_0_out_t0_37 + (-2.3285489082336426) * gru_0_out_t0_38 + (1.4976804256439209) * gru_0_out_t0_39 + (1.3908429145812988) * gru_0_out_t0_40 + (0.20749986171722412) * gru_0_out_t0_41 + (0.86148250102996826) * gru_0_out_t0_42 + (-0.5566285252571106) * gru_0_out_t0_43 + (-0.25818610191345215) * gru_0_out_t0_44 + (-0.51359099149703979) * gru_0_out_t0_45 + (0.90015131235122681) * gru_0_out_t0_46 + (0.53005307912826538) * gru_0_out_t0_47 + (0.010345185175538063) * gru_0_out_t0_48 + (-0.093372732400894165) * gru_0_out_t0_49 + (-1.0434112548828125) * gru_0_out_t0_50 + (0.63623619079589844) * gru_0_out_t0_51 + (-1.6267426013946533) * gru_0_out_t0_52 + (-0.20427854359149933) * gru_0_out_t0_53 + (-0.011858790181577206) * gru_0_out_t0_54 + (-0.13568316400051117) * gru_0_out_t0_55 + (1.0888692140579224) * gru_0_out_t0_56 + (0.16366212069988251) * gru_0_out_t0_57 + (0.1778351217508316) * gru_0_out_t0_58 + (-0.74162346124649048) * gru_0_out_t0_59 + (0.14643973112106323) * gru_0_out_t0_60 + (-0.19997216761112213) * gru_0_out_t0_61 + (-1.9679572582244873) * gru_0_out_t0_62 + (0.91109859943389893) * gru_0_out_t0_63 + (-1.393014669418335) * gru_1_rev_t1_h_0 + (-0.88358557224273682) * gru_1_rev_t1_h_1 + (0.84003007411956787) * gru_1_rev_t1_h_2 + (-0.097181119024753571) * gru_1_rev_t1_h_3 + (0.95726686716079712) * gru_1_rev_t1_h_4 + (-0.40201267600059509) * gru_1_rev_t1_h_5 + (1.8771677017211914) * gru_1_rev_t1_h_6 + (-0.051425531506538391) * gru_1_rev_t1_h_7 + (0.58183729648590088) * gru_1_rev_t1_h_8 + (0.5034947395324707) * gru_1_rev_t1_h_9 + (0.63637334108352661) * gru_1_rev_t1_h_10 + (-0.7493242621421814) * gru_1_rev_t1_h_11 + (-0.748970627784729) * gru_1_rev_t1_h_12 + (-1.4326728582382202) * gru_1_rev_t1_h_13 + (1.8572380542755127) * gru_1_rev_t1_h_14 + (-0.087580576539039612) * gru_1_rev_t1_h_15 + (0.26150813698768616) * gru_1_rev_t1_h_16 + (-0.50074493885040283) * gru_1_rev_t1_h_17 + (0.3271954357624054) * gru_1_rev_t1_h_18 + (-0.48446941375732422) * gru_1_rev_t1_h_19 + (0.51142704486846924) * gru_1_rev_t1_h_20 + (-0.85846930742263794) * gru_1_rev_t1_h_21 + (-2.0628676414489746) * gru_1_rev_t1_h_22 + (-0.79688411951065063) * gru_1_rev_t1_h_23 + (-2.009915828704834) * gru_1_rev_t1_h_24 + (-0.38876944780349731) * gru_1_rev_t1_h_25 + (0.29520708322525024) * gru_1_rev_t1_h_26 + (-1.2365313768386841) * gru_1_rev_t1_h_27 + (-1.9437899589538574) * gru_1_rev_t1_h_28 + (-0.46036922931671143) * gru_1_rev_t1_h_29 + (1.4608927965164185) * gru_1_rev_t1_h_30 + (0.254873126745224) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.90226072072982788) + (-0.57960128784179688) * gru_0_out_t0_0 + (0.27242559194564819) * gru_0_out_t0_1 + (-0.21327109634876251) * gru_0_out_t0_2 + (0.92762881517410278) * gru_0_out_t0_3 + (-0.68291246891021729) * gru_0_out_t0_4 + (-0.0072710723616182804) * gru_0_out_t0_5 + (0.60033214092254639) * gru_0_out_t0_6 + (-0.56621193885803223) * gru_0_out_t0_7 + (0.25618168711662292) * gru_0_out_t0_8 + (-0.076130054891109467) * gru_0_out_t0_9 + (0.51074522733688354) * gru_0_out_t0_10 + (0.3785252571105957) * gru_0_out_t0_11 + (0.39193156361579895) * gru_0_out_t0_12 + (0.016653843224048615) * gru_0_out_t0_13 + (-0.2917608916759491) * gru_0_out_t0_14 + (0.75295233726501465) * gru_0_out_t0_15 + (-0.16976532340049744) * gru_0_out_t0_16 + (-0.36052417755126953) * gru_0_out_t0_17 + (0.058370880782604218) * gru_0_out_t0_18 + (1.475817084312439) * gru_0_out_t0_19 + (-0.67850083112716675) * gru_0_out_t0_20 + (-0.36024388670921326) * gru_0_out_t0_21 + (0.92130082845687866) * gru_0_out_t0_22 + (-0.28144925832748413) * gru_0_out_t0_23 + (0.19770348072052002) * gru_0_out_t0_24 + (0.020706238225102425) * gru_0_out_t0_25 + (-0.47938063740730286) * gru_0_out_t0_26 + (0.17671151459217072) * gru_0_out_t0_27 + (2.200359582901001) * gru_0_out_t0_28 + (0.3864733874797821) * gru_0_out_t0_29 + (-0.8821900486946106) * gru_0_out_t0_30 + (1.5857840776443481) * gru_0_out_t0_31 + (-0.88015270233154297) * gru_0_out_t0_32 + (-0.56279444694519043) * gru_0_out_t0_33 + (-0.17454081773757935) * gru_0_out_t0_34 + (-0.4465658962726593) * gru_0_out_t0_35 + (-0.19824768602848053) * gru_0_out_t0_36 + (-0.026263585314154625) * gru_0_out_t0_37 + (0.34509462118148804) * gru_0_out_t0_38 + (-0.58315318822860718) * gru_0_out_t0_39 + (-1.1590234041213989) * gru_0_out_t0_40 + (1.0535933971405029) * gru_0_out_t0_41 + (0.059686549007892609) * gru_0_out_t0_42 + (0.023495079949498177) * gru_0_out_t0_43 + (-0.018236514180898666) * gru_0_out_t0_44 + (0.35238757729530334) * gru_0_out_t0_45 + (1.5738825798034668) * gru_0_out_t0_46 + (0.33520233631134033) * gru_0_out_t0_47 + (0.21965025365352631) * gru_0_out_t0_48 + (-0.17517662048339844) * gru_0_out_t0_49 + (-0.018518527969717979) * gru_0_out_t0_50 + (0.29251983761787415) * gru_0_out_t0_51 + (0.2362152636051178) * gru_0_out_t0_52 + (0.053717028349637985) * gru_0_out_t0_53 + (0.50045782327651978) * gru_0_out_t0_54 + (-0.17820435762405396) * gru_0_out_t0_55 + (-0.23002518713474274) * gru_0_out_t0_56 + (-0.089104704558849335) * gru_0_out_t0_57 + (-0.16939403116703033) * gru_0_out_t0_58 + (-0.48470273613929749) * gru_0_out_t0_59 + (-0.19589978456497192) * gru_0_out_t0_60 + (-0.51420271396636963) * gru_0_out_t0_61 + (0.69429200887680054) * gru_0_out_t0_62 + (-0.8138156533241272) * gru_0_out_t0_63 + (0.86850446462631226) * gru_1_rev_t1_h_0 + (1.0737069845199585) * gru_1_rev_t1_h_1 + (0.57432937622070312) * gru_1_rev_t1_h_2 + (-1.4330955743789673) * gru_1_rev_t1_h_3 + (-2.6383028030395508) * gru_1_rev_t1_h_4 + (0.86461418867111206) * gru_1_rev_t1_h_5 + (-0.76066130399703979) * gru_1_rev_t1_h_6 + (-0.27282232046127319) * gru_1_rev_t1_h_7 + (0.20151679217815399) * gru_1_rev_t1_h_8 + (0.074600070714950562) * gru_1_rev_t1_h_9 + (0.10513415932655334) * gru_1_rev_t1_h_10 + (-0.43785554170608521) * gru_1_rev_t1_h_11 + (-1.2752573490142822) * gru_1_rev_t1_h_12 + (-1.2104536294937134) * gru_1_rev_t1_h_13 + (-0.46815496683120728) * gru_1_rev_t1_h_14 + (1.3982236385345459) * gru_1_rev_t1_h_15 + (-0.3193257749080658) * gru_1_rev_t1_h_16 + (-0.061633273959159851) * gru_1_rev_t1_h_17 + (2.2159521579742432) * gru_1_rev_t1_h_18 + (-1.1831493377685547) * gru_1_rev_t1_h_19 + (-0.022984223440289497) * gru_1_rev_t1_h_20 + (0.85023021697998047) * gru_1_rev_t1_h_21 + (0.1385970413684845) * gru_1_rev_t1_h_22 + (-0.33985766768455505) * gru_1_rev_t1_h_23 + (-0.96858000755310059) * gru_1_rev_t1_h_24 + (0.11902625858783722) * gru_1_rev_t1_h_25 + (-0.45884376764297485) * gru_1_rev_t1_h_26 + (1.6419588327407837) * gru_1_rev_t1_h_27 + (3.0190167427062988) * gru_1_rev_t1_h_28 + (1.2663054466247559) * gru_1_rev_t1_h_29 + (0.088795594871044159) * gru_1_rev_t1_h_30 + (-0.14930650591850281) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.33182060718536377) + (-0.13364247977733612) * gru_0_out_t0_0 + (0.24215346574783325) * gru_0_out_t0_1 + (-0.40933153033256531) * gru_0_out_t0_2 + (0.20643326640129089) * gru_0_out_t0_3 + (0.04295479878783226) * gru_0_out_t0_4 + (0.54446130990982056) * gru_0_out_t0_5 + (0.87856292724609375) * gru_0_out_t0_6 + (-0.19129401445388794) * gru_0_out_t0_7 + (0.15498967468738556) * gru_0_out_t0_8 + (-0.45175653696060181) * gru_0_out_t0_9 + (0.22597609460353851) * gru_0_out_t0_10 + (-0.5499567985534668) * gru_0_out_t0_11 + (0.2696165144443512) * gru_0_out_t0_12 + (-0.20278584957122803) * gru_0_out_t0_13 + (-0.21225979924201965) * gru_0_out_t0_14 + (0.029270315542817116) * gru_0_out_t0_15 + (0.19798025488853455) * gru_0_out_t0_16 + (0.25304549932479858) * gru_0_out_t0_17 + (0.14713901281356812) * gru_0_out_t0_18 + (-0.029800267890095711) * gru_0_out_t0_19 + (-0.44589462876319885) * gru_0_out_t0_20 + (0.013573138974606991) * gru_0_out_t0_21 + (0.25493788719177246) * gru_0_out_t0_22 + (-0.063758723437786102) * gru_0_out_t0_23 + (-0.075549036264419556) * gru_0_out_t0_24 + (-0.37759989500045776) * gru_0_out_t0_25 + (0.12419699132442474) * gru_0_out_t0_26 + (0.17878140509128571) * gru_0_out_t0_27 + (0.48680248856544495) * gru_0_out_t0_28 + (0.11614207178354263) * gru_0_out_t0_29 + (-0.31561106443405151) * gru_0_out_t0_30 + (0.086778581142425537) * gru_0_out_t0_31 + (-1.0009082555770874) * gru_0_out_t0_32 + (-0.35904493927955627) * gru_0_out_t0_33 + (0.081106528639793396) * gru_0_out_t0_34 + (-0.1042257696390152) * gru_0_out_t0_35 + (0.11687865853309631) * gru_0_out_t0_36 + (0.19868293404579163) * gru_0_out_t0_37 + (0.53360956907272339) * gru_0_out_t0_38 + (-0.58547294139862061) * gru_0_out_t0_39 + (0.53118085861206055) * gru_0_out_t0_40 + (-0.32721793651580811) * gru_0_out_t0_41 + (-0.15219366550445557) * gru_0_out_t0_42 + (-0.038209892809391022) * gru_0_out_t0_43 + (0.040667466819286346) * gru_0_out_t0_44 + (-0.42428091168403625) * gru_0_out_t0_45 + (-1.3792816400527954) * gru_0_out_t0_46 + (0.73484081029891968) * gru_0_out_t0_47 + (0.23021470010280609) * gru_0_out_t0_48 + (-0.65408170223236084) * gru_0_out_t0_49 + (0.043954420834779739) * gru_0_out_t0_50 + (-0.35745447874069214) * gru_0_out_t0_51 + (0.1837688535451889) * gru_0_out_t0_52 + (0.154344841837883) * gru_0_out_t0_53 + (0.36932122707366943) * gru_0_out_t0_54 + (0.49375852942466736) * gru_0_out_t0_55 + (0.04163404181599617) * gru_0_out_t0_56 + (-0.32075077295303345) * gru_0_out_t0_57 + (-0.21929489076137543) * gru_0_out_t0_58 + (1.0108981132507324) * gru_0_out_t0_59 + (0.74859452247619629) * gru_0_out_t0_60 + (0.9753606915473938) * gru_0_out_t0_61 + (-0.074769608676433563) * gru_0_out_t0_62 + (-1.2365801334381104) * gru_0_out_t0_63 + gate_r * ((-0.170765221118927) + (0.13236676156520844) * gru_1_rev_t1_h_0 + (0.055467717349529266) * gru_1_rev_t1_h_1 + (0.12108356505632401) * gru_1_rev_t1_h_2 + (0.25974789261817932) * gru_1_rev_t1_h_3 + (-0.55376636981964111) * gru_1_rev_t1_h_4 + (-0.19389285147190094) * gru_1_rev_t1_h_5 + (0.11192711442708969) * gru_1_rev_t1_h_6 + (-0.22555689513683319) * gru_1_rev_t1_h_7 + (0.8027762770652771) * gru_1_rev_t1_h_8 + (-0.022971995174884796) * gru_1_rev_t1_h_9 + (0.49892070889472961) * gru_1_rev_t1_h_10 + (-0.12970916926860809) * gru_1_rev_t1_h_11 + (-0.47177526354789734) * gru_1_rev_t1_h_12 + (0.91713541746139526) * gru_1_rev_t1_h_13 + (-0.23209337890148163) * gru_1_rev_t1_h_14 + (-0.068403251469135284) * gru_1_rev_t1_h_15 + (1.0119231939315796) * gru_1_rev_t1_h_16 + (0.31407013535499573) * gru_1_rev_t1_h_17 + (0.17187108099460602) * gru_1_rev_t1_h_18 + (-0.11218081414699554) * gru_1_rev_t1_h_19 + (-0.76369005441665649) * gru_1_rev_t1_h_20 + (-0.02739500068128109) * gru_1_rev_t1_h_21 + (-0.22350393235683441) * gru_1_rev_t1_h_22 + (0.75653260946273804) * gru_1_rev_t1_h_23 + (-0.034975841641426086) * gru_1_rev_t1_h_24 + (0.14202810823917389) * gru_1_rev_t1_h_25 + (-0.15982915461063385) * gru_1_rev_t1_h_26 + (0.65278321504592896) * gru_1_rev_t1_h_27 + (-0.89674121141433716) * gru_1_rev_t1_h_28 + (-0.54915511608123779) * gru_1_rev_t1_h_29 + (0.71394693851470947) * gru_1_rev_t1_h_30 + (-0.56483310461044312) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_3 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_3;
    // h=4
    gate_r = sigmoid((-0.85284173488616943) + (-0.28436857461929321) * gru_0_out_t0_0 + (-0.30776605010032654) * gru_0_out_t0_1 + (-0.52878284454345703) * gru_0_out_t0_2 + (0.6508631706237793) * gru_0_out_t0_3 + (-0.55029314756393433) * gru_0_out_t0_4 + (1.2736679315567017) * gru_0_out_t0_5 + (-1.2393795251846313) * gru_0_out_t0_6 + (-0.64742714166641235) * gru_0_out_t0_7 + (0.68527525663375854) * gru_0_out_t0_8 + (0.21002604067325592) * gru_0_out_t0_9 + (0.47022402286529541) * gru_0_out_t0_10 + (-0.34368842840194702) * gru_0_out_t0_11 + (-1.1928057670593262) * gru_0_out_t0_12 + (-2.0482950210571289) * gru_0_out_t0_13 + (0.32477402687072754) * gru_0_out_t0_14 + (-0.35760572552680969) * gru_0_out_t0_15 + (0.66029900312423706) * gru_0_out_t0_16 + (-0.35550051927566528) * gru_0_out_t0_17 + (-0.063451096415519714) * gru_0_out_t0_18 + (1.3988646268844604) * gru_0_out_t0_19 + (-0.25908598303794861) * gru_0_out_t0_20 + (3.1605510711669922) * gru_0_out_t0_21 + (-0.95725727081298828) * gru_0_out_t0_22 + (-0.33387094736099243) * gru_0_out_t0_23 + (0.52053201198577881) * gru_0_out_t0_24 + (-0.072469927370548248) * gru_0_out_t0_25 + (0.25445547699928284) * gru_0_out_t0_26 + (-0.8192782998085022) * gru_0_out_t0_27 + (0.45953395962715149) * gru_0_out_t0_28 + (-0.17712828516960144) * gru_0_out_t0_29 + (-0.41927602887153625) * gru_0_out_t0_30 + (-1.8506424427032471) * gru_0_out_t0_31 + (-1.3312333822250366) * gru_0_out_t0_32 + (-0.40286582708358765) * gru_0_out_t0_33 + (0.28934758901596069) * gru_0_out_t0_34 + (0.083006151020526886) * gru_0_out_t0_35 + (1.3851670026779175) * gru_0_out_t0_36 + (-0.32928171753883362) * gru_0_out_t0_37 + (0.095163613557815552) * gru_0_out_t0_38 + (-0.66202330589294434) * gru_0_out_t0_39 + (0.28152617812156677) * gru_0_out_t0_40 + (-0.73174697160720825) * gru_0_out_t0_41 + (-0.60733360052108765) * gru_0_out_t0_42 + (-0.35098043084144592) * gru_0_out_t0_43 + (0.12369762361049652) * gru_0_out_t0_44 + (0.12110631912946701) * gru_0_out_t0_45 + (-0.24701137840747833) * gru_0_out_t0_46 + (0.41082018613815308) * gru_0_out_t0_47 + (0.0513291135430336) * gru_0_out_t0_48 + (-0.042957685887813568) * gru_0_out_t0_49 + (1.0406594276428223) * gru_0_out_t0_50 + (0.60547471046447754) * gru_0_out_t0_51 + (0.3280538022518158) * gru_0_out_t0_52 + (0.017066773027181625) * gru_0_out_t0_53 + (0.54390347003936768) * gru_0_out_t0_54 + (-0.004396545235067606) * gru_0_out_t0_55 + (0.064429864287376404) * gru_0_out_t0_56 + (0.18947231769561768) * gru_0_out_t0_57 + (0.10556717962026596) * gru_0_out_t0_58 + (-0.68872976303100586) * gru_0_out_t0_59 + (-0.029299363493919373) * gru_0_out_t0_60 + (-0.57261532545089722) * gru_0_out_t0_61 + (-2.2493383884429932) * gru_0_out_t0_62 + (0.16600167751312256) * gru_0_out_t0_63 + (2.3691103458404541) * gru_1_rev_t1_h_0 + (1.4865931272506714) * gru_1_rev_t1_h_1 + (-0.63094669580459595) * gru_1_rev_t1_h_2 + (0.050186395645141602) * gru_1_rev_t1_h_3 + (-1.7233586311340332) * gru_1_rev_t1_h_4 + (0.82834160327911377) * gru_1_rev_t1_h_5 + (1.6914602518081665) * gru_1_rev_t1_h_6 + (1.3476912975311279) * gru_1_rev_t1_h_7 + (0.90081048011779785) * gru_1_rev_t1_h_8 + (-1.8606255054473877) * gru_1_rev_t1_h_9 + (1.3870941400527954) * gru_1_rev_t1_h_10 + (-0.016032146289944649) * gru_1_rev_t1_h_11 + (0.87168657779693604) * gru_1_rev_t1_h_12 + (1.0485779047012329) * gru_1_rev_t1_h_13 + (2.2077515125274658) * gru_1_rev_t1_h_14 + (-0.54689556360244751) * gru_1_rev_t1_h_15 + (0.029170697554945946) * gru_1_rev_t1_h_16 + (0.22445864975452423) * gru_1_rev_t1_h_17 + (0.2737506628036499) * gru_1_rev_t1_h_18 + (-0.89695197343826294) * gru_1_rev_t1_h_19 + (-1.6392579078674316) * gru_1_rev_t1_h_20 + (-1.0440287590026855) * gru_1_rev_t1_h_21 + (0.92926281690597534) * gru_1_rev_t1_h_22 + (0.027005186304450035) * gru_1_rev_t1_h_23 + (0.013473638333380222) * gru_1_rev_t1_h_24 + (-0.94064068794250488) * gru_1_rev_t1_h_25 + (-0.4188849925994873) * gru_1_rev_t1_h_26 + (2.5533909797668457) * gru_1_rev_t1_h_27 + (2.8036954402923584) * gru_1_rev_t1_h_28 + (0.83902353048324585) * gru_1_rev_t1_h_29 + (0.023672834038734436) * gru_1_rev_t1_h_30 + (-0.74547415971755981) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.81669348478317261) + (-0.33308026194572449) * gru_0_out_t0_0 + (0.44340571761131287) * gru_0_out_t0_1 + (-1.1071795225143433) * gru_0_out_t0_2 + (-0.56527483463287354) * gru_0_out_t0_3 + (0.023389186710119247) * gru_0_out_t0_4 + (-0.89604169130325317) * gru_0_out_t0_5 + (-0.37035417556762695) * gru_0_out_t0_6 + (0.41716456413269043) * gru_0_out_t0_7 + (-0.20178313553333282) * gru_0_out_t0_8 + (0.020566478371620178) * gru_0_out_t0_9 + (1.8742918968200684) * gru_0_out_t0_10 + (0.34618765115737915) * gru_0_out_t0_11 + (-0.6505962610244751) * gru_0_out_t0_12 + (-0.32015201449394226) * gru_0_out_t0_13 + (-0.20776659250259399) * gru_0_out_t0_14 + (-0.18571199476718903) * gru_0_out_t0_15 + (0.018950192257761955) * gru_0_out_t0_16 + (-0.43294388055801392) * gru_0_out_t0_17 + (-0.19319058954715729) * gru_0_out_t0_18 + (-2.2259612083435059) * gru_0_out_t0_19 + (-0.77732276916503906) * gru_0_out_t0_20 + (0.10494133830070496) * gru_0_out_t0_21 + (0.26847547292709351) * gru_0_out_t0_22 + (-0.0042161582969129086) * gru_0_out_t0_23 + (1.4388601779937744) * gru_0_out_t0_24 + (0.19661867618560791) * gru_0_out_t0_25 + (-0.60716861486434937) * gru_0_out_t0_26 + (-0.52465540170669556) * gru_0_out_t0_27 + (-0.51530247926712036) * gru_0_out_t0_28 + (-0.094727113842964172) * gru_0_out_t0_29 + (-0.48076775670051575) * gru_0_out_t0_30 + (-1.2719722986221313) * gru_0_out_t0_31 + (0.026749864220619202) * gru_0_out_t0_32 + (0.63577008247375488) * gru_0_out_t0_33 + (1.3939803838729858) * gru_0_out_t0_34 + (-1.1500581502914429) * gru_0_out_t0_35 + (-0.25652369856834412) * gru_0_out_t0_36 + (1.0728533267974854) * gru_0_out_t0_37 + (-0.81295448541641235) * gru_0_out_t0_38 + (0.35631087422370911) * gru_0_out_t0_39 + (-0.61456859111785889) * gru_0_out_t0_40 + (-0.17657743394374847) * gru_0_out_t0_41 + (0.32728791236877441) * gru_0_out_t0_42 + (-0.23349383473396301) * gru_0_out_t0_43 + (-0.66113370656967163) * gru_0_out_t0_44 + (-0.77077627182006836) * gru_0_out_t0_45 + (0.65921300649642944) * gru_0_out_t0_46 + (0.3257274329662323) * gru_0_out_t0_47 + (0.4569607675075531) * gru_0_out_t0_48 + (-0.096899032592773438) * gru_0_out_t0_49 + (-0.81703329086303711) * gru_0_out_t0_50 + (-0.40731948614120483) * gru_0_out_t0_51 + (-1.7679767608642578) * gru_0_out_t0_52 + (0.016265247017145157) * gru_0_out_t0_53 + (0.1737811267375946) * gru_0_out_t0_54 + (-0.48866096138954163) * gru_0_out_t0_55 + (0.78875213861465454) * gru_0_out_t0_56 + (-0.20054136216640472) * gru_0_out_t0_57 + (-0.22155278921127319) * gru_0_out_t0_58 + (-0.3206636905670166) * gru_0_out_t0_59 + (0.27638965845108032) * gru_0_out_t0_60 + (-0.15564520657062531) * gru_0_out_t0_61 + (-0.67489278316497803) * gru_0_out_t0_62 + (1.0005848407745361) * gru_0_out_t0_63 + (-0.32168397307395935) * gru_1_rev_t1_h_0 + (-0.21448181569576263) * gru_1_rev_t1_h_1 + (-1.1433310508728027) * gru_1_rev_t1_h_2 + (-0.10970044136047363) * gru_1_rev_t1_h_3 + (0.19150927662849426) * gru_1_rev_t1_h_4 + (0.11642688512802124) * gru_1_rev_t1_h_5 + (-0.084535792469978333) * gru_1_rev_t1_h_6 + (0.38673746585845947) * gru_1_rev_t1_h_7 + (-0.11911729723215103) * gru_1_rev_t1_h_8 + (-0.0058390609920024872) * gru_1_rev_t1_h_9 + (0.98142445087432861) * gru_1_rev_t1_h_10 + (-0.85078513622283936) * gru_1_rev_t1_h_11 + (-0.5638735294342041) * gru_1_rev_t1_h_12 + (-0.10506743937730789) * gru_1_rev_t1_h_13 + (-0.35921987891197205) * gru_1_rev_t1_h_14 + (0.6949809193611145) * gru_1_rev_t1_h_15 + (0.83535939455032349) * gru_1_rev_t1_h_16 + (0.26858612895011902) * gru_1_rev_t1_h_17 + (0.87484884262084961) * gru_1_rev_t1_h_18 + (-0.32399207353591919) * gru_1_rev_t1_h_19 + (0.47878849506378174) * gru_1_rev_t1_h_20 + (0.4303855299949646) * gru_1_rev_t1_h_21 + (0.26860985159873962) * gru_1_rev_t1_h_22 + (0.2024909108877182) * gru_1_rev_t1_h_23 + (-0.15878455340862274) * gru_1_rev_t1_h_24 + (-0.24440160393714905) * gru_1_rev_t1_h_25 + (0.48933437466621399) * gru_1_rev_t1_h_26 + (-0.20417226850986481) * gru_1_rev_t1_h_27 + (-3.2173857688903809) * gru_1_rev_t1_h_28 + (0.38627150654792786) * gru_1_rev_t1_h_29 + (-0.12214190512895584) * gru_1_rev_t1_h_30 + (1.3946791887283325) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.21212151646614075) + (-0.046121343970298767) * gru_0_out_t0_0 + (-0.24999581277370453) * gru_0_out_t0_1 + (-0.16646437346935272) * gru_0_out_t0_2 + (-0.11696069687604904) * gru_0_out_t0_3 + (-0.30428153276443481) * gru_0_out_t0_4 + (0.16541218757629395) * gru_0_out_t0_5 + (0.25294044613838196) * gru_0_out_t0_6 + (-0.72023612260818481) * gru_0_out_t0_7 + (-0.053521167486906052) * gru_0_out_t0_8 + (-0.26079058647155762) * gru_0_out_t0_9 + (-0.32820278406143188) * gru_0_out_t0_10 + (-0.37023371458053589) * gru_0_out_t0_11 + (-0.054795637726783752) * gru_0_out_t0_12 + (0.015303418040275574) * gru_0_out_t0_13 + (0.16191062331199646) * gru_0_out_t0_14 + (0.14692226052284241) * gru_0_out_t0_15 + (-1.6961246728897095) * gru_0_out_t0_16 + (-0.60965836048126221) * gru_0_out_t0_17 + (0.018089858815073967) * gru_0_out_t0_18 + (-0.10476627200841904) * gru_0_out_t0_19 + (-0.31742554903030396) * gru_0_out_t0_20 + (-1.7301788330078125) * gru_0_out_t0_21 + (-0.31704562902450562) * gru_0_out_t0_22 + (0.55906939506530762) * gru_0_out_t0_23 + (-0.18765954673290253) * gru_0_out_t0_24 + (-0.29309350252151489) * gru_0_out_t0_25 + (0.041777607053518295) * gru_0_out_t0_26 + (0.027556486427783966) * gru_0_out_t0_27 + (-0.51574862003326416) * gru_0_out_t0_28 + (0.27060449123382568) * gru_0_out_t0_29 + (0.23513925075531006) * gru_0_out_t0_30 + (-0.017734711989760399) * gru_0_out_t0_31 + (0.68808257579803467) * gru_0_out_t0_32 + (0.19908039271831512) * gru_0_out_t0_33 + (1.306243896484375) * gru_0_out_t0_34 + (-0.045786205679178238) * gru_0_out_t0_35 + (0.68623042106628418) * gru_0_out_t0_36 + (-0.53176707029342651) * gru_0_out_t0_37 + (-0.18421696126461029) * gru_0_out_t0_38 + (0.11281236261129379) * gru_0_out_t0_39 + (0.18654315173625946) * gru_0_out_t0_40 + (0.65099447965621948) * gru_0_out_t0_41 + (-0.14548754692077637) * gru_0_out_t0_42 + (-0.07775086909532547) * gru_0_out_t0_43 + (0.24505141377449036) * gru_0_out_t0_44 + (-0.023782825097441673) * gru_0_out_t0_45 + (0.037717055529356003) * gru_0_out_t0_46 + (-0.50845783948898315) * gru_0_out_t0_47 + (-0.2098768949508667) * gru_0_out_t0_48 + (0.00015663956583011895) * gru_0_out_t0_49 + (-0.14637885987758636) * gru_0_out_t0_50 + (0.016680095344781876) * gru_0_out_t0_51 + (-0.53228509426116943) * gru_0_out_t0_52 + (0.227190762758255) * gru_0_out_t0_53 + (-0.53244978189468384) * gru_0_out_t0_54 + (0.43276244401931763) * gru_0_out_t0_55 + (-0.16802941262722015) * gru_0_out_t0_56 + (-0.071219198405742645) * gru_0_out_t0_57 + (-0.49584150314331055) * gru_0_out_t0_58 + (-0.86083376407623291) * gru_0_out_t0_59 + (0.14458438754081726) * gru_0_out_t0_60 + (0.2383958101272583) * gru_0_out_t0_61 + (0.59970206022262573) * gru_0_out_t0_62 + (0.037024576216936111) * gru_0_out_t0_63 + gate_r * ((0.24168875813484192) + (0.086057074368000031) * gru_1_rev_t1_h_0 + (-0.43999341130256653) * gru_1_rev_t1_h_1 + (-0.017091764137148857) * gru_1_rev_t1_h_2 + (0.40497076511383057) * gru_1_rev_t1_h_3 + (-1.0876723527908325) * gru_1_rev_t1_h_4 + (0.27239874005317688) * gru_1_rev_t1_h_5 + (0.67990189790725708) * gru_1_rev_t1_h_6 + (-0.80661904811859131) * gru_1_rev_t1_h_7 + (1.5571057796478271) * gru_1_rev_t1_h_8 + (-0.11284369230270386) * gru_1_rev_t1_h_9 + (0.48158362507820129) * gru_1_rev_t1_h_10 + (-0.24914976954460144) * gru_1_rev_t1_h_11 + (0.46405032277107239) * gru_1_rev_t1_h_12 + (1.2845057249069214) * gru_1_rev_t1_h_13 + (-0.31839212775230408) * gru_1_rev_t1_h_14 + (0.77746838331222534) * gru_1_rev_t1_h_15 + (-0.51793712377548218) * gru_1_rev_t1_h_16 + (0.79848718643188477) * gru_1_rev_t1_h_17 + (0.65994149446487427) * gru_1_rev_t1_h_18 + (0.30671209096908569) * gru_1_rev_t1_h_19 + (-0.12579345703125) * gru_1_rev_t1_h_20 + (-1.1305513381958008) * gru_1_rev_t1_h_21 + (-0.24421282112598419) * gru_1_rev_t1_h_22 + (-0.036108512431383133) * gru_1_rev_t1_h_23 + (-1.0063353776931763) * gru_1_rev_t1_h_24 + (-0.22752884030342102) * gru_1_rev_t1_h_25 + (-0.61396503448486328) * gru_1_rev_t1_h_26 + (0.54624485969543457) * gru_1_rev_t1_h_27 + (-2.629706859588623) * gru_1_rev_t1_h_28 + (-1.337444543838501) * gru_1_rev_t1_h_29 + (-2.4987494945526123) * gru_1_rev_t1_h_30 + (-1.2724108695983887) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_4 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_4;
    // h=5
    gate_r = sigmoid((-0.85275256633758545) + (-0.37231147289276123) * gru_0_out_t0_0 + (-0.41273888945579529) * gru_0_out_t0_1 + (-3.4210171699523926) * gru_0_out_t0_2 + (-0.54595738649368286) * gru_0_out_t0_3 + (-0.9465973973274231) * gru_0_out_t0_4 + (-0.06728006899356842) * gru_0_out_t0_5 + (1.4984585046768188) * gru_0_out_t0_6 + (1.0565659999847412) * gru_0_out_t0_7 + (0.78533220291137695) * gru_0_out_t0_8 + (-0.044619806110858917) * gru_0_out_t0_9 + (2.4052333831787109) * gru_0_out_t0_10 + (-0.24249827861785889) * gru_0_out_t0_11 + (0.062222294509410858) * gru_0_out_t0_12 + (0.334329754114151) * gru_0_out_t0_13 + (-0.39066967368125916) * gru_0_out_t0_14 + (-0.035223193466663361) * gru_0_out_t0_15 + (0.27091357111930847) * gru_0_out_t0_16 + (0.63219565153121948) * gru_0_out_t0_17 + (-0.13513840734958649) * gru_0_out_t0_18 + (-0.26814007759094238) * gru_0_out_t0_19 + (-0.27018803358078003) * gru_0_out_t0_20 + (0.79521393775939941) * gru_0_out_t0_21 + (-0.66086649894714355) * gru_0_out_t0_22 + (-0.57469141483306885) * gru_0_out_t0_23 + (3.9588806629180908) * gru_0_out_t0_24 + (1.1795332431793213) * gru_0_out_t0_25 + (0.61307573318481445) * gru_0_out_t0_26 + (-0.27912133932113647) * gru_0_out_t0_27 + (0.33552464842796326) * gru_0_out_t0_28 + (0.34554785490036011) * gru_0_out_t0_29 + (0.062455631792545319) * gru_0_out_t0_30 + (-1.9817560911178589) * gru_0_out_t0_31 + (-0.2021060436964035) * gru_0_out_t0_32 + (-0.18547999858856201) * gru_0_out_t0_33 + (0.51029932498931885) * gru_0_out_t0_34 + (-0.23184169828891754) * gru_0_out_t0_35 + (0.065086215734481812) * gru_0_out_t0_36 + (-0.30575355887413025) * gru_0_out_t0_37 + (0.46613243222236633) * gru_0_out_t0_38 + (0.058039546012878418) * gru_0_out_t0_39 + (-0.12071848660707474) * gru_0_out_t0_40 + (-0.12016037106513977) * gru_0_out_t0_41 + (1.544541597366333) * gru_0_out_t0_42 + (-0.027319518849253654) * gru_0_out_t0_43 + (0.12062805891036987) * gru_0_out_t0_44 + (-0.088251024484634399) * gru_0_out_t0_45 + (1.4941831827163696) * gru_0_out_t0_46 + (-0.020773140713572502) * gru_0_out_t0_47 + (-2.0313930511474609) * gru_0_out_t0_48 + (1.8216820955276489) * gru_0_out_t0_49 + (-0.48123803734779358) * gru_0_out_t0_50 + (-1.0743937492370605) * gru_0_out_t0_51 + (-0.03249654546380043) * gru_0_out_t0_52 + (-0.17621238529682159) * gru_0_out_t0_53 + (0.078640364110469818) * gru_0_out_t0_54 + (-2.6135110855102539) * gru_0_out_t0_55 + (-0.51477491855621338) * gru_0_out_t0_56 + (0.51743227243423462) * gru_0_out_t0_57 + (-0.33058130741119385) * gru_0_out_t0_58 + (-0.55279242992401123) * gru_0_out_t0_59 + (-2.0494387149810791) * gru_0_out_t0_60 + (0.68700236082077026) * gru_0_out_t0_61 + (0.10782763361930847) * gru_0_out_t0_62 + (0.88686764240264893) * gru_0_out_t0_63 + (-1.8087558746337891) * gru_1_rev_t1_h_0 + (-0.17551909387111664) * gru_1_rev_t1_h_1 + (-0.12375864386558533) * gru_1_rev_t1_h_2 + (0.23829488456249237) * gru_1_rev_t1_h_3 + (-0.51748949289321899) * gru_1_rev_t1_h_4 + (-1.000796914100647) * gru_1_rev_t1_h_5 + (-0.26663854718208313) * gru_1_rev_t1_h_6 + (-0.21922196447849274) * gru_1_rev_t1_h_7 + (-0.88711196184158325) * gru_1_rev_t1_h_8 + (0.10914440453052521) * gru_1_rev_t1_h_9 + (-0.77350372076034546) * gru_1_rev_t1_h_10 + (-1.6887897253036499) * gru_1_rev_t1_h_11 + (0.00065970682771876454) * gru_1_rev_t1_h_12 + (0.31174874305725098) * gru_1_rev_t1_h_13 + (0.27230638265609741) * gru_1_rev_t1_h_14 + (0.037871457636356354) * gru_1_rev_t1_h_15 + (-0.19480416178703308) * gru_1_rev_t1_h_16 + (-0.69500941038131714) * gru_1_rev_t1_h_17 + (0.81379938125610352) * gru_1_rev_t1_h_18 + (-0.83653324842453003) * gru_1_rev_t1_h_19 + (0.41803571581840515) * gru_1_rev_t1_h_20 + (0.11412100493907928) * gru_1_rev_t1_h_21 + (-0.21957924962043762) * gru_1_rev_t1_h_22 + (0.13059909641742706) * gru_1_rev_t1_h_23 + (-0.10998380184173584) * gru_1_rev_t1_h_24 + (-0.28501173853874207) * gru_1_rev_t1_h_25 + (0.2117064893245697) * gru_1_rev_t1_h_26 + (0.30344688892364502) * gru_1_rev_t1_h_27 + (-0.79458796977996826) * gru_1_rev_t1_h_28 + (-0.22236564755439758) * gru_1_rev_t1_h_29 + (-1.6000213623046875) * gru_1_rev_t1_h_30 + (0.025024957954883575) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.21083906292915344) + (0.29572367668151855) * gru_0_out_t0_0 + (-0.36876967549324036) * gru_0_out_t0_1 + (-0.63817650079727173) * gru_0_out_t0_2 + (-0.46088972687721252) * gru_0_out_t0_3 + (-0.42738914489746094) * gru_0_out_t0_4 + (0.10379841923713684) * gru_0_out_t0_5 + (0.48813578486442566) * gru_0_out_t0_6 + (-0.062365755438804626) * gru_0_out_t0_7 + (0.054881695657968521) * gru_0_out_t0_8 + (-0.93465691804885864) * gru_0_out_t0_9 + (0.83270353078842163) * gru_0_out_t0_10 + (0.57028490304946899) * gru_0_out_t0_11 + (-0.039887495338916779) * gru_0_out_t0_12 + (0.28312736749649048) * gru_0_out_t0_13 + (0.067829087376594543) * gru_0_out_t0_14 + (-0.26339083909988403) * gru_0_out_t0_15 + (0.04471689835190773) * gru_0_out_t0_16 + (-0.28516590595245361) * gru_0_out_t0_17 + (-0.46176841855049133) * gru_0_out_t0_18 + (-0.3510286808013916) * gru_0_out_t0_19 + (-0.93618220090866089) * gru_0_out_t0_20 + (-0.18463461101055145) * gru_0_out_t0_21 + (0.22288854420185089) * gru_0_out_t0_22 + (0.1839858740568161) * gru_0_out_t0_23 + (0.021833175793290138) * gru_0_out_t0_24 + (0.24573822319507599) * gru_0_out_t0_25 + (-0.85423958301544189) * gru_0_out_t0_26 + (0.27014762163162231) * gru_0_out_t0_27 + (-0.043879296630620956) * gru_0_out_t0_28 + (0.41122725605964661) * gru_0_out_t0_29 + (0.23105558753013611) * gru_0_out_t0_30 + (0.456072598695755) * gru_0_out_t0_31 + (-0.0088172294199466705) * gru_0_out_t0_32 + (0.018507339060306549) * gru_0_out_t0_33 + (0.88905602693557739) * gru_0_out_t0_34 + (-0.13916929066181183) * gru_0_out_t0_35 + (0.071937277913093567) * gru_0_out_t0_36 + (-0.21308133006095886) * gru_0_out_t0_37 + (-0.17475828528404236) * gru_0_out_t0_38 + (0.14793825149536133) * gru_0_out_t0_39 + (-0.94930493831634521) * gru_0_out_t0_40 + (-0.26791998744010925) * gru_0_out_t0_41 + (0.47908896207809448) * gru_0_out_t0_42 + (0.55365163087844849) * gru_0_out_t0_43 + (-0.12477477639913559) * gru_0_out_t0_44 + (-0.092440038919448853) * gru_0_out_t0_45 + (0.63290095329284668) * gru_0_out_t0_46 + (0.13363134860992432) * gru_0_out_t0_47 + (-0.35190102458000183) * gru_0_out_t0_48 + (0.076332330703735352) * gru_0_out_t0_49 + (-0.46334338188171387) * gru_0_out_t0_50 + (0.068668022751808167) * gru_0_out_t0_51 + (0.31255874037742615) * gru_0_out_t0_52 + (-0.25174608826637268) * gru_0_out_t0_53 + (0.49698075652122498) * gru_0_out_t0_54 + (0.41042602062225342) * gru_0_out_t0_55 + (-0.042150698602199554) * gru_0_out_t0_56 + (0.49257576465606689) * gru_0_out_t0_57 + (0.0029996265657246113) * gru_0_out_t0_58 + (-0.70677876472473145) * gru_0_out_t0_59 + (0.72095960378646851) * gru_0_out_t0_60 + (-0.26149541139602661) * gru_0_out_t0_61 + (0.72527992725372314) * gru_0_out_t0_62 + (-0.13292494416236877) * gru_0_out_t0_63 + (-0.65025192499160767) * gru_1_rev_t1_h_0 + (0.012633454985916615) * gru_1_rev_t1_h_1 + (0.15566065907478333) * gru_1_rev_t1_h_2 + (1.2557512521743774) * gru_1_rev_t1_h_3 + (-0.18067030608654022) * gru_1_rev_t1_h_4 + (-0.54113703966140747) * gru_1_rev_t1_h_5 + (0.38727834820747375) * gru_1_rev_t1_h_6 + (-0.017949441447854042) * gru_1_rev_t1_h_7 + (0.12304417788982391) * gru_1_rev_t1_h_8 + (-0.2510477602481842) * gru_1_rev_t1_h_9 + (-0.97399979829788208) * gru_1_rev_t1_h_10 + (-1.3893535137176514) * gru_1_rev_t1_h_11 + (0.84442323446273804) * gru_1_rev_t1_h_12 + (0.13102602958679199) * gru_1_rev_t1_h_13 + (-1.2468016147613525) * gru_1_rev_t1_h_14 + (0.42077136039733887) * gru_1_rev_t1_h_15 + (-0.72698009014129639) * gru_1_rev_t1_h_16 + (0.26865968108177185) * gru_1_rev_t1_h_17 + (0.042192887514829636) * gru_1_rev_t1_h_18 + (-0.2994006872177124) * gru_1_rev_t1_h_19 + (0.25727522373199463) * gru_1_rev_t1_h_20 + (-0.61721140146255493) * gru_1_rev_t1_h_21 + (2.3691976070404053) * gru_1_rev_t1_h_22 + (-0.32686284184455872) * gru_1_rev_t1_h_23 + (0.10202163457870483) * gru_1_rev_t1_h_24 + (0.0664997398853302) * gru_1_rev_t1_h_25 + (0.41689079999923706) * gru_1_rev_t1_h_26 + (0.5939452052116394) * gru_1_rev_t1_h_27 + (0.58735483884811401) * gru_1_rev_t1_h_28 + (-0.40998715162277222) * gru_1_rev_t1_h_29 + (1.7939472198486328) * gru_1_rev_t1_h_30 + (-0.33738598227500916) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.1485549658536911) + (-0.017309127375483513) * gru_0_out_t0_0 + (0.12968628108501434) * gru_0_out_t0_1 + (-0.16752439737319946) * gru_0_out_t0_2 + (0.29244992136955261) * gru_0_out_t0_3 + (0.29653835296630859) * gru_0_out_t0_4 + (0.083427123725414276) * gru_0_out_t0_5 + (-0.28429359197616577) * gru_0_out_t0_6 + (0.083677999675273895) * gru_0_out_t0_7 + (0.70336079597473145) * gru_0_out_t0_8 + (-0.14761540293693542) * gru_0_out_t0_9 + (0.024268688634037971) * gru_0_out_t0_10 + (0.20479847490787506) * gru_0_out_t0_11 + (0.17941676080226898) * gru_0_out_t0_12 + (0.067435517907142639) * gru_0_out_t0_13 + (-0.084788687527179718) * gru_0_out_t0_14 + (0.15215599536895752) * gru_0_out_t0_15 + (-0.030545994639396667) * gru_0_out_t0_16 + (0.0088785095140337944) * gru_0_out_t0_17 + (0.48280623555183411) * gru_0_out_t0_18 + (0.27373707294464111) * gru_0_out_t0_19 + (0.43739175796508789) * gru_0_out_t0_20 + (-0.17479248344898224) * gru_0_out_t0_21 + (0.14576455950737) * gru_0_out_t0_22 + (-0.70997512340545654) * gru_0_out_t0_23 + (0.1909349113702774) * gru_0_out_t0_24 + (-0.0994129478931427) * gru_0_out_t0_25 + (0.88343942165374756) * gru_0_out_t0_26 + (-0.066545553505420685) * gru_0_out_t0_27 + (-0.44508647918701172) * gru_0_out_t0_28 + (0.79155457019805908) * gru_0_out_t0_29 + (0.052655331790447235) * gru_0_out_t0_30 + (0.053580708801746368) * gru_0_out_t0_31 + (0.61274874210357666) * gru_0_out_t0_32 + (-0.69636642932891846) * gru_0_out_t0_33 + (0.63274300098419189) * gru_0_out_t0_34 + (-0.18186077475547791) * gru_0_out_t0_35 + (-0.039516214281320572) * gru_0_out_t0_36 + (-0.16290475428104401) * gru_0_out_t0_37 + (-0.17495036125183105) * gru_0_out_t0_38 + (-0.048875767737627029) * gru_0_out_t0_39 + (-0.41457238793373108) * gru_0_out_t0_40 + (0.3438030481338501) * gru_0_out_t0_41 + (-1.2345099449157715) * gru_0_out_t0_42 + (-0.29338827729225159) * gru_0_out_t0_43 + (-0.0026426829863339663) * gru_0_out_t0_44 + (-0.0062886504456400871) * gru_0_out_t0_45 + (-0.54791659116744995) * gru_0_out_t0_46 + (-0.50673598051071167) * gru_0_out_t0_47 + (-0.42454195022583008) * gru_0_out_t0_48 + (0.17304053902626038) * gru_0_out_t0_49 + (0.24635446071624756) * gru_0_out_t0_50 + (0.1861598789691925) * gru_0_out_t0_51 + (-0.15734702348709106) * gru_0_out_t0_52 + (0.10103742778301239) * gru_0_out_t0_53 + (0.10149660706520081) * gru_0_out_t0_54 + (0.1851298063993454) * gru_0_out_t0_55 + (-0.12342564761638641) * gru_0_out_t0_56 + (0.24604837596416473) * gru_0_out_t0_57 + (-0.19492115080356598) * gru_0_out_t0_58 + (0.014314576052129269) * gru_0_out_t0_59 + (-1.2897763252258301) * gru_0_out_t0_60 + (0.040037080645561218) * gru_0_out_t0_61 + (0.35444653034210205) * gru_0_out_t0_62 + (-1.009379506111145) * gru_0_out_t0_63 + gate_r * ((0.25461798906326294) + (-0.11052022129297256) * gru_1_rev_t1_h_0 + (0.48689204454421997) * gru_1_rev_t1_h_1 + (0.53877002000808716) * gru_1_rev_t1_h_2 + (-0.73483109474182129) * gru_1_rev_t1_h_3 + (-0.20556014776229858) * gru_1_rev_t1_h_4 + (-0.88186401128768921) * gru_1_rev_t1_h_5 + (-0.091017074882984161) * gru_1_rev_t1_h_6 + (-0.31197971105575562) * gru_1_rev_t1_h_7 + (-0.40484499931335449) * gru_1_rev_t1_h_8 + (0.41471102833747864) * gru_1_rev_t1_h_9 + (0.74627155065536499) * gru_1_rev_t1_h_10 + (-1.4965666532516479) * gru_1_rev_t1_h_11 + (0.91235315799713135) * gru_1_rev_t1_h_12 + (0.028757128864526749) * gru_1_rev_t1_h_13 + (-0.22726641595363617) * gru_1_rev_t1_h_14 + (0.048075143247842789) * gru_1_rev_t1_h_15 + (-0.73111605644226074) * gru_1_rev_t1_h_16 + (-0.44834122061729431) * gru_1_rev_t1_h_17 + (0.12880569696426392) * gru_1_rev_t1_h_18 + (-0.40892395377159119) * gru_1_rev_t1_h_19 + (0.24324963986873627) * gru_1_rev_t1_h_20 + (0.21724711358547211) * gru_1_rev_t1_h_21 + (-2.3350045680999756) * gru_1_rev_t1_h_22 + (0.16952139139175415) * gru_1_rev_t1_h_23 + (0.98186951875686646) * gru_1_rev_t1_h_24 + (0.32020041346549988) * gru_1_rev_t1_h_25 + (0.13464447855949402) * gru_1_rev_t1_h_26 + (0.05450240895152092) * gru_1_rev_t1_h_27 + (-0.66436249017715454) * gru_1_rev_t1_h_28 + (-0.16496919095516205) * gru_1_rev_t1_h_29 + (-2.3049619197845459) * gru_1_rev_t1_h_30 + (0.58028286695480347) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_5 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_5;
    // h=6
    gate_r = sigmoid((-0.17845836281776428) + (0.21675291657447815) * gru_0_out_t0_0 + (0.092875413596630096) * gru_0_out_t0_1 + (-1.1024574041366577) * gru_0_out_t0_2 + (-0.93104356527328491) * gru_0_out_t0_3 + (-0.053150732070207596) * gru_0_out_t0_4 + (0.1410113126039505) * gru_0_out_t0_5 + (0.54799103736877441) * gru_0_out_t0_6 + (0.83457398414611816) * gru_0_out_t0_7 + (0.64689141511917114) * gru_0_out_t0_8 + (0.48188823461532593) * gru_0_out_t0_9 + (1.3335813283920288) * gru_0_out_t0_10 + (-0.036059796810150146) * gru_0_out_t0_11 + (-0.043537463992834091) * gru_0_out_t0_12 + (0.058656293898820877) * gru_0_out_t0_13 + (-0.50566655397415161) * gru_0_out_t0_14 + (-0.49999901652336121) * gru_0_out_t0_15 + (-0.5590667724609375) * gru_0_out_t0_16 + (-0.16408759355545044) * gru_0_out_t0_17 + (0.82274937629699707) * gru_0_out_t0_18 + (-1.297120213508606) * gru_0_out_t0_19 + (-0.44155815243721008) * gru_0_out_t0_20 + (-0.42363342642784119) * gru_0_out_t0_21 + (-0.26518735289573669) * gru_0_out_t0_22 + (-1.0361405611038208) * gru_0_out_t0_23 + (2.0992810726165771) * gru_0_out_t0_24 + (0.26762589812278748) * gru_0_out_t0_25 + (-0.41395074129104614) * gru_0_out_t0_26 + (1.0264595746994019) * gru_0_out_t0_27 + (-0.85478192567825317) * gru_0_out_t0_28 + (-0.15358337759971619) * gru_0_out_t0_29 + (-0.040708236396312714) * gru_0_out_t0_30 + (-2.911768913269043) * gru_0_out_t0_31 + (0.28539800643920898) * gru_0_out_t0_32 + (0.24616996943950653) * gru_0_out_t0_33 + (-0.044476039707660675) * gru_0_out_t0_34 + (-0.17438693344593048) * gru_0_out_t0_35 + (0.36470323801040649) * gru_0_out_t0_36 + (-0.1807335764169693) * gru_0_out_t0_37 + (0.28814142942428589) * gru_0_out_t0_38 + (2.0805056095123291) * gru_0_out_t0_39 + (2.7370791435241699) * gru_0_out_t0_40 + (-0.40160742402076721) * gru_0_out_t0_41 + (2.7162458896636963) * gru_0_out_t0_42 + (-0.066900454461574554) * gru_0_out_t0_43 + (-0.3073275089263916) * gru_0_out_t0_44 + (-1.3376997709274292) * gru_0_out_t0_45 + (-1.1060822010040283) * gru_0_out_t0_46 + (0.21107695996761322) * gru_0_out_t0_47 + (-0.29750111699104309) * gru_0_out_t0_48 + (0.26030677556991577) * gru_0_out_t0_49 + (0.84176278114318848) * gru_0_out_t0_50 + (-0.55851274728775024) * gru_0_out_t0_51 + (-0.41278359293937683) * gru_0_out_t0_52 + (0.61996716260910034) * gru_0_out_t0_53 + (-0.70663034915924072) * gru_0_out_t0_54 + (0.12439332157373428) * gru_0_out_t0_55 + (-0.75193262100219727) * gru_0_out_t0_56 + (0.33096596598625183) * gru_0_out_t0_57 + (0.084024727344512939) * gru_0_out_t0_58 + (-0.1535075455904007) * gru_0_out_t0_59 + (2.415604829788208) * gru_0_out_t0_60 + (0.064034506678581238) * gru_0_out_t0_61 + (-0.33720636367797852) * gru_0_out_t0_62 + (-1.5609313249588013) * gru_0_out_t0_63 + (0.058647837489843369) * gru_1_rev_t1_h_0 + (-0.078183047473430634) * gru_1_rev_t1_h_1 + (-2.344407320022583) * gru_1_rev_t1_h_2 + (2.4382965564727783) * gru_1_rev_t1_h_3 + (-0.044292852282524109) * gru_1_rev_t1_h_4 + (0.22582575678825378) * gru_1_rev_t1_h_5 + (0.52772843837738037) * gru_1_rev_t1_h_6 + (-0.68343478441238403) * gru_1_rev_t1_h_7 + (0.052413392812013626) * gru_1_rev_t1_h_8 + (-0.2247232049703598) * gru_1_rev_t1_h_9 + (-0.10081443190574646) * gru_1_rev_t1_h_10 + (0.32961395382881165) * gru_1_rev_t1_h_11 + (3.5059576034545898) * gru_1_rev_t1_h_12 + (0.26950767636299133) * gru_1_rev_t1_h_13 + (-0.69821196794509888) * gru_1_rev_t1_h_14 + (0.47578999400138855) * gru_1_rev_t1_h_15 + (-0.75365310907363892) * gru_1_rev_t1_h_16 + (0.66621255874633789) * gru_1_rev_t1_h_17 + (0.1940264105796814) * gru_1_rev_t1_h_18 + (2.2573676109313965) * gru_1_rev_t1_h_19 + (-0.56969773769378662) * gru_1_rev_t1_h_20 + (-0.46586057543754578) * gru_1_rev_t1_h_21 + (-2.4774923324584961) * gru_1_rev_t1_h_22 + (0.38113221526145935) * gru_1_rev_t1_h_23 + (0.42476543784141541) * gru_1_rev_t1_h_24 + (0.25424987077713013) * gru_1_rev_t1_h_25 + (-0.37974211573600769) * gru_1_rev_t1_h_26 + (0.62054347991943359) * gru_1_rev_t1_h_27 + (1.4938923120498657) * gru_1_rev_t1_h_28 + (0.54759353399276733) * gru_1_rev_t1_h_29 + (-2.2850849628448486) * gru_1_rev_t1_h_30 + (0.047447748482227325) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.06146036833524704) + (0.44913685321807861) * gru_0_out_t0_0 + (-0.27391242980957031) * gru_0_out_t0_1 + (-0.46413803100585938) * gru_0_out_t0_2 + (-0.32556107640266418) * gru_0_out_t0_3 + (0.27135682106018066) * gru_0_out_t0_4 + (-0.23471201956272125) * gru_0_out_t0_5 + (0.54274576902389526) * gru_0_out_t0_6 + (0.3717266321182251) * gru_0_out_t0_7 + (0.17560477554798126) * gru_0_out_t0_8 + (-0.16319505870342255) * gru_0_out_t0_9 + (-0.18928256630897522) * gru_0_out_t0_10 + (0.16382637619972229) * gru_0_out_t0_11 + (0.042524941265583038) * gru_0_out_t0_12 + (0.43431335687637329) * gru_0_out_t0_13 + (-0.032516933977603912) * gru_0_out_t0_14 + (-0.42331540584564209) * gru_0_out_t0_15 + (0.65136253833770752) * gru_0_out_t0_16 + (1.0335118770599365) * gru_0_out_t0_17 + (-0.09628758579492569) * gru_0_out_t0_18 + (0.5561668872833252) * gru_0_out_t0_19 + (-0.57984894514083862) * gru_0_out_t0_20 + (0.55169886350631714) * gru_0_out_t0_21 + (0.69058293104171753) * gru_0_out_t0_22 + (-0.71625840663909912) * gru_0_out_t0_23 + (-0.52281063795089722) * gru_0_out_t0_24 + (-0.140528604388237) * gru_0_out_t0_25 + (0.34718126058578491) * gru_0_out_t0_26 + (-0.18457706272602081) * gru_0_out_t0_27 + (0.24715296924114227) * gru_0_out_t0_28 + (0.36671304702758789) * gru_0_out_t0_29 + (0.21187934279441833) * gru_0_out_t0_30 + (-0.24779236316680908) * gru_0_out_t0_31 + (0.41225123405456543) * gru_0_out_t0_32 + (-0.18090219795703888) * gru_0_out_t0_33 + (-0.13397662341594696) * gru_0_out_t0_34 + (0.07198256254196167) * gru_0_out_t0_35 + (0.19148793816566467) * gru_0_out_t0_36 + (-0.49366483092308044) * gru_0_out_t0_37 + (0.28032845258712769) * gru_0_out_t0_38 + (0.18161429464817047) * gru_0_out_t0_39 + (2.8569481372833252) * gru_0_out_t0_40 + (0.052882842719554901) * gru_0_out_t0_41 + (-1.4003491401672363) * gru_0_out_t0_42 + (-0.41433882713317871) * gru_0_out_t0_43 + (-0.19492824375629425) * gru_0_out_t0_44 + (-0.33201637864112854) * gru_0_out_t0_45 + (-0.75155031681060791) * gru_0_out_t0_46 + (-0.46704643964767456) * gru_0_out_t0_47 + (-0.26899498701095581) * gru_0_out_t0_48 + (0.3152310848236084) * gru_0_out_t0_49 + (0.77922719717025757) * gru_0_out_t0_50 + (0.23441037535667419) * gru_0_out_t0_51 + (0.18127255141735077) * gru_0_out_t0_52 + (0.65731441974639893) * gru_0_out_t0_53 + (-0.019581669941544533) * gru_0_out_t0_54 + (-0.15388335287570953) * gru_0_out_t0_55 + (-0.30094906687736511) * gru_0_out_t0_56 + (-0.14980976283550262) * gru_0_out_t0_57 + (0.5380713939666748) * gru_0_out_t0_58 + (0.011763636022806168) * gru_0_out_t0_59 + (-0.78393971920013428) * gru_0_out_t0_60 + (0.012046000920236111) * gru_0_out_t0_61 + (0.66465836763381958) * gru_0_out_t0_62 + (0.29096764326095581) * gru_0_out_t0_63 + (1.1673338413238525) * gru_1_rev_t1_h_0 + (0.14939285814762115) * gru_1_rev_t1_h_1 + (-0.32561290264129639) * gru_1_rev_t1_h_2 + (-0.6022346019744873) * gru_1_rev_t1_h_3 + (0.59035360813140869) * gru_1_rev_t1_h_4 + (0.49445471167564392) * gru_1_rev_t1_h_5 + (0.69845134019851685) * gru_1_rev_t1_h_6 + (-0.61494743824005127) * gru_1_rev_t1_h_7 + (1.1046082973480225) * gru_1_rev_t1_h_8 + (-0.17638376355171204) * gru_1_rev_t1_h_9 + (0.58705693483352661) * gru_1_rev_t1_h_10 + (0.39895334839820862) * gru_1_rev_t1_h_11 + (0.49830517172813416) * gru_1_rev_t1_h_12 + (0.20933225750923157) * gru_1_rev_t1_h_13 + (-0.094956129789352417) * gru_1_rev_t1_h_14 + (0.20441749691963196) * gru_1_rev_t1_h_15 + (-0.55399203300476074) * gru_1_rev_t1_h_16 + (0.30252838134765625) * gru_1_rev_t1_h_17 + (0.64790433645248413) * gru_1_rev_t1_h_18 + (1.2836524248123169) * gru_1_rev_t1_h_19 + (0.011537836864590645) * gru_1_rev_t1_h_20 + (-0.20800104737281799) * gru_1_rev_t1_h_21 + (0.029154427349567413) * gru_1_rev_t1_h_22 + (0.36066222190856934) * gru_1_rev_t1_h_23 + (0.38840353488922119) * gru_1_rev_t1_h_24 + (-0.1276332288980484) * gru_1_rev_t1_h_25 + (-0.26861265301704407) * gru_1_rev_t1_h_26 + (0.52048426866531372) * gru_1_rev_t1_h_27 + (-1.6642682552337646) * gru_1_rev_t1_h_28 + (0.54264956712722778) * gru_1_rev_t1_h_29 + (-0.59817415475845337) * gru_1_rev_t1_h_30 + (-0.79934030771255493) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.30533072352409363) + (-0.17566719651222229) * gru_0_out_t0_0 + (0.34896215796470642) * gru_0_out_t0_1 + (0.3281269371509552) * gru_0_out_t0_2 + (-0.48036849498748779) * gru_0_out_t0_3 + (0.71995961666107178) * gru_0_out_t0_4 + (0.24264141917228699) * gru_0_out_t0_5 + (-0.5215153694152832) * gru_0_out_t0_6 + (-0.33348321914672852) * gru_0_out_t0_7 + (-0.59891164302825928) * gru_0_out_t0_8 + (-1.1865718364715576) * gru_0_out_t0_9 + (-0.28748336434364319) * gru_0_out_t0_10 + (-0.21260987222194672) * gru_0_out_t0_11 + (-0.22745898365974426) * gru_0_out_t0_12 + (-0.17176425457000732) * gru_0_out_t0_13 + (0.56581020355224609) * gru_0_out_t0_14 + (-0.58140170574188232) * gru_0_out_t0_15 + (0.97201675176620483) * gru_0_out_t0_16 + (0.39902409911155701) * gru_0_out_t0_17 + (0.23950555920600891) * gru_0_out_t0_18 + (0.87772655487060547) * gru_0_out_t0_19 + (-0.23109288513660431) * gru_0_out_t0_20 + (0.65773093700408936) * gru_0_out_t0_21 + (-0.51127117872238159) * gru_0_out_t0_22 + (-0.84099924564361572) * gru_0_out_t0_23 + (-0.6141931414604187) * gru_0_out_t0_24 + (0.43514353036880493) * gru_0_out_t0_25 + (-0.62288588285446167) * gru_0_out_t0_26 + (-0.0030997730791568756) * gru_0_out_t0_27 + (0.71459883451461792) * gru_0_out_t0_28 + (0.34243413805961609) * gru_0_out_t0_29 + (-0.47076469659805298) * gru_0_out_t0_30 + (-0.087191812694072723) * gru_0_out_t0_31 + (-0.17596466839313507) * gru_0_out_t0_32 + (0.070669032633304596) * gru_0_out_t0_33 + (0.050765011459589005) * gru_0_out_t0_34 + (0.0644540935754776) * gru_0_out_t0_35 + (0.12398400902748108) * gru_0_out_t0_36 + (0.48436924815177917) * gru_0_out_t0_37 + (-0.12967999279499054) * gru_0_out_t0_38 + (-0.25178059935569763) * gru_0_out_t0_39 + (-0.018198166042566299) * gru_0_out_t0_40 + (0.84562450647354126) * gru_0_out_t0_41 + (0.51156789064407349) * gru_0_out_t0_42 + (-0.0087868673726916313) * gru_0_out_t0_43 + (-0.30030035972595215) * gru_0_out_t0_44 + (0.28340163826942444) * gru_0_out_t0_45 + (0.19809317588806152) * gru_0_out_t0_46 + (-0.13871976733207703) * gru_0_out_t0_47 + (-0.49732175469398499) * gru_0_out_t0_48 + (0.43193706870079041) * gru_0_out_t0_49 + (0.03665248304605484) * gru_0_out_t0_50 + (0.12324050068855286) * gru_0_out_t0_51 + (-0.57068496942520142) * gru_0_out_t0_52 + (-0.16301900148391724) * gru_0_out_t0_53 + (-0.1512763649225235) * gru_0_out_t0_54 + (-0.53743451833724976) * gru_0_out_t0_55 + (0.09302183985710144) * gru_0_out_t0_56 + (0.71207916736602783) * gru_0_out_t0_57 + (0.2156778872013092) * gru_0_out_t0_58 + (-0.85477250814437866) * gru_0_out_t0_59 + (1.6861205101013184) * gru_0_out_t0_60 + (2.0069625377655029) * gru_0_out_t0_61 + (0.2782418429851532) * gru_0_out_t0_62 + (-0.378591388463974) * gru_0_out_t0_63 + gate_r * ((-0.59461438655853271) + (-0.057918675243854523) * gru_1_rev_t1_h_0 + (-0.90454131364822388) * gru_1_rev_t1_h_1 + (0.31765800714492798) * gru_1_rev_t1_h_2 + (0.052217990159988403) * gru_1_rev_t1_h_3 + (0.31586641073226929) * gru_1_rev_t1_h_4 + (0.99285614490509033) * gru_1_rev_t1_h_5 + (0.053154338151216507) * gru_1_rev_t1_h_6 + (0.89941591024398804) * gru_1_rev_t1_h_7 + (0.31545668840408325) * gru_1_rev_t1_h_8 + (0.20263433456420898) * gru_1_rev_t1_h_9 + (0.74872493743896484) * gru_1_rev_t1_h_10 + (0.38063552975654602) * gru_1_rev_t1_h_11 + (-0.59519577026367188) * gru_1_rev_t1_h_12 + (0.19294486939907074) * gru_1_rev_t1_h_13 + (-0.027128051966428757) * gru_1_rev_t1_h_14 + (-0.21183779835700989) * gru_1_rev_t1_h_15 + (0.052432436496019363) * gru_1_rev_t1_h_16 + (-1.4534269571304321) * gru_1_rev_t1_h_17 + (-0.15389811992645264) * gru_1_rev_t1_h_18 + (-0.60154026746749878) * gru_1_rev_t1_h_19 + (0.99245476722717285) * gru_1_rev_t1_h_20 + (0.42543083429336548) * gru_1_rev_t1_h_21 + (-0.33548659086227417) * gru_1_rev_t1_h_22 + (-0.061212111264467239) * gru_1_rev_t1_h_23 + (0.64785414934158325) * gru_1_rev_t1_h_24 + (0.33508870005607605) * gru_1_rev_t1_h_25 + (0.32961463928222656) * gru_1_rev_t1_h_26 + (0.15967169404029846) * gru_1_rev_t1_h_27 + (0.10211530327796936) * gru_1_rev_t1_h_28 + (-0.052923377603292465) * gru_1_rev_t1_h_29 + (0.031111977994441986) * gru_1_rev_t1_h_30 + (0.56832617521286011) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_6 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_6;
    // h=7
    gate_r = sigmoid((-0.39963614940643311) + (-0.20781026780605316) * gru_0_out_t0_0 + (0.25285625457763672) * gru_0_out_t0_1 + (0.69240713119506836) * gru_0_out_t0_2 + (-0.38870251178741455) * gru_0_out_t0_3 + (-0.90489405393600464) * gru_0_out_t0_4 + (-1.7116976976394653) * gru_0_out_t0_5 + (-2.8674414157867432) * gru_0_out_t0_6 + (-1.8308275938034058) * gru_0_out_t0_7 + (1.1673561334609985) * gru_0_out_t0_8 + (2.2644722461700439) * gru_0_out_t0_9 + (-0.39915931224822998) * gru_0_out_t0_10 + (0.15972442924976349) * gru_0_out_t0_11 + (-0.56439942121505737) * gru_0_out_t0_12 + (0.1450999528169632) * gru_0_out_t0_13 + (-0.85274213552474976) * gru_0_out_t0_14 + (0.035599403083324432) * gru_0_out_t0_15 + (0.97642612457275391) * gru_0_out_t0_16 + (0.76823288202285767) * gru_0_out_t0_17 + (-0.16679497063159943) * gru_0_out_t0_18 + (1.3001182079315186) * gru_0_out_t0_19 + (1.2786688804626465) * gru_0_out_t0_20 + (2.2143032550811768) * gru_0_out_t0_21 + (-1.1033473014831543) * gru_0_out_t0_22 + (-1.1909451484680176) * gru_0_out_t0_23 + (2.0598435401916504) * gru_0_out_t0_24 + (0.23246419429779053) * gru_0_out_t0_25 + (-1.4375550746917725) * gru_0_out_t0_26 + (0.83093774318695068) * gru_0_out_t0_27 + (-1.395743727684021) * gru_0_out_t0_28 + (0.094915084540843964) * gru_0_out_t0_29 + (-1.2246594429016113) * gru_0_out_t0_30 + (-4.885129451751709) * gru_0_out_t0_31 + (-1.8223427534103394) * gru_0_out_t0_32 + (-0.20895293354988098) * gru_0_out_t0_33 + (-0.023573823273181915) * gru_0_out_t0_34 + (0.82908523082733154) * gru_0_out_t0_35 + (-0.26990383863449097) * gru_0_out_t0_36 + (-0.10903914272785187) * gru_0_out_t0_37 + (-0.11823330819606781) * gru_0_out_t0_38 + (-1.4108980894088745) * gru_0_out_t0_39 + (-1.0109844207763672) * gru_0_out_t0_40 + (0.13818904757499695) * gru_0_out_t0_41 + (0.56363588571548462) * gru_0_out_t0_42 + (0.22917753458023071) * gru_0_out_t0_43 + (0.11163564771413803) * gru_0_out_t0_44 + (-0.50050032138824463) * gru_0_out_t0_45 + (-1.1346782445907593) * gru_0_out_t0_46 + (1.9189800024032593) * gru_0_out_t0_47 + (0.28631621599197388) * gru_0_out_t0_48 + (-0.56640040874481201) * gru_0_out_t0_49 + (-0.1961047351360321) * gru_0_out_t0_50 + (0.19384555518627167) * gru_0_out_t0_51 + (-0.0068659065291285515) * gru_0_out_t0_52 + (-0.21312031149864197) * gru_0_out_t0_53 + (-0.32830429077148438) * gru_0_out_t0_54 + (-0.27280068397521973) * gru_0_out_t0_55 + (0.046869769692420959) * gru_0_out_t0_56 + (-0.23338806629180908) * gru_0_out_t0_57 + (-0.83372688293457031) * gru_0_out_t0_58 + (0.69545048475265503) * gru_0_out_t0_59 + (-1.1514420509338379) * gru_0_out_t0_60 + (0.099091134965419769) * gru_0_out_t0_61 + (0.11030840873718262) * gru_0_out_t0_62 + (0.23571893572807312) * gru_0_out_t0_63 + (-0.18678969144821167) * gru_1_rev_t1_h_0 + (-0.33943742513656616) * gru_1_rev_t1_h_1 + (0.23302121460437775) * gru_1_rev_t1_h_2 + (0.068628653883934021) * gru_1_rev_t1_h_3 + (0.14030516147613525) * gru_1_rev_t1_h_4 + (0.18720388412475586) * gru_1_rev_t1_h_5 + (-0.40872427821159363) * gru_1_rev_t1_h_6 + (0.62879079580307007) * gru_1_rev_t1_h_7 + (-1.4365921020507812) * gru_1_rev_t1_h_8 + (-0.49344563484191895) * gru_1_rev_t1_h_9 + (0.35488784313201904) * gru_1_rev_t1_h_10 + (0.7829749584197998) * gru_1_rev_t1_h_11 + (0.11642515659332275) * gru_1_rev_t1_h_12 + (0.32768678665161133) * gru_1_rev_t1_h_13 + (-0.13247939944267273) * gru_1_rev_t1_h_14 + (-0.11436754465103149) * gru_1_rev_t1_h_15 + (0.64631634950637817) * gru_1_rev_t1_h_16 + (0.78194546699523926) * gru_1_rev_t1_h_17 + (-0.096242316067218781) * gru_1_rev_t1_h_18 + (-0.059826936572790146) * gru_1_rev_t1_h_19 + (1.0867668390274048) * gru_1_rev_t1_h_20 + (-0.21334052085876465) * gru_1_rev_t1_h_21 + (-0.11769960075616837) * gru_1_rev_t1_h_22 + (1.2312448024749756) * gru_1_rev_t1_h_23 + (0.28256368637084961) * gru_1_rev_t1_h_24 + (-0.21607097983360291) * gru_1_rev_t1_h_25 + (0.50364923477172852) * gru_1_rev_t1_h_26 + (0.56010442972183228) * gru_1_rev_t1_h_27 + (-0.80903863906860352) * gru_1_rev_t1_h_28 + (0.5594145655632019) * gru_1_rev_t1_h_29 + (0.11037053912878036) * gru_1_rev_t1_h_30 + (0.091053806245326996) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.13404816389083862) + (-0.27194041013717651) * gru_0_out_t0_0 + (-0.63431650400161743) * gru_0_out_t0_1 + (-0.33037671446800232) * gru_0_out_t0_2 + (-0.1796770840883255) * gru_0_out_t0_3 + (-0.72487759590148926) * gru_0_out_t0_4 + (1.204074501991272) * gru_0_out_t0_5 + (0.27649733424186707) * gru_0_out_t0_6 + (-2.6333212852478027) * gru_0_out_t0_7 + (0.083569079637527466) * gru_0_out_t0_8 + (-0.77362829446792603) * gru_0_out_t0_9 + (-0.11932072788476944) * gru_0_out_t0_10 + (0.12006821483373642) * gru_0_out_t0_11 + (0.25559291243553162) * gru_0_out_t0_12 + (0.39614200592041016) * gru_0_out_t0_13 + (-0.66584664583206177) * gru_0_out_t0_14 + (-0.054652508348226547) * gru_0_out_t0_15 + (-0.094513125717639923) * gru_0_out_t0_16 + (0.15297441184520721) * gru_0_out_t0_17 + (-0.20389251410961151) * gru_0_out_t0_18 + (-1.1058746576309204) * gru_0_out_t0_19 + (-0.95929515361785889) * gru_0_out_t0_20 + (-0.33375281095504761) * gru_0_out_t0_21 + (0.14470851421356201) * gru_0_out_t0_22 + (0.28311082720756531) * gru_0_out_t0_23 + (-0.69516021013259888) * gru_0_out_t0_24 + (0.17527972161769867) * gru_0_out_t0_25 + (-0.22358299791812897) * gru_0_out_t0_26 + (1.3507026433944702) * gru_0_out_t0_27 + (-0.21068628132343292) * gru_0_out_t0_28 + (-1.1254456043243408) * gru_0_out_t0_29 + (-0.030660646036267281) * gru_0_out_t0_30 + (0.22548918426036835) * gru_0_out_t0_31 + (-0.25104826688766479) * gru_0_out_t0_32 + (-0.068916171789169312) * gru_0_out_t0_33 + (-0.39429590106010437) * gru_0_out_t0_34 + (0.10499512404203415) * gru_0_out_t0_35 + (0.53096765279769897) * gru_0_out_t0_36 + (-0.79691338539123535) * gru_0_out_t0_37 + (0.11348490417003632) * gru_0_out_t0_38 + (0.10195974260568619) * gru_0_out_t0_39 + (0.11139728128910065) * gru_0_out_t0_40 + (-0.14666184782981873) * gru_0_out_t0_41 + (-0.37623468041419983) * gru_0_out_t0_42 + (0.61835885047912598) * gru_0_out_t0_43 + (0.24388514459133148) * gru_0_out_t0_44 + (-0.53301805257797241) * gru_0_out_t0_45 + (0.7220768928527832) * gru_0_out_t0_46 + (-0.32932466268539429) * gru_0_out_t0_47 + (0.29145592451095581) * gru_0_out_t0_48 + (-0.10063991695642471) * gru_0_out_t0_49 + (0.2701682448387146) * gru_0_out_t0_50 + (-0.013128055259585381) * gru_0_out_t0_51 + (0.789326012134552) * gru_0_out_t0_52 + (-0.070334881544113159) * gru_0_out_t0_53 + (0.41407647728919983) * gru_0_out_t0_54 + (0.55201023817062378) * gru_0_out_t0_55 + (-0.18774272501468658) * gru_0_out_t0_56 + (-0.33452346920967102) * gru_0_out_t0_57 + (0.57453829050064087) * gru_0_out_t0_58 + (0.69652903079986572) * gru_0_out_t0_59 + (0.83067959547042847) * gru_0_out_t0_60 + (0.93279170989990234) * gru_0_out_t0_61 + (-0.21509420871734619) * gru_0_out_t0_62 + (-1.6404600143432617) * gru_0_out_t0_63 + (1.4164241552352905) * gru_1_rev_t1_h_0 + (0.92596876621246338) * gru_1_rev_t1_h_1 + (-0.16793611645698547) * gru_1_rev_t1_h_2 + (-0.34400650858879089) * gru_1_rev_t1_h_3 + (-1.898054838180542) * gru_1_rev_t1_h_4 + (-0.47341340780258179) * gru_1_rev_t1_h_5 + (0.8006356954574585) * gru_1_rev_t1_h_6 + (-0.3695862889289856) * gru_1_rev_t1_h_7 + (1.4047344923019409) * gru_1_rev_t1_h_8 + (-1.2633395195007324) * gru_1_rev_t1_h_9 + (0.44833701848983765) * gru_1_rev_t1_h_10 + (0.70123183727264404) * gru_1_rev_t1_h_11 + (-0.48786762356758118) * gru_1_rev_t1_h_12 + (1.1826697587966919) * gru_1_rev_t1_h_13 + (-1.016511082649231) * gru_1_rev_t1_h_14 + (-0.088773734867572784) * gru_1_rev_t1_h_15 + (-0.2016834169626236) * gru_1_rev_t1_h_16 + (1.2500975131988525) * gru_1_rev_t1_h_17 + (0.044986184686422348) * gru_1_rev_t1_h_18 + (0.18098784983158112) * gru_1_rev_t1_h_19 + (-0.39539220929145813) * gru_1_rev_t1_h_20 + (-0.44188979268074036) * gru_1_rev_t1_h_21 + (0.21728271245956421) * gru_1_rev_t1_h_22 + (-0.11055468767881393) * gru_1_rev_t1_h_23 + (-0.64211422204971313) * gru_1_rev_t1_h_24 + (-0.8944668173789978) * gru_1_rev_t1_h_25 + (-0.082019679248332977) * gru_1_rev_t1_h_26 + (1.7589248418807983) * gru_1_rev_t1_h_27 + (-0.96743732690811157) * gru_1_rev_t1_h_28 + (0.41310521960258484) * gru_1_rev_t1_h_29 + (0.65139162540435791) * gru_1_rev_t1_h_30 + (-1.1105321645736694) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.057324498891830444) + (0.12885567545890808) * gru_0_out_t0_0 + (-0.16960816085338593) * gru_0_out_t0_1 + (-0.99974793195724487) * gru_0_out_t0_2 + (0.1813657283782959) * gru_0_out_t0_3 + (0.050397250801324844) * gru_0_out_t0_4 + (-0.18066485226154327) * gru_0_out_t0_5 + (0.4888407289981842) * gru_0_out_t0_6 + (-0.33440813422203064) * gru_0_out_t0_7 + (-0.79696959257125854) * gru_0_out_t0_8 + (-2.4279558658599854) * gru_0_out_t0_9 + (0.0010142829269170761) * gru_0_out_t0_10 + (0.044484402984380722) * gru_0_out_t0_11 + (0.17596441507339478) * gru_0_out_t0_12 + (-0.12496243417263031) * gru_0_out_t0_13 + (0.048990163952112198) * gru_0_out_t0_14 + (0.027939919382333755) * gru_0_out_t0_15 + (-0.46052828431129456) * gru_0_out_t0_16 + (-0.48433384299278259) * gru_0_out_t0_17 + (0.076170668005943298) * gru_0_out_t0_18 + (-0.31414937973022461) * gru_0_out_t0_19 + (-1.3727266788482666) * gru_0_out_t0_20 + (-0.45654904842376709) * gru_0_out_t0_21 + (0.061530392616987228) * gru_0_out_t0_22 + (0.9483712911605835) * gru_0_out_t0_23 + (0.030208254233002663) * gru_0_out_t0_24 + (0.092941753566265106) * gru_0_out_t0_25 + (0.2545640766620636) * gru_0_out_t0_26 + (-0.27339506149291992) * gru_0_out_t0_27 + (0.41327506303787231) * gru_0_out_t0_28 + (-0.34309592843055725) * gru_0_out_t0_29 + (0.46761488914489746) * gru_0_out_t0_30 + (0.7828977108001709) * gru_0_out_t0_31 + (1.1727195978164673) * gru_0_out_t0_32 + (-0.15018010139465332) * gru_0_out_t0_33 + (-0.022846776992082596) * gru_0_out_t0_34 + (-0.60476672649383545) * gru_0_out_t0_35 + (-0.17181707918643951) * gru_0_out_t0_36 + (0.062443375587463379) * gru_0_out_t0_37 + (-0.010915153659880161) * gru_0_out_t0_38 + (-0.69575458765029907) * gru_0_out_t0_39 + (-2.6814885139465332) * gru_0_out_t0_40 + (-0.27786150574684143) * gru_0_out_t0_41 + (-0.70577716827392578) * gru_0_out_t0_42 + (-0.12238097190856934) * gru_0_out_t0_43 + (-0.26003521680831909) * gru_0_out_t0_44 + (0.056963331997394562) * gru_0_out_t0_45 + (0.26907721161842346) * gru_0_out_t0_46 + (-1.3241549730300903) * gru_0_out_t0_47 + (-0.60639947652816772) * gru_0_out_t0_48 + (0.70621949434280396) * gru_0_out_t0_49 + (0.28451547026634216) * gru_0_out_t0_50 + (-0.23454016447067261) * gru_0_out_t0_51 + (-0.010684038512408733) * gru_0_out_t0_52 + (0.54742014408111572) * gru_0_out_t0_53 + (-0.02742532454431057) * gru_0_out_t0_54 + (0.63999998569488525) * gru_0_out_t0_55 + (-0.37977299094200134) * gru_0_out_t0_56 + (0.15613767504692078) * gru_0_out_t0_57 + (0.31205976009368896) * gru_0_out_t0_58 + (-0.3015894889831543) * gru_0_out_t0_59 + (-1.5931282043457031) * gru_0_out_t0_60 + (-0.039925973862409592) * gru_0_out_t0_61 + (0.97984296083450317) * gru_0_out_t0_62 + (-0.47095397114753723) * gru_0_out_t0_63 + gate_r * ((-0.53214973211288452) + (-0.2645641565322876) * gru_1_rev_t1_h_0 + (-0.4073043167591095) * gru_1_rev_t1_h_1 + (0.23930716514587402) * gru_1_rev_t1_h_2 + (-0.51336497068405151) * gru_1_rev_t1_h_3 + (-0.34990218281745911) * gru_1_rev_t1_h_4 + (1.1341136693954468) * gru_1_rev_t1_h_5 + (-0.0045106792822480202) * gru_1_rev_t1_h_6 + (-0.96302449703216553) * gru_1_rev_t1_h_7 + (0.38057827949523926) * gru_1_rev_t1_h_8 + (-0.3416387140750885) * gru_1_rev_t1_h_9 + (0.43227067589759827) * gru_1_rev_t1_h_10 + (0.36625820398330688) * gru_1_rev_t1_h_11 + (0.20898669958114624) * gru_1_rev_t1_h_12 + (-0.22951164841651917) * gru_1_rev_t1_h_13 + (0.12221596390008926) * gru_1_rev_t1_h_14 + (0.42565765976905823) * gru_1_rev_t1_h_15 + (1.5381863117218018) * gru_1_rev_t1_h_16 + (-0.48511707782745361) * gru_1_rev_t1_h_17 + (-2.0682907104492188) * gru_1_rev_t1_h_18 + (-0.5900571346282959) * gru_1_rev_t1_h_19 + (0.87944924831390381) * gru_1_rev_t1_h_20 + (-0.44764822721481323) * gru_1_rev_t1_h_21 + (0.43549707531929016) * gru_1_rev_t1_h_22 + (1.1948413848876953) * gru_1_rev_t1_h_23 + (0.21701496839523315) * gru_1_rev_t1_h_24 + (-0.54133188724517822) * gru_1_rev_t1_h_25 + (0.21624752879142761) * gru_1_rev_t1_h_26 + (-0.60326063632965088) * gru_1_rev_t1_h_27 + (-0.46083927154541016) * gru_1_rev_t1_h_28 + (0.20273558795452118) * gru_1_rev_t1_h_29 + (-0.61339795589447021) * gru_1_rev_t1_h_30 + (-0.24521100521087646) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_7 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_7;
    // h=8
    gate_r = sigmoid((0.71153897047042847) + (0.22004126012325287) * gru_0_out_t0_0 + (0.084394022822380066) * gru_0_out_t0_1 + (1.1540189981460571) * gru_0_out_t0_2 + (0.43402218818664551) * gru_0_out_t0_3 + (0.02439156174659729) * gru_0_out_t0_4 + (-2.3316409587860107) * gru_0_out_t0_5 + (2.6299624443054199) * gru_0_out_t0_6 + (0.037251260131597519) * gru_0_out_t0_7 + (0.47053521871566772) * gru_0_out_t0_8 + (-2.294872522354126) * gru_0_out_t0_9 + (-1.6050328016281128) * gru_0_out_t0_10 + (0.025158606469631195) * gru_0_out_t0_11 + (0.11859126389026642) * gru_0_out_t0_12 + (-0.056847520172595978) * gru_0_out_t0_13 + (0.25249356031417847) * gru_0_out_t0_14 + (0.0031020641326904297) * gru_0_out_t0_15 + (-0.39286822080612183) * gru_0_out_t0_16 + (0.10026905685663223) * gru_0_out_t0_17 + (-0.1985514760017395) * gru_0_out_t0_18 + (0.043799269944429398) * gru_0_out_t0_19 + (-3.0419051647186279) * gru_0_out_t0_20 + (-4.0739345550537109) * gru_0_out_t0_21 + (2.4771218299865723) * gru_0_out_t0_22 + (-1.2024902105331421) * gru_0_out_t0_23 + (-1.8663249015808105) * gru_0_out_t0_24 + (0.30563938617706299) * gru_0_out_t0_25 + (1.1396386623382568) * gru_0_out_t0_26 + (-0.0025144626852124929) * gru_0_out_t0_27 + (0.3950253427028656) * gru_0_out_t0_28 + (-2.5138969421386719) * gru_0_out_t0_29 + (0.50044119358062744) * gru_0_out_t0_30 + (1.7435456514358521) * gru_0_out_t0_31 + (-0.78345310688018799) * gru_0_out_t0_32 + (0.20089253783226013) * gru_0_out_t0_33 + (0.49300506711006165) * gru_0_out_t0_34 + (0.37557333707809448) * gru_0_out_t0_35 + (-0.56149053573608398) * gru_0_out_t0_36 + (-0.098673194646835327) * gru_0_out_t0_37 + (-0.33790460228919983) * gru_0_out_t0_38 + (0.39689236879348755) * gru_0_out_t0_39 + (-2.7984540462493896) * gru_0_out_t0_40 + (0.063675969839096069) * gru_0_out_t0_41 + (0.93076872825622559) * gru_0_out_t0_42 + (0.16306199133396149) * gru_0_out_t0_43 + (0.057302609086036682) * gru_0_out_t0_44 + (-0.20377486944198608) * gru_0_out_t0_45 + (-1.5684714317321777) * gru_0_out_t0_46 + (0.73373955488204956) * gru_0_out_t0_47 + (2.6406033039093018) * gru_0_out_t0_48 + (-3.0300130844116211) * gru_0_out_t0_49 + (-0.55544793605804443) * gru_0_out_t0_50 + (0.58061659336090088) * gru_0_out_t0_51 + (-0.088741317391395569) * gru_0_out_t0_52 + (-0.012332289479672909) * gru_0_out_t0_53 + (-0.51713311672210693) * gru_0_out_t0_54 + (1.0057578086853027) * gru_0_out_t0_55 + (1.0984698534011841) * gru_0_out_t0_56 + (-1.1095272302627563) * gru_0_out_t0_57 + (-1.1187261343002319) * gru_0_out_t0_58 + (0.9188230037689209) * gru_0_out_t0_59 + (-0.3067842423915863) * gru_0_out_t0_60 + (-1.5359957218170166) * gru_0_out_t0_61 + (-0.11311772465705872) * gru_0_out_t0_62 + (-1.3941941261291504) * gru_0_out_t0_63 + (-0.39158126711845398) * gru_1_rev_t1_h_0 + (0.45403122901916504) * gru_1_rev_t1_h_1 + (-0.68094384670257568) * gru_1_rev_t1_h_2 + (-0.23564675450325012) * gru_1_rev_t1_h_3 + (-0.1631045788526535) * gru_1_rev_t1_h_4 + (-0.11701373755931854) * gru_1_rev_t1_h_5 + (-1.0310103893280029) * gru_1_rev_t1_h_6 + (0.15132667124271393) * gru_1_rev_t1_h_7 + (-0.33571088314056396) * gru_1_rev_t1_h_8 + (0.59780204296112061) * gru_1_rev_t1_h_9 + (-0.48714557290077209) * gru_1_rev_t1_h_10 + (0.71212148666381836) * gru_1_rev_t1_h_11 + (-0.47903361916542053) * gru_1_rev_t1_h_12 + (-0.065724574029445648) * gru_1_rev_t1_h_13 + (-0.65226715803146362) * gru_1_rev_t1_h_14 + (-0.31814464926719666) * gru_1_rev_t1_h_15 + (0.54870545864105225) * gru_1_rev_t1_h_16 + (-0.51055848598480225) * gru_1_rev_t1_h_17 + (1.6929274797439575) * gru_1_rev_t1_h_18 + (1.8460452556610107) * gru_1_rev_t1_h_19 + (0.37910333275794983) * gru_1_rev_t1_h_20 + (0.18393994867801666) * gru_1_rev_t1_h_21 + (0.84771043062210083) * gru_1_rev_t1_h_22 + (-0.39075255393981934) * gru_1_rev_t1_h_23 + (-0.36522483825683594) * gru_1_rev_t1_h_24 + (0.48982778191566467) * gru_1_rev_t1_h_25 + (0.451811283826828) * gru_1_rev_t1_h_26 + (-0.6995009183883667) * gru_1_rev_t1_h_27 + (0.8633689284324646) * gru_1_rev_t1_h_28 + (0.05908486619591713) * gru_1_rev_t1_h_29 + (1.4466145038604736) * gru_1_rev_t1_h_30 + (0.0070014148950576782) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.066117621958255768) + (-0.23075065016746521) * gru_0_out_t0_0 + (0.14558793604373932) * gru_0_out_t0_1 + (-0.29864183068275452) * gru_0_out_t0_2 + (0.013038829900324345) * gru_0_out_t0_3 + (-0.29638287425041199) * gru_0_out_t0_4 + (-0.12796927988529205) * gru_0_out_t0_5 + (0.66369932889938354) * gru_0_out_t0_6 + (0.20199048519134521) * gru_0_out_t0_7 + (0.23934242129325867) * gru_0_out_t0_8 + (0.78007519245147705) * gru_0_out_t0_9 + (-0.0023384580854326487) * gru_0_out_t0_10 + (0.047696225345134735) * gru_0_out_t0_11 + (0.33212152123451233) * gru_0_out_t0_12 + (0.21583320200443268) * gru_0_out_t0_13 + (-0.83928710222244263) * gru_0_out_t0_14 + (0.2774253785610199) * gru_0_out_t0_15 + (0.68301814794540405) * gru_0_out_t0_16 + (0.72099030017852783) * gru_0_out_t0_17 + (-0.1991993635892868) * gru_0_out_t0_18 + (0.069716572761535645) * gru_0_out_t0_19 + (1.1697835922241211) * gru_0_out_t0_20 + (0.28556370735168457) * gru_0_out_t0_21 + (0.37639766931533813) * gru_0_out_t0_22 + (-0.24117150902748108) * gru_0_out_t0_23 + (-0.42926633358001709) * gru_0_out_t0_24 + (0.31521260738372803) * gru_0_out_t0_25 + (-0.47711893916130066) * gru_0_out_t0_26 + (-0.034905698150396347) * gru_0_out_t0_27 + (-1.001376748085022) * gru_0_out_t0_28 + (1.2923375368118286) * gru_0_out_t0_29 + (-0.45025929808616638) * gru_0_out_t0_30 + (0.57948547601699829) * gru_0_out_t0_31 + (-0.015757497400045395) * gru_0_out_t0_32 + (-0.35433560609817505) * gru_0_out_t0_33 + (0.08323446661233902) * gru_0_out_t0_34 + (0.48028615117073059) * gru_0_out_t0_35 + (0.002413199283182621) * gru_0_out_t0_36 + (0.44470247626304626) * gru_0_out_t0_37 + (0.45901617407798767) * gru_0_out_t0_38 + (0.31168264150619507) * gru_0_out_t0_39 + (-0.72074145078659058) * gru_0_out_t0_40 + (-0.018161414191126823) * gru_0_out_t0_41 + (-0.13495536148548126) * gru_0_out_t0_42 + (0.204763263463974) * gru_0_out_t0_43 + (0.4217873215675354) * gru_0_out_t0_44 + (0.27654930949211121) * gru_0_out_t0_45 + (-1.2024351358413696) * gru_0_out_t0_46 + (-0.12750060856342316) * gru_0_out_t0_47 + (0.13900376856327057) * gru_0_out_t0_48 + (-0.060016505420207977) * gru_0_out_t0_49 + (0.15337757766246796) * gru_0_out_t0_50 + (0.71074867248535156) * gru_0_out_t0_51 + (0.72547560930252075) * gru_0_out_t0_52 + (-0.051597744226455688) * gru_0_out_t0_53 + (-0.43060353398323059) * gru_0_out_t0_54 + (0.4945293664932251) * gru_0_out_t0_55 + (0.22073602676391602) * gru_0_out_t0_56 + (-0.16427269577980042) * gru_0_out_t0_57 + (0.05878506600856781) * gru_0_out_t0_58 + (-1.0619670152664185) * gru_0_out_t0_59 + (0.055974531918764114) * gru_0_out_t0_60 + (0.46138027310371399) * gru_0_out_t0_61 + (0.33064800500869751) * gru_0_out_t0_62 + (-0.941475510597229) * gru_0_out_t0_63 + (0.15595255792140961) * gru_1_rev_t1_h_0 + (-0.13299588859081268) * gru_1_rev_t1_h_1 + (-0.28756493330001831) * gru_1_rev_t1_h_2 + (-0.38996940851211548) * gru_1_rev_t1_h_3 + (0.6498870849609375) * gru_1_rev_t1_h_4 + (0.91760152578353882) * gru_1_rev_t1_h_5 + (0.55721127986907959) * gru_1_rev_t1_h_6 + (0.6337888240814209) * gru_1_rev_t1_h_7 + (0.3956051766872406) * gru_1_rev_t1_h_8 + (-0.20675961673259735) * gru_1_rev_t1_h_9 + (0.42817792296409607) * gru_1_rev_t1_h_10 + (-0.49515095353126526) * gru_1_rev_t1_h_11 + (-0.29018262028694153) * gru_1_rev_t1_h_12 + (-0.16234283149242401) * gru_1_rev_t1_h_13 + (0.25859600305557251) * gru_1_rev_t1_h_14 + (0.17378158867359161) * gru_1_rev_t1_h_15 + (0.3143649697303772) * gru_1_rev_t1_h_16 + (1.712799072265625) * gru_1_rev_t1_h_17 + (-0.76548194885253906) * gru_1_rev_t1_h_18 + (-1.1964157819747925) * gru_1_rev_t1_h_19 + (0.10870376229286194) * gru_1_rev_t1_h_20 + (0.24139347672462463) * gru_1_rev_t1_h_21 + (0.19084922969341278) * gru_1_rev_t1_h_22 + (0.13438422977924347) * gru_1_rev_t1_h_23 + (0.45547398924827576) * gru_1_rev_t1_h_24 + (0.12256009131669998) * gru_1_rev_t1_h_25 + (0.39677834510803223) * gru_1_rev_t1_h_26 + (0.57842373847961426) * gru_1_rev_t1_h_27 + (-0.27105122804641724) * gru_1_rev_t1_h_28 + (0.30035170912742615) * gru_1_rev_t1_h_29 + (-1.1928585767745972) * gru_1_rev_t1_h_30 + (0.52414143085479736) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.1765127032995224) + (-0.2032693475484848) * gru_0_out_t0_0 + (0.2864222526550293) * gru_0_out_t0_1 + (0.18467503786087036) * gru_0_out_t0_2 + (0.20742826163768768) * gru_0_out_t0_3 + (-0.35955667495727539) * gru_0_out_t0_4 + (1.7253692150115967) * gru_0_out_t0_5 + (-0.22611992061138153) * gru_0_out_t0_6 + (-0.013092055916786194) * gru_0_out_t0_7 + (0.79168373346328735) * gru_0_out_t0_8 + (0.29778161644935608) * gru_0_out_t0_9 + (-0.53383076190948486) * gru_0_out_t0_10 + (0.18833756446838379) * gru_0_out_t0_11 + (-0.13303501904010773) * gru_0_out_t0_12 + (-0.25592261552810669) * gru_0_out_t0_13 + (-0.15432451665401459) * gru_0_out_t0_14 + (0.3773345947265625) * gru_0_out_t0_15 + (0.30101439356803894) * gru_0_out_t0_16 + (0.60476857423782349) * gru_0_out_t0_17 + (0.72847181558609009) * gru_0_out_t0_18 + (0.18997417390346527) * gru_0_out_t0_19 + (-0.14102877676486969) * gru_0_out_t0_20 + (1.1750783920288086) * gru_0_out_t0_21 + (0.032312758266925812) * gru_0_out_t0_22 + (-1.1372226476669312) * gru_0_out_t0_23 + (-0.29029104113578796) * gru_0_out_t0_24 + (0.13263790309429169) * gru_0_out_t0_25 + (0.31758987903594971) * gru_0_out_t0_26 + (0.30940437316894531) * gru_0_out_t0_27 + (-0.96354866027832031) * gru_0_out_t0_28 + (-0.28726688027381897) * gru_0_out_t0_29 + (-0.42891284823417664) * gru_0_out_t0_30 + (0.84204387664794922) * gru_0_out_t0_31 + (0.061037201434373856) * gru_0_out_t0_32 + (-0.27039816975593567) * gru_0_out_t0_33 + (0.17178300023078918) * gru_0_out_t0_34 + (-0.096177764236927032) * gru_0_out_t0_35 + (-0.27416259050369263) * gru_0_out_t0_36 + (0.051182910799980164) * gru_0_out_t0_37 + (-0.049445401877164841) * gru_0_out_t0_38 + (-0.11864466965198517) * gru_0_out_t0_39 + (3.4021213054656982) * gru_0_out_t0_40 + (0.063505277037620544) * gru_0_out_t0_41 + (-0.22538509964942932) * gru_0_out_t0_42 + (0.26478204131126404) * gru_0_out_t0_43 + (-0.44433170557022095) * gru_0_out_t0_44 + (0.1209583505988121) * gru_0_out_t0_45 + (-0.21770477294921875) * gru_0_out_t0_46 + (0.64245986938476562) * gru_0_out_t0_47 + (0.11538536846637726) * gru_0_out_t0_48 + (0.28733891248703003) * gru_0_out_t0_49 + (-0.10824068635702133) * gru_0_out_t0_50 + (-0.30104851722717285) * gru_0_out_t0_51 + (0.16962504386901855) * gru_0_out_t0_52 + (-0.21279595792293549) * gru_0_out_t0_53 + (-0.34869846701622009) * gru_0_out_t0_54 + (-0.095038056373596191) * gru_0_out_t0_55 + (0.43824949860572815) * gru_0_out_t0_56 + (0.73620140552520752) * gru_0_out_t0_57 + (-0.82553666830062866) * gru_0_out_t0_58 + (0.014914150349795818) * gru_0_out_t0_59 + (1.4430482387542725) * gru_0_out_t0_60 + (0.63015574216842651) * gru_0_out_t0_61 + (-0.58343571424484253) * gru_0_out_t0_62 + (-1.0278270244598389) * gru_0_out_t0_63 + gate_r * ((-0.09362657368183136) + (0.10240828990936279) * gru_1_rev_t1_h_0 + (-0.34707155823707581) * gru_1_rev_t1_h_1 + (0.44220033288002014) * gru_1_rev_t1_h_2 + (-0.045883700251579285) * gru_1_rev_t1_h_3 + (-0.29681718349456787) * gru_1_rev_t1_h_4 + (-0.65226662158966064) * gru_1_rev_t1_h_5 + (0.76792728900909424) * gru_1_rev_t1_h_6 + (0.45450344681739807) * gru_1_rev_t1_h_7 + (0.034015756100416183) * gru_1_rev_t1_h_8 + (-1.0205779075622559) * gru_1_rev_t1_h_9 + (0.14883188903331757) * gru_1_rev_t1_h_10 + (-0.35525131225585938) * gru_1_rev_t1_h_11 + (0.3975335955619812) * gru_1_rev_t1_h_12 + (0.27971097826957703) * gru_1_rev_t1_h_13 + (0.44330164790153503) * gru_1_rev_t1_h_14 + (-0.005379342008382082) * gru_1_rev_t1_h_15 + (0.91900408267974854) * gru_1_rev_t1_h_16 + (0.93961352109909058) * gru_1_rev_t1_h_17 + (1.0970392227172852) * gru_1_rev_t1_h_18 + (-0.45261991024017334) * gru_1_rev_t1_h_19 + (0.10989093780517578) * gru_1_rev_t1_h_20 + (-0.099807910621166229) * gru_1_rev_t1_h_21 + (0.37836205959320068) * gru_1_rev_t1_h_22 + (-0.11061597615480423) * gru_1_rev_t1_h_23 + (0.078600741922855377) * gru_1_rev_t1_h_24 + (-1.560454249382019) * gru_1_rev_t1_h_25 + (-0.27864423394203186) * gru_1_rev_t1_h_26 + (0.35582262277603149) * gru_1_rev_t1_h_27 + (0.74574410915374756) * gru_1_rev_t1_h_28 + (0.46714994311332703) * gru_1_rev_t1_h_29 + (0.14152780175209045) * gru_1_rev_t1_h_30 + (0.41193839907646179) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_8 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_8;
    // h=9
    gate_r = sigmoid((-0.95582729578018188) + (0.22742496430873871) * gru_0_out_t0_0 + (-0.82027143239974976) * gru_0_out_t0_1 + (-2.1254136562347412) * gru_0_out_t0_2 + (0.40380755066871643) * gru_0_out_t0_3 + (1.0038113594055176) * gru_0_out_t0_4 + (-0.91966253519058228) * gru_0_out_t0_5 + (2.5666468143463135) * gru_0_out_t0_6 + (-0.18949301540851593) * gru_0_out_t0_7 + (0.052322860807180405) * gru_0_out_t0_8 + (-1.7936608791351318) * gru_0_out_t0_9 + (2.5546557903289795) * gru_0_out_t0_10 + (0.35992297530174255) * gru_0_out_t0_11 + (-0.09709610790014267) * gru_0_out_t0_12 + (0.77677154541015625) * gru_0_out_t0_13 + (-0.22092080116271973) * gru_0_out_t0_14 + (-1.1720876693725586) * gru_0_out_t0_15 + (-0.17545461654663086) * gru_0_out_t0_16 + (0.080530218780040741) * gru_0_out_t0_17 + (-0.75187617540359497) * gru_0_out_t0_18 + (0.29687970876693726) * gru_0_out_t0_19 + (-2.126727819442749) * gru_0_out_t0_20 + (-2.9734723567962646) * gru_0_out_t0_21 + (1.1878939867019653) * gru_0_out_t0_22 + (0.60180628299713135) * gru_0_out_t0_23 + (3.8075850009918213) * gru_0_out_t0_24 + (-1.3874937295913696) * gru_0_out_t0_25 + (-0.13622123003005981) * gru_0_out_t0_26 + (-3.0334861278533936) * gru_0_out_t0_27 + (1.7596381902694702) * gru_0_out_t0_28 + (-0.74893790483474731) * gru_0_out_t0_29 + (-0.085681408643722534) * gru_0_out_t0_30 + (-6.8612689971923828) * gru_0_out_t0_31 + (-1.0411883592605591) * gru_0_out_t0_32 + (0.28089547157287598) * gru_0_out_t0_33 + (-0.32585969567298889) * gru_0_out_t0_34 + (0.35452371835708618) * gru_0_out_t0_35 + (0.7090110182762146) * gru_0_out_t0_36 + (0.13355907797813416) * gru_0_out_t0_37 + (0.044564463198184967) * gru_0_out_t0_38 + (3.6793110370635986) * gru_0_out_t0_39 + (1.3007825613021851) * gru_0_out_t0_40 + (-0.38918843865394592) * gru_0_out_t0_41 + (0.63278090953826904) * gru_0_out_t0_42 + (-0.028625210747122765) * gru_0_out_t0_43 + (-1.4365365505218506) * gru_0_out_t0_44 + (0.13984039425849915) * gru_0_out_t0_45 + (0.28115791082382202) * gru_0_out_t0_46 + (0.60261452198028564) * gru_0_out_t0_47 + (1.1967567205429077) * gru_0_out_t0_48 + (-1.3323121070861816) * gru_0_out_t0_49 + (-0.39995202422142029) * gru_0_out_t0_50 + (0.065876394510269165) * gru_0_out_t0_51 + (-0.11918669193983078) * gru_0_out_t0_52 + (-0.18704232573509216) * gru_0_out_t0_53 + (-0.13107392191886902) * gru_0_out_t0_54 + (0.31169489026069641) * gru_0_out_t0_55 + (0.60715878009796143) * gru_0_out_t0_56 + (-2.0054013729095459) * gru_0_out_t0_57 + (1.537014365196228) * gru_0_out_t0_58 + (0.20031595230102539) * gru_0_out_t0_59 + (-0.53437650203704834) * gru_0_out_t0_60 + (-1.4352445602416992) * gru_0_out_t0_61 + (0.48488056659698486) * gru_0_out_t0_62 + (-0.26031360030174255) * gru_0_out_t0_63 + (-0.45193749666213989) * gru_1_rev_t1_h_0 + (1.3735119104385376) * gru_1_rev_t1_h_1 + (-0.15941037237644196) * gru_1_rev_t1_h_2 + (-0.28527739644050598) * gru_1_rev_t1_h_3 + (0.97836214303970337) * gru_1_rev_t1_h_4 + (0.21371296048164368) * gru_1_rev_t1_h_5 + (-0.3457520604133606) * gru_1_rev_t1_h_6 + (0.85303658246994019) * gru_1_rev_t1_h_7 + (-0.7957114577293396) * gru_1_rev_t1_h_8 + (-0.89484238624572754) * gru_1_rev_t1_h_9 + (-1.3770699501037598) * gru_1_rev_t1_h_10 + (1.1117056608200073) * gru_1_rev_t1_h_11 + (1.6541718244552612) * gru_1_rev_t1_h_12 + (0.60544103384017944) * gru_1_rev_t1_h_13 + (0.29590877890586853) * gru_1_rev_t1_h_14 + (-0.0054107694886624813) * gru_1_rev_t1_h_15 + (0.85163158178329468) * gru_1_rev_t1_h_16 + (-1.3576933145523071) * gru_1_rev_t1_h_17 + (2.6052193641662598) * gru_1_rev_t1_h_18 + (1.3850579261779785) * gru_1_rev_t1_h_19 + (-0.1689741462469101) * gru_1_rev_t1_h_20 + (-0.62046736478805542) * gru_1_rev_t1_h_21 + (1.2835458517074585) * gru_1_rev_t1_h_22 + (0.73208153247833252) * gru_1_rev_t1_h_23 + (-0.75002634525299072) * gru_1_rev_t1_h_24 + (-0.25637704133987427) * gru_1_rev_t1_h_25 + (-0.96414750814437866) * gru_1_rev_t1_h_26 + (-0.62875813245773315) * gru_1_rev_t1_h_27 + (1.9528104066848755) * gru_1_rev_t1_h_28 + (-0.39277702569961548) * gru_1_rev_t1_h_29 + (-2.4417564868927002) * gru_1_rev_t1_h_30 + (-0.65078818798065186) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.38916113972663879) + (-0.016015253961086273) * gru_0_out_t0_0 + (-0.09099094569683075) * gru_0_out_t0_1 + (-0.62774235010147095) * gru_0_out_t0_2 + (-0.18479102849960327) * gru_0_out_t0_3 + (-0.075062595307826996) * gru_0_out_t0_4 + (-0.86516851186752319) * gru_0_out_t0_5 + (-0.032120015472173691) * gru_0_out_t0_6 + (-0.73764026165008545) * gru_0_out_t0_7 + (0.35798022150993347) * gru_0_out_t0_8 + (-0.43704059720039368) * gru_0_out_t0_9 + (0.12844806909561157) * gru_0_out_t0_10 + (0.022286530584096909) * gru_0_out_t0_11 + (-0.14540587365627289) * gru_0_out_t0_12 + (-0.07256721705198288) * gru_0_out_t0_13 + (-0.15329913794994354) * gru_0_out_t0_14 + (-0.37834638357162476) * gru_0_out_t0_15 + (1.5076981782913208) * gru_0_out_t0_16 + (0.77316039800643921) * gru_0_out_t0_17 + (-0.13537077605724335) * gru_0_out_t0_18 + (-0.43495118618011475) * gru_0_out_t0_19 + (-0.34728723764419556) * gru_0_out_t0_20 + (1.0125067234039307) * gru_0_out_t0_21 + (-0.13168495893478394) * gru_0_out_t0_22 + (-0.49146994948387146) * gru_0_out_t0_23 + (-0.058019433170557022) * gru_0_out_t0_24 + (-0.25647458434104919) * gru_0_out_t0_25 + (-0.27202773094177246) * gru_0_out_t0_26 + (-0.27573984861373901) * gru_0_out_t0_27 + (0.021275119855999947) * gru_0_out_t0_28 + (0.50234967470169067) * gru_0_out_t0_29 + (0.36092251539230347) * gru_0_out_t0_30 + (-0.12263344973325729) * gru_0_out_t0_31 + (0.42963448166847229) * gru_0_out_t0_32 + (-0.055024158209562302) * gru_0_out_t0_33 + (1.1205470561981201) * gru_0_out_t0_34 + (0.0045593371614813805) * gru_0_out_t0_35 + (-0.28579944372177124) * gru_0_out_t0_36 + (0.15242034196853638) * gru_0_out_t0_37 + (-0.3832181990146637) * gru_0_out_t0_38 + (0.90963762998580933) * gru_0_out_t0_39 + (0.83193045854568481) * gru_0_out_t0_40 + (-0.29524922370910645) * gru_0_out_t0_41 + (-1.3819838762283325) * gru_0_out_t0_42 + (-0.29086121916770935) * gru_0_out_t0_43 + (-0.11405661702156067) * gru_0_out_t0_44 + (0.14874568581581116) * gru_0_out_t0_45 + (1.2852749824523926) * gru_0_out_t0_46 + (-0.59379446506500244) * gru_0_out_t0_47 + (-0.2753269374370575) * gru_0_out_t0_48 + (0.366117924451828) * gru_0_out_t0_49 + (0.40599018335342407) * gru_0_out_t0_50 + (0.49594628810882568) * gru_0_out_t0_51 + (0.30146166682243347) * gru_0_out_t0_52 + (-0.34720969200134277) * gru_0_out_t0_53 + (-0.51009488105773926) * gru_0_out_t0_54 + (-0.24686093628406525) * gru_0_out_t0_55 + (-0.40534922480583191) * gru_0_out_t0_56 + (-0.17689663171768188) * gru_0_out_t0_57 + (-0.001570013933815062) * gru_0_out_t0_58 + (-0.12413228303194046) * gru_0_out_t0_59 + (0.64821285009384155) * gru_0_out_t0_60 + (-0.17016130685806274) * gru_0_out_t0_61 + (0.69290286302566528) * gru_0_out_t0_62 + (1.1252989768981934) * gru_0_out_t0_63 + (-0.151750847697258) * gru_1_rev_t1_h_0 + (-0.22038030624389648) * gru_1_rev_t1_h_1 + (-0.47501698136329651) * gru_1_rev_t1_h_2 + (0.14635796844959259) * gru_1_rev_t1_h_3 + (0.30150723457336426) * gru_1_rev_t1_h_4 + (-0.50531202554702759) * gru_1_rev_t1_h_5 + (0.042571082711219788) * gru_1_rev_t1_h_6 + (-0.67345261573791504) * gru_1_rev_t1_h_7 + (0.31396022439002991) * gru_1_rev_t1_h_8 + (-0.3423675000667572) * gru_1_rev_t1_h_9 + (0.70589154958724976) * gru_1_rev_t1_h_10 + (-0.62076097726821899) * gru_1_rev_t1_h_11 + (-0.5291827917098999) * gru_1_rev_t1_h_12 + (0.019806517288088799) * gru_1_rev_t1_h_13 + (0.21879315376281738) * gru_1_rev_t1_h_14 + (-0.46378329396247864) * gru_1_rev_t1_h_15 + (-0.55269068479537964) * gru_1_rev_t1_h_16 + (0.078214958310127258) * gru_1_rev_t1_h_17 + (-0.84176677465438843) * gru_1_rev_t1_h_18 + (0.089458391070365906) * gru_1_rev_t1_h_19 + (0.11778703331947327) * gru_1_rev_t1_h_20 + (0.065450385212898254) * gru_1_rev_t1_h_21 + (0.8279883861541748) * gru_1_rev_t1_h_22 + (0.20109656453132629) * gru_1_rev_t1_h_23 + (0.43009600043296814) * gru_1_rev_t1_h_24 + (-0.23816317319869995) * gru_1_rev_t1_h_25 + (0.23124346137046814) * gru_1_rev_t1_h_26 + (0.43465694785118103) * gru_1_rev_t1_h_27 + (0.84254121780395508) * gru_1_rev_t1_h_28 + (-0.19306549429893494) * gru_1_rev_t1_h_29 + (0.2345263808965683) * gru_1_rev_t1_h_30 + (0.40166902542114258) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.7128722071647644) + (0.17785514891147614) * gru_0_out_t0_0 + (-0.51816296577453613) * gru_0_out_t0_1 + (-0.43576896190643311) * gru_0_out_t0_2 + (0.011063060723245144) * gru_0_out_t0_3 + (-1.2091711759567261) * gru_0_out_t0_4 + (1.3171011209487915) * gru_0_out_t0_5 + (0.89143598079681396) * gru_0_out_t0_6 + (-0.016015097498893738) * gru_0_out_t0_7 + (-0.66039866209030151) * gru_0_out_t0_8 + (1.2350699901580811) * gru_0_out_t0_9 + (0.77822411060333252) * gru_0_out_t0_10 + (0.10366477072238922) * gru_0_out_t0_11 + (0.42853227257728577) * gru_0_out_t0_12 + (0.28332975506782532) * gru_0_out_t0_13 + (0.40929090976715088) * gru_0_out_t0_14 + (0.72457391023635864) * gru_0_out_t0_15 + (-0.59138822555541992) * gru_0_out_t0_16 + (-0.22661405801773071) * gru_0_out_t0_17 + (-0.65944784879684448) * gru_0_out_t0_18 + (-0.7532656192779541) * gru_0_out_t0_19 + (0.45961669087409973) * gru_0_out_t0_20 + (-2.5869078636169434) * gru_0_out_t0_21 + (-0.57203781604766846) * gru_0_out_t0_22 + (0.13572731614112854) * gru_0_out_t0_23 + (-0.37225049734115601) * gru_0_out_t0_24 + (-1.1241340637207031) * gru_0_out_t0_25 + (0.24399000406265259) * gru_0_out_t0_26 + (0.15046131610870361) * gru_0_out_t0_27 + (-1.2813221216201782) * gru_0_out_t0_28 + (1.5709693431854248) * gru_0_out_t0_29 + (-0.31425023078918457) * gru_0_out_t0_30 + (1.3193283081054688) * gru_0_out_t0_31 + (0.57251620292663574) * gru_0_out_t0_32 + (0.099741712212562561) * gru_0_out_t0_33 + (0.29461359977722168) * gru_0_out_t0_34 + (0.096776977181434631) * gru_0_out_t0_35 + (0.23942793905735016) * gru_0_out_t0_36 + (0.051541943103075027) * gru_0_out_t0_37 + (-0.079779431223869324) * gru_0_out_t0_38 + (-2.3933582305908203) * gru_0_out_t0_39 + (1.3883734941482544) * gru_0_out_t0_40 + (1.0441930294036865) * gru_0_out_t0_41 + (-1.266663670539856) * gru_0_out_t0_42 + (0.044041290879249573) * gru_0_out_t0_43 + (1.3567975759506226) * gru_0_out_t0_44 + (-0.28840398788452148) * gru_0_out_t0_45 + (1.8681256771087646) * gru_0_out_t0_46 + (-0.28131800889968872) * gru_0_out_t0_47 + (-0.29522010684013367) * gru_0_out_t0_48 + (0.10161550343036652) * gru_0_out_t0_49 + (0.16568581759929657) * gru_0_out_t0_50 + (0.83907955884933472) * gru_0_out_t0_51 + (-0.027465905994176865) * gru_0_out_t0_52 + (0.038051750510931015) * gru_0_out_t0_53 + (-0.68684530258178711) * gru_0_out_t0_54 + (-0.87953871488571167) * gru_0_out_t0_55 + (-0.045586708933115005) * gru_0_out_t0_56 + (0.50079959630966187) * gru_0_out_t0_57 + (-0.27477476000785828) * gru_0_out_t0_58 + (1.1459985971450806) * gru_0_out_t0_59 + (-0.033220700919628143) * gru_0_out_t0_60 + (0.40675458312034607) * gru_0_out_t0_61 + (-0.25763052701950073) * gru_0_out_t0_62 + (0.65593850612640381) * gru_0_out_t0_63 + gate_r * ((0.065506264567375183) + (-0.077168561518192291) * gru_1_rev_t1_h_0 + (0.75242221355438232) * gru_1_rev_t1_h_1 + (0.29778480529785156) * gru_1_rev_t1_h_2 + (0.10287664830684662) * gru_1_rev_t1_h_3 + (0.28341901302337646) * gru_1_rev_t1_h_4 + (0.25311580300331116) * gru_1_rev_t1_h_5 + (0.091497689485549927) * gru_1_rev_t1_h_6 + (0.87558817863464355) * gru_1_rev_t1_h_7 + (-0.52574640512466431) * gru_1_rev_t1_h_8 + (1.0433329343795776) * gru_1_rev_t1_h_9 + (0.37474799156188965) * gru_1_rev_t1_h_10 + (0.14544868469238281) * gru_1_rev_t1_h_11 + (-3.3012247085571289) * gru_1_rev_t1_h_12 + (0.38953596353530884) * gru_1_rev_t1_h_13 + (-0.41492068767547607) * gru_1_rev_t1_h_14 + (-0.40770915150642395) * gru_1_rev_t1_h_15 + (-1.2389676570892334) * gru_1_rev_t1_h_16 + (-1.6042883396148682) * gru_1_rev_t1_h_17 + (0.2720504105091095) * gru_1_rev_t1_h_18 + (-1.223045825958252) * gru_1_rev_t1_h_19 + (-0.43580895662307739) * gru_1_rev_t1_h_20 + (0.19612413644790649) * gru_1_rev_t1_h_21 + (0.33933177590370178) * gru_1_rev_t1_h_22 + (0.017080221325159073) * gru_1_rev_t1_h_23 + (-0.72607272863388062) * gru_1_rev_t1_h_24 + (1.1178098917007446) * gru_1_rev_t1_h_25 + (0.54505038261413574) * gru_1_rev_t1_h_26 + (-0.026001626625657082) * gru_1_rev_t1_h_27 + (-0.83994942903518677) * gru_1_rev_t1_h_28 + (-0.034329406917095184) * gru_1_rev_t1_h_29 + (0.65394264459609985) * gru_1_rev_t1_h_30 + (-0.075864851474761963) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_9 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_9;
    // h=10
    gate_r = sigmoid((0.47095489501953125) + (0.24449793994426727) * gru_0_out_t0_0 + (-0.47459802031517029) * gru_0_out_t0_1 + (-0.92217493057250977) * gru_0_out_t0_2 + (1.0199098587036133) * gru_0_out_t0_3 + (0.0054923431016504765) * gru_0_out_t0_4 + (-0.28071358799934387) * gru_0_out_t0_5 + (0.86227768659591675) * gru_0_out_t0_6 + (0.65748411417007446) * gru_0_out_t0_7 + (-0.093480944633483887) * gru_0_out_t0_8 + (-0.46785557270050049) * gru_0_out_t0_9 + (0.1957983523607254) * gru_0_out_t0_10 + (-0.26294693350791931) * gru_0_out_t0_11 + (1.0865602493286133) * gru_0_out_t0_12 + (0.41968998312950134) * gru_0_out_t0_13 + (-0.27936941385269165) * gru_0_out_t0_14 + (0.82235217094421387) * gru_0_out_t0_15 + (-0.87077265977859497) * gru_0_out_t0_16 + (-0.83084219694137573) * gru_0_out_t0_17 + (0.0003775887016672641) * gru_0_out_t0_18 + (2.0686995983123779) * gru_0_out_t0_19 + (0.16687051951885223) * gru_0_out_t0_20 + (-4.3913249969482422) * gru_0_out_t0_21 + (-0.047226149588823318) * gru_0_out_t0_22 + (0.54320961236953735) * gru_0_out_t0_23 + (0.076805941760540009) * gru_0_out_t0_24 + (-0.44199436902999878) * gru_0_out_t0_25 + (-0.60653138160705566) * gru_0_out_t0_26 + (-0.77137959003448486) * gru_0_out_t0_27 + (1.4597762823104858) * gru_0_out_t0_28 + (0.36063858866691589) * gru_0_out_t0_29 + (-0.091005146503448486) * gru_0_out_t0_30 + (0.68777775764465332) * gru_0_out_t0_31 + (1.1548449993133545) * gru_0_out_t0_32 + (-0.85319036245346069) * gru_0_out_t0_33 + (0.37774059176445007) * gru_0_out_t0_34 + (-0.061414331197738647) * gru_0_out_t0_35 + (-0.52465742826461792) * gru_0_out_t0_36 + (-0.34949061274528503) * gru_0_out_t0_37 + (0.40617117285728455) * gru_0_out_t0_38 + (-0.72260451316833496) * gru_0_out_t0_39 + (0.94992721080780029) * gru_0_out_t0_40 + (1.1490355730056763) * gru_0_out_t0_41 + (-1.0489106178283691) * gru_0_out_t0_42 + (0.087866246700286865) * gru_0_out_t0_43 + (-0.16399510204792023) * gru_0_out_t0_44 + (-0.42827025055885315) * gru_0_out_t0_45 + (0.23792821168899536) * gru_0_out_t0_46 + (-0.24387429654598236) * gru_0_out_t0_47 + (-0.074392840266227722) * gru_0_out_t0_48 + (0.33696895837783813) * gru_0_out_t0_49 + (0.29080885648727417) * gru_0_out_t0_50 + (0.17987042665481567) * gru_0_out_t0_51 + (0.32324853539466858) * gru_0_out_t0_52 + (0.10650330781936646) * gru_0_out_t0_53 + (0.38436537981033325) * gru_0_out_t0_54 + (1.6900352239608765) * gru_0_out_t0_55 + (0.27365630865097046) * gru_0_out_t0_56 + (0.58376049995422363) * gru_0_out_t0_57 + (0.38681241869926453) * gru_0_out_t0_58 + (0.093173280358314514) * gru_0_out_t0_59 + (-0.80416280031204224) * gru_0_out_t0_60 + (0.24319782853126526) * gru_0_out_t0_61 + (0.050431422889232635) * gru_0_out_t0_62 + (1.0034743547439575) * gru_0_out_t0_63 + (-0.20437394082546234) * gru_1_rev_t1_h_0 + (0.29147171974182129) * gru_1_rev_t1_h_1 + (-1.4310300350189209) * gru_1_rev_t1_h_2 + (0.17659926414489746) * gru_1_rev_t1_h_3 + (-0.43532094359397888) * gru_1_rev_t1_h_4 + (0.29980140924453735) * gru_1_rev_t1_h_5 + (-0.33451059460639954) * gru_1_rev_t1_h_6 + (-0.342704176902771) * gru_1_rev_t1_h_7 + (0.16701290011405945) * gru_1_rev_t1_h_8 + (-0.45739784836769104) * gru_1_rev_t1_h_9 + (0.60734522342681885) * gru_1_rev_t1_h_10 + (-0.3951714038848877) * gru_1_rev_t1_h_11 + (-0.24392305314540863) * gru_1_rev_t1_h_12 + (0.0083415079861879349) * gru_1_rev_t1_h_13 + (0.2497895359992981) * gru_1_rev_t1_h_14 + (0.89516156911849976) * gru_1_rev_t1_h_15 + (-1.0573010444641113) * gru_1_rev_t1_h_16 + (0.48790758848190308) * gru_1_rev_t1_h_17 + (0.27413573861122131) * gru_1_rev_t1_h_18 + (1.0373985767364502) * gru_1_rev_t1_h_19 + (-0.43148866295814514) * gru_1_rev_t1_h_20 + (-0.060109924525022507) * gru_1_rev_t1_h_21 + (1.199150562286377) * gru_1_rev_t1_h_22 + (-0.0058462056331336498) * gru_1_rev_t1_h_23 + (0.17843073606491089) * gru_1_rev_t1_h_24 + (0.27871942520141602) * gru_1_rev_t1_h_25 + (-0.42970508337020874) * gru_1_rev_t1_h_26 + (-0.17857520282268524) * gru_1_rev_t1_h_27 + (-1.3294094800949097) * gru_1_rev_t1_h_28 + (-0.71410459280014038) * gru_1_rev_t1_h_29 + (-0.46426934003829956) * gru_1_rev_t1_h_30 + (-0.10225450247526169) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.19287160038948059) + (-0.020836418494582176) * gru_0_out_t0_0 + (-0.28914734721183777) * gru_0_out_t0_1 + (-0.035838831216096878) * gru_0_out_t0_2 + (0.63933730125427246) * gru_0_out_t0_3 + (0.24110192060470581) * gru_0_out_t0_4 + (0.035203497856855392) * gru_0_out_t0_5 + (0.2981848418712616) * gru_0_out_t0_6 + (-0.012165937572717667) * gru_0_out_t0_7 + (-0.78059506416320801) * gru_0_out_t0_8 + (-0.77789968252182007) * gru_0_out_t0_9 + (0.20345319807529449) * gru_0_out_t0_10 + (0.83811140060424805) * gru_0_out_t0_11 + (0.091165468096733093) * gru_0_out_t0_12 + (0.1125512570142746) * gru_0_out_t0_13 + (-0.11979281157255173) * gru_0_out_t0_14 + (0.61500763893127441) * gru_0_out_t0_15 + (-0.72880768775939941) * gru_0_out_t0_16 + (-0.34189015626907349) * gru_0_out_t0_17 + (-0.020100755617022514) * gru_0_out_t0_18 + (-2.0162920951843262) * gru_0_out_t0_19 + (-0.57858353853225708) * gru_0_out_t0_20 + (-0.91432124376296997) * gru_0_out_t0_21 + (0.44179686903953552) * gru_0_out_t0_22 + (0.39030048251152039) * gru_0_out_t0_23 + (0.051939424127340317) * gru_0_out_t0_24 + (-0.61551189422607422) * gru_0_out_t0_25 + (-0.36486610770225525) * gru_0_out_t0_26 + (-0.11924088001251221) * gru_0_out_t0_27 + (-0.67190217971801758) * gru_0_out_t0_28 + (-0.29661765694618225) * gru_0_out_t0_29 + (0.29491320252418518) * gru_0_out_t0_30 + (0.53200632333755493) * gru_0_out_t0_31 + (1.0344574451446533) * gru_0_out_t0_32 + (-0.18927235901355743) * gru_0_out_t0_33 + (-0.11694774776697159) * gru_0_out_t0_34 + (-0.044132817536592484) * gru_0_out_t0_35 + (-0.19063675403594971) * gru_0_out_t0_36 + (-0.014205396175384521) * gru_0_out_t0_37 + (0.3627680242061615) * gru_0_out_t0_38 + (-0.5369638204574585) * gru_0_out_t0_39 + (0.47663787007331848) * gru_0_out_t0_40 + (0.87090271711349487) * gru_0_out_t0_41 + (0.56591928005218506) * gru_0_out_t0_42 + (0.13601863384246826) * gru_0_out_t0_43 + (-0.10182061046361923) * gru_0_out_t0_44 + (-0.7533225417137146) * gru_0_out_t0_45 + (0.42235013842582703) * gru_0_out_t0_46 + (-1.6871215105056763) * gru_0_out_t0_47 + (-0.10893190652132034) * gru_0_out_t0_48 + (0.15453870594501495) * gru_0_out_t0_49 + (-0.03780350461602211) * gru_0_out_t0_50 + (0.16366684436798096) * gru_0_out_t0_51 + (0.57337123155593872) * gru_0_out_t0_52 + (1.4859631061553955) * gru_0_out_t0_53 + (-0.28925248980522156) * gru_0_out_t0_54 + (-0.29481613636016846) * gru_0_out_t0_55 + (0.53825223445892334) * gru_0_out_t0_56 + (0.088309966027736664) * gru_0_out_t0_57 + (1.0518506765365601) * gru_0_out_t0_58 + (-0.066507481038570404) * gru_0_out_t0_59 + (-0.040443312376737595) * gru_0_out_t0_60 + (-0.3602738082408905) * gru_0_out_t0_61 + (1.0710396766662598) * gru_0_out_t0_62 + (0.80204677581787109) * gru_0_out_t0_63 + (0.62194722890853882) * gru_1_rev_t1_h_0 + (0.30568918585777283) * gru_1_rev_t1_h_1 + (0.49165442585945129) * gru_1_rev_t1_h_2 + (0.54244488477706909) * gru_1_rev_t1_h_3 + (0.22867485880851746) * gru_1_rev_t1_h_4 + (-0.077259548008441925) * gru_1_rev_t1_h_5 + (-0.38073357939720154) * gru_1_rev_t1_h_6 + (-0.47534799575805664) * gru_1_rev_t1_h_7 + (0.033210229128599167) * gru_1_rev_t1_h_8 + (0.59334588050842285) * gru_1_rev_t1_h_9 + (-0.57904523611068726) * gru_1_rev_t1_h_10 + (-1.2005326747894287) * gru_1_rev_t1_h_11 + (0.50314885377883911) * gru_1_rev_t1_h_12 + (0.43671783804893494) * gru_1_rev_t1_h_13 + (-1.0078275203704834) * gru_1_rev_t1_h_14 + (0.3632999062538147) * gru_1_rev_t1_h_15 + (-0.21517400443553925) * gru_1_rev_t1_h_16 + (-0.38459110260009766) * gru_1_rev_t1_h_17 + (0.48760232329368591) * gru_1_rev_t1_h_18 + (0.14733204245567322) * gru_1_rev_t1_h_19 + (-0.57530307769775391) * gru_1_rev_t1_h_20 + (-0.032081358134746552) * gru_1_rev_t1_h_21 + (0.072125732898712158) * gru_1_rev_t1_h_22 + (-1.2326996326446533) * gru_1_rev_t1_h_23 + (-0.44132870435714722) * gru_1_rev_t1_h_24 + (1.3550238609313965) * gru_1_rev_t1_h_25 + (-0.5045703649520874) * gru_1_rev_t1_h_26 + (-0.019863326102495193) * gru_1_rev_t1_h_27 + (0.89563202857971191) * gru_1_rev_t1_h_28 + (0.16223663091659546) * gru_1_rev_t1_h_29 + (1.6618245840072632) * gru_1_rev_t1_h_30 + (-0.38120979070663452) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.19174747169017792) + (0.0041668927296996117) * gru_0_out_t0_0 + (0.42051529884338379) * gru_0_out_t0_1 + (-0.16752134263515472) * gru_0_out_t0_2 + (0.30799797177314758) * gru_0_out_t0_3 + (0.073446698486804962) * gru_0_out_t0_4 + (0.58646696805953979) * gru_0_out_t0_5 + (-0.10167040675878525) * gru_0_out_t0_6 + (-0.8272283673286438) * gru_0_out_t0_7 + (-0.15778851509094238) * gru_0_out_t0_8 + (0.10730674117803574) * gru_0_out_t0_9 + (-0.25722792744636536) * gru_0_out_t0_10 + (0.37327238917350769) * gru_0_out_t0_11 + (-0.080089285969734192) * gru_0_out_t0_12 + (-0.73687148094177246) * gru_0_out_t0_13 + (0.080664172768592834) * gru_0_out_t0_14 + (0.059216871857643127) * gru_0_out_t0_15 + (1.3526006937026978) * gru_0_out_t0_16 + (0.25502777099609375) * gru_0_out_t0_17 + (0.58339470624923706) * gru_0_out_t0_18 + (0.37933892011642456) * gru_0_out_t0_19 + (0.070116057991981506) * gru_0_out_t0_20 + (1.9924936294555664) * gru_0_out_t0_21 + (-0.25710421800613403) * gru_0_out_t0_22 + (-0.98376619815826416) * gru_0_out_t0_23 + (-0.28594756126403809) * gru_0_out_t0_24 + (0.23906919360160828) * gru_0_out_t0_25 + (0.40899637341499329) * gru_0_out_t0_26 + (0.17956526577472687) * gru_0_out_t0_27 + (-0.77264171838760376) * gru_0_out_t0_28 + (0.19151216745376587) * gru_0_out_t0_29 + (-0.47341936826705933) * gru_0_out_t0_30 + (0.71004754304885864) * gru_0_out_t0_31 + (-0.82765382528305054) * gru_0_out_t0_32 + (-0.6582261323928833) * gru_0_out_t0_33 + (-0.3962838351726532) * gru_0_out_t0_34 + (-0.74665462970733643) * gru_0_out_t0_35 + (-0.14727455377578735) * gru_0_out_t0_36 + (-0.1457429975271225) * gru_0_out_t0_37 + (0.55285316705703735) * gru_0_out_t0_38 + (-0.20397403836250305) * gru_0_out_t0_39 + (0.538321852684021) * gru_0_out_t0_40 + (-0.92289626598358154) * gru_0_out_t0_41 + (0.007510072086006403) * gru_0_out_t0_42 + (0.11107008904218674) * gru_0_out_t0_43 + (-0.34468033909797668) * gru_0_out_t0_44 + (-0.45682430267333984) * gru_0_out_t0_45 + (-0.76860231161117554) * gru_0_out_t0_46 + (-0.16847275197505951) * gru_0_out_t0_47 + (-0.80644822120666504) * gru_0_out_t0_48 + (0.31150203943252563) * gru_0_out_t0_49 + (0.0028950660489499569) * gru_0_out_t0_50 + (0.2580418586730957) * gru_0_out_t0_51 + (0.22534795105457306) * gru_0_out_t0_52 + (-0.15924985706806183) * gru_0_out_t0_53 + (0.033330067992210388) * gru_0_out_t0_54 + (-0.23605053126811981) * gru_0_out_t0_55 + (-0.27873170375823975) * gru_0_out_t0_56 + (0.55793726444244385) * gru_0_out_t0_57 + (0.53304654359817505) * gru_0_out_t0_58 + (1.3098394870758057) * gru_0_out_t0_59 + (0.36830827593803406) * gru_0_out_t0_60 + (0.89727324247360229) * gru_0_out_t0_61 + (0.20181956887245178) * gru_0_out_t0_62 + (0.65386676788330078) * gru_0_out_t0_63 + gate_r * ((-0.38398337364196777) + (0.36108666658401489) * gru_1_rev_t1_h_0 + (-0.56110638380050659) * gru_1_rev_t1_h_1 + (0.36613684892654419) * gru_1_rev_t1_h_2 + (-0.50779014825820923) * gru_1_rev_t1_h_3 + (0.62218594551086426) * gru_1_rev_t1_h_4 + (-1.5355194807052612) * gru_1_rev_t1_h_5 + (0.68068379163742065) * gru_1_rev_t1_h_6 + (-0.40579533576965332) * gru_1_rev_t1_h_7 + (0.76420295238494873) * gru_1_rev_t1_h_8 + (-0.54020065069198608) * gru_1_rev_t1_h_9 + (0.0012140774633735418) * gru_1_rev_t1_h_10 + (-0.38133144378662109) * gru_1_rev_t1_h_11 + (-0.62659299373626709) * gru_1_rev_t1_h_12 + (0.17298279702663422) * gru_1_rev_t1_h_13 + (-0.65366518497467041) * gru_1_rev_t1_h_14 + (0.5436519980430603) * gru_1_rev_t1_h_15 + (0.40163099765777588) * gru_1_rev_t1_h_16 + (-0.28747576475143433) * gru_1_rev_t1_h_17 + (-0.30599018931388855) * gru_1_rev_t1_h_18 + (-0.26031672954559326) * gru_1_rev_t1_h_19 + (-0.33318746089935303) * gru_1_rev_t1_h_20 + (-0.67731881141662598) * gru_1_rev_t1_h_21 + (0.53753548860549927) * gru_1_rev_t1_h_22 + (-0.24966192245483398) * gru_1_rev_t1_h_23 + (-0.27621269226074219) * gru_1_rev_t1_h_24 + (-0.20086866617202759) * gru_1_rev_t1_h_25 + (-0.61369979381561279) * gru_1_rev_t1_h_26 + (0.50715774297714233) * gru_1_rev_t1_h_27 + (-1.3701838254928589) * gru_1_rev_t1_h_28 + (0.48118627071380615) * gru_1_rev_t1_h_29 + (0.64816159009933472) * gru_1_rev_t1_h_30 + (-1.0309680700302124) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_10 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_10;
    // h=11
    gate_r = sigmoid((0.5263209342956543) + (0.031465779989957809) * gru_0_out_t0_0 + (0.2184167355298996) * gru_0_out_t0_1 + (-1.8017576932907104) * gru_0_out_t0_2 + (-1.5981829166412354) * gru_0_out_t0_3 + (-0.35838338732719421) * gru_0_out_t0_4 + (0.92452371120452881) * gru_0_out_t0_5 + (1.7471359968185425) * gru_0_out_t0_6 + (2.9769740104675293) * gru_0_out_t0_7 + (-4.0053133964538574) * gru_0_out_t0_8 + (-1.230539083480835) * gru_0_out_t0_9 + (2.0377259254455566) * gru_0_out_t0_10 + (0.34909006953239441) * gru_0_out_t0_11 + (-0.14591705799102783) * gru_0_out_t0_12 + (-0.11876711249351501) * gru_0_out_t0_13 + (0.40320605039596558) * gru_0_out_t0_14 + (1.7227857112884521) * gru_0_out_t0_15 + (-0.32724878191947937) * gru_0_out_t0_16 + (-0.019064230844378471) * gru_0_out_t0_17 + (-0.39185681939125061) * gru_0_out_t0_18 + (0.36487969756126404) * gru_0_out_t0_19 + (-0.48391419649124146) * gru_0_out_t0_20 + (-2.5831079483032227) * gru_0_out_t0_21 + (-3.5186221599578857) * gru_0_out_t0_22 + (1.4924864768981934) * gru_0_out_t0_23 + (1.7557716369628906) * gru_0_out_t0_24 + (0.22205282747745514) * gru_0_out_t0_25 + (0.980194091796875) * gru_0_out_t0_26 + (-3.1113715171813965) * gru_0_out_t0_27 + (-1.4890928268432617) * gru_0_out_t0_28 + (3.6811778545379639) * gru_0_out_t0_29 + (-1.7621681690216064) * gru_0_out_t0_30 + (-0.71750819683074951) * gru_0_out_t0_31 + (-0.69604945182800293) * gru_0_out_t0_32 + (-0.24934220314025879) * gru_0_out_t0_33 + (-0.085192002356052399) * gru_0_out_t0_34 + (0.8760685920715332) * gru_0_out_t0_35 + (-0.14031018316745758) * gru_0_out_t0_36 + (-0.059557091444730759) * gru_0_out_t0_37 + (0.024215305224061012) * gru_0_out_t0_38 + (-2.1675295829772949) * gru_0_out_t0_39 + (-2.0588951110839844) * gru_0_out_t0_40 + (1.0233920812606812) * gru_0_out_t0_41 + (1.749861478805542) * gru_0_out_t0_42 + (0.34042108058929443) * gru_0_out_t0_43 + (0.7471269965171814) * gru_0_out_t0_44 + (0.56685274839401245) * gru_0_out_t0_45 + (-1.6745529174804688) * gru_0_out_t0_46 + (0.1244903951883316) * gru_0_out_t0_47 + (-1.6372666358947754) * gru_0_out_t0_48 + (1.2231216430664062) * gru_0_out_t0_49 + (0.31237432360649109) * gru_0_out_t0_50 + (0.43429136276245117) * gru_0_out_t0_51 + (-0.16805659234523773) * gru_0_out_t0_52 + (0.027484357357025146) * gru_0_out_t0_53 + (0.1198568269610405) * gru_0_out_t0_54 + (-2.2379529476165771) * gru_0_out_t0_55 + (-0.32773298025131226) * gru_0_out_t0_56 + (2.9345519542694092) * gru_0_out_t0_57 + (-0.17820486426353455) * gru_0_out_t0_58 + (0.25322350859642029) * gru_0_out_t0_59 + (0.23014874756336212) * gru_0_out_t0_60 + (1.2804490327835083) * gru_0_out_t0_61 + (0.61492401361465454) * gru_0_out_t0_62 + (1.3415052890777588) * gru_0_out_t0_63 + (0.5237395167350769) * gru_1_rev_t1_h_0 + (-0.19558210670948029) * gru_1_rev_t1_h_1 + (-0.6445501446723938) * gru_1_rev_t1_h_2 + (0.40985018014907837) * gru_1_rev_t1_h_3 + (0.38675418496131897) * gru_1_rev_t1_h_4 + (0.58783459663391113) * gru_1_rev_t1_h_5 + (-0.70652186870574951) * gru_1_rev_t1_h_6 + (0.50733119249343872) * gru_1_rev_t1_h_7 + (-0.20935805141925812) * gru_1_rev_t1_h_8 + (-0.2180197536945343) * gru_1_rev_t1_h_9 + (0.58668231964111328) * gru_1_rev_t1_h_10 + (-0.41651830077171326) * gru_1_rev_t1_h_11 + (1.7708282470703125) * gru_1_rev_t1_h_12 + (-0.020898796617984772) * gru_1_rev_t1_h_13 + (-0.043585479259490967) * gru_1_rev_t1_h_14 + (-0.65287637710571289) * gru_1_rev_t1_h_15 + (-0.18914638459682465) * gru_1_rev_t1_h_16 + (-0.50779515504837036) * gru_1_rev_t1_h_17 + (-0.22316665947437286) * gru_1_rev_t1_h_18 + (-0.65807431936264038) * gru_1_rev_t1_h_19 + (0.58347797393798828) * gru_1_rev_t1_h_20 + (-0.63479709625244141) * gru_1_rev_t1_h_21 + (0.64137589931488037) * gru_1_rev_t1_h_22 + (0.97083389759063721) * gru_1_rev_t1_h_23 + (0.58373457193374634) * gru_1_rev_t1_h_24 + (0.48997941613197327) * gru_1_rev_t1_h_25 + (1.1008166074752808) * gru_1_rev_t1_h_26 + (1.4085632562637329) * gru_1_rev_t1_h_27 + (0.81979984045028687) * gru_1_rev_t1_h_28 + (-0.0039211553521454334) * gru_1_rev_t1_h_29 + (1.3279765844345093) * gru_1_rev_t1_h_30 + (0.12860609591007233) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((1.0985890626907349) + (-0.12075658142566681) * gru_0_out_t0_0 + (-0.20902173221111298) * gru_0_out_t0_1 + (-0.057819545269012451) * gru_0_out_t0_2 + (0.2138725221157074) * gru_0_out_t0_3 + (-0.59575915336608887) * gru_0_out_t0_4 + (-0.58385682106018066) * gru_0_out_t0_5 + (-1.5200724601745605) * gru_0_out_t0_6 + (-1.1863647699356079) * gru_0_out_t0_7 + (-0.87915360927581787) * gru_0_out_t0_8 + (0.61937850713729858) * gru_0_out_t0_9 + (0.65149050951004028) * gru_0_out_t0_10 + (-0.2825259268283844) * gru_0_out_t0_11 + (0.049670461565256119) * gru_0_out_t0_12 + (0.375324547290802) * gru_0_out_t0_13 + (0.17716991901397705) * gru_0_out_t0_14 + (-0.070740848779678345) * gru_0_out_t0_15 + (-0.27941924333572388) * gru_0_out_t0_16 + (-0.15008625388145447) * gru_0_out_t0_17 + (-0.46711871027946472) * gru_0_out_t0_18 + (-1.4724217653274536) * gru_0_out_t0_19 + (0.41659292578697205) * gru_0_out_t0_20 + (-0.6263309121131897) * gru_0_out_t0_21 + (-0.55949586629867554) * gru_0_out_t0_22 + (1.1522021293640137) * gru_0_out_t0_23 + (-0.27533131837844849) * gru_0_out_t0_24 + (-1.7600696086883545) * gru_0_out_t0_25 + (0.20922850072383881) * gru_0_out_t0_26 + (1.025875449180603) * gru_0_out_t0_27 + (-0.64523917436599731) * gru_0_out_t0_28 + (0.083960138261318207) * gru_0_out_t0_29 + (0.36762839555740356) * gru_0_out_t0_30 + (-0.56799417734146118) * gru_0_out_t0_31 + (0.38366034626960754) * gru_0_out_t0_32 + (-0.486615389585495) * gru_0_out_t0_33 + (-0.043490774929523468) * gru_0_out_t0_34 + (-0.10148432105779648) * gru_0_out_t0_35 + (-0.25565183162689209) * gru_0_out_t0_36 + (-0.26415884494781494) * gru_0_out_t0_37 + (0.19147302210330963) * gru_0_out_t0_38 + (0.84261173009872437) * gru_0_out_t0_39 + (0.41532710194587708) * gru_0_out_t0_40 + (-0.37306225299835205) * gru_0_out_t0_41 + (-3.0373170375823975) * gru_0_out_t0_42 + (-0.38512787222862244) * gru_0_out_t0_43 + (0.21071861684322357) * gru_0_out_t0_44 + (0.71162313222885132) * gru_0_out_t0_45 + (0.8636481761932373) * gru_0_out_t0_46 + (0.13854576647281647) * gru_0_out_t0_47 + (1.0471847057342529) * gru_0_out_t0_48 + (-1.1845386028289795) * gru_0_out_t0_49 + (-0.0086968326941132545) * gru_0_out_t0_50 + (-0.28360480070114136) * gru_0_out_t0_51 + (0.88938289880752563) * gru_0_out_t0_52 + (0.064416401088237762) * gru_0_out_t0_53 + (0.45413202047348022) * gru_0_out_t0_54 + (-0.051854189485311508) * gru_0_out_t0_55 + (-0.83563804626464844) * gru_0_out_t0_56 + (-1.3427120447158813) * gru_0_out_t0_57 + (-0.0012287651188671589) * gru_0_out_t0_58 + (-0.020163565874099731) * gru_0_out_t0_59 + (0.63213992118835449) * gru_0_out_t0_60 + (0.35329413414001465) * gru_0_out_t0_61 + (1.397223949432373) * gru_0_out_t0_62 + (-0.39437964558601379) * gru_0_out_t0_63 + (-0.020677145570516586) * gru_1_rev_t1_h_0 + (0.40609714388847351) * gru_1_rev_t1_h_1 + (-0.74889737367630005) * gru_1_rev_t1_h_2 + (-0.22396734356880188) * gru_1_rev_t1_h_3 + (-0.056310247629880905) * gru_1_rev_t1_h_4 + (-0.93972373008728027) * gru_1_rev_t1_h_5 + (0.1340869814157486) * gru_1_rev_t1_h_6 + (0.56204718351364136) * gru_1_rev_t1_h_7 + (-0.99022203683853149) * gru_1_rev_t1_h_8 + (-0.075200550258159637) * gru_1_rev_t1_h_9 + (-0.51217478513717651) * gru_1_rev_t1_h_10 + (-1.4674181938171387) * gru_1_rev_t1_h_11 + (-0.76675981283187866) * gru_1_rev_t1_h_12 + (-0.18827641010284424) * gru_1_rev_t1_h_13 + (0.43229421973228455) * gru_1_rev_t1_h_14 + (-0.92816191911697388) * gru_1_rev_t1_h_15 + (0.0017465559067204595) * gru_1_rev_t1_h_16 + (0.50973236560821533) * gru_1_rev_t1_h_17 + (-0.73798972368240356) * gru_1_rev_t1_h_18 + (-0.79802197217941284) * gru_1_rev_t1_h_19 + (-1.068123459815979) * gru_1_rev_t1_h_20 + (0.017832661047577858) * gru_1_rev_t1_h_21 + (0.68519628047943115) * gru_1_rev_t1_h_22 + (0.6155584454536438) * gru_1_rev_t1_h_23 + (-1.0813294649124146) * gru_1_rev_t1_h_24 + (-0.08987811952829361) * gru_1_rev_t1_h_25 + (0.2915516197681427) * gru_1_rev_t1_h_26 + (-0.54487234354019165) * gru_1_rev_t1_h_27 + (-1.9480416774749756) * gru_1_rev_t1_h_28 + (-2.010828971862793) * gru_1_rev_t1_h_29 + (-0.91012078523635864) * gru_1_rev_t1_h_30 + (-0.64548277854919434) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.13056708872318268) + (-0.42441973090171814) * gru_0_out_t0_0 + (-0.010928607545793056) * gru_0_out_t0_1 + (1.0633108615875244) * gru_0_out_t0_2 + (0.79951679706573486) * gru_0_out_t0_3 + (0.11152221262454987) * gru_0_out_t0_4 + (-1.8594191074371338) * gru_0_out_t0_5 + (-1.310725212097168) * gru_0_out_t0_6 + (-0.51285749673843384) * gru_0_out_t0_7 + (1.1557357311248779) * gru_0_out_t0_8 + (0.098765693604946136) * gru_0_out_t0_9 + (0.2697070837020874) * gru_0_out_t0_10 + (0.16241906583309174) * gru_0_out_t0_11 + (0.10187835991382599) * gru_0_out_t0_12 + (-0.39879921078681946) * gru_0_out_t0_13 + (-0.24615859985351562) * gru_0_out_t0_14 + (-0.0070961825549602509) * gru_0_out_t0_15 + (0.0092029375955462456) * gru_0_out_t0_16 + (-0.37814703583717346) * gru_0_out_t0_17 + (0.2326066642999649) * gru_0_out_t0_18 + (0.22844210267066956) * gru_0_out_t0_19 + (-0.52714920043945312) * gru_0_out_t0_20 + (-0.019291659817099571) * gru_0_out_t0_21 + (-0.19121949374675751) * gru_0_out_t0_22 + (-0.32753115892410278) * gru_0_out_t0_23 + (-0.64163112640380859) * gru_0_out_t0_24 + (-0.051321979612112045) * gru_0_out_t0_25 + (0.41760945320129395) * gru_0_out_t0_26 + (0.97303676605224609) * gru_0_out_t0_27 + (-0.5230637788772583) * gru_0_out_t0_28 + (-1.1294091939926147) * gru_0_out_t0_29 + (-0.15091943740844727) * gru_0_out_t0_30 + (0.28109657764434814) * gru_0_out_t0_31 + (-0.0083977114409208298) * gru_0_out_t0_32 + (0.14450836181640625) * gru_0_out_t0_33 + (-0.22043183445930481) * gru_0_out_t0_34 + (-0.17287750542163849) * gru_0_out_t0_35 + (0.074599452316761017) * gru_0_out_t0_36 + (-0.024870608001947403) * gru_0_out_t0_37 + (-0.14147335290908813) * gru_0_out_t0_38 + (1.9470188617706299) * gru_0_out_t0_39 + (-0.16478998959064484) * gru_0_out_t0_40 + (-0.40761151909828186) * gru_0_out_t0_41 + (0.63688451051712036) * gru_0_out_t0_42 + (0.1246003657579422) * gru_0_out_t0_43 + (-0.30668261647224426) * gru_0_out_t0_44 + (-0.095980085432529449) * gru_0_out_t0_45 + (-0.49386903643608093) * gru_0_out_t0_46 + (0.49085012078285217) * gru_0_out_t0_47 + (0.34979498386383057) * gru_0_out_t0_48 + (-0.46324214339256287) * gru_0_out_t0_49 + (-0.52545982599258423) * gru_0_out_t0_50 + (-0.2332623153924942) * gru_0_out_t0_51 + (-0.10221260786056519) * gru_0_out_t0_52 + (0.30385118722915649) * gru_0_out_t0_53 + (0.096196793019771576) * gru_0_out_t0_54 + (1.2051459550857544) * gru_0_out_t0_55 + (0.84914171695709229) * gru_0_out_t0_56 + (-0.64589321613311768) * gru_0_out_t0_57 + (0.29056122899055481) * gru_0_out_t0_58 + (-0.39192843437194824) * gru_0_out_t0_59 + (0.33793905377388) * gru_0_out_t0_60 + (-0.61859762668609619) * gru_0_out_t0_61 + (0.59261411428451538) * gru_0_out_t0_62 + (0.26590156555175781) * gru_0_out_t0_63 + gate_r * ((-0.24268151819705963) + (-1.3472843170166016) * gru_1_rev_t1_h_0 + (0.67659920454025269) * gru_1_rev_t1_h_1 + (-0.86479282379150391) * gru_1_rev_t1_h_2 + (0.71772199869155884) * gru_1_rev_t1_h_3 + (-1.8314269781112671) * gru_1_rev_t1_h_4 + (-1.5000836849212646) * gru_1_rev_t1_h_5 + (-0.34105569124221802) * gru_1_rev_t1_h_6 + (-0.96655374765396118) * gru_1_rev_t1_h_7 + (-0.60444831848144531) * gru_1_rev_t1_h_8 + (-0.78830462694168091) * gru_1_rev_t1_h_9 + (-0.72208619117736816) * gru_1_rev_t1_h_10 + (-0.3159409761428833) * gru_1_rev_t1_h_11 + (-0.48982343077659607) * gru_1_rev_t1_h_12 + (-1.9175622463226318) * gru_1_rev_t1_h_13 + (0.63742119073867798) * gru_1_rev_t1_h_14 + (-0.078615725040435791) * gru_1_rev_t1_h_15 + (-0.9153779149055481) * gru_1_rev_t1_h_16 + (0.35138487815856934) * gru_1_rev_t1_h_17 + (0.86141973733901978) * gru_1_rev_t1_h_18 + (-1.7955237627029419) * gru_1_rev_t1_h_19 + (1.1239622831344604) * gru_1_rev_t1_h_20 + (-0.22736258804798126) * gru_1_rev_t1_h_21 + (-1.0795977115631104) * gru_1_rev_t1_h_22 + (1.0990598201751709) * gru_1_rev_t1_h_23 + (-1.4246367216110229) * gru_1_rev_t1_h_24 + (0.013980112038552761) * gru_1_rev_t1_h_25 + (0.28097489476203918) * gru_1_rev_t1_h_26 + (-0.5418703556060791) * gru_1_rev_t1_h_27 + (-1.119991660118103) * gru_1_rev_t1_h_28 + (-0.14908097684383392) * gru_1_rev_t1_h_29 + (-0.22790339589118958) * gru_1_rev_t1_h_30 + (0.83479195833206177) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_11 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_11;
    // h=12
    gate_r = sigmoid((0.39141121506690979) + (0.47022262215614319) * gru_0_out_t0_0 + (-0.25348383188247681) * gru_0_out_t0_1 + (-0.30927491188049316) * gru_0_out_t0_2 + (-0.20886476337909698) * gru_0_out_t0_3 + (-0.16606014966964722) * gru_0_out_t0_4 + (0.61391359567642212) * gru_0_out_t0_5 + (1.8051042556762695) * gru_0_out_t0_6 + (0.64952284097671509) * gru_0_out_t0_7 + (-0.64103364944458008) * gru_0_out_t0_8 + (-4.8754501342773438) * gru_0_out_t0_9 + (0.31093296408653259) * gru_0_out_t0_10 + (0.13337244093418121) * gru_0_out_t0_11 + (-0.14654079079627991) * gru_0_out_t0_12 + (0.13291171193122864) * gru_0_out_t0_13 + (0.19704832136631012) * gru_0_out_t0_14 + (-0.19924171268939972) * gru_0_out_t0_15 + (-0.28898483514785767) * gru_0_out_t0_16 + (-0.12699855864048004) * gru_0_out_t0_17 + (-0.044857554137706757) * gru_0_out_t0_18 + (4.4380149841308594) * gru_0_out_t0_19 + (-4.7677173614501953) * gru_0_out_t0_20 + (-0.59313154220581055) * gru_0_out_t0_21 + (0.27404987812042236) * gru_0_out_t0_22 + (0.54529595375061035) * gru_0_out_t0_23 + (0.032003056257963181) * gru_0_out_t0_24 + (-0.58755034208297729) * gru_0_out_t0_25 + (-0.30044519901275635) * gru_0_out_t0_26 + (-0.79001843929290771) * gru_0_out_t0_27 + (0.6735912561416626) * gru_0_out_t0_28 + (-0.38845634460449219) * gru_0_out_t0_29 + (0.26705923676490784) * gru_0_out_t0_30 + (2.4689083099365234) * gru_0_out_t0_31 + (0.23134134709835052) * gru_0_out_t0_32 + (0.21106834709644318) * gru_0_out_t0_33 + (-0.91481268405914307) * gru_0_out_t0_34 + (1.2150716781616211) * gru_0_out_t0_35 + (0.065189629793167114) * gru_0_out_t0_36 + (-0.32555150985717773) * gru_0_out_t0_37 + (-0.32623988389968872) * gru_0_out_t0_38 + (-2.7442464828491211) * gru_0_out_t0_39 + (-1.3278974294662476) * gru_0_out_t0_40 + (0.19511233270168304) * gru_0_out_t0_41 + (-0.80388039350509644) * gru_0_out_t0_42 + (0.32427871227264404) * gru_0_out_t0_43 + (0.32874324917793274) * gru_0_out_t0_44 + (0.39787280559539795) * gru_0_out_t0_45 + (0.50361686944961548) * gru_0_out_t0_46 + (-0.10364021360874176) * gru_0_out_t0_47 + (1.2198827266693115) * gru_0_out_t0_48 + (-0.94035041332244873) * gru_0_out_t0_49 + (-0.14341700077056885) * gru_0_out_t0_50 + (0.19096796214580536) * gru_0_out_t0_51 + (-0.44098404049873352) * gru_0_out_t0_52 + (0.138204425573349) * gru_0_out_t0_53 + (-0.57855522632598877) * gru_0_out_t0_54 + (0.11707889288663864) * gru_0_out_t0_55 + (-0.64840763807296753) * gru_0_out_t0_56 + (-1.2982920408248901) * gru_0_out_t0_57 + (-0.24858760833740234) * gru_0_out_t0_58 + (0.08419065922498703) * gru_0_out_t0_59 + (0.30213984847068787) * gru_0_out_t0_60 + (-0.20227141678333282) * gru_0_out_t0_61 + (1.0730043649673462) * gru_0_out_t0_62 + (0.49855482578277588) * gru_0_out_t0_63 + (-0.43623530864715576) * gru_1_rev_t1_h_0 + (1.504536509513855) * gru_1_rev_t1_h_1 + (-0.16723346710205078) * gru_1_rev_t1_h_2 + (0.1541275680065155) * gru_1_rev_t1_h_3 + (0.29193586111068726) * gru_1_rev_t1_h_4 + (-0.66095888614654541) * gru_1_rev_t1_h_5 + (-0.35746145248413086) * gru_1_rev_t1_h_6 + (0.017089016735553741) * gru_1_rev_t1_h_7 + (-0.36447599530220032) * gru_1_rev_t1_h_8 + (0.27324160933494568) * gru_1_rev_t1_h_9 + (-0.79309523105621338) * gru_1_rev_t1_h_10 + (0.19537711143493652) * gru_1_rev_t1_h_11 + (0.63370192050933838) * gru_1_rev_t1_h_12 + (-0.057003065943717957) * gru_1_rev_t1_h_13 + (0.39191213250160217) * gru_1_rev_t1_h_14 + (-1.66452956199646) * gru_1_rev_t1_h_15 + (0.052609752863645554) * gru_1_rev_t1_h_16 + (0.2402409166097641) * gru_1_rev_t1_h_17 + (-0.61560714244842529) * gru_1_rev_t1_h_18 + (-1.7285236120223999) * gru_1_rev_t1_h_19 + (-0.82342016696929932) * gru_1_rev_t1_h_20 + (0.061565220355987549) * gru_1_rev_t1_h_21 + (1.4568846225738525) * gru_1_rev_t1_h_22 + (-0.3808847963809967) * gru_1_rev_t1_h_23 + (-0.099804744124412537) * gru_1_rev_t1_h_24 + (0.51902216672897339) * gru_1_rev_t1_h_25 + (0.1631530374288559) * gru_1_rev_t1_h_26 + (-0.17129439115524292) * gru_1_rev_t1_h_27 + (0.033951371908187866) * gru_1_rev_t1_h_28 + (0.22314780950546265) * gru_1_rev_t1_h_29 + (-0.73104029893875122) * gru_1_rev_t1_h_30 + (0.18327569961547852) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.087044693529605865) + (0.79462945461273193) * gru_0_out_t0_0 + (0.35257366299629211) * gru_0_out_t0_1 + (-0.043707843869924545) * gru_0_out_t0_2 + (0.70485013723373413) * gru_0_out_t0_3 + (0.19893601536750793) * gru_0_out_t0_4 + (-0.34087848663330078) * gru_0_out_t0_5 + (0.17901962995529175) * gru_0_out_t0_6 + (-2.350905179977417) * gru_0_out_t0_7 + (1.5265114307403564) * gru_0_out_t0_8 + (-0.45630970597267151) * gru_0_out_t0_9 + (-0.35234266519546509) * gru_0_out_t0_10 + (0.33722105622291565) * gru_0_out_t0_11 + (-0.20122320950031281) * gru_0_out_t0_12 + (-0.4939160943031311) * gru_0_out_t0_13 + (0.84258353710174561) * gru_0_out_t0_14 + (0.1608310341835022) * gru_0_out_t0_15 + (0.48921921849250793) * gru_0_out_t0_16 + (0.2516903281211853) * gru_0_out_t0_17 + (0.24480263888835907) * gru_0_out_t0_18 + (2.9608440399169922) * gru_0_out_t0_19 + (0.050936568528413773) * gru_0_out_t0_20 + (2.2586729526519775) * gru_0_out_t0_21 + (0.14773081243038177) * gru_0_out_t0_22 + (-0.79892057180404663) * gru_0_out_t0_23 + (0.31867989897727966) * gru_0_out_t0_24 + (-0.63414138555526733) * gru_0_out_t0_25 + (0.34982967376708984) * gru_0_out_t0_26 + (0.33822998404502869) * gru_0_out_t0_27 + (0.38061988353729248) * gru_0_out_t0_28 + (-0.048703711479902267) * gru_0_out_t0_29 + (-0.003598436014726758) * gru_0_out_t0_30 + (0.10290121287107468) * gru_0_out_t0_31 + (-1.1747699975967407) * gru_0_out_t0_32 + (-0.097516804933547974) * gru_0_out_t0_33 + (1.3841280937194824) * gru_0_out_t0_34 + (-0.84746980667114258) * gru_0_out_t0_35 + (-0.68984919786453247) * gru_0_out_t0_36 + (0.65112584829330444) * gru_0_out_t0_37 + (0.21165594458580017) * gru_0_out_t0_38 + (0.20721857249736786) * gru_0_out_t0_39 + (-1.9675354957580566) * gru_0_out_t0_40 + (-0.79474884271621704) * gru_0_out_t0_41 + (-1.8761589527130127) * gru_0_out_t0_42 + (-1.2453190088272095) * gru_0_out_t0_43 + (-0.47919625043869019) * gru_0_out_t0_44 + (-0.0047920187935233116) * gru_0_out_t0_45 + (-1.3887530565261841) * gru_0_out_t0_46 + (0.59561759233474731) * gru_0_out_t0_47 + (0.61858981847763062) * gru_0_out_t0_48 + (-0.052535407245159149) * gru_0_out_t0_49 + (0.10191407799720764) * gru_0_out_t0_50 + (-0.082296684384346008) * gru_0_out_t0_51 + (0.093276269733905792) * gru_0_out_t0_52 + (-0.097830943763256073) * gru_0_out_t0_53 + (0.089157789945602417) * gru_0_out_t0_54 + (0.28810968995094299) * gru_0_out_t0_55 + (-0.29894545674324036) * gru_0_out_t0_56 + (0.25113210082054138) * gru_0_out_t0_57 + (0.27464002370834351) * gru_0_out_t0_58 + (0.6998792290687561) * gru_0_out_t0_59 + (0.37697497010231018) * gru_0_out_t0_60 + (0.11079305410385132) * gru_0_out_t0_61 + (-0.7660071849822998) * gru_0_out_t0_62 + (-0.84549856185913086) * gru_0_out_t0_63 + (0.071367852389812469) * gru_1_rev_t1_h_0 + (-0.25244471430778503) * gru_1_rev_t1_h_1 + (-0.1126580610871315) * gru_1_rev_t1_h_2 + (-0.12152563780546188) * gru_1_rev_t1_h_3 + (-1.0785230398178101) * gru_1_rev_t1_h_4 + (0.024831576272845268) * gru_1_rev_t1_h_5 + (-0.047287821769714355) * gru_1_rev_t1_h_6 + (0.36607643961906433) * gru_1_rev_t1_h_7 + (0.44724622368812561) * gru_1_rev_t1_h_8 + (0.080209828913211823) * gru_1_rev_t1_h_9 + (-0.13942280411720276) * gru_1_rev_t1_h_10 + (0.039590299129486084) * gru_1_rev_t1_h_11 + (0.53679937124252319) * gru_1_rev_t1_h_12 + (0.33845639228820801) * gru_1_rev_t1_h_13 + (-0.14335915446281433) * gru_1_rev_t1_h_14 + (-1.3147941827774048) * gru_1_rev_t1_h_15 + (0.48005190491676331) * gru_1_rev_t1_h_16 + (1.3228732347488403) * gru_1_rev_t1_h_17 + (-0.34820380806922913) * gru_1_rev_t1_h_18 + (0.86338222026824951) * gru_1_rev_t1_h_19 + (-0.53892576694488525) * gru_1_rev_t1_h_20 + (-0.37124133110046387) * gru_1_rev_t1_h_21 + (-1.1142526865005493) * gru_1_rev_t1_h_22 + (0.1106504499912262) * gru_1_rev_t1_h_23 + (0.4974459707736969) * gru_1_rev_t1_h_24 + (-0.17235609889030457) * gru_1_rev_t1_h_25 + (-0.75333565473556519) * gru_1_rev_t1_h_26 + (-0.37014788389205933) * gru_1_rev_t1_h_27 + (-0.9053349494934082) * gru_1_rev_t1_h_28 + (0.19615012407302856) * gru_1_rev_t1_h_29 + (0.59665787220001221) * gru_1_rev_t1_h_30 + (-0.66973453760147095) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.028650565072894096) + (-0.075675137341022491) * gru_0_out_t0_0 + (0.35578694939613342) * gru_0_out_t0_1 + (-0.19949404895305634) * gru_0_out_t0_2 + (0.098511815071105957) * gru_0_out_t0_3 + (0.68179678916931152) * gru_0_out_t0_4 + (-0.25390753149986267) * gru_0_out_t0_5 + (0.2472817599773407) * gru_0_out_t0_6 + (-0.37901967763900757) * gru_0_out_t0_7 + (0.22810238599777222) * gru_0_out_t0_8 + (0.1015632227063179) * gru_0_out_t0_9 + (0.13624268770217896) * gru_0_out_t0_10 + (-0.24867111444473267) * gru_0_out_t0_11 + (0.21862886846065521) * gru_0_out_t0_12 + (-0.38916894793510437) * gru_0_out_t0_13 + (0.22855411469936371) * gru_0_out_t0_14 + (0.20934055745601654) * gru_0_out_t0_15 + (0.13557732105255127) * gru_0_out_t0_16 + (0.11597409099340439) * gru_0_out_t0_17 + (0.061765529215335846) * gru_0_out_t0_18 + (0.80761295557022095) * gru_0_out_t0_19 + (0.11664843559265137) * gru_0_out_t0_20 + (-0.11853381246328354) * gru_0_out_t0_21 + (0.15639391541481018) * gru_0_out_t0_22 + (-0.15087810158729553) * gru_0_out_t0_23 + (0.10246942937374115) * gru_0_out_t0_24 + (0.42587012052536011) * gru_0_out_t0_25 + (-0.14839725196361542) * gru_0_out_t0_26 + (-0.023924218490719795) * gru_0_out_t0_27 + (-0.025356853380799294) * gru_0_out_t0_28 + (0.94055944681167603) * gru_0_out_t0_29 + (0.10024741291999817) * gru_0_out_t0_30 + (0.13711702823638916) * gru_0_out_t0_31 + (-0.25347551703453064) * gru_0_out_t0_32 + (-0.36647161841392517) * gru_0_out_t0_33 + (-0.91201770305633545) * gru_0_out_t0_34 + (-0.11644885689020157) * gru_0_out_t0_35 + (-0.028156325221061707) * gru_0_out_t0_36 + (0.09293423593044281) * gru_0_out_t0_37 + (0.38446295261383057) * gru_0_out_t0_38 + (-0.19020146131515503) * gru_0_out_t0_39 + (0.8530159592628479) * gru_0_out_t0_40 + (-0.1537272036075592) * gru_0_out_t0_41 + (0.049706246703863144) * gru_0_out_t0_42 + (-0.12128979712724686) * gru_0_out_t0_43 + (-0.1008281409740448) * gru_0_out_t0_44 + (-0.12327896058559418) * gru_0_out_t0_45 + (-0.79769730567932129) * gru_0_out_t0_46 + (0.28656226396560669) * gru_0_out_t0_47 + (0.45152795314788818) * gru_0_out_t0_48 + (-0.28837427496910095) * gru_0_out_t0_49 + (-0.1009335070848465) * gru_0_out_t0_50 + (-0.14261877536773682) * gru_0_out_t0_51 + (0.25793096423149109) * gru_0_out_t0_52 + (-0.033949136734008789) * gru_0_out_t0_53 + (-0.23612214624881744) * gru_0_out_t0_54 + (-0.020654736086726189) * gru_0_out_t0_55 + (-0.0084608085453510284) * gru_0_out_t0_56 + (-0.56888008117675781) * gru_0_out_t0_57 + (0.024410249665379524) * gru_0_out_t0_58 + (0.40613079071044922) * gru_0_out_t0_59 + (0.018475295975804329) * gru_0_out_t0_60 + (0.096394427120685577) * gru_0_out_t0_61 + (0.43465855717658997) * gru_0_out_t0_62 + (-0.76130110025405884) * gru_0_out_t0_63 + gate_r * ((-0.026259757578372955) + (-0.44418591260910034) * gru_1_rev_t1_h_0 + (-0.033721767365932465) * gru_1_rev_t1_h_1 + (1.1684573888778687) * gru_1_rev_t1_h_2 + (-0.22029086947441101) * gru_1_rev_t1_h_3 + (0.28800565004348755) * gru_1_rev_t1_h_4 + (-0.68420010805130005) * gru_1_rev_t1_h_5 + (-0.13781851530075073) * gru_1_rev_t1_h_6 + (0.081403054296970367) * gru_1_rev_t1_h_7 + (-0.38779455423355103) * gru_1_rev_t1_h_8 + (0.1783587783575058) * gru_1_rev_t1_h_9 + (0.160018190741539) * gru_1_rev_t1_h_10 + (1.0984333753585815) * gru_1_rev_t1_h_11 + (-0.28609195351600647) * gru_1_rev_t1_h_12 + (-0.15946295857429504) * gru_1_rev_t1_h_13 + (0.26024413108825684) * gru_1_rev_t1_h_14 + (-0.4359295666217804) * gru_1_rev_t1_h_15 + (-0.40497443079948425) * gru_1_rev_t1_h_16 + (-0.83608400821685791) * gru_1_rev_t1_h_17 + (0.098083391785621643) * gru_1_rev_t1_h_18 + (-0.46509861946105957) * gru_1_rev_t1_h_19 + (0.43796929717063904) * gru_1_rev_t1_h_20 + (0.32427552342414856) * gru_1_rev_t1_h_21 + (-0.75728321075439453) * gru_1_rev_t1_h_22 + (-0.3490757942199707) * gru_1_rev_t1_h_23 + (1.0922572612762451) * gru_1_rev_t1_h_24 + (0.27703282237052917) * gru_1_rev_t1_h_25 + (0.29153311252593994) * gru_1_rev_t1_h_26 + (-0.13929755985736847) * gru_1_rev_t1_h_27 + (0.91858756542205811) * gru_1_rev_t1_h_28 + (-0.40119189023971558) * gru_1_rev_t1_h_29 + (-0.40740466117858887) * gru_1_rev_t1_h_30 + (0.051418542861938477) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_12 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_12;
    // h=13
    gate_r = sigmoid((0.55282759666442871) + (0.46930316090583801) * gru_0_out_t0_0 + (0.16869974136352539) * gru_0_out_t0_1 + (-0.48277100920677185) * gru_0_out_t0_2 + (-0.67939943075180054) * gru_0_out_t0_3 + (-0.2828296422958374) * gru_0_out_t0_4 + (-1.9492646455764771) * gru_0_out_t0_5 + (0.96305632591247559) * gru_0_out_t0_6 + (-0.77842801809310913) * gru_0_out_t0_7 + (0.086645036935806274) * gru_0_out_t0_8 + (-1.0446134805679321) * gru_0_out_t0_9 + (0.53850555419921875) * gru_0_out_t0_10 + (0.59308522939682007) * gru_0_out_t0_11 + (0.29645645618438721) * gru_0_out_t0_12 + (-0.14748677611351013) * gru_0_out_t0_13 + (0.40361317992210388) * gru_0_out_t0_14 + (-0.15618322789669037) * gru_0_out_t0_15 + (-0.042387612164020538) * gru_0_out_t0_16 + (-0.95479404926300049) * gru_0_out_t0_17 + (-0.092936784029006958) * gru_0_out_t0_18 + (0.78182065486907959) * gru_0_out_t0_19 + (-2.1352448463439941) * gru_0_out_t0_20 + (-0.42782464623451233) * gru_0_out_t0_21 + (0.38887870311737061) * gru_0_out_t0_22 + (0.24168454110622406) * gru_0_out_t0_23 + (0.93897342681884766) * gru_0_out_t0_24 + (-0.92255508899688721) * gru_0_out_t0_25 + (-2.1768789291381836) * gru_0_out_t0_26 + (0.29877680540084839) * gru_0_out_t0_27 + (0.13690975308418274) * gru_0_out_t0_28 + (-0.18162770569324493) * gru_0_out_t0_29 + (-0.39664077758789062) * gru_0_out_t0_30 + (-0.51379376649856567) * gru_0_out_t0_31 + (-0.54410123825073242) * gru_0_out_t0_32 + (0.68875879049301147) * gru_0_out_t0_33 + (0.070681281387805939) * gru_0_out_t0_34 + (0.26004967093467712) * gru_0_out_t0_35 + (0.032351478934288025) * gru_0_out_t0_36 + (0.55012685060501099) * gru_0_out_t0_37 + (-0.24916540086269379) * gru_0_out_t0_38 + (-1.4312620162963867) * gru_0_out_t0_39 + (4.0754823684692383) * gru_0_out_t0_40 + (0.91876363754272461) * gru_0_out_t0_41 + (-0.19377319514751434) * gru_0_out_t0_42 + (0.10206512361764908) * gru_0_out_t0_43 + (-0.24957956373691559) * gru_0_out_t0_44 + (-0.37816253304481506) * gru_0_out_t0_45 + (0.10861195623874664) * gru_0_out_t0_46 + (0.35187637805938721) * gru_0_out_t0_47 + (1.5587993860244751) * gru_0_out_t0_48 + (-1.2546470165252686) * gru_0_out_t0_49 + (-0.031119896098971367) * gru_0_out_t0_50 + (0.44745820760726929) * gru_0_out_t0_51 + (-0.37445783615112305) * gru_0_out_t0_52 + (0.49065017700195312) * gru_0_out_t0_53 + (-3.7768495082855225) * gru_0_out_t0_54 + (1.1871341466903687) * gru_0_out_t0_55 + (2.0033385753631592) * gru_0_out_t0_56 + (-0.7372317910194397) * gru_0_out_t0_57 + (0.97337931394577026) * gru_0_out_t0_58 + (0.69543188810348511) * gru_0_out_t0_59 + (0.50765889883041382) * gru_0_out_t0_60 + (1.127550482749939) * gru_0_out_t0_61 + (0.089881733059883118) * gru_0_out_t0_62 + (0.22545161843299866) * gru_0_out_t0_63 + (0.50717586278915405) * gru_1_rev_t1_h_0 + (0.55107742547988892) * gru_1_rev_t1_h_1 + (-0.24874785542488098) * gru_1_rev_t1_h_2 + (0.16665846109390259) * gru_1_rev_t1_h_3 + (-0.11209072172641754) * gru_1_rev_t1_h_4 + (-0.52023947238922119) * gru_1_rev_t1_h_5 + (-0.6429903507232666) * gru_1_rev_t1_h_6 + (-0.33727917075157166) * gru_1_rev_t1_h_7 + (-0.28365561366081238) * gru_1_rev_t1_h_8 + (0.012047885917127132) * gru_1_rev_t1_h_9 + (-0.51050436496734619) * gru_1_rev_t1_h_10 + (0.51390808820724487) * gru_1_rev_t1_h_11 + (0.89945685863494873) * gru_1_rev_t1_h_12 + (-0.78797674179077148) * gru_1_rev_t1_h_13 + (-0.86577296257019043) * gru_1_rev_t1_h_14 + (-0.70119637250900269) * gru_1_rev_t1_h_15 + (0.68745124340057373) * gru_1_rev_t1_h_16 + (1.6216012239456177) * gru_1_rev_t1_h_17 + (1.0597914457321167) * gru_1_rev_t1_h_18 + (0.97582089900970459) * gru_1_rev_t1_h_19 + (-0.45338943600654602) * gru_1_rev_t1_h_20 + (-0.025961251929402351) * gru_1_rev_t1_h_21 + (-1.5721268653869629) * gru_1_rev_t1_h_22 + (-1.5223110914230347) * gru_1_rev_t1_h_23 + (-0.14653940498828888) * gru_1_rev_t1_h_24 + (0.43890285491943359) * gru_1_rev_t1_h_25 + (0.54834985733032227) * gru_1_rev_t1_h_26 + (-0.96398478746414185) * gru_1_rev_t1_h_27 + (-1.1269760131835938) * gru_1_rev_t1_h_28 + (-0.42921701073646545) * gru_1_rev_t1_h_29 + (0.54316562414169312) * gru_1_rev_t1_h_30 + (0.54006415605545044) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.7061687707901001) + (-0.22867250442504883) * gru_0_out_t0_0 + (0.078681506216526031) * gru_0_out_t0_1 + (1.4185534715652466) * gru_0_out_t0_2 + (0.14404839277267456) * gru_0_out_t0_3 + (-0.098840929567813873) * gru_0_out_t0_4 + (0.12931083142757416) * gru_0_out_t0_5 + (1.3375471830368042) * gru_0_out_t0_6 + (-0.79176324605941772) * gru_0_out_t0_7 + (0.17090253531932831) * gru_0_out_t0_8 + (-0.27023005485534668) * gru_0_out_t0_9 + (-1.473017692565918) * gru_0_out_t0_10 + (0.053476445376873016) * gru_0_out_t0_11 + (-0.10535344481468201) * gru_0_out_t0_12 + (-0.036493506282567978) * gru_0_out_t0_13 + (-0.41229552030563354) * gru_0_out_t0_14 + (0.19478656351566315) * gru_0_out_t0_15 + (-0.21423773467540741) * gru_0_out_t0_16 + (0.13015945255756378) * gru_0_out_t0_17 + (-0.15622740983963013) * gru_0_out_t0_18 + (0.19699573516845703) * gru_0_out_t0_19 + (-0.26986169815063477) * gru_0_out_t0_20 + (0.069639585912227631) * gru_0_out_t0_21 + (0.30735072493553162) * gru_0_out_t0_22 + (-0.10056216269731522) * gru_0_out_t0_23 + (-0.48153352737426758) * gru_0_out_t0_24 + (-0.22827674448490143) * gru_0_out_t0_25 + (-0.011269029229879379) * gru_0_out_t0_26 + (0.52004694938659668) * gru_0_out_t0_27 + (-1.3361413478851318) * gru_0_out_t0_28 + (1.4852086305618286) * gru_0_out_t0_29 + (0.52874356508255005) * gru_0_out_t0_30 + (-0.081489957869052887) * gru_0_out_t0_31 + (0.30236893892288208) * gru_0_out_t0_32 + (-0.11818500608205795) * gru_0_out_t0_33 + (-0.23642925918102264) * gru_0_out_t0_34 + (0.12331680208444595) * gru_0_out_t0_35 + (0.28372576832771301) * gru_0_out_t0_36 + (-0.08941110223531723) * gru_0_out_t0_37 + (0.18741908669471741) * gru_0_out_t0_38 + (0.11274969577789307) * gru_0_out_t0_39 + (0.63469952344894409) * gru_0_out_t0_40 + (0.26392796635627747) * gru_0_out_t0_41 + (0.36347472667694092) * gru_0_out_t0_42 + (-0.15999746322631836) * gru_0_out_t0_43 + (0.17642650008201599) * gru_0_out_t0_44 + (0.63740557432174683) * gru_0_out_t0_45 + (-0.11664268374443054) * gru_0_out_t0_46 + (-0.091110877692699432) * gru_0_out_t0_47 + (1.0304673910140991) * gru_0_out_t0_48 + (-0.94792187213897705) * gru_0_out_t0_49 + (-0.073847845196723938) * gru_0_out_t0_50 + (0.18382687866687775) * gru_0_out_t0_51 + (1.2514737844467163) * gru_0_out_t0_52 + (0.1104656383395195) * gru_0_out_t0_53 + (0.10962693393230438) * gru_0_out_t0_54 + (-0.15341147780418396) * gru_0_out_t0_55 + (1.4064062833786011) * gru_0_out_t0_56 + (-0.17609779536724091) * gru_0_out_t0_57 + (0.1724238246679306) * gru_0_out_t0_58 + (0.88018465042114258) * gru_0_out_t0_59 + (0.50435012578964233) * gru_0_out_t0_60 + (0.29342493414878845) * gru_0_out_t0_61 + (0.18284812569618225) * gru_0_out_t0_62 + (1.2771998643875122) * gru_0_out_t0_63 + (-0.89329421520233154) * gru_1_rev_t1_h_0 + (0.097511768341064453) * gru_1_rev_t1_h_1 + (-1.3385860919952393) * gru_1_rev_t1_h_2 + (1.4727014303207397) * gru_1_rev_t1_h_3 + (-0.025164343416690826) * gru_1_rev_t1_h_4 + (-0.27253496646881104) * gru_1_rev_t1_h_5 + (0.66084933280944824) * gru_1_rev_t1_h_6 + (-0.82165306806564331) * gru_1_rev_t1_h_7 + (0.33806213736534119) * gru_1_rev_t1_h_8 + (-0.06332378089427948) * gru_1_rev_t1_h_9 + (-0.50377142429351807) * gru_1_rev_t1_h_10 + (-0.0067947525531053543) * gru_1_rev_t1_h_11 + (-0.71047675609588623) * gru_1_rev_t1_h_12 + (-0.63206827640533447) * gru_1_rev_t1_h_13 + (-0.063173606991767883) * gru_1_rev_t1_h_14 + (0.061823859810829163) * gru_1_rev_t1_h_15 + (2.3983469009399414) * gru_1_rev_t1_h_16 + (0.14580680429935455) * gru_1_rev_t1_h_17 + (0.35446393489837646) * gru_1_rev_t1_h_18 + (0.27320066094398499) * gru_1_rev_t1_h_19 + (-1.7384234666824341) * gru_1_rev_t1_h_20 + (-0.3289792537689209) * gru_1_rev_t1_h_21 + (-0.462921142578125) * gru_1_rev_t1_h_22 + (-0.19856101274490356) * gru_1_rev_t1_h_23 + (-0.026841461658477783) * gru_1_rev_t1_h_24 + (0.0066686286590993404) * gru_1_rev_t1_h_25 + (0.13719907402992249) * gru_1_rev_t1_h_26 + (-0.87756508588790894) * gru_1_rev_t1_h_27 + (-0.80177325010299683) * gru_1_rev_t1_h_28 + (0.2288656085729599) * gru_1_rev_t1_h_29 + (1.0473531484603882) * gru_1_rev_t1_h_30 + (-0.30005061626434326) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.14634542167186737) + (-0.10877470672130585) * gru_0_out_t0_0 + (0.44668689370155334) * gru_0_out_t0_1 + (-0.066927552223205566) * gru_0_out_t0_2 + (0.90290021896362305) * gru_0_out_t0_3 + (-0.15796409547328949) * gru_0_out_t0_4 + (2.4428954124450684) * gru_0_out_t0_5 + (-0.39837384223937988) * gru_0_out_t0_6 + (-0.055105309933423996) * gru_0_out_t0_7 + (0.44017884135246277) * gru_0_out_t0_8 + (-0.23248408734798431) * gru_0_out_t0_9 + (0.010108479298651218) * gru_0_out_t0_10 + (-0.14040008187294006) * gru_0_out_t0_11 + (-0.054043494164943695) * gru_0_out_t0_12 + (0.022081559523940086) * gru_0_out_t0_13 + (-0.15497320890426636) * gru_0_out_t0_14 + (0.0036570955999195576) * gru_0_out_t0_15 + (-0.021268650889396667) * gru_0_out_t0_16 + (0.31988441944122314) * gru_0_out_t0_17 + (0.26429247856140137) * gru_0_out_t0_18 + (-0.2854037880897522) * gru_0_out_t0_19 + (0.98514550924301147) * gru_0_out_t0_20 + (0.033035799860954285) * gru_0_out_t0_21 + (-0.62623262405395508) * gru_0_out_t0_22 + (-0.29612007737159729) * gru_0_out_t0_23 + (-0.28753894567489624) * gru_0_out_t0_24 + (0.70466494560241699) * gru_0_out_t0_25 + (0.98308408260345459) * gru_0_out_t0_26 + (-0.019664036110043526) * gru_0_out_t0_27 + (-0.4289831817150116) * gru_0_out_t0_28 + (-0.29411828517913818) * gru_0_out_t0_29 + (0.30919179320335388) * gru_0_out_t0_30 + (-0.32188674807548523) * gru_0_out_t0_31 + (-0.20447826385498047) * gru_0_out_t0_32 + (-0.59436649084091187) * gru_0_out_t0_33 + (0.090776540338993073) * gru_0_out_t0_34 + (-0.35331672430038452) * gru_0_out_t0_35 + (0.053213272243738174) * gru_0_out_t0_36 + (0.043515812605619431) * gru_0_out_t0_37 + (0.31444481015205383) * gru_0_out_t0_38 + (0.76933962106704712) * gru_0_out_t0_39 + (4.2920775413513184) * gru_0_out_t0_40 + (-0.12745213508605957) * gru_0_out_t0_41 + (0.43535569310188293) * gru_0_out_t0_42 + (-0.16497918963432312) * gru_0_out_t0_43 + (0.35094770789146423) * gru_0_out_t0_44 + (0.2871164083480835) * gru_0_out_t0_45 + (-0.074349507689476013) * gru_0_out_t0_46 + (0.17089813947677612) * gru_0_out_t0_47 + (0.20119886100292206) * gru_0_out_t0_48 + (-0.13364548981189728) * gru_0_out_t0_49 + (-0.091465473175048828) * gru_0_out_t0_50 + (-0.20156417787075043) * gru_0_out_t0_51 + (-0.10703303664922714) * gru_0_out_t0_52 + (-0.041517496109008789) * gru_0_out_t0_53 + (0.3724835216999054) * gru_0_out_t0_54 + (-0.083921439945697784) * gru_0_out_t0_55 + (-0.13570794463157654) * gru_0_out_t0_56 + (0.59338092803955078) * gru_0_out_t0_57 + (-0.21425510942935944) * gru_0_out_t0_58 + (-0.088959261775016785) * gru_0_out_t0_59 + (0.22802282869815826) * gru_0_out_t0_60 + (0.28701251745223999) * gru_0_out_t0_61 + (-0.017905393615365028) * gru_0_out_t0_62 + (0.010603058151900768) * gru_0_out_t0_63 + gate_r * ((-0.45735511183738708) + (-0.079724684357643127) * gru_1_rev_t1_h_0 + (-0.30162134766578674) * gru_1_rev_t1_h_1 + (0.08560384064912796) * gru_1_rev_t1_h_2 + (0.06037517637014389) * gru_1_rev_t1_h_3 + (0.13549458980560303) * gru_1_rev_t1_h_4 + (-0.12743298709392548) * gru_1_rev_t1_h_5 + (0.56739085912704468) * gru_1_rev_t1_h_6 + (-0.21643021702766418) * gru_1_rev_t1_h_7 + (0.43685966730117798) * gru_1_rev_t1_h_8 + (-0.3281252384185791) * gru_1_rev_t1_h_9 + (-0.27332010865211487) * gru_1_rev_t1_h_10 + (0.51824671030044556) * gru_1_rev_t1_h_11 + (0.23531633615493774) * gru_1_rev_t1_h_12 + (0.03581102192401886) * gru_1_rev_t1_h_13 + (-0.16180247068405151) * gru_1_rev_t1_h_14 + (-0.35428404808044434) * gru_1_rev_t1_h_15 + (-0.37353330850601196) * gru_1_rev_t1_h_16 + (-0.34287771582603455) * gru_1_rev_t1_h_17 + (0.54323655366897583) * gru_1_rev_t1_h_18 + (0.27207154035568237) * gru_1_rev_t1_h_19 + (0.08408009260892868) * gru_1_rev_t1_h_20 + (-0.35072565078735352) * gru_1_rev_t1_h_21 + (-0.43256694078445435) * gru_1_rev_t1_h_22 + (0.3863542377948761) * gru_1_rev_t1_h_23 + (-0.12022532522678375) * gru_1_rev_t1_h_24 + (-0.67877858877182007) * gru_1_rev_t1_h_25 + (-0.42158779501914978) * gru_1_rev_t1_h_26 + (-0.2632039487361908) * gru_1_rev_t1_h_27 + (0.021852647885680199) * gru_1_rev_t1_h_28 + (0.31078505516052246) * gru_1_rev_t1_h_29 + (-0.38632318377494812) * gru_1_rev_t1_h_30 + (-0.31148821115493774) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_13 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_13;
    // h=14
    gate_r = sigmoid((-0.43125519156455994) + (-0.036483027040958405) * gru_0_out_t0_0 + (0.010721863247454166) * gru_0_out_t0_1 + (2.2870337963104248) * gru_0_out_t0_2 + (2.419081449508667) * gru_0_out_t0_3 + (0.57300305366516113) * gru_0_out_t0_4 + (-0.039618436247110367) * gru_0_out_t0_5 + (-4.766944408416748) * gru_0_out_t0_6 + (-1.1026146411895752) * gru_0_out_t0_7 + (-1.2037258148193359) * gru_0_out_t0_8 + (1.5287297964096069) * gru_0_out_t0_9 + (-2.3472139835357666) * gru_0_out_t0_10 + (-0.52688664197921753) * gru_0_out_t0_11 + (0.38571232557296753) * gru_0_out_t0_12 + (0.63007873296737671) * gru_0_out_t0_13 + (0.10150563716888428) * gru_0_out_t0_14 + (0.028008610010147095) * gru_0_out_t0_15 + (0.35803306102752686) * gru_0_out_t0_16 + (0.44225558638572693) * gru_0_out_t0_17 + (-0.33577245473861694) * gru_0_out_t0_18 + (1.7001785039901733) * gru_0_out_t0_19 + (2.1723001003265381) * gru_0_out_t0_20 + (0.34896507859230042) * gru_0_out_t0_21 + (3.4564318656921387) * gru_0_out_t0_22 + (0.0628628209233284) * gru_0_out_t0_23 + (-4.1560626029968262) * gru_0_out_t0_24 + (-2.5850832462310791) * gru_0_out_t0_25 + (-0.2875404953956604) * gru_0_out_t0_26 + (2.9732227325439453) * gru_0_out_t0_27 + (-2.1251034736633301) * gru_0_out_t0_28 + (-1.229794979095459) * gru_0_out_t0_29 + (0.061342082917690277) * gru_0_out_t0_30 + (0.10895950347185135) * gru_0_out_t0_31 + (-1.7743316888809204) * gru_0_out_t0_32 + (-0.29179322719573975) * gru_0_out_t0_33 + (0.050211213529109955) * gru_0_out_t0_34 + (-0.10082656890153885) * gru_0_out_t0_35 + (0.25614804029464722) * gru_0_out_t0_36 + (-0.34795209765434265) * gru_0_out_t0_37 + (0.57002055644989014) * gru_0_out_t0_38 + (0.070922344923019409) * gru_0_out_t0_39 + (-3.6610877513885498) * gru_0_out_t0_40 + (0.0523819699883461) * gru_0_out_t0_41 + (-0.87220287322998047) * gru_0_out_t0_42 + (0.32857683300971985) * gru_0_out_t0_43 + (0.16785827279090881) * gru_0_out_t0_44 + (0.39431846141815186) * gru_0_out_t0_45 + (0.28003385663032532) * gru_0_out_t0_46 + (1.0163894891738892) * gru_0_out_t0_47 + (-0.0051656090654432774) * gru_0_out_t0_48 + (0.12287435680627823) * gru_0_out_t0_49 + (-0.19208748638629913) * gru_0_out_t0_50 + (0.77718925476074219) * gru_0_out_t0_51 + (0.38668709993362427) * gru_0_out_t0_52 + (-0.93473440408706665) * gru_0_out_t0_53 + (0.96336030960083008) * gru_0_out_t0_54 + (-0.59158194065093994) * gru_0_out_t0_55 + (0.8214990496635437) * gru_0_out_t0_56 + (-0.47062316536903381) * gru_0_out_t0_57 + (0.087474696338176727) * gru_0_out_t0_58 + (0.96718847751617432) * gru_0_out_t0_59 + (1.0576953887939453) * gru_0_out_t0_60 + (1.5989686250686646) * gru_0_out_t0_61 + (0.14351846277713776) * gru_0_out_t0_62 + (-0.30119553208351135) * gru_0_out_t0_63 + (0.26477298140525818) * gru_1_rev_t1_h_0 + (0.72458499670028687) * gru_1_rev_t1_h_1 + (0.45927029848098755) * gru_1_rev_t1_h_2 + (0.076365746557712555) * gru_1_rev_t1_h_3 + (-0.38672828674316406) * gru_1_rev_t1_h_4 + (0.49131959676742554) * gru_1_rev_t1_h_5 + (0.66502964496612549) * gru_1_rev_t1_h_6 + (-0.11118688434362411) * gru_1_rev_t1_h_7 + (0.64984309673309326) * gru_1_rev_t1_h_8 + (0.63167822360992432) * gru_1_rev_t1_h_9 + (0.2302272617816925) * gru_1_rev_t1_h_10 + (-1.3998699188232422) * gru_1_rev_t1_h_11 + (-0.42028149962425232) * gru_1_rev_t1_h_12 + (2.264460563659668) * gru_1_rev_t1_h_13 + (-0.67981243133544922) * gru_1_rev_t1_h_14 + (0.25867956876754761) * gru_1_rev_t1_h_15 + (0.8519633412361145) * gru_1_rev_t1_h_16 + (0.347147136926651) * gru_1_rev_t1_h_17 + (0.091515772044658661) * gru_1_rev_t1_h_18 + (0.1558040976524353) * gru_1_rev_t1_h_19 + (-0.95581883192062378) * gru_1_rev_t1_h_20 + (-0.44346100091934204) * gru_1_rev_t1_h_21 + (1.0623805522918701) * gru_1_rev_t1_h_22 + (0.14119419455528259) * gru_1_rev_t1_h_23 + (-1.2040419578552246) * gru_1_rev_t1_h_24 + (-0.64604717493057251) * gru_1_rev_t1_h_25 + (-0.60406357049942017) * gru_1_rev_t1_h_26 + (0.50189542770385742) * gru_1_rev_t1_h_27 + (-0.55101656913757324) * gru_1_rev_t1_h_28 + (-1.0185447931289673) * gru_1_rev_t1_h_29 + (-0.19960620999336243) * gru_1_rev_t1_h_30 + (-0.5409361720085144) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.38779670000076294) + (0.4930880069732666) * gru_0_out_t0_0 + (-0.26307573914527893) * gru_0_out_t0_1 + (-0.11037640273571014) * gru_0_out_t0_2 + (-0.86220884323120117) * gru_0_out_t0_3 + (-0.23062802851200104) * gru_0_out_t0_4 + (0.6336553692817688) * gru_0_out_t0_5 + (-0.073547191917896271) * gru_0_out_t0_6 + (-1.0840914249420166) * gru_0_out_t0_7 + (0.10888782888650894) * gru_0_out_t0_8 + (-0.70136898756027222) * gru_0_out_t0_9 + (0.84905225038528442) * gru_0_out_t0_10 + (0.23686504364013672) * gru_0_out_t0_11 + (0.94472920894622803) * gru_0_out_t0_12 + (1.4331356287002563) * gru_0_out_t0_13 + (-0.10078699141740799) * gru_0_out_t0_14 + (-0.71550959348678589) * gru_0_out_t0_15 + (0.23450793325901031) * gru_0_out_t0_16 + (0.25986751914024353) * gru_0_out_t0_17 + (-0.45610859990119934) * gru_0_out_t0_18 + (1.3086800575256348) * gru_0_out_t0_19 + (-0.10698574781417847) * gru_0_out_t0_20 + (-0.55644476413726807) * gru_0_out_t0_21 + (0.87446731328964233) * gru_0_out_t0_22 + (-0.52561748027801514) * gru_0_out_t0_23 + (-2.1796462535858154) * gru_0_out_t0_24 + (-0.27503800392150879) * gru_0_out_t0_25 + (-0.35925936698913574) * gru_0_out_t0_26 + (0.21355515718460083) * gru_0_out_t0_27 + (-0.32807502150535583) * gru_0_out_t0_28 + (1.0220812559127808) * gru_0_out_t0_29 + (0.66365355253219604) * gru_0_out_t0_30 + (0.29825732111930847) * gru_0_out_t0_31 + (0.30209022760391235) * gru_0_out_t0_32 + (-0.53370022773742676) * gru_0_out_t0_33 + (0.25775030255317688) * gru_0_out_t0_34 + (0.31656217575073242) * gru_0_out_t0_35 + (0.39127281308174133) * gru_0_out_t0_36 + (-0.59443557262420654) * gru_0_out_t0_37 + (0.30264142155647278) * gru_0_out_t0_38 + (-0.45668762922286987) * gru_0_out_t0_39 + (1.0874406099319458) * gru_0_out_t0_40 + (0.69131314754486084) * gru_0_out_t0_41 + (0.39688920974731445) * gru_0_out_t0_42 + (-0.55026209354400635) * gru_0_out_t0_43 + (0.14104433357715607) * gru_0_out_t0_44 + (0.034280341118574142) * gru_0_out_t0_45 + (0.41134658455848694) * gru_0_out_t0_46 + (-0.37292084097862244) * gru_0_out_t0_47 + (-0.32384178042411804) * gru_0_out_t0_48 + (0.42310228943824768) * gru_0_out_t0_49 + (1.3887064456939697) * gru_0_out_t0_50 + (0.19236193597316742) * gru_0_out_t0_51 + (0.68265676498413086) * gru_0_out_t0_52 + (-0.024246938526630402) * gru_0_out_t0_53 + (-1.0264245271682739) * gru_0_out_t0_54 + (0.65959912538528442) * gru_0_out_t0_55 + (-0.067892797291278839) * gru_0_out_t0_56 + (0.46456077694892883) * gru_0_out_t0_57 + (-0.15480995178222656) * gru_0_out_t0_58 + (-0.80564957857131958) * gru_0_out_t0_59 + (-0.26363614201545715) * gru_0_out_t0_60 + (-0.028295319527387619) * gru_0_out_t0_61 + (0.59366345405578613) * gru_0_out_t0_62 + (0.035899650305509567) * gru_0_out_t0_63 + (-0.37336206436157227) * gru_1_rev_t1_h_0 + (-0.80725103616714478) * gru_1_rev_t1_h_1 + (1.4990710020065308) * gru_1_rev_t1_h_2 + (-1.2482088804244995) * gru_1_rev_t1_h_3 + (0.34088864922523499) * gru_1_rev_t1_h_4 + (0.62641143798828125) * gru_1_rev_t1_h_5 + (-1.2568707466125488) * gru_1_rev_t1_h_6 + (-0.1430564820766449) * gru_1_rev_t1_h_7 + (-0.073506958782672882) * gru_1_rev_t1_h_8 + (0.56285524368286133) * gru_1_rev_t1_h_9 + (1.6425716876983643) * gru_1_rev_t1_h_10 + (0.2082330584526062) * gru_1_rev_t1_h_11 + (-3.9649519920349121) * gru_1_rev_t1_h_12 + (-0.62660712003707886) * gru_1_rev_t1_h_13 + (0.83472853899002075) * gru_1_rev_t1_h_14 + (-0.054687265306711197) * gru_1_rev_t1_h_15 + (-2.0911836624145508) * gru_1_rev_t1_h_16 + (-0.25378164649009705) * gru_1_rev_t1_h_17 + (-0.22046366333961487) * gru_1_rev_t1_h_18 + (0.44044187664985657) * gru_1_rev_t1_h_19 + (-1.9153690338134766) * gru_1_rev_t1_h_20 + (-0.74290645122528076) * gru_1_rev_t1_h_21 + (0.86752760410308838) * gru_1_rev_t1_h_22 + (-0.78898453712463379) * gru_1_rev_t1_h_23 + (-0.36752751469612122) * gru_1_rev_t1_h_24 + (0.30790993571281433) * gru_1_rev_t1_h_25 + (0.33688634634017944) * gru_1_rev_t1_h_26 + (0.6685752272605896) * gru_1_rev_t1_h_27 + (1.3743985891342163) * gru_1_rev_t1_h_28 + (0.053749594837427139) * gru_1_rev_t1_h_29 + (0.036065429449081421) * gru_1_rev_t1_h_30 + (-0.72217714786529541) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.064018242061138153) + (0.1016295850276947) * gru_0_out_t0_0 + (0.50618290901184082) * gru_0_out_t0_1 + (-0.71328818798065186) * gru_0_out_t0_2 + (-0.52660834789276123) * gru_0_out_t0_3 + (0.38836103677749634) * gru_0_out_t0_4 + (0.20739816129207611) * gru_0_out_t0_5 + (0.23486979305744171) * gru_0_out_t0_6 + (0.62533628940582275) * gru_0_out_t0_7 + (0.04528350755572319) * gru_0_out_t0_8 + (-0.9908183217048645) * gru_0_out_t0_9 + (0.53925365209579468) * gru_0_out_t0_10 + (-0.18555212020874023) * gru_0_out_t0_11 + (0.20200242102146149) * gru_0_out_t0_12 + (-0.12502105534076691) * gru_0_out_t0_13 + (0.64741033315658569) * gru_0_out_t0_14 + (-0.66569441556930542) * gru_0_out_t0_15 + (-0.273130863904953) * gru_0_out_t0_16 + (-0.16130624711513519) * gru_0_out_t0_17 + (0.24576514959335327) * gru_0_out_t0_18 + (0.29258561134338379) * gru_0_out_t0_19 + (-0.73457825183868408) * gru_0_out_t0_20 + (0.44154584407806396) * gru_0_out_t0_21 + (-0.87243890762329102) * gru_0_out_t0_22 + (-0.012254567816853523) * gru_0_out_t0_23 + (1.276323676109314) * gru_0_out_t0_24 + (0.81985300779342651) * gru_0_out_t0_25 + (0.098233148455619812) * gru_0_out_t0_26 + (-1.1982781887054443) * gru_0_out_t0_27 + (0.50361496210098267) * gru_0_out_t0_28 + (0.097322165966033936) * gru_0_out_t0_29 + (0.016574881970882416) * gru_0_out_t0_30 + (-0.57937890291213989) * gru_0_out_t0_31 + (1.1466412544250488) * gru_0_out_t0_32 + (0.32577154040336609) * gru_0_out_t0_33 + (0.29312291741371155) * gru_0_out_t0_34 + (-0.40743830800056458) * gru_0_out_t0_35 + (-0.23701648414134979) * gru_0_out_t0_36 + (0.052707906812429428) * gru_0_out_t0_37 + (-0.023208817467093468) * gru_0_out_t0_38 + (-0.69757425785064697) * gru_0_out_t0_39 + (3.0763823986053467) * gru_0_out_t0_40 + (-0.7478291392326355) * gru_0_out_t0_41 + (-0.66132771968841553) * gru_0_out_t0_42 + (-0.41055649518966675) * gru_0_out_t0_43 + (-0.62090998888015747) * gru_0_out_t0_44 + (0.10030172765254974) * gru_0_out_t0_45 + (1.2255206108093262) * gru_0_out_t0_46 + (-0.68026107549667358) * gru_0_out_t0_47 + (0.12329826503992081) * gru_0_out_t0_48 + (0.36275234818458557) * gru_0_out_t0_49 + (0.92877805233001709) * gru_0_out_t0_50 + (0.25730669498443604) * gru_0_out_t0_51 + (0.14606857299804688) * gru_0_out_t0_52 + (0.23232394456863403) * gru_0_out_t0_53 + (-0.32108515501022339) * gru_0_out_t0_54 + (0.23944519460201263) * gru_0_out_t0_55 + (-0.93113183975219727) * gru_0_out_t0_56 + (0.020269701257348061) * gru_0_out_t0_57 + (0.49709156155586243) * gru_0_out_t0_58 + (0.36596882343292236) * gru_0_out_t0_59 + (-1.3830347061157227) * gru_0_out_t0_60 + (0.083709530532360077) * gru_0_out_t0_61 + (-0.46551719307899475) * gru_0_out_t0_62 + (0.66332358121871948) * gru_0_out_t0_63 + gate_r * ((-0.07043948769569397) + (-0.029815921559929848) * gru_1_rev_t1_h_0 + (0.42264962196350098) * gru_1_rev_t1_h_1 + (-0.81693488359451294) * gru_1_rev_t1_h_2 + (0.39455124735832214) * gru_1_rev_t1_h_3 + (0.76668882369995117) * gru_1_rev_t1_h_4 + (0.34693863987922668) * gru_1_rev_t1_h_5 + (-0.18528307974338531) * gru_1_rev_t1_h_6 + (-0.0035340010654181242) * gru_1_rev_t1_h_7 + (0.25837266445159912) * gru_1_rev_t1_h_8 + (-0.21027357876300812) * gru_1_rev_t1_h_9 + (0.15026183426380157) * gru_1_rev_t1_h_10 + (-0.75579094886779785) * gru_1_rev_t1_h_11 + (0.73454844951629639) * gru_1_rev_t1_h_12 + (1.8015662431716919) * gru_1_rev_t1_h_13 + (0.025612188503146172) * gru_1_rev_t1_h_14 + (-0.35803025960922241) * gru_1_rev_t1_h_15 + (-0.44431337714195251) * gru_1_rev_t1_h_16 + (-0.41438993811607361) * gru_1_rev_t1_h_17 + (0.079091303050518036) * gru_1_rev_t1_h_18 + (0.39329767227172852) * gru_1_rev_t1_h_19 + (-0.12849347293376923) * gru_1_rev_t1_h_20 + (0.7860184907913208) * gru_1_rev_t1_h_21 + (-0.50455522537231445) * gru_1_rev_t1_h_22 + (0.63689267635345459) * gru_1_rev_t1_h_23 + (1.9043337106704712) * gru_1_rev_t1_h_24 + (0.97689759731292725) * gru_1_rev_t1_h_25 + (0.074886798858642578) * gru_1_rev_t1_h_26 + (-0.020648619160056114) * gru_1_rev_t1_h_27 + (-0.7782137393951416) * gru_1_rev_t1_h_28 + (0.49887976050376892) * gru_1_rev_t1_h_29 + (-0.12493210285902023) * gru_1_rev_t1_h_30 + (0.17144443094730377) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_14 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_14;
    // h=15
    gate_r = sigmoid((-0.91758573055267334) + (-1.1700328588485718) * gru_0_out_t0_0 + (-1.1264976263046265) * gru_0_out_t0_1 + (-0.60981416702270508) * gru_0_out_t0_2 + (0.92616468667984009) * gru_0_out_t0_3 + (-0.4777604341506958) * gru_0_out_t0_4 + (0.45088359713554382) * gru_0_out_t0_5 + (-0.70253032445907593) * gru_0_out_t0_6 + (0.57655191421508789) * gru_0_out_t0_7 + (-0.16202977299690247) * gru_0_out_t0_8 + (0.10147494822740555) * gru_0_out_t0_9 + (1.034649133682251) * gru_0_out_t0_10 + (-0.07411888986825943) * gru_0_out_t0_11 + (-0.34667250514030457) * gru_0_out_t0_12 + (1.017472505569458) * gru_0_out_t0_13 + (-0.034044675529003143) * gru_0_out_t0_14 + (-0.81048458814620972) * gru_0_out_t0_15 + (0.87078046798706055) * gru_0_out_t0_16 + (0.29149901866912842) * gru_0_out_t0_17 + (-0.25193628668785095) * gru_0_out_t0_18 + (-0.4019697904586792) * gru_0_out_t0_19 + (0.67365646362304688) * gru_0_out_t0_20 + (1.160391092300415) * gru_0_out_t0_21 + (-0.36387372016906738) * gru_0_out_t0_22 + (0.016067188233137131) * gru_0_out_t0_23 + (0.50830590724945068) * gru_0_out_t0_24 + (-1.9985400438308716) * gru_0_out_t0_25 + (-0.068947054445743561) * gru_0_out_t0_26 + (0.56564211845397949) * gru_0_out_t0_27 + (-0.083019398152828217) * gru_0_out_t0_28 + (-1.4010391235351562) * gru_0_out_t0_29 + (-0.6217537522315979) * gru_0_out_t0_30 + (-0.95564889907836914) * gru_0_out_t0_31 + (-0.047187082469463348) * gru_0_out_t0_32 + (0.64469128847122192) * gru_0_out_t0_33 + (0.70081621408462524) * gru_0_out_t0_34 + (0.89910030364990234) * gru_0_out_t0_35 + (-0.68865472078323364) * gru_0_out_t0_36 + (0.67237263917922974) * gru_0_out_t0_37 + (-0.89822167158126831) * gru_0_out_t0_38 + (0.33381950855255127) * gru_0_out_t0_39 + (-0.36286169290542603) * gru_0_out_t0_40 + (1.2126985788345337) * gru_0_out_t0_41 + (1.1262373924255371) * gru_0_out_t0_42 + (0.93429362773895264) * gru_0_out_t0_43 + (0.57002633810043335) * gru_0_out_t0_44 + (0.43336978554725647) * gru_0_out_t0_45 + (2.1344985961914062) * gru_0_out_t0_46 + (-0.96592479944229126) * gru_0_out_t0_47 + (-1.4342771768569946) * gru_0_out_t0_48 + (1.5998274087905884) * gru_0_out_t0_49 + (0.57940340042114258) * gru_0_out_t0_50 + (2.813673734664917) * gru_0_out_t0_51 + (0.38500392436981201) * gru_0_out_t0_52 + (1.1620571613311768) * gru_0_out_t0_53 + (0.31967592239379883) * gru_0_out_t0_54 + (-0.055408138781785965) * gru_0_out_t0_55 + (-1.5085335969924927) * gru_0_out_t0_56 + (1.546358585357666) * gru_0_out_t0_57 + (-0.11812501400709152) * gru_0_out_t0_58 + (-1.6357041597366333) * gru_0_out_t0_59 + (-1.6005769968032837) * gru_0_out_t0_60 + (0.29661813378334045) * gru_0_out_t0_61 + (0.20172688364982605) * gru_0_out_t0_62 + (-0.048460114747285843) * gru_0_out_t0_63 + (0.24793396890163422) * gru_1_rev_t1_h_0 + (0.12344116717576981) * gru_1_rev_t1_h_1 + (-0.0051076146773993969) * gru_1_rev_t1_h_2 + (1.1196820735931396) * gru_1_rev_t1_h_3 + (-2.2700226306915283) * gru_1_rev_t1_h_4 + (-0.37328782677650452) * gru_1_rev_t1_h_5 + (0.38026481866836548) * gru_1_rev_t1_h_6 + (-0.28443470597267151) * gru_1_rev_t1_h_7 + (0.24702927470207214) * gru_1_rev_t1_h_8 + (-0.99644798040390015) * gru_1_rev_t1_h_9 + (-0.044971361756324768) * gru_1_rev_t1_h_10 + (2.3071146011352539) * gru_1_rev_t1_h_11 + (-0.01087571494281292) * gru_1_rev_t1_h_12 + (-0.2456045001745224) * gru_1_rev_t1_h_13 + (1.6984902620315552) * gru_1_rev_t1_h_14 + (2.0386779308319092) * gru_1_rev_t1_h_15 + (-1.6985809803009033) * gru_1_rev_t1_h_16 + (-0.17736275494098663) * gru_1_rev_t1_h_17 + (0.86311608552932739) * gru_1_rev_t1_h_18 + (-0.99041545391082764) * gru_1_rev_t1_h_19 + (0.62026810646057129) * gru_1_rev_t1_h_20 + (-0.28774276375770569) * gru_1_rev_t1_h_21 + (-0.51473784446716309) * gru_1_rev_t1_h_22 + (-0.85319679975509644) * gru_1_rev_t1_h_23 + (-0.6073760986328125) * gru_1_rev_t1_h_24 + (-0.64034312963485718) * gru_1_rev_t1_h_25 + (-1.9026247262954712) * gru_1_rev_t1_h_26 + (0.72066503763198853) * gru_1_rev_t1_h_27 + (0.62387549877166748) * gru_1_rev_t1_h_28 + (-1.59059739112854) * gru_1_rev_t1_h_29 + (-0.2657584547996521) * gru_1_rev_t1_h_30 + (-2.3481545448303223) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.1730768084526062) + (0.41976276040077209) * gru_0_out_t0_0 + (-0.47231966257095337) * gru_0_out_t0_1 + (0.29114240407943726) * gru_0_out_t0_2 + (-0.18292936682701111) * gru_0_out_t0_3 + (-1.0804359912872314) * gru_0_out_t0_4 + (0.1749674528837204) * gru_0_out_t0_5 + (0.73984611034393311) * gru_0_out_t0_6 + (-0.75696784257888794) * gru_0_out_t0_7 + (-0.037801634520292282) * gru_0_out_t0_8 + (0.3002173900604248) * gru_0_out_t0_9 + (0.086390994489192963) * gru_0_out_t0_10 + (0.8817746639251709) * gru_0_out_t0_11 + (0.57902133464813232) * gru_0_out_t0_12 + (0.47277897596359253) * gru_0_out_t0_13 + (-0.17971764504909515) * gru_0_out_t0_14 + (-0.17547816038131714) * gru_0_out_t0_15 + (-0.71430480480194092) * gru_0_out_t0_16 + (-0.29133647680282593) * gru_0_out_t0_17 + (-0.55194449424743652) * gru_0_out_t0_18 + (0.21053537726402283) * gru_0_out_t0_19 + (-0.26442909240722656) * gru_0_out_t0_20 + (-0.52147918939590454) * gru_0_out_t0_21 + (1.3325002193450928) * gru_0_out_t0_22 + (0.39015597105026245) * gru_0_out_t0_23 + (-0.67202019691467285) * gru_0_out_t0_24 + (0.26101630926132202) * gru_0_out_t0_25 + (-0.29688945412635803) * gru_0_out_t0_26 + (-0.080816082656383514) * gru_0_out_t0_27 + (-0.59967899322509766) * gru_0_out_t0_28 + (-0.40994894504547119) * gru_0_out_t0_29 + (-0.41906729340553284) * gru_0_out_t0_30 + (0.49658608436584473) * gru_0_out_t0_31 + (0.20803818106651306) * gru_0_out_t0_32 + (0.60312503576278687) * gru_0_out_t0_33 + (-0.64511257410049438) * gru_0_out_t0_34 + (0.60894322395324707) * gru_0_out_t0_35 + (0.03946923092007637) * gru_0_out_t0_36 + (0.64040940999984741) * gru_0_out_t0_37 + (-0.93286794424057007) * gru_0_out_t0_38 + (0.66182368993759155) * gru_0_out_t0_39 + (-1.2056287527084351) * gru_0_out_t0_40 + (0.1129717230796814) * gru_0_out_t0_41 + (-0.29094836115837097) * gru_0_out_t0_42 + (0.51638734340667725) * gru_0_out_t0_43 + (0.18743318319320679) * gru_0_out_t0_44 + (0.45757043361663818) * gru_0_out_t0_45 + (-0.57211065292358398) * gru_0_out_t0_46 + (0.10660050064325333) * gru_0_out_t0_47 + (-1.232871413230896) * gru_0_out_t0_48 + (1.0074741840362549) * gru_0_out_t0_49 + (0.063570648431777954) * gru_0_out_t0_50 + (0.061976484954357147) * gru_0_out_t0_51 + (-0.69260138273239136) * gru_0_out_t0_52 + (-0.20531193912029266) * gru_0_out_t0_53 + (-0.50036275386810303) * gru_0_out_t0_54 + (-0.60572916269302368) * gru_0_out_t0_55 + (-0.67944574356079102) * gru_0_out_t0_56 + (0.83759164810180664) * gru_0_out_t0_57 + (-0.73686110973358154) * gru_0_out_t0_58 + (-0.20659460127353668) * gru_0_out_t0_59 + (-0.02800990454852581) * gru_0_out_t0_60 + (0.01516045443713665) * gru_0_out_t0_61 + (0.48323273658752441) * gru_0_out_t0_62 + (0.76625287532806396) * gru_0_out_t0_63 + (0.099508784711360931) * gru_1_rev_t1_h_0 + (-1.3618769645690918) * gru_1_rev_t1_h_1 + (0.065173648297786713) * gru_1_rev_t1_h_2 + (-0.14201250672340393) * gru_1_rev_t1_h_3 + (-0.061520278453826904) * gru_1_rev_t1_h_4 + (0.33167138695716858) * gru_1_rev_t1_h_5 + (0.17380152642726898) * gru_1_rev_t1_h_6 + (-0.20220443606376648) * gru_1_rev_t1_h_7 + (0.45311969518661499) * gru_1_rev_t1_h_8 + (-0.26905596256256104) * gru_1_rev_t1_h_9 + (-0.024499474093317986) * gru_1_rev_t1_h_10 + (-2.0325255393981934) * gru_1_rev_t1_h_11 + (-0.31836938858032227) * gru_1_rev_t1_h_12 + (0.030792174860835075) * gru_1_rev_t1_h_13 + (0.8863903284072876) * gru_1_rev_t1_h_14 + (0.10081630200147629) * gru_1_rev_t1_h_15 + (-0.6059577465057373) * gru_1_rev_t1_h_16 + (1.5948694944381714) * gru_1_rev_t1_h_17 + (-1.1538759469985962) * gru_1_rev_t1_h_18 + (-0.80618560314178467) * gru_1_rev_t1_h_19 + (1.473909854888916) * gru_1_rev_t1_h_20 + (0.33381643891334534) * gru_1_rev_t1_h_21 + (-0.15630848705768585) * gru_1_rev_t1_h_22 + (-0.053244136273860931) * gru_1_rev_t1_h_23 + (0.78525352478027344) * gru_1_rev_t1_h_24 + (-0.45765280723571777) * gru_1_rev_t1_h_25 + (0.81158959865570068) * gru_1_rev_t1_h_26 + (0.94486182928085327) * gru_1_rev_t1_h_27 + (1.6752870082855225) * gru_1_rev_t1_h_28 + (2.0662314891815186) * gru_1_rev_t1_h_29 + (0.45708742737770081) * gru_1_rev_t1_h_30 + (0.34803721308708191) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.28034630417823792) + (-0.28375720977783203) * gru_0_out_t0_0 + (0.1253301203250885) * gru_0_out_t0_1 + (0.62009209394454956) * gru_0_out_t0_2 + (-0.41611015796661377) * gru_0_out_t0_3 + (-0.40418076515197754) * gru_0_out_t0_4 + (0.32010146975517273) * gru_0_out_t0_5 + (-0.21222396194934845) * gru_0_out_t0_6 + (0.21945288777351379) * gru_0_out_t0_7 + (-0.1058482900261879) * gru_0_out_t0_8 + (-0.80151110887527466) * gru_0_out_t0_9 + (-0.39157584309577942) * gru_0_out_t0_10 + (0.064073987305164337) * gru_0_out_t0_11 + (-0.038563944399356842) * gru_0_out_t0_12 + (0.12440196424722672) * gru_0_out_t0_13 + (-0.12557134032249451) * gru_0_out_t0_14 + (0.22077280282974243) * gru_0_out_t0_15 + (0.82181590795516968) * gru_0_out_t0_16 + (0.074750788509845734) * gru_0_out_t0_17 + (0.011940616182982922) * gru_0_out_t0_18 + (0.054791923612356186) * gru_0_out_t0_19 + (-0.25837510824203491) * gru_0_out_t0_20 + (1.2398819923400879) * gru_0_out_t0_21 + (-0.49060541391372681) * gru_0_out_t0_22 + (0.31573206186294556) * gru_0_out_t0_23 + (-0.16863314807415009) * gru_0_out_t0_24 + (-0.51857376098632812) * gru_0_out_t0_25 + (0.090805232524871826) * gru_0_out_t0_26 + (0.20969147980213165) * gru_0_out_t0_27 + (0.92931431531906128) * gru_0_out_t0_28 + (-0.43672165274620056) * gru_0_out_t0_29 + (-0.31509658694267273) * gru_0_out_t0_30 + (-0.37239921092987061) * gru_0_out_t0_31 + (-2.1655068397521973) * gru_0_out_t0_32 + (0.038771104067564011) * gru_0_out_t0_33 + (-0.22815290093421936) * gru_0_out_t0_34 + (0.090722247958183289) * gru_0_out_t0_35 + (-0.22529050707817078) * gru_0_out_t0_36 + (0.17051719129085541) * gru_0_out_t0_37 + (-0.18470057845115662) * gru_0_out_t0_38 + (0.17501306533813477) * gru_0_out_t0_39 + (0.42377099394798279) * gru_0_out_t0_40 + (-0.045453093945980072) * gru_0_out_t0_41 + (0.2568720281124115) * gru_0_out_t0_42 + (0.24731408059597015) * gru_0_out_t0_43 + (0.21805037558078766) * gru_0_out_t0_44 + (0.15108148753643036) * gru_0_out_t0_45 + (-0.36843952536582947) * gru_0_out_t0_46 + (0.87918061017990112) * gru_0_out_t0_47 + (0.4427478015422821) * gru_0_out_t0_48 + (-0.22284023463726044) * gru_0_out_t0_49 + (-0.161911740899086) * gru_0_out_t0_50 + (0.2422240823507309) * gru_0_out_t0_51 + (-0.15053319931030273) * gru_0_out_t0_52 + (-0.47175455093383789) * gru_0_out_t0_53 + (0.12543170154094696) * gru_0_out_t0_54 + (0.42181968688964844) * gru_0_out_t0_55 + (0.17265407741069794) * gru_0_out_t0_56 + (-0.10747390240430832) * gru_0_out_t0_57 + (0.13929717242717743) * gru_0_out_t0_58 + (0.70636749267578125) * gru_0_out_t0_59 + (1.200871467590332) * gru_0_out_t0_60 + (0.53607618808746338) * gru_0_out_t0_61 + (-0.070430479943752289) * gru_0_out_t0_62 + (0.19666442275047302) * gru_0_out_t0_63 + gate_r * ((-1.1407738924026489) + (-0.00085304881213232875) * gru_1_rev_t1_h_0 + (-2.319636344909668) * gru_1_rev_t1_h_1 + (-0.62085628509521484) * gru_1_rev_t1_h_2 + (-0.41425246000289917) * gru_1_rev_t1_h_3 + (2.2106914520263672) * gru_1_rev_t1_h_4 + (-1.5881928205490112) * gru_1_rev_t1_h_5 + (-0.1892477422952652) * gru_1_rev_t1_h_6 + (0.69059610366821289) * gru_1_rev_t1_h_7 + (1.5618783235549927) * gru_1_rev_t1_h_8 + (-0.3187943696975708) * gru_1_rev_t1_h_9 + (0.97717094421386719) * gru_1_rev_t1_h_10 + (0.18814530968666077) * gru_1_rev_t1_h_11 + (0.1731199324131012) * gru_1_rev_t1_h_12 + (-0.84766441583633423) * gru_1_rev_t1_h_13 + (0.097641982138156891) * gru_1_rev_t1_h_14 + (-0.57023352384567261) * gru_1_rev_t1_h_15 + (0.74774265289306641) * gru_1_rev_t1_h_16 + (-0.25913158059120178) * gru_1_rev_t1_h_17 + (-0.14387746155261993) * gru_1_rev_t1_h_18 + (0.095663242042064667) * gru_1_rev_t1_h_19 + (-3.4808173179626465) * gru_1_rev_t1_h_20 + (0.2416793555021286) * gru_1_rev_t1_h_21 + (0.3666224479675293) * gru_1_rev_t1_h_22 + (-1.3354686498641968) * gru_1_rev_t1_h_23 + (0.028191935271024704) * gru_1_rev_t1_h_24 + (0.3738141655921936) * gru_1_rev_t1_h_25 + (0.31033983826637268) * gru_1_rev_t1_h_26 + (-2.2039446830749512) * gru_1_rev_t1_h_27 + (-0.73193562030792236) * gru_1_rev_t1_h_28 + (0.18202416598796844) * gru_1_rev_t1_h_29 + (0.93597424030303955) * gru_1_rev_t1_h_30 + (1.4967637062072754) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_15 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_15;
    // h=16
    gate_r = sigmoid((-0.40385925769805908) + (-0.19056916236877441) * gru_0_out_t0_0 + (-0.040529105812311172) * gru_0_out_t0_1 + (0.82251131534576416) * gru_0_out_t0_2 + (-2.4945104122161865) * gru_0_out_t0_3 + (1.0464355945587158) * gru_0_out_t0_4 + (-0.79890638589859009) * gru_0_out_t0_5 + (-2.4342277050018311) * gru_0_out_t0_6 + (-0.13128486275672913) * gru_0_out_t0_7 + (0.79072427749633789) * gru_0_out_t0_8 + (1.3650590181350708) * gru_0_out_t0_9 + (-0.38055709004402161) * gru_0_out_t0_10 + (0.039253409951925278) * gru_0_out_t0_11 + (-0.77065521478652954) * gru_0_out_t0_12 + (0.12069187313318253) * gru_0_out_t0_13 + (-0.049526020884513855) * gru_0_out_t0_14 + (-1.7804732322692871) * gru_0_out_t0_15 + (1.343528151512146) * gru_0_out_t0_16 + (0.35952088236808777) * gru_0_out_t0_17 + (-0.02160460501909256) * gru_0_out_t0_18 + (0.91316843032836914) * gru_0_out_t0_19 + (0.18083611130714417) * gru_0_out_t0_20 + (2.8002610206604004) * gru_0_out_t0_21 + (0.12944439053535461) * gru_0_out_t0_22 + (-0.3571220338344574) * gru_0_out_t0_23 + (1.8206546306610107) * gru_0_out_t0_24 + (0.89954769611358643) * gru_0_out_t0_25 + (-0.10546304285526276) * gru_0_out_t0_26 + (-1.6504917144775391) * gru_0_out_t0_27 + (-1.2711321115493774) * gru_0_out_t0_28 + (0.18225724995136261) * gru_0_out_t0_29 + (0.24751321971416473) * gru_0_out_t0_30 + (-0.78882324695587158) * gru_0_out_t0_31 + (-3.1962683200836182) * gru_0_out_t0_32 + (-0.50320291519165039) * gru_0_out_t0_33 + (-0.44341471791267395) * gru_0_out_t0_34 + (0.43858391046524048) * gru_0_out_t0_35 + (0.26022240519523621) * gru_0_out_t0_36 + (-0.27681946754455566) * gru_0_out_t0_37 + (0.65182048082351685) * gru_0_out_t0_38 + (-0.020564772188663483) * gru_0_out_t0_39 + (0.75324046611785889) * gru_0_out_t0_40 + (-0.85187774896621704) * gru_0_out_t0_41 + (0.78370571136474609) * gru_0_out_t0_42 + (0.29261231422424316) * gru_0_out_t0_43 + (-0.14714686572551727) * gru_0_out_t0_44 + (-1.0607786178588867) * gru_0_out_t0_45 + (-1.5238769054412842) * gru_0_out_t0_46 + (0.87058806419372559) * gru_0_out_t0_47 + (0.43038040399551392) * gru_0_out_t0_48 + (-0.45924076437950134) * gru_0_out_t0_49 + (-0.80867111682891846) * gru_0_out_t0_50 + (-0.28723543882369995) * gru_0_out_t0_51 + (0.32373145222663879) * gru_0_out_t0_52 + (-0.063979901373386383) * gru_0_out_t0_53 + (-0.14467145502567291) * gru_0_out_t0_54 + (-0.65791410207748413) * gru_0_out_t0_55 + (0.60978657007217407) * gru_0_out_t0_56 + (-0.48486226797103882) * gru_0_out_t0_57 + (0.44036969542503357) * gru_0_out_t0_58 + (0.18189418315887451) * gru_0_out_t0_59 + (0.57297945022583008) * gru_0_out_t0_60 + (-0.10447638481855392) * gru_0_out_t0_61 + (0.54950618743896484) * gru_0_out_t0_62 + (-1.4233361482620239) * gru_0_out_t0_63 + (0.72381174564361572) * gru_1_rev_t1_h_0 + (2.176422119140625) * gru_1_rev_t1_h_1 + (-0.69861608743667603) * gru_1_rev_t1_h_2 + (0.9821392297744751) * gru_1_rev_t1_h_3 + (-2.2215206623077393) * gru_1_rev_t1_h_4 + (-0.97946542501449585) * gru_1_rev_t1_h_5 + (-0.35345184803009033) * gru_1_rev_t1_h_6 + (-1.2186390161514282) * gru_1_rev_t1_h_7 + (-0.33158141374588013) * gru_1_rev_t1_h_8 + (-0.27361631393432617) * gru_1_rev_t1_h_9 + (0.35438689589500427) * gru_1_rev_t1_h_10 + (-1.8349697589874268) * gru_1_rev_t1_h_11 + (-0.31376984715461731) * gru_1_rev_t1_h_12 + (1.1908612251281738) * gru_1_rev_t1_h_13 + (-0.04279540479183197) * gru_1_rev_t1_h_14 + (-0.21044677495956421) * gru_1_rev_t1_h_15 + (1.6566023826599121) * gru_1_rev_t1_h_16 + (1.3253762722015381) * gru_1_rev_t1_h_17 + (0.59199988842010498) * gru_1_rev_t1_h_18 + (-0.47315433621406555) * gru_1_rev_t1_h_19 + (-1.0910143852233887) * gru_1_rev_t1_h_20 + (-0.37448042631149292) * gru_1_rev_t1_h_21 + (0.29076635837554932) * gru_1_rev_t1_h_22 + (-0.073005281388759613) * gru_1_rev_t1_h_23 + (-0.73827123641967773) * gru_1_rev_t1_h_24 + (0.074098967015743256) * gru_1_rev_t1_h_25 + (-1.1841049194335938) * gru_1_rev_t1_h_26 + (-0.50232279300689697) * gru_1_rev_t1_h_27 + (0.54625219106674194) * gru_1_rev_t1_h_28 + (-0.63101202249526978) * gru_1_rev_t1_h_29 + (1.4679021835327148) * gru_1_rev_t1_h_30 + (-0.36145034432411194) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.57988220453262329) + (-0.21693186461925507) * gru_0_out_t0_0 + (0.1488494873046875) * gru_0_out_t0_1 + (0.53410071134567261) * gru_0_out_t0_2 + (0.20869718492031097) * gru_0_out_t0_3 + (-0.10384370386600494) * gru_0_out_t0_4 + (-0.03397100418806076) * gru_0_out_t0_5 + (-0.46905949711799622) * gru_0_out_t0_6 + (0.97145330905914307) * gru_0_out_t0_7 + (-0.17810654640197754) * gru_0_out_t0_8 + (0.16547642648220062) * gru_0_out_t0_9 + (-0.32255932688713074) * gru_0_out_t0_10 + (0.15726543962955475) * gru_0_out_t0_11 + (-0.19458980858325958) * gru_0_out_t0_12 + (0.58761429786682129) * gru_0_out_t0_13 + (-0.14564372599124908) * gru_0_out_t0_14 + (-0.36928868293762207) * gru_0_out_t0_15 + (-0.54202985763549805) * gru_0_out_t0_16 + (-0.19088089466094971) * gru_0_out_t0_17 + (0.26961743831634521) * gru_0_out_t0_18 + (0.3311760425567627) * gru_0_out_t0_19 + (0.31020963191986084) * gru_0_out_t0_20 + (-0.25863903760910034) * gru_0_out_t0_21 + (1.0270401239395142) * gru_0_out_t0_22 + (0.39626970887184143) * gru_0_out_t0_23 + (-0.89023309946060181) * gru_0_out_t0_24 + (-1.1271336078643799) * gru_0_out_t0_25 + (0.453023761510849) * gru_0_out_t0_26 + (0.147971510887146) * gru_0_out_t0_27 + (-0.30280712246894836) * gru_0_out_t0_28 + (0.45705434679985046) * gru_0_out_t0_29 + (0.30927988886833191) * gru_0_out_t0_30 + (-0.49188673496246338) * gru_0_out_t0_31 + (-0.31653869152069092) * gru_0_out_t0_32 + (-0.027519812807440758) * gru_0_out_t0_33 + (0.10475680232048035) * gru_0_out_t0_34 + (0.18204799294471741) * gru_0_out_t0_35 + (0.15570703148841858) * gru_0_out_t0_36 + (0.8276631236076355) * gru_0_out_t0_37 + (-0.26887872815132141) * gru_0_out_t0_38 + (1.3384737968444824) * gru_0_out_t0_39 + (-0.35139158368110657) * gru_0_out_t0_40 + (-0.16068819165229797) * gru_0_out_t0_41 + (1.5475722551345825) * gru_0_out_t0_42 + (0.095709152519702911) * gru_0_out_t0_43 + (0.25375205278396606) * gru_0_out_t0_44 + (-0.050397597253322601) * gru_0_out_t0_45 + (-0.92746919393539429) * gru_0_out_t0_46 + (0.1209055632352829) * gru_0_out_t0_47 + (0.51284027099609375) * gru_0_out_t0_48 + (-0.20292896032333374) * gru_0_out_t0_49 + (0.41928768157958984) * gru_0_out_t0_50 + (-0.2721254825592041) * gru_0_out_t0_51 + (0.3830828070640564) * gru_0_out_t0_52 + (0.23477780818939209) * gru_0_out_t0_53 + (0.50941181182861328) * gru_0_out_t0_54 + (-0.089572511613368988) * gru_0_out_t0_55 + (0.61348056793212891) * gru_0_out_t0_56 + (-0.38686642050743103) * gru_0_out_t0_57 + (-0.036189470440149307) * gru_0_out_t0_58 + (-0.20263336598873138) * gru_0_out_t0_59 + (0.11454407870769501) * gru_0_out_t0_60 + (0.74444657564163208) * gru_0_out_t0_61 + (0.76675510406494141) * gru_0_out_t0_62 + (-0.43409499526023865) * gru_0_out_t0_63 + (0.15173999965190887) * gru_1_rev_t1_h_0 + (-0.83437776565551758) * gru_1_rev_t1_h_1 + (0.21262861788272858) * gru_1_rev_t1_h_2 + (0.17501889169216156) * gru_1_rev_t1_h_3 + (0.24165132641792297) * gru_1_rev_t1_h_4 + (-1.7972927093505859) * gru_1_rev_t1_h_5 + (0.025459196418523788) * gru_1_rev_t1_h_6 + (0.42487689852714539) * gru_1_rev_t1_h_7 + (0.21671022474765778) * gru_1_rev_t1_h_8 + (-0.10112752765417099) * gru_1_rev_t1_h_9 + (0.079692691564559937) * gru_1_rev_t1_h_10 + (-0.81690794229507446) * gru_1_rev_t1_h_11 + (0.26989847421646118) * gru_1_rev_t1_h_12 + (0.16245505213737488) * gru_1_rev_t1_h_13 + (-0.47219473123550415) * gru_1_rev_t1_h_14 + (0.14482748508453369) * gru_1_rev_t1_h_15 + (-0.41643249988555908) * gru_1_rev_t1_h_16 + (-2.3370475769042969) * gru_1_rev_t1_h_17 + (0.33579158782958984) * gru_1_rev_t1_h_18 + (0.68052345514297485) * gru_1_rev_t1_h_19 + (-0.78640419244766235) * gru_1_rev_t1_h_20 + (-0.56320863962173462) * gru_1_rev_t1_h_21 + (0.29901942610740662) * gru_1_rev_t1_h_22 + (-0.063657894730567932) * gru_1_rev_t1_h_23 + (0.27299976348876953) * gru_1_rev_t1_h_24 + (0.56483358144760132) * gru_1_rev_t1_h_25 + (-0.056745432317256927) * gru_1_rev_t1_h_26 + (-0.33472833037376404) * gru_1_rev_t1_h_27 + (-1.5371559858322144) * gru_1_rev_t1_h_28 + (-0.91868287324905396) * gru_1_rev_t1_h_29 + (0.032674897462129593) * gru_1_rev_t1_h_30 + (0.51346397399902344) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.16687101125717163) + (-0.16185379028320312) * gru_0_out_t0_0 + (0.33224537968635559) * gru_0_out_t0_1 + (0.067100226879119873) * gru_0_out_t0_2 + (0.61550378799438477) * gru_0_out_t0_3 + (0.82396554946899414) * gru_0_out_t0_4 + (-1.0709521770477295) * gru_0_out_t0_5 + (0.31438404321670532) * gru_0_out_t0_6 + (0.55568921566009521) * gru_0_out_t0_7 + (0.78195250034332275) * gru_0_out_t0_8 + (0.47761204838752747) * gru_0_out_t0_9 + (0.11514594405889511) * gru_0_out_t0_10 + (1.0892854928970337) * gru_0_out_t0_11 + (0.28379765152931213) * gru_0_out_t0_12 + (0.075282774865627289) * gru_0_out_t0_13 + (-0.64476656913757324) * gru_0_out_t0_14 + (0.26431912183761597) * gru_0_out_t0_15 + (0.71232855319976807) * gru_0_out_t0_16 + (0.21489760279655457) * gru_0_out_t0_17 + (-0.22436267137527466) * gru_0_out_t0_18 + (0.14282378554344177) * gru_0_out_t0_19 + (0.62041199207305908) * gru_0_out_t0_20 + (1.3187369108200073) * gru_0_out_t0_21 + (0.92351102828979492) * gru_0_out_t0_22 + (-0.5967528223991394) * gru_0_out_t0_23 + (-0.36735093593597412) * gru_0_out_t0_24 + (0.5647309422492981) * gru_0_out_t0_25 + (-0.035634748637676239) * gru_0_out_t0_26 + (-1.0368481874465942) * gru_0_out_t0_27 + (-0.12299077957868576) * gru_0_out_t0_28 + (0.35461756587028503) * gru_0_out_t0_29 + (0.36864644289016724) * gru_0_out_t0_30 + (-0.35495498776435852) * gru_0_out_t0_31 + (-0.21914319694042206) * gru_0_out_t0_32 + (-0.19323134422302246) * gru_0_out_t0_33 + (-0.013354081660509109) * gru_0_out_t0_34 + (0.11511501669883728) * gru_0_out_t0_35 + (-0.27835491299629211) * gru_0_out_t0_36 + (0.50314700603485107) * gru_0_out_t0_37 + (-0.05962425097823143) * gru_0_out_t0_38 + (-0.48435461521148682) * gru_0_out_t0_39 + (-0.40078175067901611) * gru_0_out_t0_40 + (-0.91777998208999634) * gru_0_out_t0_41 + (0.43784347176551819) * gru_0_out_t0_42 + (-0.17940615117549896) * gru_0_out_t0_43 + (-0.30672299861907959) * gru_0_out_t0_44 + (0.0096668517217040062) * gru_0_out_t0_45 + (-0.18379616737365723) * gru_0_out_t0_46 + (0.16606619954109192) * gru_0_out_t0_47 + (0.51083821058273315) * gru_0_out_t0_48 + (-0.38505095243453979) * gru_0_out_t0_49 + (-0.27209386229515076) * gru_0_out_t0_50 + (-0.47472718358039856) * gru_0_out_t0_51 + (0.58448582887649536) * gru_0_out_t0_52 + (0.1832723468542099) * gru_0_out_t0_53 + (-0.17374420166015625) * gru_0_out_t0_54 + (0.42756021022796631) * gru_0_out_t0_55 + (1.1190783977508545) * gru_0_out_t0_56 + (-0.38588923215866089) * gru_0_out_t0_57 + (0.41310217976570129) * gru_0_out_t0_58 + (0.49192497134208679) * gru_0_out_t0_59 + (0.19976599514484406) * gru_0_out_t0_60 + (-0.17201313376426697) * gru_0_out_t0_61 + (-0.43440777063369751) * gru_0_out_t0_62 + (0.058129105716943741) * gru_0_out_t0_63 + gate_r * ((0.083923175930976868) + (-1.0966273546218872) * gru_1_rev_t1_h_0 + (-1.0869531631469727) * gru_1_rev_t1_h_1 + (1.703346848487854) * gru_1_rev_t1_h_2 + (-1.8014489412307739) * gru_1_rev_t1_h_3 + (1.3282082080841064) * gru_1_rev_t1_h_4 + (-0.67220836877822876) * gru_1_rev_t1_h_5 + (-1.031781792640686) * gru_1_rev_t1_h_6 + (0.7077479362487793) * gru_1_rev_t1_h_7 + (-1.0578169822692871) * gru_1_rev_t1_h_8 + (-0.13524821400642395) * gru_1_rev_t1_h_9 + (0.075925491750240326) * gru_1_rev_t1_h_10 + (0.63981640338897705) * gru_1_rev_t1_h_11 + (-0.87738227844238281) * gru_1_rev_t1_h_12 + (-1.8171740770339966) * gru_1_rev_t1_h_13 + (-0.58148878812789917) * gru_1_rev_t1_h_14 + (-0.44741570949554443) * gru_1_rev_t1_h_15 + (-0.72601884603500366) * gru_1_rev_t1_h_16 + (-1.0446200370788574) * gru_1_rev_t1_h_17 + (-0.39515799283981323) * gru_1_rev_t1_h_18 + (-0.38756921887397766) * gru_1_rev_t1_h_19 + (0.85246831178665161) * gru_1_rev_t1_h_20 + (0.083941899240016937) * gru_1_rev_t1_h_21 + (-0.96433407068252563) * gru_1_rev_t1_h_22 + (-0.028998443856835365) * gru_1_rev_t1_h_23 + (0.5600854754447937) * gru_1_rev_t1_h_24 + (-0.38318762183189392) * gru_1_rev_t1_h_25 + (1.8170571327209473) * gru_1_rev_t1_h_26 + (-0.47875463962554932) * gru_1_rev_t1_h_27 + (0.53021949529647827) * gru_1_rev_t1_h_28 + (1.0238738059997559) * gru_1_rev_t1_h_29 + (0.41586849093437195) * gru_1_rev_t1_h_30 + (1.1776013374328613) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_16 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_16;
    // h=17
    gate_r = sigmoid((-0.12562324106693268) + (0.085653685033321381) * gru_0_out_t0_0 + (0.55698984861373901) * gru_0_out_t0_1 + (0.89399755001068115) * gru_0_out_t0_2 + (-0.76996690034866333) * gru_0_out_t0_3 + (-0.46835541725158691) * gru_0_out_t0_4 + (1.9941030740737915) * gru_0_out_t0_5 + (0.51716947555541992) * gru_0_out_t0_6 + (-0.53569412231445312) * gru_0_out_t0_7 + (0.3786281943321228) * gru_0_out_t0_8 + (-1.098930835723877) * gru_0_out_t0_9 + (-0.84516280889511108) * gru_0_out_t0_10 + (-0.1795736700296402) * gru_0_out_t0_11 + (-0.05866386741399765) * gru_0_out_t0_12 + (0.40251424908638) * gru_0_out_t0_13 + (0.69272232055664062) * gru_0_out_t0_14 + (0.36360850930213928) * gru_0_out_t0_15 + (-0.069185473024845123) * gru_0_out_t0_16 + (-0.20157048106193542) * gru_0_out_t0_17 + (-0.47928574681282043) * gru_0_out_t0_18 + (-1.1660399436950684) * gru_0_out_t0_19 + (0.56121730804443359) * gru_0_out_t0_20 + (-4.0058603286743164) * gru_0_out_t0_21 + (1.6947810649871826) * gru_0_out_t0_22 + (-1.1090716123580933) * gru_0_out_t0_23 + (-1.8029855489730835) * gru_0_out_t0_24 + (-1.1732122898101807) * gru_0_out_t0_25 + (0.3174934983253479) * gru_0_out_t0_26 + (2.9602794647216797) * gru_0_out_t0_27 + (-0.65762954950332642) * gru_0_out_t0_28 + (-0.34224909543991089) * gru_0_out_t0_29 + (-0.28384709358215332) * gru_0_out_t0_30 + (1.3211969137191772) * gru_0_out_t0_31 + (0.017934616655111313) * gru_0_out_t0_32 + (-0.18890306353569031) * gru_0_out_t0_33 + (0.20527030527591705) * gru_0_out_t0_34 + (-0.2113373726606369) * gru_0_out_t0_35 + (-0.10468214750289917) * gru_0_out_t0_36 + (-0.12541338801383972) * gru_0_out_t0_37 + (0.28206655383110046) * gru_0_out_t0_38 + (0.1706228107213974) * gru_0_out_t0_39 + (-3.8478071689605713) * gru_0_out_t0_40 + (0.53446274995803833) * gru_0_out_t0_41 + (-0.62497556209564209) * gru_0_out_t0_42 + (0.082209385931491852) * gru_0_out_t0_43 + (0.55138599872589111) * gru_0_out_t0_44 + (0.073295123875141144) * gru_0_out_t0_45 + (-0.53786200284957886) * gru_0_out_t0_46 + (0.077682346105575562) * gru_0_out_t0_47 + (0.14706458151340485) * gru_0_out_t0_48 + (0.040437053889036179) * gru_0_out_t0_49 + (-0.88880771398544312) * gru_0_out_t0_50 + (0.27513983845710754) * gru_0_out_t0_51 + (-0.043255645781755447) * gru_0_out_t0_52 + (0.21940380334854126) * gru_0_out_t0_53 + (0.48417413234710693) * gru_0_out_t0_54 + (-0.46986132860183716) * gru_0_out_t0_55 + (1.0513864755630493) * gru_0_out_t0_56 + (0.45130595564842224) * gru_0_out_t0_57 + (-0.69930964708328247) * gru_0_out_t0_58 + (-0.58879989385604858) * gru_0_out_t0_59 + (1.3638644218444824) * gru_0_out_t0_60 + (0.88145828247070312) * gru_0_out_t0_61 + (0.29753684997558594) * gru_0_out_t0_62 + (0.10217323154211044) * gru_0_out_t0_63 + (-0.15655273199081421) * gru_1_rev_t1_h_0 + (0.5737464427947998) * gru_1_rev_t1_h_1 + (-1.5565861463546753) * gru_1_rev_t1_h_2 + (0.097126878798007965) * gru_1_rev_t1_h_3 + (-0.69745403528213501) * gru_1_rev_t1_h_4 + (-0.38533663749694824) * gru_1_rev_t1_h_5 + (0.14681960642337799) * gru_1_rev_t1_h_6 + (-0.025948861613869667) * gru_1_rev_t1_h_7 + (-0.84887731075286865) * gru_1_rev_t1_h_8 + (0.78570222854614258) * gru_1_rev_t1_h_9 + (0.37431558966636658) * gru_1_rev_t1_h_10 + (-0.4314027726650238) * gru_1_rev_t1_h_11 + (-1.2382627725601196) * gru_1_rev_t1_h_12 + (-1.8706547021865845) * gru_1_rev_t1_h_13 + (-0.84809082746505737) * gru_1_rev_t1_h_14 + (0.72613650560379028) * gru_1_rev_t1_h_15 + (1.2359704971313477) * gru_1_rev_t1_h_16 + (0.61504560708999634) * gru_1_rev_t1_h_17 + (0.076656349003314972) * gru_1_rev_t1_h_18 + (0.90752506256103516) * gru_1_rev_t1_h_19 + (1.2712963819503784) * gru_1_rev_t1_h_20 + (0.70427954196929932) * gru_1_rev_t1_h_21 + (0.27350074052810669) * gru_1_rev_t1_h_22 + (0.15620376169681549) * gru_1_rev_t1_h_23 + (-1.1131113767623901) * gru_1_rev_t1_h_24 + (0.64701932668685913) * gru_1_rev_t1_h_25 + (0.98734402656555176) * gru_1_rev_t1_h_26 + (-0.70867437124252319) * gru_1_rev_t1_h_27 + (-1.7930513620376587) * gru_1_rev_t1_h_28 + (-0.32310894131660461) * gru_1_rev_t1_h_29 + (2.825592041015625) * gru_1_rev_t1_h_30 + (0.70474916696548462) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.456319659948349) + (-0.053165104240179062) * gru_0_out_t0_0 + (-0.90152430534362793) * gru_0_out_t0_1 + (0.19806905090808868) * gru_0_out_t0_2 + (-1.1520562171936035) * gru_0_out_t0_3 + (-0.46261200308799744) * gru_0_out_t0_4 + (0.065652325749397278) * gru_0_out_t0_5 + (0.1550067812204361) * gru_0_out_t0_6 + (-0.52493453025817871) * gru_0_out_t0_7 + (0.29718217253684998) * gru_0_out_t0_8 + (0.089924879372119904) * gru_0_out_t0_9 + (-0.20680534839630127) * gru_0_out_t0_10 + (0.27234578132629395) * gru_0_out_t0_11 + (0.28782707452774048) * gru_0_out_t0_12 + (0.67073923349380493) * gru_0_out_t0_13 + (0.060374297201633453) * gru_0_out_t0_14 + (-0.33991909027099609) * gru_0_out_t0_15 + (-0.27202045917510986) * gru_0_out_t0_16 + (-0.22569744288921356) * gru_0_out_t0_17 + (-0.69002938270568848) * gru_0_out_t0_18 + (-0.27793538570404053) * gru_0_out_t0_19 + (0.18474416434764862) * gru_0_out_t0_20 + (-0.57669693231582642) * gru_0_out_t0_21 + (0.49824070930480957) * gru_0_out_t0_22 + (-0.54911923408508301) * gru_0_out_t0_23 + (-0.30262526869773865) * gru_0_out_t0_24 + (-0.75730103254318237) * gru_0_out_t0_25 + (-0.02945425733923912) * gru_0_out_t0_26 + (0.33043855428695679) * gru_0_out_t0_27 + (0.41105958819389343) * gru_0_out_t0_28 + (-0.91633987426757812) * gru_0_out_t0_29 + (0.3194638192653656) * gru_0_out_t0_30 + (-0.66543745994567871) * gru_0_out_t0_31 + (0.49333035945892334) * gru_0_out_t0_32 + (0.59869241714477539) * gru_0_out_t0_33 + (0.17675408720970154) * gru_0_out_t0_34 + (-1.2984439134597778) * gru_0_out_t0_35 + (0.11140664666891098) * gru_0_out_t0_36 + (-0.50277054309844971) * gru_0_out_t0_37 + (-0.44644579291343689) * gru_0_out_t0_38 + (1.4768627882003784) * gru_0_out_t0_39 + (0.49128583073616028) * gru_0_out_t0_40 + (0.16697733104228973) * gru_0_out_t0_41 + (0.12081529200077057) * gru_0_out_t0_42 + (-0.64657092094421387) * gru_0_out_t0_43 + (0.41510647535324097) * gru_0_out_t0_44 + (-0.28649657964706421) * gru_0_out_t0_45 + (1.5185443162918091) * gru_0_out_t0_46 + (-0.47994884848594666) * gru_0_out_t0_47 + (-0.35347869992256165) * gru_0_out_t0_48 + (0.83813649415969849) * gru_0_out_t0_49 + (-0.58615052700042725) * gru_0_out_t0_50 + (-0.40006420016288757) * gru_0_out_t0_51 + (-0.58723604679107666) * gru_0_out_t0_52 + (0.24470843374729156) * gru_0_out_t0_53 + (0.23792020976543427) * gru_0_out_t0_54 + (1.4273512363433838) * gru_0_out_t0_55 + (0.14557042717933655) * gru_0_out_t0_56 + (0.18876749277114868) * gru_0_out_t0_57 + (-0.1819598525762558) * gru_0_out_t0_58 + (-0.87617325782775879) * gru_0_out_t0_59 + (-0.53376859426498413) * gru_0_out_t0_60 + (-0.44438394904136658) * gru_0_out_t0_61 + (-0.39132013916969299) * gru_0_out_t0_62 + (0.019674871116876602) * gru_0_out_t0_63 + (0.28357750177383423) * gru_1_rev_t1_h_0 + (-0.53439724445343018) * gru_1_rev_t1_h_1 + (0.4999714195728302) * gru_1_rev_t1_h_2 + (-0.56205904483795166) * gru_1_rev_t1_h_3 + (0.46378403902053833) * gru_1_rev_t1_h_4 + (-0.38404875993728638) * gru_1_rev_t1_h_5 + (0.39233610033988953) * gru_1_rev_t1_h_6 + (0.20558463037014008) * gru_1_rev_t1_h_7 + (0.39635440707206726) * gru_1_rev_t1_h_8 + (-0.37122815847396851) * gru_1_rev_t1_h_9 + (-1.3010674715042114) * gru_1_rev_t1_h_10 + (0.60369026660919189) * gru_1_rev_t1_h_11 + (0.33445525169372559) * gru_1_rev_t1_h_12 + (0.38464373350143433) * gru_1_rev_t1_h_13 + (-0.1654222309589386) * gru_1_rev_t1_h_14 + (0.2370111346244812) * gru_1_rev_t1_h_15 + (0.31826925277709961) * gru_1_rev_t1_h_16 + (-0.55039286613464355) * gru_1_rev_t1_h_17 + (0.0842147096991539) * gru_1_rev_t1_h_18 + (0.26231148838996887) * gru_1_rev_t1_h_19 + (0.024789242073893547) * gru_1_rev_t1_h_20 + (0.047480262815952301) * gru_1_rev_t1_h_21 + (0.38466411828994751) * gru_1_rev_t1_h_22 + (-0.19031469523906708) * gru_1_rev_t1_h_23 + (-0.16684268414974213) * gru_1_rev_t1_h_24 + (-0.13728383183479309) * gru_1_rev_t1_h_25 + (0.36996617913246155) * gru_1_rev_t1_h_26 + (0.064244344830513) * gru_1_rev_t1_h_27 + (0.42027795314788818) * gru_1_rev_t1_h_28 + (0.34072619676589966) * gru_1_rev_t1_h_29 + (0.19745628535747528) * gru_1_rev_t1_h_30 + (0.012161594815552235) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.021744035184383392) + (-0.40359112620353699) * gru_0_out_t0_0 + (-0.41215923428535461) * gru_0_out_t0_1 + (0.00083091401029378176) * gru_0_out_t0_2 + (-0.092819578945636749) * gru_0_out_t0_3 + (-0.3685615062713623) * gru_0_out_t0_4 + (0.41024619340896606) * gru_0_out_t0_5 + (0.55292856693267822) * gru_0_out_t0_6 + (-1.7605699300765991) * gru_0_out_t0_7 + (0.5288652777671814) * gru_0_out_t0_8 + (1.0981417894363403) * gru_0_out_t0_9 + (-0.35527917742729187) * gru_0_out_t0_10 + (0.48642995953559875) * gru_0_out_t0_11 + (0.630820631980896) * gru_0_out_t0_12 + (0.19456006586551666) * gru_0_out_t0_13 + (-0.14242862164974213) * gru_0_out_t0_14 + (0.50464069843292236) * gru_0_out_t0_15 + (0.82736307382583618) * gru_0_out_t0_16 + (0.56790900230407715) * gru_0_out_t0_17 + (-0.63468384742736816) * gru_0_out_t0_18 + (0.11186579614877701) * gru_0_out_t0_19 + (0.3852171003818512) * gru_0_out_t0_20 + (1.0459805727005005) * gru_0_out_t0_21 + (0.28240662813186646) * gru_0_out_t0_22 + (-0.82904142141342163) * gru_0_out_t0_23 + (-0.68013161420822144) * gru_0_out_t0_24 + (-0.95735698938369751) * gru_0_out_t0_25 + (-0.65955334901809692) * gru_0_out_t0_26 + (0.87021493911743164) * gru_0_out_t0_27 + (-0.24187551438808441) * gru_0_out_t0_28 + (0.027119511738419533) * gru_0_out_t0_29 + (0.06409144401550293) * gru_0_out_t0_30 + (0.51446539163589478) * gru_0_out_t0_31 + (-1.6347743272781372) * gru_0_out_t0_32 + (-0.28867796063423157) * gru_0_out_t0_33 + (-0.81366199254989624) * gru_0_out_t0_34 + (-0.48118531703948975) * gru_0_out_t0_35 + (-0.041077964007854462) * gru_0_out_t0_36 + (-0.18122559785842896) * gru_0_out_t0_37 + (-0.01555962860584259) * gru_0_out_t0_38 + (-0.17033618688583374) * gru_0_out_t0_39 + (-0.80921310186386108) * gru_0_out_t0_40 + (-0.42460495233535767) * gru_0_out_t0_41 + (-0.49632641673088074) * gru_0_out_t0_42 + (0.20794408023357391) * gru_0_out_t0_43 + (-0.013822947628796101) * gru_0_out_t0_44 + (-0.55236715078353882) * gru_0_out_t0_45 + (-0.14933794736862183) * gru_0_out_t0_46 + (0.78462624549865723) * gru_0_out_t0_47 + (0.25771194696426392) * gru_0_out_t0_48 + (-0.22510869801044464) * gru_0_out_t0_49 + (-0.58957201242446899) * gru_0_out_t0_50 + (-0.62846904993057251) * gru_0_out_t0_51 + (0.1579446941614151) * gru_0_out_t0_52 + (-0.3444327712059021) * gru_0_out_t0_53 + (-0.44831454753875732) * gru_0_out_t0_54 + (-0.63808614015579224) * gru_0_out_t0_55 + (0.95672601461410522) * gru_0_out_t0_56 + (-0.063316449522972107) * gru_0_out_t0_57 + (-0.033568147569894791) * gru_0_out_t0_58 + (0.73903316259384155) * gru_0_out_t0_59 + (0.43018826842308044) * gru_0_out_t0_60 + (-0.030467232689261436) * gru_0_out_t0_61 + (-1.1435807943344116) * gru_0_out_t0_62 + (-0.54714721441268921) * gru_0_out_t0_63 + gate_r * ((-0.0033705593086779118) + (0.081658743321895599) * gru_1_rev_t1_h_0 + (0.18087510764598846) * gru_1_rev_t1_h_1 + (0.10629068315029144) * gru_1_rev_t1_h_2 + (0.096840687096118927) * gru_1_rev_t1_h_3 + (-0.72921985387802124) * gru_1_rev_t1_h_4 + (-0.37482845783233643) * gru_1_rev_t1_h_5 + (0.33344593644142151) * gru_1_rev_t1_h_6 + (0.38709580898284912) * gru_1_rev_t1_h_7 + (0.24978254735469818) * gru_1_rev_t1_h_8 + (-0.66479337215423584) * gru_1_rev_t1_h_9 + (-0.30783209204673767) * gru_1_rev_t1_h_10 + (0.15430650115013123) * gru_1_rev_t1_h_11 + (0.035455342382192612) * gru_1_rev_t1_h_12 + (0.95935380458831787) * gru_1_rev_t1_h_13 + (0.17472760379314423) * gru_1_rev_t1_h_14 + (-0.52252089977264404) * gru_1_rev_t1_h_15 + (0.33442500233650208) * gru_1_rev_t1_h_16 + (-0.05582660436630249) * gru_1_rev_t1_h_17 + (0.54707324504852295) * gru_1_rev_t1_h_18 + (-0.81500446796417236) * gru_1_rev_t1_h_19 + (-0.043531283736228943) * gru_1_rev_t1_h_20 + (-0.38952159881591797) * gru_1_rev_t1_h_21 + (-2.0402779579162598) * gru_1_rev_t1_h_22 + (-0.40585491061210632) * gru_1_rev_t1_h_23 + (-0.45114293694496155) * gru_1_rev_t1_h_24 + (-1.0783288478851318) * gru_1_rev_t1_h_25 + (0.8104172945022583) * gru_1_rev_t1_h_26 + (0.50771242380142212) * gru_1_rev_t1_h_27 + (0.27107006311416626) * gru_1_rev_t1_h_28 + (0.282258540391922) * gru_1_rev_t1_h_29 + (0.11486905813217163) * gru_1_rev_t1_h_30 + (-0.0038436716422438622) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_17 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_17;
    // h=18
    gate_r = sigmoid((0.61203330755233765) + (0.4821237325668335) * gru_0_out_t0_0 + (0.40334579348564148) * gru_0_out_t0_1 + (0.23448024690151215) * gru_0_out_t0_2 + (0.2262008935213089) * gru_0_out_t0_3 + (0.15562672913074493) * gru_0_out_t0_4 + (1.5720562934875488) * gru_0_out_t0_5 + (0.14667554199695587) * gru_0_out_t0_6 + (-0.33666890859603882) * gru_0_out_t0_7 + (1.3710441589355469) * gru_0_out_t0_8 + (-0.58000081777572632) * gru_0_out_t0_9 + (-0.22435899078845978) * gru_0_out_t0_10 + (0.70514136552810669) * gru_0_out_t0_11 + (-0.38625150918960571) * gru_0_out_t0_12 + (-0.353934645652771) * gru_0_out_t0_13 + (0.2915242612361908) * gru_0_out_t0_14 + (-0.18665596842765808) * gru_0_out_t0_15 + (-0.47860419750213623) * gru_0_out_t0_16 + (0.092405945062637329) * gru_0_out_t0_17 + (2.2710304260253906) * gru_0_out_t0_18 + (-1.7421921491622925) * gru_0_out_t0_19 + (0.53033596277236938) * gru_0_out_t0_20 + (0.0069261835888028145) * gru_0_out_t0_21 + (-0.049546524882316589) * gru_0_out_t0_22 + (-3.1720190048217773) * gru_0_out_t0_23 + (-0.22844038903713226) * gru_0_out_t0_24 + (0.46105542778968811) * gru_0_out_t0_25 + (0.34316357970237732) * gru_0_out_t0_26 + (0.089707434177398682) * gru_0_out_t0_27 + (-1.0270612239837646) * gru_0_out_t0_28 + (-0.35210922360420227) * gru_0_out_t0_29 + (0.42349448800086975) * gru_0_out_t0_30 + (-0.54614931344985962) * gru_0_out_t0_31 + (0.27202489972114563) * gru_0_out_t0_32 + (-0.010376796126365662) * gru_0_out_t0_33 + (0.28476566076278687) * gru_0_out_t0_34 + (-0.43242612481117249) * gru_0_out_t0_35 + (-0.1799849271774292) * gru_0_out_t0_36 + (0.67205458879470825) * gru_0_out_t0_37 + (-0.30279546976089478) * gru_0_out_t0_38 + (-0.22818981111049652) * gru_0_out_t0_39 + (-0.16352148354053497) * gru_0_out_t0_40 + (-0.20758792757987976) * gru_0_out_t0_41 + (-0.69556093215942383) * gru_0_out_t0_42 + (-0.43218162655830383) * gru_0_out_t0_43 + (0.26677334308624268) * gru_0_out_t0_44 + (-0.51129263639450073) * gru_0_out_t0_45 + (-0.18897832930088043) * gru_0_out_t0_46 + (0.18243835866451263) * gru_0_out_t0_47 + (0.76617902517318726) * gru_0_out_t0_48 + (-0.86559700965881348) * gru_0_out_t0_49 + (-0.27259370684623718) * gru_0_out_t0_50 + (-0.16744996607303619) * gru_0_out_t0_51 + (-0.082706280052661896) * gru_0_out_t0_52 + (0.58566963672637939) * gru_0_out_t0_53 + (0.024073811247944832) * gru_0_out_t0_54 + (0.021195696666836739) * gru_0_out_t0_55 + (0.61410975456237793) * gru_0_out_t0_56 + (-0.3599315881729126) * gru_0_out_t0_57 + (-0.47290119528770447) * gru_0_out_t0_58 + (0.37538111209869385) * gru_0_out_t0_59 + (4.87451171875) * gru_0_out_t0_60 + (2.1927835941314697) * gru_0_out_t0_61 + (-0.3438449501991272) * gru_0_out_t0_62 + (-1.0636318922042847) * gru_0_out_t0_63 + (0.55658626556396484) * gru_1_rev_t1_h_0 + (-0.19288590550422668) * gru_1_rev_t1_h_1 + (-0.33920979499816895) * gru_1_rev_t1_h_2 + (0.078324221074581146) * gru_1_rev_t1_h_3 + (-0.032808862626552582) * gru_1_rev_t1_h_4 + (0.68752318620681763) * gru_1_rev_t1_h_5 + (0.19151404500007629) * gru_1_rev_t1_h_6 + (-0.088938958942890167) * gru_1_rev_t1_h_7 + (0.36605584621429443) * gru_1_rev_t1_h_8 + (0.88191276788711548) * gru_1_rev_t1_h_9 + (-0.55707651376724243) * gru_1_rev_t1_h_10 + (-0.038539059460163116) * gru_1_rev_t1_h_11 + (-0.20578569173812866) * gru_1_rev_t1_h_12 + (-0.1482514888048172) * gru_1_rev_t1_h_13 + (0.016076676547527313) * gru_1_rev_t1_h_14 + (-0.21103987097740173) * gru_1_rev_t1_h_15 + (-1.1759699583053589) * gru_1_rev_t1_h_16 + (-0.24134327471256256) * gru_1_rev_t1_h_17 + (0.045003138482570648) * gru_1_rev_t1_h_18 + (1.2376997470855713) * gru_1_rev_t1_h_19 + (-0.10457285493612289) * gru_1_rev_t1_h_20 + (-0.070099107921123505) * gru_1_rev_t1_h_21 + (0.56994980573654175) * gru_1_rev_t1_h_22 + (-0.31019160151481628) * gru_1_rev_t1_h_23 + (-0.37686020135879517) * gru_1_rev_t1_h_24 + (-0.41495662927627563) * gru_1_rev_t1_h_25 + (-0.2188018262386322) * gru_1_rev_t1_h_26 + (-0.096376895904541016) * gru_1_rev_t1_h_27 + (0.91828954219818115) * gru_1_rev_t1_h_28 + (0.021679721772670746) * gru_1_rev_t1_h_29 + (0.72782689332962036) * gru_1_rev_t1_h_30 + (-0.8229251503944397) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.56092220544815063) + (-0.37333157658576965) * gru_0_out_t0_0 + (-0.37335443496704102) * gru_0_out_t0_1 + (0.90674138069152832) * gru_0_out_t0_2 + (-0.26356229186058044) * gru_0_out_t0_3 + (-0.28162690997123718) * gru_0_out_t0_4 + (0.037186678498983383) * gru_0_out_t0_5 + (0.20267194509506226) * gru_0_out_t0_6 + (-0.70503252744674683) * gru_0_out_t0_7 + (-0.34475407004356384) * gru_0_out_t0_8 + (-0.00015587981033604592) * gru_0_out_t0_9 + (-0.97960853576660156) * gru_0_out_t0_10 + (-0.31008258461952209) * gru_0_out_t0_11 + (0.68742763996124268) * gru_0_out_t0_12 + (0.18833737075328827) * gru_0_out_t0_13 + (-0.26271635293960571) * gru_0_out_t0_14 + (0.28125035762786865) * gru_0_out_t0_15 + (0.12458392232656479) * gru_0_out_t0_16 + (0.29592111706733704) * gru_0_out_t0_17 + (-0.65643632411956787) * gru_0_out_t0_18 + (-1.4458273649215698) * gru_0_out_t0_19 + (0.42176055908203125) * gru_0_out_t0_20 + (-0.41768500208854675) * gru_0_out_t0_21 + (-0.19711720943450928) * gru_0_out_t0_22 + (-0.11991977691650391) * gru_0_out_t0_23 + (-0.23783218860626221) * gru_0_out_t0_24 + (-0.061736229807138443) * gru_0_out_t0_25 + (0.345895916223526) * gru_0_out_t0_26 + (0.43231484293937683) * gru_0_out_t0_27 + (-0.55346661806106567) * gru_0_out_t0_28 + (-0.31315651535987854) * gru_0_out_t0_29 + (0.39418485760688782) * gru_0_out_t0_30 + (-1.3036023378372192) * gru_0_out_t0_31 + (0.78916031122207642) * gru_0_out_t0_32 + (-0.25789576768875122) * gru_0_out_t0_33 + (0.20913974940776825) * gru_0_out_t0_34 + (0.13913027942180634) * gru_0_out_t0_35 + (-0.48740664124488831) * gru_0_out_t0_36 + (0.059110701084136963) * gru_0_out_t0_37 + (-0.30152344703674316) * gru_0_out_t0_38 + (1.4426687955856323) * gru_0_out_t0_39 + (0.3754325807094574) * gru_0_out_t0_40 + (0.5188068151473999) * gru_0_out_t0_41 + (-0.11400088667869568) * gru_0_out_t0_42 + (-0.29081752896308899) * gru_0_out_t0_43 + (0.13334262371063232) * gru_0_out_t0_44 + (0.20027519762516022) * gru_0_out_t0_45 + (0.24265015125274658) * gru_0_out_t0_46 + (-0.72337371110916138) * gru_0_out_t0_47 + (-0.6486886739730835) * gru_0_out_t0_48 + (0.91109627485275269) * gru_0_out_t0_49 + (0.5905185341835022) * gru_0_out_t0_50 + (-0.01611027866601944) * gru_0_out_t0_51 + (0.23927927017211914) * gru_0_out_t0_52 + (0.016336381435394287) * gru_0_out_t0_53 + (0.35512462258338928) * gru_0_out_t0_54 + (-0.47046193480491638) * gru_0_out_t0_55 + (-0.45836135745048523) * gru_0_out_t0_56 + (0.8093264102935791) * gru_0_out_t0_57 + (-0.19242972135543823) * gru_0_out_t0_58 + (0.31525826454162598) * gru_0_out_t0_59 + (-1.2547194957733154) * gru_0_out_t0_60 + (1.340984582901001) * gru_0_out_t0_61 + (-0.018116883933544159) * gru_0_out_t0_62 + (-0.49473819136619568) * gru_0_out_t0_63 + (0.52436453104019165) * gru_1_rev_t1_h_0 + (-0.3911471962928772) * gru_1_rev_t1_h_1 + (0.97513353824615479) * gru_1_rev_t1_h_2 + (-0.61311197280883789) * gru_1_rev_t1_h_3 + (0.23736363649368286) * gru_1_rev_t1_h_4 + (0.01562218926846981) * gru_1_rev_t1_h_5 + (0.43321758508682251) * gru_1_rev_t1_h_6 + (-0.28989255428314209) * gru_1_rev_t1_h_7 + (0.88489031791687012) * gru_1_rev_t1_h_8 + (0.006075114943087101) * gru_1_rev_t1_h_9 + (1.0965783596038818) * gru_1_rev_t1_h_10 + (-0.71649962663650513) * gru_1_rev_t1_h_11 + (-0.36281198263168335) * gru_1_rev_t1_h_12 + (0.55503243207931519) * gru_1_rev_t1_h_13 + (0.3558306097984314) * gru_1_rev_t1_h_14 + (0.35748273134231567) * gru_1_rev_t1_h_15 + (0.75244396924972534) * gru_1_rev_t1_h_16 + (-0.081734821200370789) * gru_1_rev_t1_h_17 + (0.51112490892410278) * gru_1_rev_t1_h_18 + (0.21508489549160004) * gru_1_rev_t1_h_19 + (0.29612100124359131) * gru_1_rev_t1_h_20 + (-0.18180927634239197) * gru_1_rev_t1_h_21 + (0.075666852295398712) * gru_1_rev_t1_h_22 + (0.031667608767747879) * gru_1_rev_t1_h_23 + (0.26245635747909546) * gru_1_rev_t1_h_24 + (-0.17593511939048767) * gru_1_rev_t1_h_25 + (-0.47823184728622437) * gru_1_rev_t1_h_26 + (0.2806566059589386) * gru_1_rev_t1_h_27 + (-0.56865048408508301) * gru_1_rev_t1_h_28 + (0.12447782605886459) * gru_1_rev_t1_h_29 + (-0.24293144047260284) * gru_1_rev_t1_h_30 + (-0.082125619053840637) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.43919488787651062) + (-0.19325093924999237) * gru_0_out_t0_0 + (-0.58417755365371704) * gru_0_out_t0_1 + (0.12251561880111694) * gru_0_out_t0_2 + (0.067880406975746155) * gru_0_out_t0_3 + (0.31579107046127319) * gru_0_out_t0_4 + (0.81033295392990112) * gru_0_out_t0_5 + (1.3606374263763428) * gru_0_out_t0_6 + (-1.1044783592224121) * gru_0_out_t0_7 + (0.1610560268163681) * gru_0_out_t0_8 + (-2.1919181346893311) * gru_0_out_t0_9 + (-0.049179725348949432) * gru_0_out_t0_10 + (-0.30192422866821289) * gru_0_out_t0_11 + (-0.062146659940481186) * gru_0_out_t0_12 + (0.1031140610575676) * gru_0_out_t0_13 + (-0.77904170751571655) * gru_0_out_t0_14 + (-0.43634527921676636) * gru_0_out_t0_15 + (0.3405342698097229) * gru_0_out_t0_16 + (0.39236339926719666) * gru_0_out_t0_17 + (0.54621517658233643) * gru_0_out_t0_18 + (0.46937820315361023) * gru_0_out_t0_19 + (-0.91364747285842896) * gru_0_out_t0_20 + (0.091450005769729614) * gru_0_out_t0_21 + (0.38198047876358032) * gru_0_out_t0_22 + (-2.158724308013916) * gru_0_out_t0_23 + (-0.24047228693962097) * gru_0_out_t0_24 + (0.24492992460727692) * gru_0_out_t0_25 + (0.087845854461193085) * gru_0_out_t0_26 + (0.208311527967453) * gru_0_out_t0_27 + (1.5034704208374023) * gru_0_out_t0_28 + (-1.5728136301040649) * gru_0_out_t0_29 + (-0.2690461277961731) * gru_0_out_t0_30 + (0.090102814137935638) * gru_0_out_t0_31 + (-0.079710289835929871) * gru_0_out_t0_32 + (-0.047697007656097412) * gru_0_out_t0_33 + (-0.41452705860137939) * gru_0_out_t0_34 + (-0.23187567293643951) * gru_0_out_t0_35 + (0.20865486562252045) * gru_0_out_t0_36 + (-0.27047047019004822) * gru_0_out_t0_37 + (0.14189958572387695) * gru_0_out_t0_38 + (0.63004446029663086) * gru_0_out_t0_39 + (0.025803182274103165) * gru_0_out_t0_40 + (-0.29059013724327087) * gru_0_out_t0_41 + (0.7579805850982666) * gru_0_out_t0_42 + (0.11970978230237961) * gru_0_out_t0_43 + (-0.031596384942531586) * gru_0_out_t0_44 + (-0.69425910711288452) * gru_0_out_t0_45 + (0.15070532262325287) * gru_0_out_t0_46 + (-0.27502918243408203) * gru_0_out_t0_47 + (-0.34177431464195251) * gru_0_out_t0_48 + (0.21445560455322266) * gru_0_out_t0_49 + (-0.26833167672157288) * gru_0_out_t0_50 + (-0.13885630667209625) * gru_0_out_t0_51 + (0.21455922722816467) * gru_0_out_t0_52 + (0.076114006340503693) * gru_0_out_t0_53 + (0.20994505286216736) * gru_0_out_t0_54 + (-0.67740052938461304) * gru_0_out_t0_55 + (0.8379862904548645) * gru_0_out_t0_56 + (0.055189885199069977) * gru_0_out_t0_57 + (-0.35035106539726257) * gru_0_out_t0_58 + (-0.21237117052078247) * gru_0_out_t0_59 + (1.5212429761886597) * gru_0_out_t0_60 + (-1.2529197931289673) * gru_0_out_t0_61 + (-0.4456685483455658) * gru_0_out_t0_62 + (0.53413039445877075) * gru_0_out_t0_63 + gate_r * ((0.54983353614807129) + (1.9981158971786499) * gru_1_rev_t1_h_0 + (0.09321429580450058) * gru_1_rev_t1_h_1 + (0.73046249151229858) * gru_1_rev_t1_h_2 + (0.62916147708892822) * gru_1_rev_t1_h_3 + (-0.15535669028759003) * gru_1_rev_t1_h_4 + (-1.7900786399841309) * gru_1_rev_t1_h_5 + (-0.16821400821208954) * gru_1_rev_t1_h_6 + (0.40586850047111511) * gru_1_rev_t1_h_7 + (-0.6792529821395874) * gru_1_rev_t1_h_8 + (-0.98325729370117188) * gru_1_rev_t1_h_9 + (0.65228033065795898) * gru_1_rev_t1_h_10 + (2.3221611976623535) * gru_1_rev_t1_h_11 + (-0.15990188717842102) * gru_1_rev_t1_h_12 + (-0.3135046660900116) * gru_1_rev_t1_h_13 + (0.86431783437728882) * gru_1_rev_t1_h_14 + (0.2276843786239624) * gru_1_rev_t1_h_15 + (-0.068657942116260529) * gru_1_rev_t1_h_16 + (-0.92692059278488159) * gru_1_rev_t1_h_17 + (-2.0131399631500244) * gru_1_rev_t1_h_18 + (-2.0472850799560547) * gru_1_rev_t1_h_19 + (0.10924992710351944) * gru_1_rev_t1_h_20 + (0.91690629720687866) * gru_1_rev_t1_h_21 + (-0.23813405632972717) * gru_1_rev_t1_h_22 + (1.0817151069641113) * gru_1_rev_t1_h_23 + (0.47287970781326294) * gru_1_rev_t1_h_24 + (-2.3145453929901123) * gru_1_rev_t1_h_25 + (0.50478357076644897) * gru_1_rev_t1_h_26 + (0.1614614874124527) * gru_1_rev_t1_h_27 + (-1.324448823928833) * gru_1_rev_t1_h_28 + (-0.65908533334732056) * gru_1_rev_t1_h_29 + (-0.35315418243408203) * gru_1_rev_t1_h_30 + (1.4974222183227539) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_18 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_18;
    // h=19
    gate_r = sigmoid((1.3585845232009888) + (0.92713874578475952) * gru_0_out_t0_0 + (0.54453903436660767) * gru_0_out_t0_1 + (-0.71237212419509888) * gru_0_out_t0_2 + (-1.8387352228164673) * gru_0_out_t0_3 + (0.19668005406856537) * gru_0_out_t0_4 + (-0.60360366106033325) * gru_0_out_t0_5 + (1.1838164329528809) * gru_0_out_t0_6 + (1.2298539876937866) * gru_0_out_t0_7 + (1.229907751083374) * gru_0_out_t0_8 + (3.4042716026306152) * gru_0_out_t0_9 + (0.34014654159545898) * gru_0_out_t0_10 + (-0.097058266401290894) * gru_0_out_t0_11 + (-0.016961175948381424) * gru_0_out_t0_12 + (-0.37700515985488892) * gru_0_out_t0_13 + (0.22891908884048462) * gru_0_out_t0_14 + (0.789875328540802) * gru_0_out_t0_15 + (-0.014070860110223293) * gru_0_out_t0_16 + (-0.094995610415935516) * gru_0_out_t0_17 + (0.30283766984939575) * gru_0_out_t0_18 + (2.2536776065826416) * gru_0_out_t0_19 + (0.91398674249649048) * gru_0_out_t0_20 + (0.57453501224517822) * gru_0_out_t0_21 + (0.21898114681243896) * gru_0_out_t0_22 + (-1.2874982357025146) * gru_0_out_t0_23 + (-0.86209487915039062) * gru_0_out_t0_24 + (1.2268757820129395) * gru_0_out_t0_25 + (-0.23755660653114319) * gru_0_out_t0_26 + (-0.84675413370132446) * gru_0_out_t0_27 + (-0.031684070825576782) * gru_0_out_t0_28 + (-0.092987194657325745) * gru_0_out_t0_29 + (0.26359653472900391) * gru_0_out_t0_30 + (0.046272870153188705) * gru_0_out_t0_31 + (-0.52451032400131226) * gru_0_out_t0_32 + (-0.25781124830245972) * gru_0_out_t0_33 + (0.54315567016601562) * gru_0_out_t0_34 + (0.13979688286781311) * gru_0_out_t0_35 + (-0.36319148540496826) * gru_0_out_t0_36 + (0.14175082743167877) * gru_0_out_t0_37 + (-0.23658353090286255) * gru_0_out_t0_38 + (-0.47878485918045044) * gru_0_out_t0_39 + (0.21909289062023163) * gru_0_out_t0_40 + (0.34808218479156494) * gru_0_out_t0_41 + (-3.136716365814209) * gru_0_out_t0_42 + (-0.19570781290531158) * gru_0_out_t0_43 + (0.50477474927902222) * gru_0_out_t0_44 + (0.21262991428375244) * gru_0_out_t0_45 + (-2.5966813564300537) * gru_0_out_t0_46 + (0.74891561269760132) * gru_0_out_t0_47 + (2.0114288330078125) * gru_0_out_t0_48 + (-1.5019466876983643) * gru_0_out_t0_49 + (0.15146152675151825) * gru_0_out_t0_50 + (0.11779484152793884) * gru_0_out_t0_51 + (-0.11236763745546341) * gru_0_out_t0_52 + (-0.10375957190990448) * gru_0_out_t0_53 + (0.6068960428237915) * gru_0_out_t0_54 + (-2.3066442012786865) * gru_0_out_t0_55 + (-0.09757242351770401) * gru_0_out_t0_56 + (-1.2299487590789795) * gru_0_out_t0_57 + (-0.27708238363265991) * gru_0_out_t0_58 + (0.85025924444198608) * gru_0_out_t0_59 + (0.78883528709411621) * gru_0_out_t0_60 + (0.27415722608566284) * gru_0_out_t0_61 + (-0.098900310695171356) * gru_0_out_t0_62 + (-0.78380817174911499) * gru_0_out_t0_63 + (-0.087552912533283234) * gru_1_rev_t1_h_0 + (0.45747679471969604) * gru_1_rev_t1_h_1 + (-0.30629801750183105) * gru_1_rev_t1_h_2 + (0.73073762655258179) * gru_1_rev_t1_h_3 + (-0.49993985891342163) * gru_1_rev_t1_h_4 + (-1.3544869422912598) * gru_1_rev_t1_h_5 + (-0.71443784236907959) * gru_1_rev_t1_h_6 + (0.22785490751266479) * gru_1_rev_t1_h_7 + (-0.15326981246471405) * gru_1_rev_t1_h_8 + (0.30847820639610291) * gru_1_rev_t1_h_9 + (2.4224264621734619) * gru_1_rev_t1_h_10 + (0.6002008318901062) * gru_1_rev_t1_h_11 + (1.5926183462142944) * gru_1_rev_t1_h_12 + (-0.02279338613152504) * gru_1_rev_t1_h_13 + (-0.48675626516342163) * gru_1_rev_t1_h_14 + (1.4464107751846313) * gru_1_rev_t1_h_15 + (-0.15206567943096161) * gru_1_rev_t1_h_16 + (0.26627463102340698) * gru_1_rev_t1_h_17 + (0.29017540812492371) * gru_1_rev_t1_h_18 + (-0.043561536818742752) * gru_1_rev_t1_h_19 + (1.4620964527130127) * gru_1_rev_t1_h_20 + (0.091995075345039368) * gru_1_rev_t1_h_21 + (0.79100751876831055) * gru_1_rev_t1_h_22 + (-0.32126519083976746) * gru_1_rev_t1_h_23 + (-0.028888506814837456) * gru_1_rev_t1_h_24 + (1.0053876638412476) * gru_1_rev_t1_h_25 + (-0.66239583492279053) * gru_1_rev_t1_h_26 + (-0.5115056037902832) * gru_1_rev_t1_h_27 + (1.1009049415588379) * gru_1_rev_t1_h_28 + (-0.0013422059128060937) * gru_1_rev_t1_h_29 + (-1.9301023483276367) * gru_1_rev_t1_h_30 + (0.11885405331850052) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.91853141784667969) + (-0.19877526164054871) * gru_0_out_t0_0 + (-0.29891946911811829) * gru_0_out_t0_1 + (0.25698143243789673) * gru_0_out_t0_2 + (-0.26862204074859619) * gru_0_out_t0_3 + (0.32915958762168884) * gru_0_out_t0_4 + (0.11838594824075699) * gru_0_out_t0_5 + (0.58737528324127197) * gru_0_out_t0_6 + (0.27154535055160522) * gru_0_out_t0_7 + (-0.29570591449737549) * gru_0_out_t0_8 + (-1.0162442922592163) * gru_0_out_t0_9 + (-0.049405790865421295) * gru_0_out_t0_10 + (0.46546304225921631) * gru_0_out_t0_11 + (0.17971606552600861) * gru_0_out_t0_12 + (0.21126845479011536) * gru_0_out_t0_13 + (0.58855068683624268) * gru_0_out_t0_14 + (0.21704237163066864) * gru_0_out_t0_15 + (-0.1509065181016922) * gru_0_out_t0_16 + (-0.093055583536624908) * gru_0_out_t0_17 + (-0.22582809627056122) * gru_0_out_t0_18 + (-0.77320528030395508) * gru_0_out_t0_19 + (0.23846521973609924) * gru_0_out_t0_20 + (-0.083365827798843384) * gru_0_out_t0_21 + (0.19709396362304688) * gru_0_out_t0_22 + (0.13965629041194916) * gru_0_out_t0_23 + (-0.61810863018035889) * gru_0_out_t0_24 + (0.036717548966407776) * gru_0_out_t0_25 + (-0.11374072730541229) * gru_0_out_t0_26 + (0.18138910830020905) * gru_0_out_t0_27 + (-0.64454543590545654) * gru_0_out_t0_28 + (0.5019107460975647) * gru_0_out_t0_29 + (0.517070472240448) * gru_0_out_t0_30 + (-0.39402380585670471) * gru_0_out_t0_31 + (0.43103137612342834) * gru_0_out_t0_32 + (0.26021045446395874) * gru_0_out_t0_33 + (0.6967812180519104) * gru_0_out_t0_34 + (0.28197482228279114) * gru_0_out_t0_35 + (-0.3905559778213501) * gru_0_out_t0_36 + (-0.50016415119171143) * gru_0_out_t0_37 + (0.031074339523911476) * gru_0_out_t0_38 + (-0.079523459076881409) * gru_0_out_t0_39 + (-0.37222883105278015) * gru_0_out_t0_40 + (0.56024163961410522) * gru_0_out_t0_41 + (-0.016238756477832794) * gru_0_out_t0_42 + (-0.31617099046707153) * gru_0_out_t0_43 + (0.35090941190719604) * gru_0_out_t0_44 + (0.31314679980278015) * gru_0_out_t0_45 + (2.2445695400238037) * gru_0_out_t0_46 + (-1.0520236492156982) * gru_0_out_t0_47 + (-0.16583108901977539) * gru_0_out_t0_48 + (0.056231316179037094) * gru_0_out_t0_49 + (1.0103954076766968) * gru_0_out_t0_50 + (-0.23297832906246185) * gru_0_out_t0_51 + (0.32866507768630981) * gru_0_out_t0_52 + (0.80315178632736206) * gru_0_out_t0_53 + (-0.28336435556411743) * gru_0_out_t0_54 + (0.14749480783939362) * gru_0_out_t0_55 + (-0.058905467391014099) * gru_0_out_t0_56 + (-0.11743486672639847) * gru_0_out_t0_57 + (0.41084679961204529) * gru_0_out_t0_58 + (-0.2497706413269043) * gru_0_out_t0_59 + (-1.1434539556503296) * gru_0_out_t0_60 + (0.048280622810125351) * gru_0_out_t0_61 + (0.44144347310066223) * gru_0_out_t0_62 + (-0.045267757028341293) * gru_0_out_t0_63 + (0.6260836124420166) * gru_1_rev_t1_h_0 + (0.29951813817024231) * gru_1_rev_t1_h_1 + (0.49369251728057861) * gru_1_rev_t1_h_2 + (0.33832120895385742) * gru_1_rev_t1_h_3 + (-0.54025900363922119) * gru_1_rev_t1_h_4 + (0.2820427417755127) * gru_1_rev_t1_h_5 + (-0.25165596604347229) * gru_1_rev_t1_h_6 + (-0.45029979944229126) * gru_1_rev_t1_h_7 + (-0.37385541200637817) * gru_1_rev_t1_h_8 + (0.36513581871986389) * gru_1_rev_t1_h_9 + (-0.18006403744220734) * gru_1_rev_t1_h_10 + (-0.75358951091766357) * gru_1_rev_t1_h_11 + (0.39672455191612244) * gru_1_rev_t1_h_12 + (-0.40972191095352173) * gru_1_rev_t1_h_13 + (0.12042739987373352) * gru_1_rev_t1_h_14 + (0.51260411739349365) * gru_1_rev_t1_h_15 + (-0.36989808082580566) * gru_1_rev_t1_h_16 + (-0.72935885190963745) * gru_1_rev_t1_h_17 + (-0.32966658473014832) * gru_1_rev_t1_h_18 + (-1.1894420385360718) * gru_1_rev_t1_h_19 + (0.30174610018730164) * gru_1_rev_t1_h_20 + (0.13116496801376343) * gru_1_rev_t1_h_21 + (0.6361624002456665) * gru_1_rev_t1_h_22 + (-0.29549926519393921) * gru_1_rev_t1_h_23 + (-0.19847126305103302) * gru_1_rev_t1_h_24 + (0.35504397749900818) * gru_1_rev_t1_h_25 + (0.39430329203605652) * gru_1_rev_t1_h_26 + (-0.33985590934753418) * gru_1_rev_t1_h_27 + (0.4894716739654541) * gru_1_rev_t1_h_28 + (-0.011745931580662727) * gru_1_rev_t1_h_29 + (1.1885271072387695) * gru_1_rev_t1_h_30 + (0.35596972703933716) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.31659004092216492) + (-0.27749228477478027) * gru_0_out_t0_0 + (0.049338560551404953) * gru_0_out_t0_1 + (1.8257800340652466) * gru_0_out_t0_2 + (0.63251471519470215) * gru_0_out_t0_3 + (0.099822863936424255) * gru_0_out_t0_4 + (-0.6710858941078186) * gru_0_out_t0_5 + (-1.6035842895507812) * gru_0_out_t0_6 + (-1.0540801286697388) * gru_0_out_t0_7 + (-0.4651552140712738) * gru_0_out_t0_8 + (3.4130823612213135) * gru_0_out_t0_9 + (-1.6215404272079468) * gru_0_out_t0_10 + (-0.57454901933670044) * gru_0_out_t0_11 + (0.12557326257228851) * gru_0_out_t0_12 + (0.074804790318012238) * gru_0_out_t0_13 + (0.069176293909549713) * gru_0_out_t0_14 + (0.1483338326215744) * gru_0_out_t0_15 + (0.0085982689633965492) * gru_0_out_t0_16 + (0.45527896285057068) * gru_0_out_t0_17 + (-0.2502085268497467) * gru_0_out_t0_18 + (-0.94448721408843994) * gru_0_out_t0_19 + (1.1682373285293579) * gru_0_out_t0_20 + (-1.7056659460067749) * gru_0_out_t0_21 + (-0.52971655130386353) * gru_0_out_t0_22 + (0.38094609975814819) * gru_0_out_t0_23 + (0.26566097140312195) * gru_0_out_t0_24 + (-0.77322781085968018) * gru_0_out_t0_25 + (-0.016919802874326706) * gru_0_out_t0_26 + (1.0217417478561401) * gru_0_out_t0_27 + (-1.231964111328125) * gru_0_out_t0_28 + (0.3168773353099823) * gru_0_out_t0_29 + (1.1274058818817139) * gru_0_out_t0_30 + (0.056105952709913254) * gru_0_out_t0_31 + (2.5091614723205566) * gru_0_out_t0_32 + (-0.081881709396839142) * gru_0_out_t0_33 + (0.22773382067680359) * gru_0_out_t0_34 + (-0.082141652703285217) * gru_0_out_t0_35 + (0.10073042660951614) * gru_0_out_t0_36 + (-0.13771817088127136) * gru_0_out_t0_37 + (0.47558549046516418) * gru_0_out_t0_38 + (1.0474072694778442) * gru_0_out_t0_39 + (-0.17687149345874786) * gru_0_out_t0_40 + (-0.63588154315948486) * gru_0_out_t0_41 + (-3.8300940990447998) * gru_0_out_t0_42 + (-0.1803077757358551) * gru_0_out_t0_43 + (0.45576408505439758) * gru_0_out_t0_44 + (0.41946783661842346) * gru_0_out_t0_45 + (0.071851491928100586) * gru_0_out_t0_46 + (-0.50924748182296753) * gru_0_out_t0_47 + (-0.15229704976081848) * gru_0_out_t0_48 + (0.49728506803512573) * gru_0_out_t0_49 + (0.59357684850692749) * gru_0_out_t0_50 + (0.064275190234184265) * gru_0_out_t0_51 + (0.46589162945747375) * gru_0_out_t0_52 + (-0.15617464482784271) * gru_0_out_t0_53 + (-0.080607913434505463) * gru_0_out_t0_54 + (0.10559092462062836) * gru_0_out_t0_55 + (-0.93213266134262085) * gru_0_out_t0_56 + (0.07593245804309845) * gru_0_out_t0_57 + (-0.37366467714309692) * gru_0_out_t0_58 + (-0.69575142860412598) * gru_0_out_t0_59 + (-0.83328014612197876) * gru_0_out_t0_60 + (-1.6558254957199097) * gru_0_out_t0_61 + (0.091911569237709045) * gru_0_out_t0_62 + (-0.34609794616699219) * gru_0_out_t0_63 + gate_r * ((0.40852788090705872) + (0.15369653701782227) * gru_1_rev_t1_h_0 + (-0.98856991529464722) * gru_1_rev_t1_h_1 + (-0.11349958181381226) * gru_1_rev_t1_h_2 + (-0.68638086318969727) * gru_1_rev_t1_h_3 + (0.89725309610366821) * gru_1_rev_t1_h_4 + (0.60430949926376343) * gru_1_rev_t1_h_5 + (0.12853796780109406) * gru_1_rev_t1_h_6 + (0.14565877616405487) * gru_1_rev_t1_h_7 + (-0.65770024061203003) * gru_1_rev_t1_h_8 + (0.93523770570755005) * gru_1_rev_t1_h_9 + (-0.63800603151321411) * gru_1_rev_t1_h_10 + (0.6423335075378418) * gru_1_rev_t1_h_11 + (-0.78630656003952026) * gru_1_rev_t1_h_12 + (-0.31435614824295044) * gru_1_rev_t1_h_13 + (-0.02703050896525383) * gru_1_rev_t1_h_14 + (-0.45177894830703735) * gru_1_rev_t1_h_15 + (0.022140679880976677) * gru_1_rev_t1_h_16 + (-1.0264065265655518) * gru_1_rev_t1_h_17 + (-0.24274183809757233) * gru_1_rev_t1_h_18 + (0.55067777633666992) * gru_1_rev_t1_h_19 + (0.47982150316238403) * gru_1_rev_t1_h_20 + (1.4116449356079102) * gru_1_rev_t1_h_21 + (0.3394317626953125) * gru_1_rev_t1_h_22 + (-0.06271517276763916) * gru_1_rev_t1_h_23 + (0.24200752377510071) * gru_1_rev_t1_h_24 + (0.67329907417297363) * gru_1_rev_t1_h_25 + (-0.014809105545282364) * gru_1_rev_t1_h_26 + (-1.0610502958297729) * gru_1_rev_t1_h_27 + (2.6871109008789062) * gru_1_rev_t1_h_28 + (0.99635207653045654) * gru_1_rev_t1_h_29 + (0.025679986923933029) * gru_1_rev_t1_h_30 + (1.4751064777374268) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_19 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_19;
    // h=20
    gate_r = sigmoid((-0.68445390462875366) + (-0.38611987233161926) * gru_0_out_t0_0 + (-0.16700387001037598) * gru_0_out_t0_1 + (-1.6311428546905518) * gru_0_out_t0_2 + (-0.83732271194458008) * gru_0_out_t0_3 + (-0.30137485265731812) * gru_0_out_t0_4 + (-0.51939862966537476) * gru_0_out_t0_5 + (-3.6734929084777832) * gru_0_out_t0_6 + (-0.099337778985500336) * gru_0_out_t0_7 + (0.35600224137306213) * gru_0_out_t0_8 + (-0.26660886406898499) * gru_0_out_t0_9 + (0.83714377880096436) * gru_0_out_t0_10 + (0.0062690898776054382) * gru_0_out_t0_11 + (0.13210678100585938) * gru_0_out_t0_12 + (-0.023403745144605637) * gru_0_out_t0_13 + (-0.093250870704650879) * gru_0_out_t0_14 + (0.22437961399555206) * gru_0_out_t0_15 + (0.054977923631668091) * gru_0_out_t0_16 + (0.11695538461208344) * gru_0_out_t0_17 + (0.33784890174865723) * gru_0_out_t0_18 + (-0.24100673198699951) * gru_0_out_t0_19 + (-0.66152268648147583) * gru_0_out_t0_20 + (2.2053477764129639) * gru_0_out_t0_21 + (0.41723540425300598) * gru_0_out_t0_22 + (-0.011347103863954544) * gru_0_out_t0_23 + (1.3161385059356689) * gru_0_out_t0_24 + (0.17030048370361328) * gru_0_out_t0_25 + (-0.48526635766029358) * gru_0_out_t0_26 + (-0.68443435430526733) * gru_0_out_t0_27 + (1.1938103437423706) * gru_0_out_t0_28 + (0.071547769010066986) * gru_0_out_t0_29 + (0.58633172512054443) * gru_0_out_t0_30 + (-0.64204937219619751) * gru_0_out_t0_31 + (-1.345012903213501) * gru_0_out_t0_32 + (-0.21373501420021057) * gru_0_out_t0_33 + (0.33853954076766968) * gru_0_out_t0_34 + (-0.35760992765426636) * gru_0_out_t0_35 + (0.061229981482028961) * gru_0_out_t0_36 + (-0.017960567027330399) * gru_0_out_t0_37 + (-0.037200987339019775) * gru_0_out_t0_38 + (0.38374310731887817) * gru_0_out_t0_39 + (0.53874361515045166) * gru_0_out_t0_40 + (-0.38097038865089417) * gru_0_out_t0_41 + (-0.91184425354003906) * gru_0_out_t0_42 + (0.84486097097396851) * gru_0_out_t0_43 + (-1.4181829690933228) * gru_0_out_t0_44 + (-0.14491723477840424) * gru_0_out_t0_45 + (-1.1942651271820068) * gru_0_out_t0_46 + (3.7597684860229492) * gru_0_out_t0_47 + (1.2293163537979126) * gru_0_out_t0_48 + (-1.0909546613693237) * gru_0_out_t0_49 + (-0.69650346040725708) * gru_0_out_t0_50 + (0.19332641363143921) * gru_0_out_t0_51 + (-0.37448105216026306) * gru_0_out_t0_52 + (-0.11465936899185181) * gru_0_out_t0_53 + (-0.4817548394203186) * gru_0_out_t0_54 + (0.32103860378265381) * gru_0_out_t0_55 + (-0.72126948833465576) * gru_0_out_t0_56 + (-1.2885450124740601) * gru_0_out_t0_57 + (-0.018889106810092926) * gru_0_out_t0_58 + (-1.0279626846313477) * gru_0_out_t0_59 + (0.081805385649204254) * gru_0_out_t0_60 + (-1.1152538061141968) * gru_0_out_t0_61 + (-0.033276643604040146) * gru_0_out_t0_62 + (1.6932977437973022) * gru_0_out_t0_63 + (0.058605603873729706) * gru_1_rev_t1_h_0 + (-0.10833780467510223) * gru_1_rev_t1_h_1 + (-0.81719338893890381) * gru_1_rev_t1_h_2 + (-0.17426426708698273) * gru_1_rev_t1_h_3 + (-0.64370673894882202) * gru_1_rev_t1_h_4 + (0.24613235890865326) * gru_1_rev_t1_h_5 + (0.26495248079299927) * gru_1_rev_t1_h_6 + (-0.52031612396240234) * gru_1_rev_t1_h_7 + (-0.37763181328773499) * gru_1_rev_t1_h_8 + (-0.79477453231811523) * gru_1_rev_t1_h_9 + (-0.86277425289154053) * gru_1_rev_t1_h_10 + (-0.47146779298782349) * gru_1_rev_t1_h_11 + (0.3775901198387146) * gru_1_rev_t1_h_12 + (-0.53525745868682861) * gru_1_rev_t1_h_13 + (0.033802095800638199) * gru_1_rev_t1_h_14 + (0.059562601149082184) * gru_1_rev_t1_h_15 + (0.92572027444839478) * gru_1_rev_t1_h_16 + (-0.28593012690544128) * gru_1_rev_t1_h_17 + (-0.18669791519641876) * gru_1_rev_t1_h_18 + (0.35859107971191406) * gru_1_rev_t1_h_19 + (-0.2713627815246582) * gru_1_rev_t1_h_20 + (-0.079692654311656952) * gru_1_rev_t1_h_21 + (-0.26467752456665039) * gru_1_rev_t1_h_22 + (0.37203338742256165) * gru_1_rev_t1_h_23 + (0.16673767566680908) * gru_1_rev_t1_h_24 + (-0.030225764960050583) * gru_1_rev_t1_h_25 + (-0.52512377500534058) * gru_1_rev_t1_h_26 + (-0.43620339035987854) * gru_1_rev_t1_h_27 + (2.8577401638031006) * gru_1_rev_t1_h_28 + (0.18111249804496765) * gru_1_rev_t1_h_29 + (0.081798776984214783) * gru_1_rev_t1_h_30 + (-0.23038586974143982) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.10228950530290604) + (-0.39781433343887329) * gru_0_out_t0_0 + (-0.26791355013847351) * gru_0_out_t0_1 + (-0.5078350305557251) * gru_0_out_t0_2 + (0.38844165205955505) * gru_0_out_t0_3 + (-0.16850759088993073) * gru_0_out_t0_4 + (0.53345441818237305) * gru_0_out_t0_5 + (0.31419137120246887) * gru_0_out_t0_6 + (0.46693271398544312) * gru_0_out_t0_7 + (0.051786936819553375) * gru_0_out_t0_8 + (-1.8194636106491089) * gru_0_out_t0_9 + (0.28232923150062561) * gru_0_out_t0_10 + (0.23307101428508759) * gru_0_out_t0_11 + (-0.045791614800691605) * gru_0_out_t0_12 + (0.60666143894195557) * gru_0_out_t0_13 + (0.14384296536445618) * gru_0_out_t0_14 + (0.1225939467549324) * gru_0_out_t0_15 + (-0.59174197912216187) * gru_0_out_t0_16 + (-0.23220092058181763) * gru_0_out_t0_17 + (0.10877957940101624) * gru_0_out_t0_18 + (-0.64457017183303833) * gru_0_out_t0_19 + (-0.8964046835899353) * gru_0_out_t0_20 + (-0.82864940166473389) * gru_0_out_t0_21 + (0.50768113136291504) * gru_0_out_t0_22 + (-0.38167384266853333) * gru_0_out_t0_23 + (-1.5390046834945679) * gru_0_out_t0_24 + (-0.28423783183097839) * gru_0_out_t0_25 + (-0.037796817719936371) * gru_0_out_t0_26 + (0.040625806897878647) * gru_0_out_t0_27 + (0.95613598823547363) * gru_0_out_t0_28 + (0.04450693354010582) * gru_0_out_t0_29 + (0.25216901302337646) * gru_0_out_t0_30 + (0.070837423205375671) * gru_0_out_t0_31 + (-0.16081503033638) * gru_0_out_t0_32 + (-0.24409162998199463) * gru_0_out_t0_33 + (0.10508731752634048) * gru_0_out_t0_34 + (-0.17935054004192352) * gru_0_out_t0_35 + (-0.13491813838481903) * gru_0_out_t0_36 + (0.052433032542467117) * gru_0_out_t0_37 + (0.17960470914840698) * gru_0_out_t0_38 + (0.34366101026535034) * gru_0_out_t0_39 + (-1.9195109605789185) * gru_0_out_t0_40 + (-0.28483214974403381) * gru_0_out_t0_41 + (-0.24031111598014832) * gru_0_out_t0_42 + (0.081480018794536591) * gru_0_out_t0_43 + (0.21398533880710602) * gru_0_out_t0_44 + (-0.19124366343021393) * gru_0_out_t0_45 + (-1.1067497730255127) * gru_0_out_t0_46 + (0.1324535459280014) * gru_0_out_t0_47 + (0.98906993865966797) * gru_0_out_t0_48 + (-0.7464214563369751) * gru_0_out_t0_49 + (0.025763947516679764) * gru_0_out_t0_50 + (-0.12728135287761688) * gru_0_out_t0_51 + (0.73357856273651123) * gru_0_out_t0_52 + (0.19245608150959015) * gru_0_out_t0_53 + (0.18120163679122925) * gru_0_out_t0_54 + (0.90432077646255493) * gru_0_out_t0_55 + (0.26176300644874573) * gru_0_out_t0_56 + (-1.0651123523712158) * gru_0_out_t0_57 + (-0.34208738803863525) * gru_0_out_t0_58 + (-0.58260595798492432) * gru_0_out_t0_59 + (1.4644457101821899) * gru_0_out_t0_60 + (0.75264805555343628) * gru_0_out_t0_61 + (-0.58337360620498657) * gru_0_out_t0_62 + (1.3694390058517456) * gru_0_out_t0_63 + (-1.4604170322418213) * gru_1_rev_t1_h_0 + (0.39122673869132996) * gru_1_rev_t1_h_1 + (0.028528323397040367) * gru_1_rev_t1_h_2 + (0.77981621026992798) * gru_1_rev_t1_h_3 + (-0.0021719334181398153) * gru_1_rev_t1_h_4 + (-0.20155170559883118) * gru_1_rev_t1_h_5 + (-0.14599472284317017) * gru_1_rev_t1_h_6 + (-0.48506316542625427) * gru_1_rev_t1_h_7 + (-0.030633062124252319) * gru_1_rev_t1_h_8 + (0.22953967750072479) * gru_1_rev_t1_h_9 + (0.27875891327857971) * gru_1_rev_t1_h_10 + (-0.55952936410903931) * gru_1_rev_t1_h_11 + (0.28666487336158752) * gru_1_rev_t1_h_12 + (0.17250476777553558) * gru_1_rev_t1_h_13 + (0.1364363431930542) * gru_1_rev_t1_h_14 + (0.29431816935539246) * gru_1_rev_t1_h_15 + (-0.53445893526077271) * gru_1_rev_t1_h_16 + (0.21056634187698364) * gru_1_rev_t1_h_17 + (0.26289403438568115) * gru_1_rev_t1_h_18 + (-1.5464533567428589) * gru_1_rev_t1_h_19 + (1.0583051443099976) * gru_1_rev_t1_h_20 + (-0.16589045524597168) * gru_1_rev_t1_h_21 + (0.59759235382080078) * gru_1_rev_t1_h_22 + (0.72827666997909546) * gru_1_rev_t1_h_23 + (0.045141860842704773) * gru_1_rev_t1_h_24 + (0.61680293083190918) * gru_1_rev_t1_h_25 + (-0.36711978912353516) * gru_1_rev_t1_h_26 + (0.82382327318191528) * gru_1_rev_t1_h_27 + (0.5494115948677063) * gru_1_rev_t1_h_28 + (0.15530051290988922) * gru_1_rev_t1_h_29 + (0.66093963384628296) * gru_1_rev_t1_h_30 + (-0.068748250603675842) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.0053023714572191238) + (0.11101575195789337) * gru_0_out_t0_0 + (0.31285089254379272) * gru_0_out_t0_1 + (-1.0677660703659058) * gru_0_out_t0_2 + (-0.84570121765136719) * gru_0_out_t0_3 + (0.39640721678733826) * gru_0_out_t0_4 + (-1.0035765171051025) * gru_0_out_t0_5 + (0.03213852271437645) * gru_0_out_t0_6 + (0.17310658097267151) * gru_0_out_t0_7 + (-0.047848772257566452) * gru_0_out_t0_8 + (-0.52508544921875) * gru_0_out_t0_9 + (-0.017091542482376099) * gru_0_out_t0_10 + (-0.18405896425247192) * gru_0_out_t0_11 + (0.046477381139993668) * gru_0_out_t0_12 + (-0.10422490537166595) * gru_0_out_t0_13 + (0.24324515461921692) * gru_0_out_t0_14 + (-0.44397839903831482) * gru_0_out_t0_15 + (0.13865883648395538) * gru_0_out_t0_16 + (-0.11269652843475342) * gru_0_out_t0_17 + (0.39490979909896851) * gru_0_out_t0_18 + (0.83345866203308105) * gru_0_out_t0_19 + (0.2609819769859314) * gru_0_out_t0_20 + (0.85519272089004517) * gru_0_out_t0_21 + (-0.1468873918056488) * gru_0_out_t0_22 + (0.099238336086273193) * gru_0_out_t0_23 + (0.82708919048309326) * gru_0_out_t0_24 + (-0.67599081993103027) * gru_0_out_t0_25 + (-0.23929747939109802) * gru_0_out_t0_26 + (-0.24249221384525299) * gru_0_out_t0_27 + (-2.0187578201293945) * gru_0_out_t0_28 + (-0.69097644090652466) * gru_0_out_t0_29 + (0.79839241504669189) * gru_0_out_t0_30 + (-0.063834108412265778) * gru_0_out_t0_31 + (0.70849615335464478) * gru_0_out_t0_32 + (0.034592822194099426) * gru_0_out_t0_33 + (0.083021886646747589) * gru_0_out_t0_34 + (0.26727673411369324) * gru_0_out_t0_35 + (-0.12686792016029358) * gru_0_out_t0_36 + (-0.11273614317178726) * gru_0_out_t0_37 + (-0.13626059889793396) * gru_0_out_t0_38 + (0.44513246417045593) * gru_0_out_t0_39 + (0.46874338388442993) * gru_0_out_t0_40 + (0.25259771943092346) * gru_0_out_t0_41 + (0.065465383231639862) * gru_0_out_t0_42 + (-0.19233289361000061) * gru_0_out_t0_43 + (-0.070004843175411224) * gru_0_out_t0_44 + (0.29074442386627197) * gru_0_out_t0_45 + (0.18208329379558563) * gru_0_out_t0_46 + (-0.45683193206787109) * gru_0_out_t0_47 + (-1.0517141819000244) * gru_0_out_t0_48 + (1.0564452409744263) * gru_0_out_t0_49 + (-0.069939814507961273) * gru_0_out_t0_50 + (-0.12356752902269363) * gru_0_out_t0_51 + (-0.30965238809585571) * gru_0_out_t0_52 + (0.23993411660194397) * gru_0_out_t0_53 + (-0.73138010501861572) * gru_0_out_t0_54 + (-0.24607774615287781) * gru_0_out_t0_55 + (0.16020606458187103) * gru_0_out_t0_56 + (0.7986418604850769) * gru_0_out_t0_57 + (0.30954459309577942) * gru_0_out_t0_58 + (-0.053416457027196884) * gru_0_out_t0_59 + (-0.18039649724960327) * gru_0_out_t0_60 + (0.57477861642837524) * gru_0_out_t0_61 + (-0.030563732609152794) * gru_0_out_t0_62 + (0.4967382550239563) * gru_0_out_t0_63 + gate_r * ((0.58663588762283325) + (-2.1094117164611816) * gru_1_rev_t1_h_0 + (-0.2611440122127533) * gru_1_rev_t1_h_1 + (-0.26323747634887695) * gru_1_rev_t1_h_2 + (0.33804258704185486) * gru_1_rev_t1_h_3 + (0.164563849568367) * gru_1_rev_t1_h_4 + (-1.0876719951629639) * gru_1_rev_t1_h_5 + (-1.3711351156234741) * gru_1_rev_t1_h_6 + (0.43350645899772644) * gru_1_rev_t1_h_7 + (0.075519829988479614) * gru_1_rev_t1_h_8 + (-0.5681646466255188) * gru_1_rev_t1_h_9 + (-0.66256445646286011) * gru_1_rev_t1_h_10 + (0.10367092490196228) * gru_1_rev_t1_h_11 + (0.26853975653648376) * gru_1_rev_t1_h_12 + (0.049445994198322296) * gru_1_rev_t1_h_13 + (0.13617514073848724) * gru_1_rev_t1_h_14 + (0.33525383472442627) * gru_1_rev_t1_h_15 + (-0.30296808481216431) * gru_1_rev_t1_h_16 + (-0.15274801850318909) * gru_1_rev_t1_h_17 + (-1.764265775680542) * gru_1_rev_t1_h_18 + (0.96969741582870483) * gru_1_rev_t1_h_19 + (0.30863752961158752) * gru_1_rev_t1_h_20 + (-0.19201730191707611) * gru_1_rev_t1_h_21 + (-0.89782482385635376) * gru_1_rev_t1_h_22 + (-0.10620944201946259) * gru_1_rev_t1_h_23 + (0.31052252650260925) * gru_1_rev_t1_h_24 + (-0.92293256521224976) * gru_1_rev_t1_h_25 + (-0.18600696325302124) * gru_1_rev_t1_h_26 + (0.08107023686170578) * gru_1_rev_t1_h_27 + (-1.8470429182052612) * gru_1_rev_t1_h_28 + (0.049924001097679138) * gru_1_rev_t1_h_29 + (0.18290221691131592) * gru_1_rev_t1_h_30 + (0.42097249627113342) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_20 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_20;
    // h=21
