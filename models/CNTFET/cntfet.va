    gate_r = sigmoid((0.15828375518321991) + (-0.21667875349521637) * gru_0_out_t0_0 + (0.17282083630561829) * gru_0_out_t0_1 + (0.2730640172958374) * gru_0_out_t0_2 + (1.4154857397079468) * gru_0_out_t0_3 + (-0.060421030968427658) * gru_0_out_t0_4 + (2.0716490745544434) * gru_0_out_t0_5 + (0.30417004227638245) * gru_0_out_t0_6 + (-0.56303137540817261) * gru_0_out_t0_7 + (-0.67171716690063477) * gru_0_out_t0_8 + (1.7976105213165283) * gru_0_out_t0_9 + (-0.66730457544326782) * gru_0_out_t0_10 + (0.25825724005699158) * gru_0_out_t0_11 + (0.21561728417873383) * gru_0_out_t0_12 + (-0.53052657842636108) * gru_0_out_t0_13 + (-0.065738819539546967) * gru_0_out_t0_14 + (0.29796609282493591) * gru_0_out_t0_15 + (-0.17339198291301727) * gru_0_out_t0_16 + (-0.19988624751567841) * gru_0_out_t0_17 + (-0.19300490617752075) * gru_0_out_t0_18 + (0.54492390155792236) * gru_0_out_t0_19 + (-0.14264050126075745) * gru_0_out_t0_20 + (-1.559805154800415) * gru_0_out_t0_21 + (-0.12618711590766907) * gru_0_out_t0_22 + (0.23782643675804138) * gru_0_out_t0_23 + (-1.0851055383682251) * gru_0_out_t0_24 + (-0.38625228404998779) * gru_0_out_t0_25 + (1.184913158416748) * gru_0_out_t0_26 + (0.28803697228431702) * gru_0_out_t0_27 + (0.86992412805557251) * gru_0_out_t0_28 + (-0.66516667604446411) * gru_0_out_t0_29 + (-0.36176484823226929) * gru_0_out_t0_30 + (2.0704538822174072) * gru_0_out_t0_31 + (-1.3981943130493164) * gru_0_out_t0_32 + (0.10949337482452393) * gru_0_out_t0_33 + (-0.081931404769420624) * gru_0_out_t0_34 + (0.094534255564212799) * gru_0_out_t0_35 + (0.1969563215970993) * gru_0_out_t0_36 + (0.16860908269882202) * gru_0_out_t0_37 + (0.37135928869247437) * gru_0_out_t0_38 + (-1.0970072746276855) * gru_0_out_t0_39 + (-0.19556453824043274) * gru_0_out_t0_40 + (0.57895749807357788) * gru_0_out_t0_41 + (-1.8849166631698608) * gru_0_out_t0_42 + (-0.18274906277656555) * gru_0_out_t0_43 + (0.14086256921291351) * gru_0_out_t0_44 + (0.037774529308080673) * gru_0_out_t0_45 + (-1.768079400062561) * gru_0_out_t0_46 + (0.35390552878379822) * gru_0_out_t0_47 + (-0.1729917973279953) * gru_0_out_t0_48 + (0.13345783948898315) * gru_0_out_t0_49 + (2.0049755573272705) * gru_0_out_t0_50 + (-0.55315738916397095) * gru_0_out_t0_51 + (-0.19570975005626678) * gru_0_out_t0_52 + (0.3481350839138031) * gru_0_out_t0_53 + (-0.12740860879421234) * gru_0_out_t0_54 + (1.5709991455078125) * gru_0_out_t0_55 + (-0.73046004772186279) * gru_0_out_t0_56 + (-0.35761624574661255) * gru_0_out_t0_57 + (-0.16454377770423889) * gru_0_out_t0_58 + (1.2947542667388916) * gru_0_out_t0_59 + (0.043653972446918488) * gru_0_out_t0_60 + (1.1869040727615356) * gru_0_out_t0_61 + (-0.12487702071666718) * gru_0_out_t0_62 + (-1.4327778816223145) * gru_0_out_t0_63 + (0.56060123443603516) * gru_1_rev_t1_h_0 + (1.1173454523086548) * gru_1_rev_t1_h_1 + (-0.5045972466468811) * gru_1_rev_t1_h_2 + (0.75879621505737305) * gru_1_rev_t1_h_3 + (-1.1040316820144653) * gru_1_rev_t1_h_4 + (0.11088752746582031) * gru_1_rev_t1_h_5 + (-0.65783864259719849) * gru_1_rev_t1_h_6 + (-0.40668463706970215) * gru_1_rev_t1_h_7 + (0.3488437831401825) * gru_1_rev_t1_h_8 + (0.24018880724906921) * gru_1_rev_t1_h_9 + (-0.014562197960913181) * gru_1_rev_t1_h_10 + (0.083501942455768585) * gru_1_rev_t1_h_11 + (0.14288191497325897) * gru_1_rev_t1_h_12 + (1.6588044166564941) * gru_1_rev_t1_h_13 + (-0.067028895020484924) * gru_1_rev_t1_h_14 + (-0.084810614585876465) * gru_1_rev_t1_h_15 + (1.1551593542098999) * gru_1_rev_t1_h_16 + (-0.058757796883583069) * gru_1_rev_t1_h_17 + (0.0043633878231048584) * gru_1_rev_t1_h_18 + (-0.15587291121482849) * gru_1_rev_t1_h_19 + (-1.0757893323898315) * gru_1_rev_t1_h_20 + (-0.063883475959300995) * gru_1_rev_t1_h_21 + (-0.12322050333023071) * gru_1_rev_t1_h_22 + (0.28772613406181335) * gru_1_rev_t1_h_23 + (-0.61289697885513306) * gru_1_rev_t1_h_24 + (0.26497733592987061) * gru_1_rev_t1_h_25 + (-0.27576336264610291) * gru_1_rev_t1_h_26 + (0.58816933631896973) * gru_1_rev_t1_h_27 + (1.38701331615448) * gru_1_rev_t1_h_28 + (-1.6659246683120728) * gru_1_rev_t1_h_29 + (1.1452916860580444) * gru_1_rev_t1_h_30 + (0.17356152832508087) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.16296866536140442) + (0.1532631516456604) * gru_0_out_t0_0 + (-0.61915451288223267) * gru_0_out_t0_1 + (0.074869431555271149) * gru_0_out_t0_2 + (0.54278123378753662) * gru_0_out_t0_3 + (0.039842478930950165) * gru_0_out_t0_4 + (-0.1616823822259903) * gru_0_out_t0_5 + (0.1021784245967865) * gru_0_out_t0_6 + (0.36382991075515747) * gru_0_out_t0_7 + (0.077224716544151306) * gru_0_out_t0_8 + (-0.18239586055278778) * gru_0_out_t0_9 + (-0.25780755281448364) * gru_0_out_t0_10 + (0.68119543790817261) * gru_0_out_t0_11 + (-0.11030463129281998) * gru_0_out_t0_12 + (0.3421122133731842) * gru_0_out_t0_13 + (-0.46572303771972656) * gru_0_out_t0_14 + (0.41332787275314331) * gru_0_out_t0_15 + (0.68423593044281006) * gru_0_out_t0_16 + (0.81394696235656738) * gru_0_out_t0_17 + (0.098360829055309296) * gru_0_out_t0_18 + (0.51598650217056274) * gru_0_out_t0_19 + (1.3858033418655396) * gru_0_out_t0_20 + (0.33486023545265198) * gru_0_out_t0_21 + (0.50753843784332275) * gru_0_out_t0_22 + (-0.41474831104278564) * gru_0_out_t0_23 + (-0.64757919311523438) * gru_0_out_t0_24 + (-0.05926162376999855) * gru_0_out_t0_25 + (-0.33416551351547241) * gru_0_out_t0_26 + (0.19750687479972839) * gru_0_out_t0_27 + (-1.6423913240432739) * gru_0_out_t0_28 + (0.82888263463973999) * gru_0_out_t0_29 + (-0.011365357786417007) * gru_0_out_t0_30 + (0.27506965398788452) * gru_0_out_t0_31 + (-0.088003717362880707) * gru_0_out_t0_32 + (-0.57611697912216187) * gru_0_out_t0_33 + (-0.45926523208618164) * gru_0_out_t0_34 + (0.039115488529205322) * gru_0_out_t0_35 + (0.45749962329864502) * gru_0_out_t0_36 + (0.13006094098091125) * gru_0_out_t0_37 + (0.75557416677474976) * gru_0_out_t0_38 + (-0.57008731365203857) * gru_0_out_t0_39 + (0.7773665189743042) * gru_0_out_t0_40 + (-0.15872423350811005) * gru_0_out_t0_41 + (-0.36064416170120239) * gru_0_out_t0_42 + (0.11046507209539413) * gru_0_out_t0_43 + (-0.076829344034194946) * gru_0_out_t0_44 + (-0.4532371461391449) * gru_0_out_t0_45 + (-1.6157467365264893) * gru_0_out_t0_46 + (0.046743594110012054) * gru_0_out_t0_47 + (0.48785626888275146) * gru_0_out_t0_48 + (-0.23775121569633484) * gru_0_out_t0_49 + (0.614296555519104) * gru_0_out_t0_50 + (-0.20721395313739777) * gru_0_out_t0_51 + (0.59868758916854858) * gru_0_out_t0_52 + (0.11702436953783035) * gru_0_out_t0_53 + (-0.34612852334976196) * gru_0_out_t0_54 + (0.6845734715461731) * gru_0_out_t0_55 + (-0.15184815227985382) * gru_0_out_t0_56 + (-0.26018008589744568) * gru_0_out_t0_57 + (0.040635313838720322) * gru_0_out_t0_58 + (0.42831382155418396) * gru_0_out_t0_59 + (-0.39042747020721436) * gru_0_out_t0_60 + (0.12128127366304398) * gru_0_out_t0_61 + (-0.39848178625106812) * gru_0_out_t0_62 + (-1.281664252281189) * gru_0_out_t0_63 + (-0.046609837561845779) * gru_1_rev_t1_h_0 + (0.72684967517852783) * gru_1_rev_t1_h_1 + (0.24697364866733551) * gru_1_rev_t1_h_2 + (0.77732443809509277) * gru_1_rev_t1_h_3 + (-1.0642678737640381) * gru_1_rev_t1_h_4 + (-0.8105437159538269) * gru_1_rev_t1_h_5 + (0.19246083498001099) * gru_1_rev_t1_h_6 + (0.010306928306818008) * gru_1_rev_t1_h_7 + (0.26187005639076233) * gru_1_rev_t1_h_8 + (-1.072833776473999) * gru_1_rev_t1_h_9 + (0.82778781652450562) * gru_1_rev_t1_h_10 + (1.5634140968322754) * gru_1_rev_t1_h_11 + (1.1738986968994141) * gru_1_rev_t1_h_12 + (2.344390869140625) * gru_1_rev_t1_h_13 + (0.60699152946472168) * gru_1_rev_t1_h_14 + (0.28138783574104309) * gru_1_rev_t1_h_15 + (0.22183319926261902) * gru_1_rev_t1_h_16 + (-0.73195558786392212) * gru_1_rev_t1_h_17 + (0.16448508203029633) * gru_1_rev_t1_h_18 + (-0.88525259494781494) * gru_1_rev_t1_h_19 + (-2.0793793201446533) * gru_1_rev_t1_h_20 + (0.12166190892457962) * gru_1_rev_t1_h_21 + (1.0161861181259155) * gru_1_rev_t1_h_22 + (0.18954348564147949) * gru_1_rev_t1_h_23 + (2.2387914657592773) * gru_1_rev_t1_h_24 + (-1.3264570236206055) * gru_1_rev_t1_h_25 + (-1.0823590755462646) * gru_1_rev_t1_h_26 + (1.2973599433898926) * gru_1_rev_t1_h_27 + (1.6622099876403809) * gru_1_rev_t1_h_28 + (-0.42558130621910095) * gru_1_rev_t1_h_29 + (-0.75155282020568848) * gru_1_rev_t1_h_30 + (-0.22933517396450043) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.24233773350715637) + (0.42769870162010193) * gru_0_out_t0_0 + (-0.093199752271175385) * gru_0_out_t0_1 + (-0.23331144452095032) * gru_0_out_t0_2 + (-0.95216339826583862) * gru_0_out_t0_3 + (-0.043934833258390427) * gru_0_out_t0_4 + (-0.33234021067619324) * gru_0_out_t0_5 + (-0.0071947770193219185) * gru_0_out_t0_6 + (1.2455120086669922) * gru_0_out_t0_7 + (0.21658831834793091) * gru_0_out_t0_8 + (-0.29356372356414795) * gru_0_out_t0_9 + (0.32628095149993896) * gru_0_out_t0_10 + (0.12682090699672699) * gru_0_out_t0_11 + (-0.13583275675773621) * gru_0_out_t0_12 + (0.16946811974048615) * gru_0_out_t0_13 + (0.44435712695121765) * gru_0_out_t0_14 + (-0.34305348992347717) * gru_0_out_t0_15 + (-0.6105351448059082) * gru_0_out_t0_16 + (-0.50137782096862793) * gru_0_out_t0_17 + (-0.26719820499420166) * gru_0_out_t0_18 + (0.017057968303561211) * gru_0_out_t0_19 + (0.10998648405075073) * gru_0_out_t0_20 + (-0.77550971508026123) * gru_0_out_t0_21 + (-0.058590933680534363) * gru_0_out_t0_22 + (-0.3645203709602356) * gru_0_out_t0_23 + (0.70039337873458862) * gru_0_out_t0_24 + (0.29853531718254089) * gru_0_out_t0_25 + (-0.11782580614089966) * gru_0_out_t0_26 + (-0.18577118217945099) * gru_0_out_t0_27 + (0.41717174649238586) * gru_0_out_t0_28 + (0.74937188625335693) * gru_0_out_t0_29 + (0.33273395895957947) * gru_0_out_t0_30 + (-1.0429728031158447) * gru_0_out_t0_31 + (2.5278427600860596) * gru_0_out_t0_32 + (0.15409055352210999) * gru_0_out_t0_33 + (-0.073881037533283234) * gru_0_out_t0_34 + (0.034905578941106796) * gru_0_out_t0_35 + (0.28732883930206299) * gru_0_out_t0_36 + (-0.040987115353345871) * gru_0_out_t0_37 + (-0.086160756647586823) * gru_0_out_t0_38 + (0.32070344686508179) * gru_0_out_t0_39 + (-0.60531079769134521) * gru_0_out_t0_40 + (-0.12663641571998596) * gru_0_out_t0_41 + (0.59953141212463379) * gru_0_out_t0_42 + (0.016223754733800888) * gru_0_out_t0_43 + (-0.054653074592351913) * gru_0_out_t0_44 + (-0.24534384906291962) * gru_0_out_t0_45 + (1.3737455606460571) * gru_0_out_t0_46 + (-0.76306742429733276) * gru_0_out_t0_47 + (0.067664369940757751) * gru_0_out_t0_48 + (0.11779728531837463) * gru_0_out_t0_49 + (-0.37777045369148254) * gru_0_out_t0_50 + (-0.1212870329618454) * gru_0_out_t0_51 + (-0.18890190124511719) * gru_0_out_t0_52 + (0.57070964574813843) * gru_0_out_t0_53 + (-0.11837755888700485) * gru_0_out_t0_54 + (0.54012036323547363) * gru_0_out_t0_55 + (0.059383399784564972) * gru_0_out_t0_56 + (-0.17909801006317139) * gru_0_out_t0_57 + (0.20343297719955444) * gru_0_out_t0_58 + (-1.0960054397583008) * gru_0_out_t0_59 + (-1.1222445964813232) * gru_0_out_t0_60 + (-1.0134117603302002) * gru_0_out_t0_61 + (-0.16041722893714905) * gru_0_out_t0_62 + (0.76451492309570312) * gru_0_out_t0_63 + gate_r * ((0.31511962413787842) + (-0.647408127784729) * gru_1_rev_t1_h_0 + (0.42277529835700989) * gru_1_rev_t1_h_1 + (-0.17567196488380432) * gru_1_rev_t1_h_2 + (-0.27702856063842773) * gru_1_rev_t1_h_3 + (0.54943692684173584) * gru_1_rev_t1_h_4 + (0.35554459691047668) * gru_1_rev_t1_h_5 + (-0.064035601913928986) * gru_1_rev_t1_h_6 + (-0.11003079265356064) * gru_1_rev_t1_h_7 + (-0.42061084508895874) * gru_1_rev_t1_h_8 + (0.67624366283416748) * gru_1_rev_t1_h_9 + (-0.46658337116241455) * gru_1_rev_t1_h_10 + (-1.1924782991409302) * gru_1_rev_t1_h_11 + (1.28794264793396) * gru_1_rev_t1_h_12 + (-0.81556075811386108) * gru_1_rev_t1_h_13 + (-0.31411981582641602) * gru_1_rev_t1_h_14 + (-0.0044255699031054974) * gru_1_rev_t1_h_15 + (-0.098814971745014191) * gru_1_rev_t1_h_16 + (0.55211502313613892) * gru_1_rev_t1_h_17 + (-0.51023662090301514) * gru_1_rev_t1_h_18 + (0.97332876920700073) * gru_1_rev_t1_h_19 + (1.4454872608184814) * gru_1_rev_t1_h_20 + (-0.042069762945175171) * gru_1_rev_t1_h_21 + (0.22468595206737518) * gru_1_rev_t1_h_22 + (-0.12342973053455353) * gru_1_rev_t1_h_23 + (0.56658488512039185) * gru_1_rev_t1_h_24 + (0.75614380836486816) * gru_1_rev_t1_h_25 + (0.062464281916618347) * gru_1_rev_t1_h_26 + (-0.24281127750873566) * gru_1_rev_t1_h_27 + (0.43438053131103516) * gru_1_rev_t1_h_28 + (0.48558735847473145) * gru_1_rev_t1_h_29 + (-0.9780610203742981) * gru_1_rev_t1_h_30 + (-0.55911368131637573) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_21 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_21;
    // h=22
    gate_r = sigmoid((0.057750921696424484) + (-0.056154847145080566) * gru_0_out_t0_0 + (0.13897086679935455) * gru_0_out_t0_1 + (0.0013480753405019641) * gru_0_out_t0_2 + (0.84241616725921631) * gru_0_out_t0_3 + (1.5201041698455811) * gru_0_out_t0_4 + (0.18867923319339752) * gru_0_out_t0_5 + (-0.41475176811218262) * gru_0_out_t0_6 + (-0.88454413414001465) * gru_0_out_t0_7 + (0.94310766458511353) * gru_0_out_t0_8 + (1.6871911287307739) * gru_0_out_t0_9 + (-1.4982982873916626) * gru_0_out_t0_10 + (-0.037357538938522339) * gru_0_out_t0_11 + (0.11211337894201279) * gru_0_out_t0_12 + (-0.033419989049434662) * gru_0_out_t0_13 + (0.073133848607540131) * gru_0_out_t0_14 + (1.0399951934814453) * gru_0_out_t0_15 + (-0.074085615575313568) * gru_0_out_t0_16 + (0.31649738550186157) * gru_0_out_t0_17 + (0.12414709478616714) * gru_0_out_t0_18 + (2.0231220722198486) * gru_0_out_t0_19 + (1.1347267627716064) * gru_0_out_t0_20 + (1.1279611587524414) * gru_0_out_t0_21 + (-0.90489894151687622) * gru_0_out_t0_22 + (0.42612096667289734) * gru_0_out_t0_23 + (-2.1843688488006592) * gru_0_out_t0_24 + (-0.24569439888000488) * gru_0_out_t0_25 + (1.36988365650177) * gru_0_out_t0_26 + (1.8121097087860107) * gru_0_out_t0_27 + (2.2856457233428955) * gru_0_out_t0_28 + (1.5955206155776978) * gru_0_out_t0_29 + (-0.8710293173789978) * gru_0_out_t0_30 + (2.5988976955413818) * gru_0_out_t0_31 + (0.1235545426607132) * gru_0_out_t0_32 + (-0.26221072673797607) * gru_0_out_t0_33 + (-0.25203260779380798) * gru_0_out_t0_34 + (0.2506517767906189) * gru_0_out_t0_35 + (0.18021835386753082) * gru_0_out_t0_36 + (-0.20845691859722137) * gru_0_out_t0_37 + (0.18121108412742615) * gru_0_out_t0_38 + (1.5272489786148071) * gru_0_out_t0_39 + (-1.0454883575439453) * gru_0_out_t0_40 + (0.47630134224891663) * gru_0_out_t0_41 + (-1.2767690420150757) * gru_0_out_t0_42 + (0.34895554184913635) * gru_0_out_t0_43 + (-0.92250460386276245) * gru_0_out_t0_44 + (0.50776797533035278) * gru_0_out_t0_45 + (0.096638485789299011) * gru_0_out_t0_46 + (-0.052310612052679062) * gru_0_out_t0_47 + (-0.15840868651866913) * gru_0_out_t0_48 + (-0.43107223510742188) * gru_0_out_t0_49 + (-0.50884926319122314) * gru_0_out_t0_50 + (0.86771476268768311) * gru_0_out_t0_51 + (0.057381913065910339) * gru_0_out_t0_52 + (-0.25849461555480957) * gru_0_out_t0_53 + (-1.2260463237762451) * gru_0_out_t0_54 + (-3.3921341896057129) * gru_0_out_t0_55 + (-0.52439725399017334) * gru_0_out_t0_56 + (-0.11193255335092545) * gru_0_out_t0_57 + (1.3856498003005981) * gru_0_out_t0_58 + (-2.0449039936065674) * gru_0_out_t0_59 + (0.33423393964767456) * gru_0_out_t0_60 + (0.67172849178314209) * gru_0_out_t0_61 + (0.95241349935531616) * gru_0_out_t0_62 + (1.1145249605178833) * gru_0_out_t0_63 + (0.82594448328018188) * gru_1_rev_t1_h_0 + (0.34742063283920288) * gru_1_rev_t1_h_1 + (-0.9520682692527771) * gru_1_rev_t1_h_2 + (-0.54514050483703613) * gru_1_rev_t1_h_3 + (-0.12529785931110382) * gru_1_rev_t1_h_4 + (-0.91637319326400757) * gru_1_rev_t1_h_5 + (0.60567164421081543) * gru_1_rev_t1_h_6 + (-0.12158635258674622) * gru_1_rev_t1_h_7 + (-0.22215896844863892) * gru_1_rev_t1_h_8 + (1.1385641098022461) * gru_1_rev_t1_h_9 + (-0.42934224009513855) * gru_1_rev_t1_h_10 + (1.600522518157959) * gru_1_rev_t1_h_11 + (-0.42535543441772461) * gru_1_rev_t1_h_12 + (-1.3368288278579712) * gru_1_rev_t1_h_13 + (-0.59059882164001465) * gru_1_rev_t1_h_14 + (-0.027790982276201248) * gru_1_rev_t1_h_15 + (0.12042590975761414) * gru_1_rev_t1_h_16 + (0.30117371678352356) * gru_1_rev_t1_h_17 + (0.56971359252929688) * gru_1_rev_t1_h_18 + (0.23860064148902893) * gru_1_rev_t1_h_19 + (0.18275520205497742) * gru_1_rev_t1_h_20 + (-0.10323323309421539) * gru_1_rev_t1_h_21 + (-0.10748326033353806) * gru_1_rev_t1_h_22 + (0.69824504852294922) * gru_1_rev_t1_h_23 + (0.23407538235187531) * gru_1_rev_t1_h_24 + (0.42144590616226196) * gru_1_rev_t1_h_25 + (0.68003606796264648) * gru_1_rev_t1_h_26 + (-0.3259570300579071) * gru_1_rev_t1_h_27 + (-2.7651863098144531) * gru_1_rev_t1_h_28 + (-0.60263597965240479) * gru_1_rev_t1_h_29 + (-2.2399814128875732) * gru_1_rev_t1_h_30 + (0.48584973812103271) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((1.3430523872375488) + (0.013889334164559841) * gru_0_out_t0_0 + (-0.5356372594833374) * gru_0_out_t0_1 + (-1.2895878553390503) * gru_0_out_t0_2 + (-1.0495072603225708) * gru_0_out_t0_3 + (-0.033183876425027847) * gru_0_out_t0_4 + (0.42511123418807983) * gru_0_out_t0_5 + (-1.2656540870666504) * gru_0_out_t0_6 + (-0.51720172166824341) * gru_0_out_t0_7 + (-0.34565845131874084) * gru_0_out_t0_8 + (-0.029040638357400894) * gru_0_out_t0_9 + (1.1226614713668823) * gru_0_out_t0_10 + (0.15075351297855377) * gru_0_out_t0_11 + (-0.22274598479270935) * gru_0_out_t0_12 + (0.60623210668563843) * gru_0_out_t0_13 + (0.63378649950027466) * gru_0_out_t0_14 + (0.068881422281265259) * gru_0_out_t0_15 + (0.034448318183422089) * gru_0_out_t0_16 + (-0.15120050311088562) * gru_0_out_t0_17 + (-0.51955109834671021) * gru_0_out_t0_18 + (0.68477970361709595) * gru_0_out_t0_19 + (1.3593225479125977) * gru_0_out_t0_20 + (0.20678189396858215) * gru_0_out_t0_21 + (-0.54600894451141357) * gru_0_out_t0_22 + (-0.44547775387763977) * gru_0_out_t0_23 + (-0.13123823702335358) * gru_0_out_t0_24 + (-0.61925911903381348) * gru_0_out_t0_25 + (-0.12913720309734344) * gru_0_out_t0_26 + (0.10447137057781219) * gru_0_out_t0_27 + (-0.045564617961645126) * gru_0_out_t0_28 + (-0.23027780652046204) * gru_0_out_t0_29 + (0.73600399494171143) * gru_0_out_t0_30 + (0.41531771421432495) * gru_0_out_t0_31 + (0.30127134919166565) * gru_0_out_t0_32 + (0.054785780608654022) * gru_0_out_t0_33 + (-0.39064204692840576) * gru_0_out_t0_34 + (1.0434416532516479) * gru_0_out_t0_35 + (-0.038481492549180984) * gru_0_out_t0_36 + (-0.14371579885482788) * gru_0_out_t0_37 + (-0.20561836659908295) * gru_0_out_t0_38 + (-0.19823424518108368) * gru_0_out_t0_39 + (-2.0175232887268066) * gru_0_out_t0_40 + (-0.017632249742746353) * gru_0_out_t0_41 + (0.35067400336265564) * gru_0_out_t0_42 + (0.055032625794410706) * gru_0_out_t0_43 + (0.54710888862609863) * gru_0_out_t0_44 + (0.37148800492286682) * gru_0_out_t0_45 + (-0.80432158708572388) * gru_0_out_t0_46 + (-0.33048826456069946) * gru_0_out_t0_47 + (-0.71915537118911743) * gru_0_out_t0_48 + (0.1518896222114563) * gru_0_out_t0_49 + (-0.82423019409179688) * gru_0_out_t0_50 + (0.30971330404281616) * gru_0_out_t0_51 + (0.12231264263391495) * gru_0_out_t0_52 + (0.24122056365013123) * gru_0_out_t0_53 + (-0.22144995629787445) * gru_0_out_t0_54 + (-0.020980218425393105) * gru_0_out_t0_55 + (0.45581918954849243) * gru_0_out_t0_56 + (0.35016795992851257) * gru_0_out_t0_57 + (0.090445183217525482) * gru_0_out_t0_58 + (1.9483424425125122) * gru_0_out_t0_59 + (0.94795984029769897) * gru_0_out_t0_60 + (1.3683040142059326) * gru_0_out_t0_61 + (-0.37391418218612671) * gru_0_out_t0_62 + (0.56186920404434204) * gru_0_out_t0_63 + (-0.6437690258026123) * gru_1_rev_t1_h_0 + (-0.50128811597824097) * gru_1_rev_t1_h_1 + (-0.60391402244567871) * gru_1_rev_t1_h_2 + (-0.28998616337776184) * gru_1_rev_t1_h_3 + (-0.14618688821792603) * gru_1_rev_t1_h_4 + (0.71750050783157349) * gru_1_rev_t1_h_5 + (0.11274527013301849) * gru_1_rev_t1_h_6 + (-0.12757864594459534) * gru_1_rev_t1_h_7 + (-0.49147328734397888) * gru_1_rev_t1_h_8 + (0.11160275340080261) * gru_1_rev_t1_h_9 + (-0.16009573638439178) * gru_1_rev_t1_h_10 + (0.45426768064498901) * gru_1_rev_t1_h_11 + (-0.66326415538787842) * gru_1_rev_t1_h_12 + (0.84251028299331665) * gru_1_rev_t1_h_13 + (-0.13162185251712799) * gru_1_rev_t1_h_14 + (-0.23347215354442596) * gru_1_rev_t1_h_15 + (0.30931606888771057) * gru_1_rev_t1_h_16 + (0.37610247731208801) * gru_1_rev_t1_h_17 + (0.097947828471660614) * gru_1_rev_t1_h_18 + (0.24867589771747589) * gru_1_rev_t1_h_19 + (1.9795181751251221) * gru_1_rev_t1_h_20 + (0.42106518149375916) * gru_1_rev_t1_h_21 + (-1.7667545080184937) * gru_1_rev_t1_h_22 + (0.6429639458656311) * gru_1_rev_t1_h_23 + (0.44902694225311279) * gru_1_rev_t1_h_24 + (0.92394447326660156) * gru_1_rev_t1_h_25 + (0.47967562079429626) * gru_1_rev_t1_h_26 + (0.69406092166900635) * gru_1_rev_t1_h_27 + (-0.44688227772712708) * gru_1_rev_t1_h_28 + (0.42540860176086426) * gru_1_rev_t1_h_29 + (1.7737963199615479) * gru_1_rev_t1_h_30 + (-0.1357877254486084) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.041076365858316422) + (0.30681049823760986) * gru_0_out_t0_0 + (-0.14824993908405304) * gru_0_out_t0_1 + (0.36111143231391907) * gru_0_out_t0_2 + (-0.78955298662185669) * gru_0_out_t0_3 + (-2.1200120449066162) * gru_0_out_t0_4 + (0.23089653253555298) * gru_0_out_t0_5 + (-0.11731218546628952) * gru_0_out_t0_6 + (1.176706075668335) * gru_0_out_t0_7 + (-0.051518682390451431) * gru_0_out_t0_8 + (-1.3824454545974731) * gru_0_out_t0_9 + (-0.51499390602111816) * gru_0_out_t0_10 + (0.46933811902999878) * gru_0_out_t0_11 + (-0.81383669376373291) * gru_0_out_t0_12 + (-0.28008148074150085) * gru_0_out_t0_13 + (0.29727181792259216) * gru_0_out_t0_14 + (-0.1719098687171936) * gru_0_out_t0_15 + (0.33642524480819702) * gru_0_out_t0_16 + (0.20388582348823547) * gru_0_out_t0_17 + (-0.13840657472610474) * gru_0_out_t0_18 + (0.095529749989509583) * gru_0_out_t0_19 + (0.46676459908485413) * gru_0_out_t0_20 + (0.8827667236328125) * gru_0_out_t0_21 + (0.06217682734131813) * gru_0_out_t0_22 + (-0.36629402637481689) * gru_0_out_t0_23 + (0.22614669799804688) * gru_0_out_t0_24 + (0.44407930970191956) * gru_0_out_t0_25 + (1.4078409671783447) * gru_0_out_t0_26 + (-0.54250109195709229) * gru_0_out_t0_27 + (-1.6869549751281738) * gru_0_out_t0_28 + (0.23521864414215088) * gru_0_out_t0_29 + (0.072822071611881256) * gru_0_out_t0_30 + (-0.97959613800048828) * gru_0_out_t0_31 + (1.1799769401550293) * gru_0_out_t0_32 + (0.21055474877357483) * gru_0_out_t0_33 + (-0.040410742163658142) * gru_0_out_t0_34 + (0.32957890629768372) * gru_0_out_t0_35 + (-0.0005777247715741396) * gru_0_out_t0_36 + (0.048569560050964355) * gru_0_out_t0_37 + (0.22198639810085297) * gru_0_out_t0_38 + (-1.2681800127029419) * gru_0_out_t0_39 + (0.40665030479431152) * gru_0_out_t0_40 + (-0.98193603754043579) * gru_0_out_t0_41 + (-2.006523609161377) * gru_0_out_t0_42 + (0.19985388219356537) * gru_0_out_t0_43 + (0.9103049635887146) * gru_0_out_t0_44 + (0.015629034489393234) * gru_0_out_t0_45 + (1.615606427192688) * gru_0_out_t0_46 + (-0.79374998807907104) * gru_0_out_t0_47 + (-0.44329735636711121) * gru_0_out_t0_48 + (0.46246448159217834) * gru_0_out_t0_49 + (-0.076922833919525146) * gru_0_out_t0_50 + (0.32351997494697571) * gru_0_out_t0_51 + (0.032646194100379944) * gru_0_out_t0_52 + (0.35222214460372925) * gru_0_out_t0_53 + (0.69927585124969482) * gru_0_out_t0_54 + (-0.27106162905693054) * gru_0_out_t0_55 + (-1.4039241075515747) * gru_0_out_t0_56 + (0.19063282012939453) * gru_0_out_t0_57 + (-0.87392652034759521) * gru_0_out_t0_58 + (-0.099939815700054169) * gru_0_out_t0_59 + (-0.38854578137397766) * gru_0_out_t0_60 + (-0.0058568152599036694) * gru_0_out_t0_61 + (-0.4768214225769043) * gru_0_out_t0_62 + (1.9110003709793091) * gru_0_out_t0_63 + gate_r * ((-0.72957420349121094) + (-0.91804677248001099) * gru_1_rev_t1_h_0 + (-0.19567789137363434) * gru_1_rev_t1_h_1 + (0.89793300628662109) * gru_1_rev_t1_h_2 + (-0.35803073644638062) * gru_1_rev_t1_h_3 + (0.16755181550979614) * gru_1_rev_t1_h_4 + (0.65617823600769043) * gru_1_rev_t1_h_5 + (1.0033358335494995) * gru_1_rev_t1_h_6 + (0.11710573732852936) * gru_1_rev_t1_h_7 + (1.4375920295715332) * gru_1_rev_t1_h_8 + (0.2616783082485199) * gru_1_rev_t1_h_9 + (-0.30419912934303284) * gru_1_rev_t1_h_10 + (0.26006925106048584) * gru_1_rev_t1_h_11 + (0.68746364116668701) * gru_1_rev_t1_h_12 + (1.8257802724838257) * gru_1_rev_t1_h_13 + (0.16062659025192261) * gru_1_rev_t1_h_14 + (0.049167849123477936) * gru_1_rev_t1_h_15 + (1.218126654624939) * gru_1_rev_t1_h_16 + (-1.1750348806381226) * gru_1_rev_t1_h_17 + (0.10771293938159943) * gru_1_rev_t1_h_18 + (1.8838931322097778) * gru_1_rev_t1_h_19 + (0.67132651805877686) * gru_1_rev_t1_h_20 + (0.90741914510726929) * gru_1_rev_t1_h_21 + (1.4612314701080322) * gru_1_rev_t1_h_22 + (0.4346010684967041) * gru_1_rev_t1_h_23 + (0.51001781225204468) * gru_1_rev_t1_h_24 + (-0.094051219522953033) * gru_1_rev_t1_h_25 + (-0.24493266642093658) * gru_1_rev_t1_h_26 + (1.2932156324386597) * gru_1_rev_t1_h_27 + (-2.0425763130187988) * gru_1_rev_t1_h_28 + (0.39931395649909973) * gru_1_rev_t1_h_29 + (-0.24287617206573486) * gru_1_rev_t1_h_30 + (-0.45157921314239502) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_22 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_22;
    // h=23
    gate_r = sigmoid((0.57912248373031616) + (-0.060610782355070114) * gru_0_out_t0_0 + (-2.4822282791137695) * gru_0_out_t0_1 + (1.2930433750152588) * gru_0_out_t0_2 + (1.0794585943222046) * gru_0_out_t0_3 + (-0.23055748641490936) * gru_0_out_t0_4 + (0.77691227197647095) * gru_0_out_t0_5 + (-0.96379095315933228) * gru_0_out_t0_6 + (-0.79916435480117798) * gru_0_out_t0_7 + (-0.56424790620803833) * gru_0_out_t0_8 + (1.9146583080291748) * gru_0_out_t0_9 + (-1.3327031135559082) * gru_0_out_t0_10 + (-0.56662720441818237) * gru_0_out_t0_11 + (0.064468078315258026) * gru_0_out_t0_12 + (1.5441648960113525) * gru_0_out_t0_13 + (0.045211747288703918) * gru_0_out_t0_14 + (1.7488610744476318) * gru_0_out_t0_15 + (-0.10053617507219315) * gru_0_out_t0_16 + (0.050078056752681732) * gru_0_out_t0_17 + (-0.20855963230133057) * gru_0_out_t0_18 + (-0.43739992380142212) * gru_0_out_t0_19 + (0.49685609340667725) * gru_0_out_t0_20 + (-0.75689160823822021) * gru_0_out_t0_21 + (1.5578945875167847) * gru_0_out_t0_22 + (0.43617698550224304) * gru_0_out_t0_23 + (-1.9216568470001221) * gru_0_out_t0_24 + (-0.14378717541694641) * gru_0_out_t0_25 + (0.0009998345049098134) * gru_0_out_t0_26 + (1.398045539855957) * gru_0_out_t0_27 + (0.28634163737297058) * gru_0_out_t0_28 + (-0.86058545112609863) * gru_0_out_t0_29 + (0.47926723957061768) * gru_0_out_t0_30 + (1.8596919775009155) * gru_0_out_t0_31 + (0.28452193737030029) * gru_0_out_t0_32 + (-0.011272946372628212) * gru_0_out_t0_33 + (0.0011794993188232183) * gru_0_out_t0_34 + (2.7754321098327637) * gru_0_out_t0_35 + (-0.21812771260738373) * gru_0_out_t0_36 + (-0.83816665410995483) * gru_0_out_t0_37 + (0.43304184079170227) * gru_0_out_t0_38 + (1.3147377967834473) * gru_0_out_t0_39 + (0.56476986408233643) * gru_0_out_t0_40 + (3.2157347202301025) * gru_0_out_t0_41 + (1.3864707946777344) * gru_0_out_t0_42 + (0.072475507855415344) * gru_0_out_t0_43 + (0.36776167154312134) * gru_0_out_t0_44 + (0.35382428765296936) * gru_0_out_t0_45 + (0.37392261624336243) * gru_0_out_t0_46 + (-0.40313887596130371) * gru_0_out_t0_47 + (0.26513242721557617) * gru_0_out_t0_48 + (-0.11508964747190475) * gru_0_out_t0_49 + (0.38999029994010925) * gru_0_out_t0_50 + (2.5998020172119141) * gru_0_out_t0_51 + (0.30950894951820374) * gru_0_out_t0_52 + (-0.14022338390350342) * gru_0_out_t0_53 + (1.7979782819747925) * gru_0_out_t0_54 + (0.41404670476913452) * gru_0_out_t0_55 + (1.2918124198913574) * gru_0_out_t0_56 + (0.82758808135986328) * gru_0_out_t0_57 + (-0.47905108332633972) * gru_0_out_t0_58 + (-1.1227724552154541) * gru_0_out_t0_59 + (0.11583571881055832) * gru_0_out_t0_60 + (0.88509285449981689) * gru_0_out_t0_61 + (0.6007656455039978) * gru_0_out_t0_62 + (-2.3330786228179932) * gru_0_out_t0_63 + (0.078306719660758972) * gru_1_rev_t1_h_0 + (-0.59744828939437866) * gru_1_rev_t1_h_1 + (0.56526100635528564) * gru_1_rev_t1_h_2 + (-0.16300034523010254) * gru_1_rev_t1_h_3 + (-0.40841051936149597) * gru_1_rev_t1_h_4 + (1.1211690902709961) * gru_1_rev_t1_h_5 + (-0.078890301287174225) * gru_1_rev_t1_h_6 + (0.025704450905323029) * gru_1_rev_t1_h_7 + (-0.36082515120506287) * gru_1_rev_t1_h_8 + (0.2198510468006134) * gru_1_rev_t1_h_9 + (0.065204158425331116) * gru_1_rev_t1_h_10 + (0.37083712220191956) * gru_1_rev_t1_h_11 + (0.41083091497421265) * gru_1_rev_t1_h_12 + (-0.76392561197280884) * gru_1_rev_t1_h_13 + (-0.024855675175786018) * gru_1_rev_t1_h_14 + (0.37839919328689575) * gru_1_rev_t1_h_15 + (0.16213476657867432) * gru_1_rev_t1_h_16 + (1.2540156841278076) * gru_1_rev_t1_h_17 + (-0.09157998114824295) * gru_1_rev_t1_h_18 + (-0.92853909730911255) * gru_1_rev_t1_h_19 + (-0.35588786005973816) * gru_1_rev_t1_h_20 + (-0.12859392166137695) * gru_1_rev_t1_h_21 + (-0.5163688063621521) * gru_1_rev_t1_h_22 + (-0.022556483745574951) * gru_1_rev_t1_h_23 + (-1.1354420185089111) * gru_1_rev_t1_h_24 + (-0.034524332731962204) * gru_1_rev_t1_h_25 + (0.3575209379196167) * gru_1_rev_t1_h_26 + (-1.2580492496490479) * gru_1_rev_t1_h_27 + (-0.77270752191543579) * gru_1_rev_t1_h_28 + (0.066260375082492828) * gru_1_rev_t1_h_29 + (-0.81471306085586548) * gru_1_rev_t1_h_30 + (-0.020977433770895004) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.25151574611663818) + (0.28577888011932373) * gru_0_out_t0_0 + (0.20749232172966003) * gru_0_out_t0_1 + (0.63410884141921997) * gru_0_out_t0_2 + (-0.17025986313819885) * gru_0_out_t0_3 + (0.086461164057254791) * gru_0_out_t0_4 + (1.0372211933135986) * gru_0_out_t0_5 + (-0.072778031229972839) * gru_0_out_t0_6 + (0.89526069164276123) * gru_0_out_t0_7 + (0.74514442682266235) * gru_0_out_t0_8 + (0.31512308120727539) * gru_0_out_t0_9 + (-0.51057332754135132) * gru_0_out_t0_10 + (-0.068456389009952545) * gru_0_out_t0_11 + (-0.30696448683738708) * gru_0_out_t0_12 + (-0.073415353894233704) * gru_0_out_t0_13 + (0.60118353366851807) * gru_0_out_t0_14 + (-1.0354100465774536) * gru_0_out_t0_15 + (1.5873328447341919) * gru_0_out_t0_16 + (0.69110840559005737) * gru_0_out_t0_17 + (0.014662942849099636) * gru_0_out_t0_18 + (-0.13595007359981537) * gru_0_out_t0_19 + (-0.44445362687110901) * gru_0_out_t0_20 + (3.0455377101898193) * gru_0_out_t0_21 + (-0.12854313850402832) * gru_0_out_t0_22 + (-0.94811779260635376) * gru_0_out_t0_23 + (0.62374234199523926) * gru_0_out_t0_24 + (0.24717363715171814) * gru_0_out_t0_25 + (-0.56860077381134033) * gru_0_out_t0_26 + (0.19470959901809692) * gru_0_out_t0_27 + (0.28060171008110046) * gru_0_out_t0_28 + (-0.38385903835296631) * gru_0_out_t0_29 + (-0.22718565165996552) * gru_0_out_t0_30 + (0.9415745735168457) * gru_0_out_t0_31 + (-1.553417444229126) * gru_0_out_t0_32 + (0.10065502673387527) * gru_0_out_t0_33 + (0.4113616943359375) * gru_0_out_t0_34 + (-0.28567588329315186) * gru_0_out_t0_35 + (0.34574729204177856) * gru_0_out_t0_36 + (-0.19665670394897461) * gru_0_out_t0_37 + (-0.64330911636352539) * gru_0_out_t0_38 + (0.26661631464958191) * gru_0_out_t0_39 + (-3.2169120311737061) * gru_0_out_t0_40 + (-0.47723942995071411) * gru_0_out_t0_41 + (0.27988433837890625) * gru_0_out_t0_42 + (-0.05139295756816864) * gru_0_out_t0_43 + (0.023977510631084442) * gru_0_out_t0_44 + (-0.34234252572059631) * gru_0_out_t0_45 + (-1.0300320386886597) * gru_0_out_t0_46 + (0.75000321865081787) * gru_0_out_t0_47 + (-0.30720952153205872) * gru_0_out_t0_48 + (-0.061271972954273224) * gru_0_out_t0_49 + (0.065337829291820526) * gru_0_out_t0_50 + (0.39977595210075378) * gru_0_out_t0_51 + (-0.37217453122138977) * gru_0_out_t0_52 + (-0.27658239006996155) * gru_0_out_t0_53 + (0.30236941576004028) * gru_0_out_t0_54 + (-0.11339209973812103) * gru_0_out_t0_55 + (0.43587720394134521) * gru_0_out_t0_56 + (0.2908855676651001) * gru_0_out_t0_57 + (0.55984830856323242) * gru_0_out_t0_58 + (0.46695578098297119) * gru_0_out_t0_59 + (0.93862301111221313) * gru_0_out_t0_60 + (0.38193109631538391) * gru_0_out_t0_61 + (0.19808365404605865) * gru_0_out_t0_62 + (-1.0700350999832153) * gru_0_out_t0_63 + (-0.79401862621307373) * gru_1_rev_t1_h_0 + (0.11077437549829483) * gru_1_rev_t1_h_1 + (0.66126930713653564) * gru_1_rev_t1_h_2 + (-0.076787449419498444) * gru_1_rev_t1_h_3 + (-0.29193291068077087) * gru_1_rev_t1_h_4 + (-0.42978444695472717) * gru_1_rev_t1_h_5 + (0.052302252501249313) * gru_1_rev_t1_h_6 + (-0.61247760057449341) * gru_1_rev_t1_h_7 + (0.35741817951202393) * gru_1_rev_t1_h_8 + (0.17685091495513916) * gru_1_rev_t1_h_9 + (-0.43660950660705566) * gru_1_rev_t1_h_10 + (-0.61202120780944824) * gru_1_rev_t1_h_11 + (0.22485090792179108) * gru_1_rev_t1_h_12 + (-0.20352114737033844) * gru_1_rev_t1_h_13 + (0.09755445271730423) * gru_1_rev_t1_h_14 + (-0.0057502305135130882) * gru_1_rev_t1_h_15 + (0.0308732520788908) * gru_1_rev_t1_h_16 + (-0.68934065103530884) * gru_1_rev_t1_h_17 + (-0.77646750211715698) * gru_1_rev_t1_h_18 + (0.53572440147399902) * gru_1_rev_t1_h_19 + (-0.52634060382843018) * gru_1_rev_t1_h_20 + (-0.45791754126548767) * gru_1_rev_t1_h_21 + (-0.37393292784690857) * gru_1_rev_t1_h_22 + (-0.87604033946990967) * gru_1_rev_t1_h_23 + (0.30867010354995728) * gru_1_rev_t1_h_24 + (-0.081227406859397888) * gru_1_rev_t1_h_25 + (-0.96684074401855469) * gru_1_rev_t1_h_26 + (0.3077264130115509) * gru_1_rev_t1_h_27 + (-1.4082832336425781) * gru_1_rev_t1_h_28 + (0.18718896806240082) * gru_1_rev_t1_h_29 + (-0.021717367693781853) * gru_1_rev_t1_h_30 + (-0.55933725833892822) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.12496943771839142) + (0.1448565274477005) * gru_0_out_t0_0 + (0.22692506015300751) * gru_0_out_t0_1 + (-0.097553104162216187) * gru_0_out_t0_2 + (-0.1036965623497963) * gru_0_out_t0_3 + (0.031517598778009415) * gru_0_out_t0_4 + (-0.34878420829772949) * gru_0_out_t0_5 + (-0.37062937021255493) * gru_0_out_t0_6 + (0.20441484451293945) * gru_0_out_t0_7 + (-0.025669548660516739) * gru_0_out_t0_8 + (0.18017725646495819) * gru_0_out_t0_9 + (-0.073015592992305756) * gru_0_out_t0_10 + (0.28086802363395691) * gru_0_out_t0_11 + (-0.09160478413105011) * gru_0_out_t0_12 + (-0.31614860892295837) * gru_0_out_t0_13 + (-0.14097005128860474) * gru_0_out_t0_14 + (-0.082336030900478363) * gru_0_out_t0_15 + (0.26241940259933472) * gru_0_out_t0_16 + (-0.11670865118503571) * gru_0_out_t0_17 + (-0.23459981381893158) * gru_0_out_t0_18 + (0.13176323473453522) * gru_0_out_t0_19 + (0.23414605855941772) * gru_0_out_t0_20 + (0.095174945890903473) * gru_0_out_t0_21 + (-0.37852540612220764) * gru_0_out_t0_22 + (0.28007775545120239) * gru_0_out_t0_23 + (0.36722218990325928) * gru_0_out_t0_24 + (0.23995983600616455) * gru_0_out_t0_25 + (-0.38818418979644775) * gru_0_out_t0_26 + (-0.43615394830703735) * gru_0_out_t0_27 + (0.24126282334327698) * gru_0_out_t0_28 + (0.34801894426345825) * gru_0_out_t0_29 + (0.37655410170555115) * gru_0_out_t0_30 + (-0.84516745805740356) * gru_0_out_t0_31 + (0.58280473947525024) * gru_0_out_t0_32 + (-0.61177223920822144) * gru_0_out_t0_33 + (-0.41152641177177429) * gru_0_out_t0_34 + (-0.53671002388000488) * gru_0_out_t0_35 + (0.34637176990509033) * gru_0_out_t0_36 + (-0.065531842410564423) * gru_0_out_t0_37 + (0.1317916065454483) * gru_0_out_t0_38 + (-0.20242181420326233) * gru_0_out_t0_39 + (0.094229914247989655) * gru_0_out_t0_40 + (-0.89318108558654785) * gru_0_out_t0_41 + (0.62076389789581299) * gru_0_out_t0_42 + (-0.40476745367050171) * gru_0_out_t0_43 + (0.1014166846871376) * gru_0_out_t0_44 + (-0.30219507217407227) * gru_0_out_t0_45 + (-0.23410157859325409) * gru_0_out_t0_46 + (-0.40368464589118958) * gru_0_out_t0_47 + (-0.082179918885231018) * gru_0_out_t0_48 + (0.19890296459197998) * gru_0_out_t0_49 + (0.50316977500915527) * gru_0_out_t0_50 + (0.018120216205716133) * gru_0_out_t0_51 + (0.30786210298538208) * gru_0_out_t0_52 + (-0.22612935304641724) * gru_0_out_t0_53 + (-0.2711627185344696) * gru_0_out_t0_54 + (0.48368421196937561) * gru_0_out_t0_55 + (-0.58510655164718628) * gru_0_out_t0_56 + (0.06196778267621994) * gru_0_out_t0_57 + (-0.29741990566253662) * gru_0_out_t0_58 + (-0.26598015427589417) * gru_0_out_t0_59 + (-0.62684965133666992) * gru_0_out_t0_60 + (-0.46356514096260071) * gru_0_out_t0_61 + (-0.77833431959152222) * gru_0_out_t0_62 + (0.42090794444084167) * gru_0_out_t0_63 + gate_r * ((-0.12716244161128998) + (-0.50767791271209717) * gru_1_rev_t1_h_0 + (-0.045751091092824936) * gru_1_rev_t1_h_1 + (1.0142762660980225) * gru_1_rev_t1_h_2 + (-0.53044146299362183) * gru_1_rev_t1_h_3 + (-0.099377691745758057) * gru_1_rev_t1_h_4 + (0.14739063382148743) * gru_1_rev_t1_h_5 + (0.1935545802116394) * gru_1_rev_t1_h_6 + (-0.033105514943599701) * gru_1_rev_t1_h_7 + (-0.11854406446218491) * gru_1_rev_t1_h_8 + (-0.52346479892730713) * gru_1_rev_t1_h_9 + (-0.0042983214370906353) * gru_1_rev_t1_h_10 + (0.093348026275634766) * gru_1_rev_t1_h_11 + (0.47405683994293213) * gru_1_rev_t1_h_12 + (1.4858615398406982) * gru_1_rev_t1_h_13 + (0.25885635614395142) * gru_1_rev_t1_h_14 + (-0.81367069482803345) * gru_1_rev_t1_h_15 + (-0.55401885509490967) * gru_1_rev_t1_h_16 + (-0.18721428513526917) * gru_1_rev_t1_h_17 + (0.057779837399721146) * gru_1_rev_t1_h_18 + (0.15176242589950562) * gru_1_rev_t1_h_19 + (1.2920783758163452) * gru_1_rev_t1_h_20 + (-0.36697971820831299) * gru_1_rev_t1_h_21 + (0.19116158783435822) * gru_1_rev_t1_h_22 + (-0.52217614650726318) * gru_1_rev_t1_h_23 + (1.4250432252883911) * gru_1_rev_t1_h_24 + (-0.92895668745040894) * gru_1_rev_t1_h_25 + (0.27153488993644714) * gru_1_rev_t1_h_26 + (1.8092880249023438) * gru_1_rev_t1_h_27 + (-0.43880137801170349) * gru_1_rev_t1_h_28 + (1.0088309049606323) * gru_1_rev_t1_h_29 + (-1.3579831123352051) * gru_1_rev_t1_h_30 + (-0.76464974880218506) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_23 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_23;
    // h=24
    gate_r = sigmoid((0.67716670036315918) + (0.12755954265594482) * gru_0_out_t0_0 + (-0.77821284532546997) * gru_0_out_t0_1 + (0.35458076000213623) * gru_0_out_t0_2 + (0.89700609445571899) * gru_0_out_t0_3 + (-0.40275734663009644) * gru_0_out_t0_4 + (0.83693277835845947) * gru_0_out_t0_5 + (0.67218101024627686) * gru_0_out_t0_6 + (-0.89414405822753906) * gru_0_out_t0_7 + (-0.94244480133056641) * gru_0_out_t0_8 + (0.21779540181159973) * gru_0_out_t0_9 + (-0.48200792074203491) * gru_0_out_t0_10 + (-0.482177734375) * gru_0_out_t0_11 + (0.42294710874557495) * gru_0_out_t0_12 + (-0.5128900408744812) * gru_0_out_t0_13 + (0.098782598972320557) * gru_0_out_t0_14 + (0.412679523229599) * gru_0_out_t0_15 + (-1.1664198637008667) * gru_0_out_t0_16 + (-0.066619187593460083) * gru_0_out_t0_17 + (1.0720069408416748) * gru_0_out_t0_18 + (0.62158501148223877) * gru_0_out_t0_19 + (0.52933382987976074) * gru_0_out_t0_20 + (-2.0011000633239746) * gru_0_out_t0_21 + (0.71812653541564941) * gru_0_out_t0_22 + (0.27037239074707031) * gru_0_out_t0_23 + (-1.4750754833221436) * gru_0_out_t0_24 + (0.04219253733754158) * gru_0_out_t0_25 + (0.3134789764881134) * gru_0_out_t0_26 + (1.1332876682281494) * gru_0_out_t0_27 + (1.0728960037231445) * gru_0_out_t0_28 + (0.32814356684684753) * gru_0_out_t0_29 + (0.13439776003360748) * gru_0_out_t0_30 + (0.47268301248550415) * gru_0_out_t0_31 + (2.1907854080200195) * gru_0_out_t0_32 + (-0.68154841661453247) * gru_0_out_t0_33 + (0.088571369647979736) * gru_0_out_t0_34 + (0.049184300005435944) * gru_0_out_t0_35 + (-0.28088828921318054) * gru_0_out_t0_36 + (-0.1946321576833725) * gru_0_out_t0_37 + (0.38633981347084045) * gru_0_out_t0_38 + (0.72349256277084351) * gru_0_out_t0_39 + (2.5432002544403076) * gru_0_out_t0_40 + (0.50516700744628906) * gru_0_out_t0_41 + (0.034253686666488647) * gru_0_out_t0_42 + (0.39487126469612122) * gru_0_out_t0_43 + (0.23286689817905426) * gru_0_out_t0_44 + (0.45215418934822083) * gru_0_out_t0_45 + (-0.44765502214431763) * gru_0_out_t0_46 + (-1.0132352113723755) * gru_0_out_t0_47 + (-0.9002271294593811) * gru_0_out_t0_48 + (1.0863083600997925) * gru_0_out_t0_49 + (0.72558313608169556) * gru_0_out_t0_50 + (-0.9536902904510498) * gru_0_out_t0_51 + (0.12993490695953369) * gru_0_out_t0_52 + (0.44029876589775085) * gru_0_out_t0_53 + (0.14091245830059052) * gru_0_out_t0_54 + (1.0717428922653198) * gru_0_out_t0_55 + (-0.028489610180258751) * gru_0_out_t0_56 + (0.93480628728866577) * gru_0_out_t0_57 + (-0.20069779455661774) * gru_0_out_t0_58 + (-0.23850759863853455) * gru_0_out_t0_59 + (0.17925733327865601) * gru_0_out_t0_60 + (0.90062069892883301) * gru_0_out_t0_61 + (-1.8585528135299683) * gru_0_out_t0_62 + (1.2682526111602783) * gru_0_out_t0_63 + (-0.40378004312515259) * gru_1_rev_t1_h_0 + (0.71817255020141602) * gru_1_rev_t1_h_1 + (-1.4584076404571533) * gru_1_rev_t1_h_2 + (0.088912248611450195) * gru_1_rev_t1_h_3 + (0.8418547511100769) * gru_1_rev_t1_h_4 + (-0.76983118057250977) * gru_1_rev_t1_h_5 + (-0.20257408916950226) * gru_1_rev_t1_h_6 + (0.099691852927207947) * gru_1_rev_t1_h_7 + (-0.48936834931373596) * gru_1_rev_t1_h_8 + (-1.0069247484207153) * gru_1_rev_t1_h_9 + (1.260507345199585) * gru_1_rev_t1_h_10 + (-0.67223137617111206) * gru_1_rev_t1_h_11 + (0.93055087327957153) * gru_1_rev_t1_h_12 + (-0.25944957137107849) * gru_1_rev_t1_h_13 + (-1.1124926805496216) * gru_1_rev_t1_h_14 + (0.59317284822463989) * gru_1_rev_t1_h_15 + (0.37545964121818542) * gru_1_rev_t1_h_16 + (-0.29388353228569031) * gru_1_rev_t1_h_17 + (-0.31289893388748169) * gru_1_rev_t1_h_18 + (0.90587508678436279) * gru_1_rev_t1_h_19 + (-0.49410936236381531) * gru_1_rev_t1_h_20 + (1.3558758497238159) * gru_1_rev_t1_h_21 + (0.28516417741775513) * gru_1_rev_t1_h_22 + (0.68772017955780029) * gru_1_rev_t1_h_23 + (-0.65662240982055664) * gru_1_rev_t1_h_24 + (0.56361442804336548) * gru_1_rev_t1_h_25 + (0.22395345568656921) * gru_1_rev_t1_h_26 + (0.47641894221305847) * gru_1_rev_t1_h_27 + (-0.8307909369468689) * gru_1_rev_t1_h_28 + (-0.41557213664054871) * gru_1_rev_t1_h_29 + (-2.0979766845703125) * gru_1_rev_t1_h_30 + (0.56947797536849976) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.064756311476230621) + (0.30718889832496643) * gru_0_out_t0_0 + (-0.095930680632591248) * gru_0_out_t0_1 + (0.78129267692565918) * gru_0_out_t0_2 + (-0.21648788452148438) * gru_0_out_t0_3 + (-0.50453841686248779) * gru_0_out_t0_4 + (1.4477152824401855) * gru_0_out_t0_5 + (0.613761305809021) * gru_0_out_t0_6 + (1.0879737138748169) * gru_0_out_t0_7 + (0.012940666638314724) * gru_0_out_t0_8 + (-0.27601796388626099) * gru_0_out_t0_9 + (0.30376529693603516) * gru_0_out_t0_10 + (0.98931366205215454) * gru_0_out_t0_11 + (0.52886468172073364) * gru_0_out_t0_12 + (0.77672839164733887) * gru_0_out_t0_13 + (-0.48119845986366272) * gru_0_out_t0_14 + (0.50836753845214844) * gru_0_out_t0_15 + (0.050744246691465378) * gru_0_out_t0_16 + (0.20092304050922394) * gru_0_out_t0_17 + (-0.59187215566635132) * gru_0_out_t0_18 + (-0.46986159682273865) * gru_0_out_t0_19 + (-0.5086822509765625) * gru_0_out_t0_20 + (-0.14866407215595245) * gru_0_out_t0_21 + (0.97529011964797974) * gru_0_out_t0_22 + (-0.19943630695343018) * gru_0_out_t0_23 + (-0.14562016725540161) * gru_0_out_t0_24 + (-0.62057745456695557) * gru_0_out_t0_25 + (0.69045603275299072) * gru_0_out_t0_26 + (0.29122290015220642) * gru_0_out_t0_27 + (1.5295441150665283) * gru_0_out_t0_28 + (0.16073994338512421) * gru_0_out_t0_29 + (-0.34573107957839966) * gru_0_out_t0_30 + (0.31544411182403564) * gru_0_out_t0_31 + (-2.0298264026641846) * gru_0_out_t0_32 + (0.829600989818573) * gru_0_out_t0_33 + (-0.10943248122930527) * gru_0_out_t0_34 + (-0.066457509994506836) * gru_0_out_t0_35 + (0.066131830215454102) * gru_0_out_t0_36 + (0.13418391346931458) * gru_0_out_t0_37 + (-0.54315352439880371) * gru_0_out_t0_38 + (0.75348025560379028) * gru_0_out_t0_39 + (-1.5707815885543823) * gru_0_out_t0_40 + (0.10500741750001907) * gru_0_out_t0_41 + (-0.24067328870296478) * gru_0_out_t0_42 + (0.4787280261516571) * gru_0_out_t0_43 + (-0.28987538814544678) * gru_0_out_t0_44 + (-0.41288614273071289) * gru_0_out_t0_45 + (-1.0574361085891724) * gru_0_out_t0_46 + (0.73015326261520386) * gru_0_out_t0_47 + (0.23295488953590393) * gru_0_out_t0_48 + (-0.084627613425254822) * gru_0_out_t0_49 + (-0.43914982676506042) * gru_0_out_t0_50 + (0.80177938938140869) * gru_0_out_t0_51 + (-0.29905039072036743) * gru_0_out_t0_52 + (-0.020908843725919724) * gru_0_out_t0_53 + (0.30011624097824097) * gru_0_out_t0_54 + (1.5771631002426147) * gru_0_out_t0_55 + (-0.18286755681037903) * gru_0_out_t0_56 + (0.13204255700111389) * gru_0_out_t0_57 + (0.63538879156112671) * gru_0_out_t0_58 + (0.29766595363616943) * gru_0_out_t0_59 + (1.3448009490966797) * gru_0_out_t0_60 + (1.3223707675933838) * gru_0_out_t0_61 + (-0.83467471599578857) * gru_0_out_t0_62 + (-0.71177250146865845) * gru_0_out_t0_63 + (-0.34289127588272095) * gru_1_rev_t1_h_0 + (-0.91829508543014526) * gru_1_rev_t1_h_1 + (0.063749879598617554) * gru_1_rev_t1_h_2 + (0.24851012229919434) * gru_1_rev_t1_h_3 + (-0.99244320392608643) * gru_1_rev_t1_h_4 + (-0.76070690155029297) * gru_1_rev_t1_h_5 + (0.3613036572933197) * gru_1_rev_t1_h_6 + (-0.42517724633216858) * gru_1_rev_t1_h_7 + (-0.056558001786470413) * gru_1_rev_t1_h_8 + (-0.46931847929954529) * gru_1_rev_t1_h_9 + (0.12886594235897064) * gru_1_rev_t1_h_10 + (0.21237972378730774) * gru_1_rev_t1_h_11 + (-0.93901097774505615) * gru_1_rev_t1_h_12 + (-0.17291033267974854) * gru_1_rev_t1_h_13 + (-0.14613461494445801) * gru_1_rev_t1_h_14 + (-0.22833357751369476) * gru_1_rev_t1_h_15 + (0.80675393342971802) * gru_1_rev_t1_h_16 + (0.58238792419433594) * gru_1_rev_t1_h_17 + (0.15494728088378906) * gru_1_rev_t1_h_18 + (0.36121031641960144) * gru_1_rev_t1_h_19 + (0.51009625196456909) * gru_1_rev_t1_h_20 + (-0.99438661336898804) * gru_1_rev_t1_h_21 + (-0.49125656485557556) * gru_1_rev_t1_h_22 + (0.57548278570175171) * gru_1_rev_t1_h_23 + (-0.46654817461967468) * gru_1_rev_t1_h_24 + (-0.29409918189048767) * gru_1_rev_t1_h_25 + (-0.099743455648422241) * gru_1_rev_t1_h_26 + (1.3910070657730103) * gru_1_rev_t1_h_27 + (-1.5768228769302368) * gru_1_rev_t1_h_28 + (-0.38987442851066589) * gru_1_rev_t1_h_29 + (1.1536402702331543) * gru_1_rev_t1_h_30 + (-0.060362204909324646) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.047642260789871216) + (-0.8390384316444397) * gru_0_out_t0_0 + (0.38486915826797485) * gru_0_out_t0_1 + (-0.68896925449371338) * gru_0_out_t0_2 + (0.21516774594783783) * gru_0_out_t0_3 + (0.31702506542205811) * gru_0_out_t0_4 + (-0.53984808921813965) * gru_0_out_t0_5 + (0.3868410587310791) * gru_0_out_t0_6 + (-0.079134516417980194) * gru_0_out_t0_7 + (-0.1364014595746994) * gru_0_out_t0_8 + (-0.41994443535804749) * gru_0_out_t0_9 + (0.87232917547225952) * gru_0_out_t0_10 + (-0.50202840566635132) * gru_0_out_t0_11 + (-0.54522877931594849) * gru_0_out_t0_12 + (-0.65830183029174805) * gru_0_out_t0_13 + (0.2742314338684082) * gru_0_out_t0_14 + (-0.71831399202346802) * gru_0_out_t0_15 + (-0.46435487270355225) * gru_0_out_t0_16 + (-0.27805733680725098) * gru_0_out_t0_17 + (0.46553215384483337) * gru_0_out_t0_18 + (-0.71487146615982056) * gru_0_out_t0_19 + (0.015688169747591019) * gru_0_out_t0_20 + (-0.21254284679889679) * gru_0_out_t0_21 + (-0.1592562347650528) * gru_0_out_t0_22 + (0.51560968160629272) * gru_0_out_t0_23 + (1.200957179069519) * gru_0_out_t0_24 + (-0.23085834085941315) * gru_0_out_t0_25 + (-0.12868762016296387) * gru_0_out_t0_26 + (-0.12676739692687988) * gru_0_out_t0_27 + (-0.56767183542251587) * gru_0_out_t0_28 + (0.13375023007392883) * gru_0_out_t0_29 + (-0.12488507479429245) * gru_0_out_t0_30 + (0.33940032124519348) * gru_0_out_t0_31 + (0.95893466472625732) * gru_0_out_t0_32 + (-0.40778130292892456) * gru_0_out_t0_33 + (0.16722163558006287) * gru_0_out_t0_34 + (-0.34943893551826477) * gru_0_out_t0_35 + (-0.3026462197303772) * gru_0_out_t0_36 + (-0.13663609325885773) * gru_0_out_t0_37 + (0.7228473424911499) * gru_0_out_t0_38 + (1.0917237997055054) * gru_0_out_t0_39 + (-0.47965303063392639) * gru_0_out_t0_40 + (0.50533038377761841) * gru_0_out_t0_41 + (-0.38380688428878784) * gru_0_out_t0_42 + (-0.21269214153289795) * gru_0_out_t0_43 + (-0.37573185563087463) * gru_0_out_t0_44 + (0.29142099618911743) * gru_0_out_t0_45 + (-0.36884379386901855) * gru_0_out_t0_46 + (-0.10382306575775146) * gru_0_out_t0_47 + (0.061545334756374359) * gru_0_out_t0_48 + (-0.039712242782115936) * gru_0_out_t0_49 + (0.36601433157920837) * gru_0_out_t0_50 + (0.10713274776935577) * gru_0_out_t0_51 + (0.72829419374465942) * gru_0_out_t0_52 + (0.39498558640480042) * gru_0_out_t0_53 + (0.20543679594993591) * gru_0_out_t0_54 + (-0.10963305830955505) * gru_0_out_t0_55 + (-1.2933933734893799) * gru_0_out_t0_56 + (-0.037884030491113663) * gru_0_out_t0_57 + (-0.011826789006590843) * gru_0_out_t0_58 + (-1.528321385383606) * gru_0_out_t0_59 + (-0.26187777519226074) * gru_0_out_t0_60 + (0.44501194357872009) * gru_0_out_t0_61 + (0.58552044630050659) * gru_0_out_t0_62 + (-0.26960897445678711) * gru_0_out_t0_63 + gate_r * ((-0.18040646612644196) + (-0.26277837157249451) * gru_1_rev_t1_h_0 + (0.48694694042205811) * gru_1_rev_t1_h_1 + (-0.99450784921646118) * gru_1_rev_t1_h_2 + (0.52640587091445923) * gru_1_rev_t1_h_3 + (0.95334523916244507) * gru_1_rev_t1_h_4 + (0.4776187539100647) * gru_1_rev_t1_h_5 + (-1.2680472135543823) * gru_1_rev_t1_h_6 + (0.049339190125465393) * gru_1_rev_t1_h_7 + (-0.35120463371276855) * gru_1_rev_t1_h_8 + (0.47614026069641113) * gru_1_rev_t1_h_9 + (-1.075276255607605) * gru_1_rev_t1_h_10 + (0.074330717325210571) * gru_1_rev_t1_h_11 + (-1.0357192754745483) * gru_1_rev_t1_h_12 + (0.19469013810157776) * gru_1_rev_t1_h_13 + (-0.47360867261886597) * gru_1_rev_t1_h_14 + (-0.50178152322769165) * gru_1_rev_t1_h_15 + (-0.075868278741836548) * gru_1_rev_t1_h_16 + (1.1177390813827515) * gru_1_rev_t1_h_17 + (-1.0828514099121094) * gru_1_rev_t1_h_18 + (2.2804548740386963) * gru_1_rev_t1_h_19 + (-0.23992703855037689) * gru_1_rev_t1_h_20 + (0.4726739227771759) * gru_1_rev_t1_h_21 + (-0.18442513048648834) * gru_1_rev_t1_h_22 + (0.088708974421024323) * gru_1_rev_t1_h_23 + (-0.25001037120819092) * gru_1_rev_t1_h_24 + (0.86952996253967285) * gru_1_rev_t1_h_25 + (-0.47891974449157715) * gru_1_rev_t1_h_26 + (0.17702697217464447) * gru_1_rev_t1_h_27 + (0.50373721122741699) * gru_1_rev_t1_h_28 + (-0.24426186084747314) * gru_1_rev_t1_h_29 + (-0.037016607820987701) * gru_1_rev_t1_h_30 + (1.5139617919921875) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_24 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_24;
    // h=25
    gate_r = sigmoid((-0.68872278928756714) + (0.36069002747535706) * gru_0_out_t0_0 + (0.71517562866210938) * gru_0_out_t0_1 + (-0.99392968416213989) * gru_0_out_t0_2 + (0.38534748554229736) * gru_0_out_t0_3 + (-0.19741858541965485) * gru_0_out_t0_4 + (0.043304946273565292) * gru_0_out_t0_5 + (1.1694974899291992) * gru_0_out_t0_6 + (0.11177445948123932) * gru_0_out_t0_7 + (-0.20850341022014618) * gru_0_out_t0_8 + (-0.17900639772415161) * gru_0_out_t0_9 + (0.39058849215507507) * gru_0_out_t0_10 + (-0.37520793080329895) * gru_0_out_t0_11 + (0.56499123573303223) * gru_0_out_t0_12 + (0.60227823257446289) * gru_0_out_t0_13 + (-0.37562569975852966) * gru_0_out_t0_14 + (0.37927168607711792) * gru_0_out_t0_15 + (0.92597073316574097) * gru_0_out_t0_16 + (-0.06651720404624939) * gru_0_out_t0_17 + (0.33824589848518372) * gru_0_out_t0_18 + (1.0773898363113403) * gru_0_out_t0_19 + (-0.16736890375614166) * gru_0_out_t0_20 + (0.52859139442443848) * gru_0_out_t0_21 + (0.60521113872528076) * gru_0_out_t0_22 + (-0.42439541220664978) * gru_0_out_t0_23 + (0.20992039144039154) * gru_0_out_t0_24 + (0.90285736322402954) * gru_0_out_t0_25 + (0.52016681432723999) * gru_0_out_t0_26 + (0.13756980001926422) * gru_0_out_t0_27 + (-1.0828664302825928) * gru_0_out_t0_28 + (0.15396140515804291) * gru_0_out_t0_29 + (-0.091489166021347046) * gru_0_out_t0_30 + (0.6299583911895752) * gru_0_out_t0_31 + (0.45895460247993469) * gru_0_out_t0_32 + (-0.32255271077156067) * gru_0_out_t0_33 + (-1.1023681163787842) * gru_0_out_t0_34 + (1.0012598037719727) * gru_0_out_t0_35 + (1.1804112195968628) * gru_0_out_t0_36 + (-1.0099633932113647) * gru_0_out_t0_37 + (0.74185484647750854) * gru_0_out_t0_38 + (-1.3310835361480713) * gru_0_out_t0_39 + (-2.2966156005859375) * gru_0_out_t0_40 + (1.432637095451355) * gru_0_out_t0_41 + (-0.66869258880615234) * gru_0_out_t0_42 + (0.32025089859962463) * gru_0_out_t0_43 + (0.33058920502662659) * gru_0_out_t0_44 + (-0.07027098536491394) * gru_0_out_t0_45 + (0.17212650179862976) * gru_0_out_t0_46 + (-0.37059327960014343) * gru_0_out_t0_47 + (0.084893472492694855) * gru_0_out_t0_48 + (-0.32169178128242493) * gru_0_out_t0_49 + (1.0965685844421387) * gru_0_out_t0_50 + (1.1026610136032104) * gru_0_out_t0_51 + (0.5448920726776123) * gru_0_out_t0_52 + (-0.54577904939651489) * gru_0_out_t0_53 + (-0.025114711374044418) * gru_0_out_t0_54 + (0.84211868047714233) * gru_0_out_t0_55 + (-1.6047921180725098) * gru_0_out_t0_56 + (0.78105896711349487) * gru_0_out_t0_57 + (-0.52728748321533203) * gru_0_out_t0_58 + (-0.5426490306854248) * gru_0_out_t0_59 + (0.058411728590726852) * gru_0_out_t0_60 + (0.31183773279190063) * gru_0_out_t0_61 + (-0.21657763421535492) * gru_0_out_t0_62 + (-1.1230523586273193) * gru_0_out_t0_63 + (1.1993770599365234) * gru_1_rev_t1_h_0 + (-0.33510327339172363) * gru_1_rev_t1_h_1 + (-1.225332498550415) * gru_1_rev_t1_h_2 + (3.3180224895477295) * gru_1_rev_t1_h_3 + (-0.11117099970579147) * gru_1_rev_t1_h_4 + (0.59104150533676147) * gru_1_rev_t1_h_5 + (1.4880579710006714) * gru_1_rev_t1_h_6 + (-0.02300756610929966) * gru_1_rev_t1_h_7 + (0.72380596399307251) * gru_1_rev_t1_h_8 + (-0.24485540390014648) * gru_1_rev_t1_h_9 + (-0.94089603424072266) * gru_1_rev_t1_h_10 + (-0.39606964588165283) * gru_1_rev_t1_h_11 + (2.6677491664886475) * gru_1_rev_t1_h_12 + (1.1836587190628052) * gru_1_rev_t1_h_13 + (0.84342306852340698) * gru_1_rev_t1_h_14 + (0.21934781968593597) * gru_1_rev_t1_h_15 + (0.040235843509435654) * gru_1_rev_t1_h_16 + (-0.81046819686889648) * gru_1_rev_t1_h_17 + (-0.27802133560180664) * gru_1_rev_t1_h_18 + (1.5077669620513916) * gru_1_rev_t1_h_19 + (-1.2212316989898682) * gru_1_rev_t1_h_20 + (-1.2865390777587891) * gru_1_rev_t1_h_21 + (-1.0127407312393188) * gru_1_rev_t1_h_22 + (-0.33258774876594543) * gru_1_rev_t1_h_23 + (0.57150888442993164) * gru_1_rev_t1_h_24 + (-0.41477862000465393) * gru_1_rev_t1_h_25 + (-0.71880102157592773) * gru_1_rev_t1_h_26 + (1.4207507371902466) * gru_1_rev_t1_h_27 + (4.4697318077087402) * gru_1_rev_t1_h_28 + (-0.62855976819992065) * gru_1_rev_t1_h_29 + (-1.43726646900177) * gru_1_rev_t1_h_30 + (-1.3448024988174438) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-1.3806666135787964) + (-0.58700364828109741) * gru_0_out_t0_0 + (0.26571473479270935) * gru_0_out_t0_1 + (-0.32685825228691101) * gru_0_out_t0_2 + (-0.90101999044418335) * gru_0_out_t0_3 + (0.35757860541343689) * gru_0_out_t0_4 + (-0.54397678375244141) * gru_0_out_t0_5 + (0.28882408142089844) * gru_0_out_t0_6 + (-0.42557385563850403) * gru_0_out_t0_7 + (0.40694007277488708) * gru_0_out_t0_8 + (-0.99995297193527222) * gru_0_out_t0_9 + (0.096525333821773529) * gru_0_out_t0_10 + (0.17275959253311157) * gru_0_out_t0_11 + (-0.22417077422142029) * gru_0_out_t0_12 + (-0.22835682332515717) * gru_0_out_t0_13 + (-0.28330114483833313) * gru_0_out_t0_14 + (-0.4054696261882782) * gru_0_out_t0_15 + (0.72596818208694458) * gru_0_out_t0_16 + (0.52691817283630371) * gru_0_out_t0_17 + (-0.14814548194408417) * gru_0_out_t0_18 + (-1.0273617506027222) * gru_0_out_t0_19 + (-0.63775330781936646) * gru_0_out_t0_20 + (2.1266162395477295) * gru_0_out_t0_21 + (-0.61278611421585083) * gru_0_out_t0_22 + (-0.53326821327209473) * gru_0_out_t0_23 + (0.1020834669470787) * gru_0_out_t0_24 + (0.68824303150177002) * gru_0_out_t0_25 + (0.39001506567001343) * gru_0_out_t0_26 + (-0.46168527007102966) * gru_0_out_t0_27 + (-1.2828541994094849) * gru_0_out_t0_28 + (-0.56002676486968994) * gru_0_out_t0_29 + (-1.0278382301330566) * gru_0_out_t0_30 + (0.65274471044540405) * gru_0_out_t0_31 + (-0.21438898146152496) * gru_0_out_t0_32 + (-0.34641027450561523) * gru_0_out_t0_33 + (0.0032906208653002977) * gru_0_out_t0_34 + (0.29625648260116577) * gru_0_out_t0_35 + (0.39076119661331177) * gru_0_out_t0_36 + (0.17421466112136841) * gru_0_out_t0_37 + (0.66873526573181152) * gru_0_out_t0_38 + (-1.2488648891448975) * gru_0_out_t0_39 + (1.4559496641159058) * gru_0_out_t0_40 + (-0.040352210402488708) * gru_0_out_t0_41 + (-1.4171470403671265) * gru_0_out_t0_42 + (0.26955947279930115) * gru_0_out_t0_43 + (0.55390739440917969) * gru_0_out_t0_44 + (0.23300084471702576) * gru_0_out_t0_45 + (-0.11313316971063614) * gru_0_out_t0_46 + (0.013845196925103664) * gru_0_out_t0_47 + (-0.61378484964370728) * gru_0_out_t0_48 + (0.92378604412078857) * gru_0_out_t0_49 + (-0.16182556748390198) * gru_0_out_t0_50 + (0.47823807597160339) * gru_0_out_t0_51 + (0.33600771427154541) * gru_0_out_t0_52 + (-0.24655236303806305) * gru_0_out_t0_53 + (2.9110496044158936) * gru_0_out_t0_54 + (-0.052052333950996399) * gru_0_out_t0_55 + (-1.0303739309310913) * gru_0_out_t0_56 + (1.5366804599761963) * gru_0_out_t0_57 + (-0.50297069549560547) * gru_0_out_t0_58 + (-2.1096131801605225) * gru_0_out_t0_59 + (-0.37937512993812561) * gru_0_out_t0_60 + (-0.64973890781402588) * gru_0_out_t0_61 + (-0.053456485271453857) * gru_0_out_t0_62 + (2.8340628147125244) * gru_0_out_t0_63 + (1.3118062019348145) * gru_1_rev_t1_h_0 + (0.72601211071014404) * gru_1_rev_t1_h_1 + (0.8403896689414978) * gru_1_rev_t1_h_2 + (0.9631306529045105) * gru_1_rev_t1_h_3 + (-1.3059902191162109) * gru_1_rev_t1_h_4 + (0.39217755198478699) * gru_1_rev_t1_h_5 + (0.22251453995704651) * gru_1_rev_t1_h_6 + (-0.38418540358543396) * gru_1_rev_t1_h_7 + (0.17794956266880035) * gru_1_rev_t1_h_8 + (-1.3219239711761475) * gru_1_rev_t1_h_9 + (0.030402036383748055) * gru_1_rev_t1_h_10 + (-0.94055426120758057) * gru_1_rev_t1_h_11 + (-1.0486565828323364) * gru_1_rev_t1_h_12 + (0.48371332883834839) * gru_1_rev_t1_h_13 + (0.64712578058242798) * gru_1_rev_t1_h_14 + (0.082876898348331451) * gru_1_rev_t1_h_15 + (0.64624106884002686) * gru_1_rev_t1_h_16 + (-0.6692662239074707) * gru_1_rev_t1_h_17 + (0.76401370763778687) * gru_1_rev_t1_h_18 + (-3.9688270092010498) * gru_1_rev_t1_h_19 + (0.34651711583137512) * gru_1_rev_t1_h_20 + (0.35951527953147888) * gru_1_rev_t1_h_21 + (-1.71735680103302) * gru_1_rev_t1_h_22 + (0.66552460193634033) * gru_1_rev_t1_h_23 + (-0.23552107810974121) * gru_1_rev_t1_h_24 + (-0.39188441634178162) * gru_1_rev_t1_h_25 + (-0.37041723728179932) * gru_1_rev_t1_h_26 + (0.74386674165725708) * gru_1_rev_t1_h_27 + (-2.8867461681365967) * gru_1_rev_t1_h_28 + (0.41335520148277283) * gru_1_rev_t1_h_29 + (-0.70892912149429321) * gru_1_rev_t1_h_30 + (0.64873170852661133) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.42075583338737488) + (0.29455700516700745) * gru_0_out_t0_0 + (-1.2316609621047974) * gru_0_out_t0_1 + (-0.24127385020256042) * gru_0_out_t0_2 + (0.12402823567390442) * gru_0_out_t0_3 + (-0.92426884174346924) * gru_0_out_t0_4 + (0.6823958158493042) * gru_0_out_t0_5 + (1.3001562356948853) * gru_0_out_t0_6 + (-0.021451219916343689) * gru_0_out_t0_7 + (-0.14869573712348938) * gru_0_out_t0_8 + (0.63034754991531372) * gru_0_out_t0_9 + (0.24176689982414246) * gru_0_out_t0_10 + (0.016120696440339088) * gru_0_out_t0_11 + (1.0096893310546875) * gru_0_out_t0_12 + (0.18879173696041107) * gru_0_out_t0_13 + (0.31400904059410095) * gru_0_out_t0_14 + (0.50824850797653198) * gru_0_out_t0_15 + (-1.5484104156494141) * gru_0_out_t0_16 + (-0.10726187378168106) * gru_0_out_t0_17 + (-0.29704809188842773) * gru_0_out_t0_18 + (-0.36398449540138245) * gru_0_out_t0_19 + (0.61971956491470337) * gru_0_out_t0_20 + (-1.6753532886505127) * gru_0_out_t0_21 + (-0.035529263317584991) * gru_0_out_t0_22 + (0.22071681916713715) * gru_0_out_t0_23 + (-1.3711931705474854) * gru_0_out_t0_24 + (-0.55373275279998779) * gru_0_out_t0_25 + (0.17192965745925903) * gru_0_out_t0_26 + (-0.28454670310020447) * gru_0_out_t0_27 + (-1.871662974357605) * gru_0_out_t0_28 + (0.21489638090133667) * gru_0_out_t0_29 + (-0.5381094217300415) * gru_0_out_t0_30 + (0.88996607065200806) * gru_0_out_t0_31 + (1.5324912071228027) * gru_0_out_t0_32 + (-0.66878044605255127) * gru_0_out_t0_33 + (-0.99872201681137085) * gru_0_out_t0_34 + (0.59640860557556152) * gru_0_out_t0_35 + (-0.24413782358169556) * gru_0_out_t0_36 + (-0.73545742034912109) * gru_0_out_t0_37 + (0.8918454647064209) * gru_0_out_t0_38 + (-1.8465534448623657) * gru_0_out_t0_39 + (2.1779768466949463) * gru_0_out_t0_40 + (0.71242803335189819) * gru_0_out_t0_41 + (-0.29210388660430908) * gru_0_out_t0_42 + (0.022092429921030998) * gru_0_out_t0_43 + (-0.0057449727319180965) * gru_0_out_t0_44 + (-0.5264696478843689) * gru_0_out_t0_45 + (-0.91483044624328613) * gru_0_out_t0_46 + (-0.92364460229873657) * gru_0_out_t0_47 + (-0.80660921335220337) * gru_0_out_t0_48 + (0.12668250501155853) * gru_0_out_t0_49 + (0.6585925817489624) * gru_0_out_t0_50 + (-0.044622279703617096) * gru_0_out_t0_51 + (0.50692439079284668) * gru_0_out_t0_52 + (0.60111653804779053) * gru_0_out_t0_53 + (-0.28614088892936707) * gru_0_out_t0_54 + (-0.51850801706314087) * gru_0_out_t0_55 + (-0.37587946653366089) * gru_0_out_t0_56 + (0.14975480735301971) * gru_0_out_t0_57 + (-0.41916921734809875) * gru_0_out_t0_58 + (0.61755919456481934) * gru_0_out_t0_59 + (-0.53422755002975464) * gru_0_out_t0_60 + (1.0413503646850586) * gru_0_out_t0_61 + (0.43674063682556152) * gru_0_out_t0_62 + (0.2721983790397644) * gru_0_out_t0_63 + gate_r * ((0.38431325554847717) + (-0.41206768155097961) * gru_1_rev_t1_h_0 + (-0.27722847461700439) * gru_1_rev_t1_h_1 + (-0.74833011627197266) * gru_1_rev_t1_h_2 + (1.8245695829391479) * gru_1_rev_t1_h_3 + (1.2125097513198853) * gru_1_rev_t1_h_4 + (0.49687474966049194) * gru_1_rev_t1_h_5 + (-0.13226146996021271) * gru_1_rev_t1_h_6 + (0.47737330198287964) * gru_1_rev_t1_h_7 + (0.30610096454620361) * gru_1_rev_t1_h_8 + (0.92558646202087402) * gru_1_rev_t1_h_9 + (-0.4937383234500885) * gru_1_rev_t1_h_10 + (-0.26371854543685913) * gru_1_rev_t1_h_11 + (1.5507224798202515) * gru_1_rev_t1_h_12 + (-2.4346861839294434) * gru_1_rev_t1_h_13 + (-1.0647842884063721) * gru_1_rev_t1_h_14 + (0.48473095893859863) * gru_1_rev_t1_h_15 + (-0.14139547944068909) * gru_1_rev_t1_h_16 + (0.050848450511693954) * gru_1_rev_t1_h_17 + (-0.088865429162979126) * gru_1_rev_t1_h_18 + (0.49576026201248169) * gru_1_rev_t1_h_19 + (0.33802276849746704) * gru_1_rev_t1_h_20 + (0.41915205121040344) * gru_1_rev_t1_h_21 + (1.341840386390686) * gru_1_rev_t1_h_22 + (-0.011196828447282314) * gru_1_rev_t1_h_23 + (-1.2566180229187012) * gru_1_rev_t1_h_24 + (-0.14192281663417816) * gru_1_rev_t1_h_25 + (0.49107468128204346) * gru_1_rev_t1_h_26 + (-0.68868738412857056) * gru_1_rev_t1_h_27 + (0.22797045111656189) * gru_1_rev_t1_h_28 + (-0.006672966293990612) * gru_1_rev_t1_h_29 + (-0.95045918226242065) * gru_1_rev_t1_h_30 + (1.1420725584030151) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_25 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_25;
    // h=26
    gate_r = sigmoid((-1.3849070072174072) + (0.2035602331161499) * gru_0_out_t0_0 + (-0.040443520992994308) * gru_0_out_t0_1 + (0.90126663446426392) * gru_0_out_t0_2 + (3.7027628421783447) * gru_0_out_t0_3 + (-0.94711905717849731) * gru_0_out_t0_4 + (-1.0484776496887207) * gru_0_out_t0_5 + (-1.182924747467041) * gru_0_out_t0_6 + (-1.0356642007827759) * gru_0_out_t0_7 + (-0.54311269521713257) * gru_0_out_t0_8 + (1.3705152273178101) * gru_0_out_t0_9 + (-0.43722140789031982) * gru_0_out_t0_10 + (-0.41263672709465027) * gru_0_out_t0_11 + (1.029377818107605) * gru_0_out_t0_12 + (-0.24379687011241913) * gru_0_out_t0_13 + (-0.10094958543777466) * gru_0_out_t0_14 + (1.8372827768325806) * gru_0_out_t0_15 + (0.84937864542007446) * gru_0_out_t0_16 + (0.098124809563159943) * gru_0_out_t0_17 + (0.84803563356399536) * gru_0_out_t0_18 + (3.8540334701538086) * gru_0_out_t0_19 + (1.5363163948059082) * gru_0_out_t0_20 + (0.0037667234428226948) * gru_0_out_t0_21 + (2.4095726013183594) * gru_0_out_t0_22 + (1.0084015130996704) * gru_0_out_t0_23 + (-2.4194860458374023) * gru_0_out_t0_24 + (-0.37978023290634155) * gru_0_out_t0_25 + (1.0542058944702148) * gru_0_out_t0_26 + (-0.32768318057060242) * gru_0_out_t0_27 + (0.68030530214309692) * gru_0_out_t0_28 + (-0.64886075258255005) * gru_0_out_t0_29 + (-3.4111189842224121) * gru_0_out_t0_30 + (2.2584981918334961) * gru_0_out_t0_31 + (-0.79855525493621826) * gru_0_out_t0_32 + (0.28479057550430298) * gru_0_out_t0_33 + (-0.38185584545135498) * gru_0_out_t0_34 + (0.78153342008590698) * gru_0_out_t0_35 + (0.89593559503555298) * gru_0_out_t0_36 + (-0.35564634203910828) * gru_0_out_t0_37 + (-0.13578081130981445) * gru_0_out_t0_38 + (-0.81159037351608276) * gru_0_out_t0_39 + (-2.0690281391143799) * gru_0_out_t0_40 + (0.76316094398498535) * gru_0_out_t0_41 + (-2.7663488388061523) * gru_0_out_t0_42 + (0.22821745276451111) * gru_0_out_t0_43 + (0.59312111139297485) * gru_0_out_t0_44 + (0.44644013047218323) * gru_0_out_t0_45 + (0.97447651624679565) * gru_0_out_t0_46 + (0.67504113912582397) * gru_0_out_t0_47 + (0.55783563852310181) * gru_0_out_t0_48 + (-0.56568372249603271) * gru_0_out_t0_49 + (-2.0430543422698975) * gru_0_out_t0_50 + (-0.58569294214248657) * gru_0_out_t0_51 + (0.58834236860275269) * gru_0_out_t0_52 + (-1.1708426475524902) * gru_0_out_t0_53 + (0.11008942872285843) * gru_0_out_t0_54 + (-0.032929278910160065) * gru_0_out_t0_55 + (-0.050686139613389969) * gru_0_out_t0_56 + (-1.3835775852203369) * gru_0_out_t0_57 + (-0.86650913953781128) * gru_0_out_t0_58 + (0.019592069089412689) * gru_0_out_t0_59 + (0.080178983509540558) * gru_0_out_t0_60 + (-1.3714538812637329) * gru_0_out_t0_61 + (-0.070283360779285431) * gru_0_out_t0_62 + (-0.35907617211341858) * gru_0_out_t0_63 + (-1.3266624212265015) * gru_1_rev_t1_h_0 + (-0.59424960613250732) * gru_1_rev_t1_h_1 + (0.031020978465676308) * gru_1_rev_t1_h_2 + (-0.39354684948921204) * gru_1_rev_t1_h_3 + (-0.50971841812133789) * gru_1_rev_t1_h_4 + (-0.48355755209922791) * gru_1_rev_t1_h_5 + (0.538482666015625) * gru_1_rev_t1_h_6 + (0.72413349151611328) * gru_1_rev_t1_h_7 + (-0.89606177806854248) * gru_1_rev_t1_h_8 + (0.053694963455200195) * gru_1_rev_t1_h_9 + (-0.91725605726242065) * gru_1_rev_t1_h_10 + (1.8685430288314819) * gru_1_rev_t1_h_11 + (0.10486017912626266) * gru_1_rev_t1_h_12 + (0.017982715740799904) * gru_1_rev_t1_h_13 + (0.57254713773727417) * gru_1_rev_t1_h_14 + (-0.97832280397415161) * gru_1_rev_t1_h_15 + (0.89050012826919556) * gru_1_rev_t1_h_16 + (-1.5839756727218628) * gru_1_rev_t1_h_17 + (0.1805608868598938) * gru_1_rev_t1_h_18 + (-2.5272164344787598) * gru_1_rev_t1_h_19 + (0.66472572088241577) * gru_1_rev_t1_h_20 + (-0.066327854990959167) * gru_1_rev_t1_h_21 + (-0.13813367486000061) * gru_1_rev_t1_h_22 + (-0.11463271826505661) * gru_1_rev_t1_h_23 + (0.38933312892913818) * gru_1_rev_t1_h_24 + (-0.21292941272258759) * gru_1_rev_t1_h_25 + (0.83010673522949219) * gru_1_rev_t1_h_26 + (0.50835114717483521) * gru_1_rev_t1_h_27 + (-1.3303238153457642) * gru_1_rev_t1_h_28 + (0.14575265347957611) * gru_1_rev_t1_h_29 + (-3.2273106575012207) * gru_1_rev_t1_h_30 + (0.10206147283315659) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.14969632029533386) + (0.098499134182929993) * gru_0_out_t0_0 + (-0.058121107518672943) * gru_0_out_t0_1 + (-0.020033961161971092) * gru_0_out_t0_2 + (0.36861327290534973) * gru_0_out_t0_3 + (-0.050071202218532562) * gru_0_out_t0_4 + (0.30397269129753113) * gru_0_out_t0_5 + (0.43292230367660522) * gru_0_out_t0_6 + (-0.87640184164047241) * gru_0_out_t0_7 + (0.2692071795463562) * gru_0_out_t0_8 + (0.40779668092727661) * gru_0_out_t0_9 + (0.38683417439460754) * gru_0_out_t0_10 + (0.57386118173599243) * gru_0_out_t0_11 + (0.41480997204780579) * gru_0_out_t0_12 + (0.38796854019165039) * gru_0_out_t0_13 + (-0.33451014757156372) * gru_0_out_t0_14 + (-0.14412827789783478) * gru_0_out_t0_15 + (-0.041270174086093903) * gru_0_out_t0_16 + (0.19578152894973755) * gru_0_out_t0_17 + (-0.32512015104293823) * gru_0_out_t0_18 + (0.047837506979703903) * gru_0_out_t0_19 + (0.37509843707084656) * gru_0_out_t0_20 + (-0.005351304542273283) * gru_0_out_t0_21 + (0.38668501377105713) * gru_0_out_t0_22 + (-0.44822195172309875) * gru_0_out_t0_23 + (0.46944025158882141) * gru_0_out_t0_24 + (-0.0082537569105625153) * gru_0_out_t0_25 + (-0.18922829627990723) * gru_0_out_t0_26 + (-0.0075922147370874882) * gru_0_out_t0_27 + (-0.022318162024021149) * gru_0_out_t0_28 + (1.995606541633606) * gru_0_out_t0_29 + (0.1362847238779068) * gru_0_out_t0_30 + (0.21843306720256805) * gru_0_out_t0_31 + (0.10659537464380264) * gru_0_out_t0_32 + (-0.99396711587905884) * gru_0_out_t0_33 + (-0.41160410642623901) * gru_0_out_t0_34 + (-0.50163859128952026) * gru_0_out_t0_35 + (-0.58482944965362549) * gru_0_out_t0_36 + (0.28164824843406677) * gru_0_out_t0_37 + (0.097125247120857239) * gru_0_out_t0_38 + (0.035281296819448471) * gru_0_out_t0_39 + (-1.2833260297775269) * gru_0_out_t0_40 + (0.06861598789691925) * gru_0_out_t0_41 + (0.019984792917966843) * gru_0_out_t0_42 + (0.23431785404682159) * gru_0_out_t0_43 + (0.13151144981384277) * gru_0_out_t0_44 + (-0.14272071421146393) * gru_0_out_t0_45 + (0.4253203272819519) * gru_0_out_t0_46 + (-0.41288486123085022) * gru_0_out_t0_47 + (0.088689051568508148) * gru_0_out_t0_48 + (0.35712751746177673) * gru_0_out_t0_49 + (0.25982645153999329) * gru_0_out_t0_50 + (-0.51312887668609619) * gru_0_out_t0_51 + (0.3521881103515625) * gru_0_out_t0_52 + (0.12718643248081207) * gru_0_out_t0_53 + (0.34499099850654602) * gru_0_out_t0_54 + (-0.27264934778213501) * gru_0_out_t0_55 + (0.03059670515358448) * gru_0_out_t0_56 + (0.35458385944366455) * gru_0_out_t0_57 + (-0.13553923368453979) * gru_0_out_t0_58 + (-1.1489249467849731) * gru_0_out_t0_59 + (-0.45713049173355103) * gru_0_out_t0_60 + (0.097685150802135468) * gru_0_out_t0_61 + (-0.19748847186565399) * gru_0_out_t0_62 + (0.56220328807830811) * gru_0_out_t0_63 + (0.25940781831741333) * gru_1_rev_t1_h_0 + (-0.23720091581344604) * gru_1_rev_t1_h_1 + (-0.61685347557067871) * gru_1_rev_t1_h_2 + (-1.0932610034942627) * gru_1_rev_t1_h_3 + (-0.80595147609710693) * gru_1_rev_t1_h_4 + (-0.72378283739089966) * gru_1_rev_t1_h_5 + (0.22080934047698975) * gru_1_rev_t1_h_6 + (-0.39638310670852661) * gru_1_rev_t1_h_7 + (0.13694871962070465) * gru_1_rev_t1_h_8 + (-1.1780130863189697) * gru_1_rev_t1_h_9 + (0.60650289058685303) * gru_1_rev_t1_h_10 + (0.35453850030899048) * gru_1_rev_t1_h_11 + (0.76122367382049561) * gru_1_rev_t1_h_12 + (-0.57087409496307373) * gru_1_rev_t1_h_13 + (0.37808296084403992) * gru_1_rev_t1_h_14 + (-0.016317769885063171) * gru_1_rev_t1_h_15 + (-1.3718936443328857) * gru_1_rev_t1_h_16 + (1.5174386501312256) * gru_1_rev_t1_h_17 + (0.80149561166763306) * gru_1_rev_t1_h_18 + (-1.3558560609817505) * gru_1_rev_t1_h_19 + (-0.022964000701904297) * gru_1_rev_t1_h_20 + (0.7291749119758606) * gru_1_rev_t1_h_21 + (-0.55455338954925537) * gru_1_rev_t1_h_22 + (0.23619359731674194) * gru_1_rev_t1_h_23 + (-0.17507891356945038) * gru_1_rev_t1_h_24 + (-0.82050329446792603) * gru_1_rev_t1_h_25 + (0.078206591308116913) * gru_1_rev_t1_h_26 + (0.10018184781074524) * gru_1_rev_t1_h_27 + (-1.9592317342758179) * gru_1_rev_t1_h_28 + (0.44502219557762146) * gru_1_rev_t1_h_29 + (-0.30903509259223938) * gru_1_rev_t1_h_30 + (0.28640913963317871) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.28438782691955566) + (0.03224225714802742) * gru_0_out_t0_0 + (-0.22251491248607635) * gru_0_out_t0_1 + (0.24897474050521851) * gru_0_out_t0_2 + (0.51020926237106323) * gru_0_out_t0_3 + (-0.3331902027130127) * gru_0_out_t0_4 + (-0.12126055359840393) * gru_0_out_t0_5 + (0.89374619722366333) * gru_0_out_t0_6 + (-2.0917167663574219) * gru_0_out_t0_7 + (-0.6761174201965332) * gru_0_out_t0_8 + (-1.068554162979126) * gru_0_out_t0_9 + (0.25473994016647339) * gru_0_out_t0_10 + (0.12363075464963913) * gru_0_out_t0_11 + (0.11133992671966553) * gru_0_out_t0_12 + (0.35330888628959656) * gru_0_out_t0_13 + (-0.064566835761070251) * gru_0_out_t0_14 + (0.24817520380020142) * gru_0_out_t0_15 + (-0.95763415098190308) * gru_0_out_t0_16 + (-0.45638585090637207) * gru_0_out_t0_17 + (0.045507695525884628) * gru_0_out_t0_18 + (-1.0613921880722046) * gru_0_out_t0_19 + (0.25074699521064758) * gru_0_out_t0_20 + (-1.3195301294326782) * gru_0_out_t0_21 + (-0.15837457776069641) * gru_0_out_t0_22 + (0.98696291446685791) * gru_0_out_t0_23 + (0.022206159308552742) * gru_0_out_t0_24 + (-0.31491154432296753) * gru_0_out_t0_25 + (-0.035650786012411118) * gru_0_out_t0_26 + (0.30069461464881897) * gru_0_out_t0_27 + (0.93242067098617554) * gru_0_out_t0_28 + (-0.33105766773223877) * gru_0_out_t0_29 + (0.41289466619491577) * gru_0_out_t0_30 + (0.3467043936252594) * gru_0_out_t0_31 + (1.0731692314147949) * gru_0_out_t0_32 + (-0.29181236028671265) * gru_0_out_t0_33 + (0.25750330090522766) * gru_0_out_t0_34 + (0.35239326953887939) * gru_0_out_t0_35 + (-0.21127203106880188) * gru_0_out_t0_36 + (-0.20493632555007935) * gru_0_out_t0_37 + (0.17752508819103241) * gru_0_out_t0_38 + (0.39301154017448425) * gru_0_out_t0_39 + (-1.4752867221832275) * gru_0_out_t0_40 + (-0.16636273264884949) * gru_0_out_t0_41 + (-0.23854056000709534) * gru_0_out_t0_42 + (0.046220947057008743) * gru_0_out_t0_43 + (0.018332194536924362) * gru_0_out_t0_44 + (0.29956617951393127) * gru_0_out_t0_45 + (0.13400860130786896) * gru_0_out_t0_46 + (-0.81807136535644531) * gru_0_out_t0_47 + (-0.02093847468495369) * gru_0_out_t0_48 + (0.32666090130805969) * gru_0_out_t0_49 + (0.3327580988407135) * gru_0_out_t0_50 + (0.095665670931339264) * gru_0_out_t0_51 + (0.093630507588386536) * gru_0_out_t0_52 + (0.68123269081115723) * gru_0_out_t0_53 + (-0.28688549995422363) * gru_0_out_t0_54 + (-0.17934301495552063) * gru_0_out_t0_55 + (-0.095353804528713226) * gru_0_out_t0_56 + (-0.035506121814250946) * gru_0_out_t0_57 + (-0.0085240649059414864) * gru_0_out_t0_58 + (-0.85637521743774414) * gru_0_out_t0_59 + (-1.0530228614807129) * gru_0_out_t0_60 + (-0.14414586126804352) * gru_0_out_t0_61 + (0.99007993936538696) * gru_0_out_t0_62 + (-1.0537717342376709) * gru_0_out_t0_63 + gate_r * ((-0.42977431416511536) + (-0.087007559835910797) * gru_1_rev_t1_h_0 + (-0.14809881150722504) * gru_1_rev_t1_h_1 + (-0.5050385594367981) * gru_1_rev_t1_h_2 + (1.054185152053833) * gru_1_rev_t1_h_3 + (-0.14374500513076782) * gru_1_rev_t1_h_4 + (0.85547411441802979) * gru_1_rev_t1_h_5 + (-0.73488253355026245) * gru_1_rev_t1_h_6 + (0.012056845240294933) * gru_1_rev_t1_h_7 + (0.4540073573589325) * gru_1_rev_t1_h_8 + (-0.45818799734115601) * gru_1_rev_t1_h_9 + (0.15304900705814362) * gru_1_rev_t1_h_10 + (-1.5027923583984375) * gru_1_rev_t1_h_11 + (1.0831973552703857) * gru_1_rev_t1_h_12 + (0.83801233768463135) * gru_1_rev_t1_h_13 + (-0.25330975651741028) * gru_1_rev_t1_h_14 + (0.35657611489295959) * gru_1_rev_t1_h_15 + (0.27194392681121826) * gru_1_rev_t1_h_16 + (-0.27401778101921082) * gru_1_rev_t1_h_17 + (-0.43792930245399475) * gru_1_rev_t1_h_18 + (1.6203814744949341) * gru_1_rev_t1_h_19 + (-0.29565960168838501) * gru_1_rev_t1_h_20 + (-0.70135390758514404) * gru_1_rev_t1_h_21 + (0.14205916225910187) * gru_1_rev_t1_h_22 + (0.30389034748077393) * gru_1_rev_t1_h_23 + (0.2330603301525116) * gru_1_rev_t1_h_24 + (0.11077108979225159) * gru_1_rev_t1_h_25 + (-0.1046941950917244) * gru_1_rev_t1_h_26 + (-0.29495805501937866) * gru_1_rev_t1_h_27 + (0.9245685338973999) * gru_1_rev_t1_h_28 + (-0.26904049515724182) * gru_1_rev_t1_h_29 + (1.4777230024337769) * gru_1_rev_t1_h_30 + (0.10978471487760544) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_26 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_26;
    // h=27
    gate_r = sigmoid((-0.28831538558006287) + (0.19522950053215027) * gru_0_out_t0_0 + (0.063962951302528381) * gru_0_out_t0_1 + (-0.033160276710987091) * gru_0_out_t0_2 + (-0.65896791219711304) * gru_0_out_t0_3 + (0.31294536590576172) * gru_0_out_t0_4 + (-3.345921516418457) * gru_0_out_t0_5 + (-1.2133930921554565) * gru_0_out_t0_6 + (0.72442775964736938) * gru_0_out_t0_7 + (0.10570076107978821) * gru_0_out_t0_8 + (-0.035752445459365845) * gru_0_out_t0_9 + (0.34319251775741577) * gru_0_out_t0_10 + (-0.070207789540290833) * gru_0_out_t0_11 + (-0.031761173158884048) * gru_0_out_t0_12 + (-0.15376977622509003) * gru_0_out_t0_13 + (0.14712102711200714) * gru_0_out_t0_14 + (-0.10423563420772552) * gru_0_out_t0_15 + (0.2049870640039444) * gru_0_out_t0_16 + (-0.5251421332359314) * gru_0_out_t0_17 + (-0.94625335931777954) * gru_0_out_t0_18 + (-1.2454417943954468) * gru_0_out_t0_19 + (-0.56189048290252686) * gru_0_out_t0_20 + (1.4805910587310791) * gru_0_out_t0_21 + (0.22788353264331818) * gru_0_out_t0_22 + (3.294156551361084) * gru_0_out_t0_23 + (0.52854269742965698) * gru_0_out_t0_24 + (0.20716136693954468) * gru_0_out_t0_25 + (-1.0457937717437744) * gru_0_out_t0_26 + (-0.53028279542922974) * gru_0_out_t0_27 + (0.27535593509674072) * gru_0_out_t0_28 + (-0.43526044487953186) * gru_0_out_t0_29 + (0.089854590594768524) * gru_0_out_t0_30 + (-2.311762809753418) * gru_0_out_t0_31 + (-0.33743578195571899) * gru_0_out_t0_32 + (0.28387072682380676) * gru_0_out_t0_33 + (-0.63422125577926636) * gru_0_out_t0_34 + (0.52689993381500244) * gru_0_out_t0_35 + (0.028313731774687767) * gru_0_out_t0_36 + (0.27350506186485291) * gru_0_out_t0_37 + (-0.17585311830043793) * gru_0_out_t0_38 + (0.40815377235412598) * gru_0_out_t0_39 + (-1.0963338613510132) * gru_0_out_t0_40 + (0.16626718640327454) * gru_0_out_t0_41 + (1.612789511680603) * gru_0_out_t0_42 + (0.22638307511806488) * gru_0_out_t0_43 + (-0.9733847975730896) * gru_0_out_t0_44 + (0.87267422676086426) * gru_0_out_t0_45 + (1.0673621892929077) * gru_0_out_t0_46 + (0.23525483906269073) * gru_0_out_t0_47 + (0.99385583400726318) * gru_0_out_t0_48 + (-0.943767249584198) * gru_0_out_t0_49 + (-0.26808366179466248) * gru_0_out_t0_50 + (0.33952417969703674) * gru_0_out_t0_51 + (-0.26812741160392761) * gru_0_out_t0_52 + (-0.27410963177680969) * gru_0_out_t0_53 + (-2.7675399780273438) * gru_0_out_t0_54 + (-0.16688139736652374) * gru_0_out_t0_55 + (0.35239323973655701) * gru_0_out_t0_56 + (-0.12228724360466003) * gru_0_out_t0_57 + (-0.41591536998748779) * gru_0_out_t0_58 + (0.32379776239395142) * gru_0_out_t0_59 + (0.079443186521530151) * gru_0_out_t0_60 + (-3.0097000598907471) * gru_0_out_t0_61 + (0.19968399405479431) * gru_0_out_t0_62 + (0.40376776456832886) * gru_0_out_t0_63 + (0.54741442203521729) * gru_1_rev_t1_h_0 + (0.43920531868934631) * gru_1_rev_t1_h_1 + (-0.44236555695533752) * gru_1_rev_t1_h_2 + (-0.12652997672557831) * gru_1_rev_t1_h_3 + (-0.12488659471273422) * gru_1_rev_t1_h_4 + (0.67693424224853516) * gru_1_rev_t1_h_5 + (-0.22922204434871674) * gru_1_rev_t1_h_6 + (-0.17010068893432617) * gru_1_rev_t1_h_7 + (-0.952892005443573) * gru_1_rev_t1_h_8 + (-0.25607973337173462) * gru_1_rev_t1_h_9 + (-1.0971106290817261) * gru_1_rev_t1_h_10 + (0.56143462657928467) * gru_1_rev_t1_h_11 + (0.20169998705387115) * gru_1_rev_t1_h_12 + (-0.52232694625854492) * gru_1_rev_t1_h_13 + (-0.057153023779392242) * gru_1_rev_t1_h_14 + (-0.86585336923599243) * gru_1_rev_t1_h_15 + (-1.182182788848877) * gru_1_rev_t1_h_16 + (-0.53353589773178101) * gru_1_rev_t1_h_17 + (0.50066030025482178) * gru_1_rev_t1_h_18 + (0.017651580274105072) * gru_1_rev_t1_h_19 + (-0.39345145225524902) * gru_1_rev_t1_h_20 + (-0.12052380293607712) * gru_1_rev_t1_h_21 + (0.13550804555416107) * gru_1_rev_t1_h_22 + (-0.5383266806602478) * gru_1_rev_t1_h_23 + (-0.33238360285758972) * gru_1_rev_t1_h_24 + (0.30329662561416626) * gru_1_rev_t1_h_25 + (0.41191715002059937) * gru_1_rev_t1_h_26 + (-0.21781088411808014) * gru_1_rev_t1_h_27 + (0.083599120378494263) * gru_1_rev_t1_h_28 + (-0.054715558886528015) * gru_1_rev_t1_h_29 + (-0.58357119560241699) * gru_1_rev_t1_h_30 + (0.30187490582466125) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.061054226011037827) + (-0.41728505492210388) * gru_0_out_t0_0 + (-0.023665005341172218) * gru_0_out_t0_1 + (0.1132797971367836) * gru_0_out_t0_2 + (0.13780045509338379) * gru_0_out_t0_3 + (0.010538240894675255) * gru_0_out_t0_4 + (-0.18486326932907104) * gru_0_out_t0_5 + (-0.6363336443901062) * gru_0_out_t0_6 + (-0.053916025906801224) * gru_0_out_t0_7 + (-0.22441484034061432) * gru_0_out_t0_8 + (0.25992301106452942) * gru_0_out_t0_9 + (0.10673618316650391) * gru_0_out_t0_10 + (-0.5913550853729248) * gru_0_out_t0_11 + (-0.03510839119553566) * gru_0_out_t0_12 + (-0.16584886610507965) * gru_0_out_t0_13 + (-0.2089548259973526) * gru_0_out_t0_14 + (-0.095754854381084442) * gru_0_out_t0_15 + (0.15267075598239899) * gru_0_out_t0_16 + (-0.12822359800338745) * gru_0_out_t0_17 + (0.14956201612949371) * gru_0_out_t0_18 + (-0.92975836992263794) * gru_0_out_t0_19 + (0.90978986024856567) * gru_0_out_t0_20 + (0.08058534562587738) * gru_0_out_t0_21 + (-0.5122484564781189) * gru_0_out_t0_22 + (0.13374724984169006) * gru_0_out_t0_23 + (0.15319502353668213) * gru_0_out_t0_24 + (0.0038195198867470026) * gru_0_out_t0_25 + (-0.075328484177589417) * gru_0_out_t0_26 + (0.12666705250740051) * gru_0_out_t0_27 + (0.92413479089736938) * gru_0_out_t0_28 + (-1.5491005182266235) * gru_0_out_t0_29 + (-0.057907138019800186) * gru_0_out_t0_30 + (-0.63088202476501465) * gru_0_out_t0_31 + (0.075930967926979065) * gru_0_out_t0_32 + (-0.33337599039077759) * gru_0_out_t0_33 + (0.10941644012928009) * gru_0_out_t0_34 + (-0.091142937541007996) * gru_0_out_t0_35 + (-0.95818966627120972) * gru_0_out_t0_36 + (0.065427981317043304) * gru_0_out_t0_37 + (0.23410408198833466) * gru_0_out_t0_38 + (0.55235308408737183) * gru_0_out_t0_39 + (0.91209077835083008) * gru_0_out_t0_40 + (0.051325671374797821) * gru_0_out_t0_41 + (-0.38183653354644775) * gru_0_out_t0_42 + (-0.53851932287216187) * gru_0_out_t0_43 + (0.15073877573013306) * gru_0_out_t0_44 + (0.11819285899400711) * gru_0_out_t0_45 + (-0.2157491147518158) * gru_0_out_t0_46 + (0.50161665678024292) * gru_0_out_t0_47 + (0.34651455283164978) * gru_0_out_t0_48 + (-0.49277818202972412) * gru_0_out_t0_49 + (0.020954851061105728) * gru_0_out_t0_50 + (0.020804468542337418) * gru_0_out_t0_51 + (-0.049971658736467361) * gru_0_out_t0_52 + (-0.0059814448468387127) * gru_0_out_t0_53 + (0.17260503768920898) * gru_0_out_t0_54 + (-0.1163136214017868) * gru_0_out_t0_55 + (0.48281118273735046) * gru_0_out_t0_56 + (-0.31399655342102051) * gru_0_out_t0_57 + (0.32108935713768005) * gru_0_out_t0_58 + (0.39556977152824402) * gru_0_out_t0_59 + (0.13550055027008057) * gru_0_out_t0_60 + (0.26093286275863647) * gru_0_out_t0_61 + (-0.047188568860292435) * gru_0_out_t0_62 + (-0.43597352504730225) * gru_0_out_t0_63 + (0.63402175903320312) * gru_1_rev_t1_h_0 + (-0.75626897811889648) * gru_1_rev_t1_h_1 + (0.47654172778129578) * gru_1_rev_t1_h_2 + (0.20966456830501556) * gru_1_rev_t1_h_3 + (-0.46073612570762634) * gru_1_rev_t1_h_4 + (0.82701760530471802) * gru_1_rev_t1_h_5 + (0.68125182390213013) * gru_1_rev_t1_h_6 + (-0.13182029128074646) * gru_1_rev_t1_h_7 + (0.66373544931411743) * gru_1_rev_t1_h_8 + (0.44698655605316162) * gru_1_rev_t1_h_9 + (1.0451512336730957) * gru_1_rev_t1_h_10 + (-1.4969738721847534) * gru_1_rev_t1_h_11 + (-0.23423154652118683) * gru_1_rev_t1_h_12 + (0.18541623651981354) * gru_1_rev_t1_h_13 + (0.044841296970844269) * gru_1_rev_t1_h_14 + (1.4394901990890503) * gru_1_rev_t1_h_15 + (0.96798050403594971) * gru_1_rev_t1_h_16 + (0.3353537917137146) * gru_1_rev_t1_h_17 + (-0.018812963739037514) * gru_1_rev_t1_h_18 + (-0.30800029635429382) * gru_1_rev_t1_h_19 + (0.60540133714675903) * gru_1_rev_t1_h_20 + (-0.42648041248321533) * gru_1_rev_t1_h_21 + (-1.2718510627746582) * gru_1_rev_t1_h_22 + (0.66983062028884888) * gru_1_rev_t1_h_23 + (-0.36984339356422424) * gru_1_rev_t1_h_24 + (-0.6824108362197876) * gru_1_rev_t1_h_25 + (-0.17256252467632294) * gru_1_rev_t1_h_26 + (-0.19305828213691711) * gru_1_rev_t1_h_27 + (-0.83201181888580322) * gru_1_rev_t1_h_28 + (-0.5386207103729248) * gru_1_rev_t1_h_29 + (0.045245654881000519) * gru_1_rev_t1_h_30 + (-0.20905523002147675) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.055888228118419647) + (0.23970018327236176) * gru_0_out_t0_0 + (0.72848016023635864) * gru_0_out_t0_1 + (-0.29254448413848877) * gru_0_out_t0_2 + (-0.23698987066745758) * gru_0_out_t0_3 + (0.425127774477005) * gru_0_out_t0_4 + (0.25611427426338196) * gru_0_out_t0_5 + (-0.67846304178237915) * gru_0_out_t0_6 + (0.97954642772674561) * gru_0_out_t0_7 + (-0.054137270897626877) * gru_0_out_t0_8 + (0.0038908200804144144) * gru_0_out_t0_9 + (0.13408327102661133) * gru_0_out_t0_10 + (-0.083344228565692902) * gru_0_out_t0_11 + (-0.70605957508087158) * gru_0_out_t0_12 + (-0.47657063603401184) * gru_0_out_t0_13 + (0.063094824552536011) * gru_0_out_t0_14 + (-0.19434286653995514) * gru_0_out_t0_15 + (0.40125066041946411) * gru_0_out_t0_16 + (0.084499813616275787) * gru_0_out_t0_17 + (0.28462466597557068) * gru_0_out_t0_18 + (-0.038473214954137802) * gru_0_out_t0_19 + (0.32616430521011353) * gru_0_out_t0_20 + (1.8178490400314331) * gru_0_out_t0_21 + (-0.74116021394729614) * gru_0_out_t0_22 + (-0.76459687948226929) * gru_0_out_t0_23 + (-0.20578932762145996) * gru_0_out_t0_24 + (-0.25766286253929138) * gru_0_out_t0_25 + (0.076891243457794189) * gru_0_out_t0_26 + (-0.42391479015350342) * gru_0_out_t0_27 + (0.28550750017166138) * gru_0_out_t0_28 + (0.53601294755935669) * gru_0_out_t0_29 + (-0.53732484579086304) * gru_0_out_t0_30 + (-0.37314251065254211) * gru_0_out_t0_31 + (-0.22411236166954041) * gru_0_out_t0_32 + (-0.089037522673606873) * gru_0_out_t0_33 + (0.19442380964756012) * gru_0_out_t0_34 + (-0.5298306941986084) * gru_0_out_t0_35 + (-0.059884153306484222) * gru_0_out_t0_36 + (-0.093729913234710693) * gru_0_out_t0_37 + (0.45952439308166504) * gru_0_out_t0_38 + (-1.5024527311325073) * gru_0_out_t0_39 + (1.6420607566833496) * gru_0_out_t0_40 + (-0.54342484474182129) * gru_0_out_t0_41 + (-1.8958513736724854) * gru_0_out_t0_42 + (-0.29252675175666809) * gru_0_out_t0_43 + (-0.43946880102157593) * gru_0_out_t0_44 + (-0.13999417424201965) * gru_0_out_t0_45 + (-0.44499897956848145) * gru_0_out_t0_46 + (0.056745186448097229) * gru_0_out_t0_47 + (-0.15355624258518219) * gru_0_out_t0_48 + (0.30705609917640686) * gru_0_out_t0_49 + (0.24390937387943268) * gru_0_out_t0_50 + (-0.056140400469303131) * gru_0_out_t0_51 + (0.38696497678756714) * gru_0_out_t0_52 + (0.058019809424877167) * gru_0_out_t0_53 + (0.89175838232040405) * gru_0_out_t0_54 + (-0.43426719307899475) * gru_0_out_t0_55 + (0.0070846611633896828) * gru_0_out_t0_56 + (0.2888144850730896) * gru_0_out_t0_57 + (0.11952608823776245) * gru_0_out_t0_58 + (0.49300023913383484) * gru_0_out_t0_59 + (0.030797075480222702) * gru_0_out_t0_60 + (0.71325129270553589) * gru_0_out_t0_61 + (0.18240049481391907) * gru_0_out_t0_62 + (0.68815410137176514) * gru_0_out_t0_63 + gate_r * ((0.1124502569437027) + (0.91907906532287598) * gru_1_rev_t1_h_0 + (0.079965531826019287) * gru_1_rev_t1_h_1 + (-0.13280303776264191) * gru_1_rev_t1_h_2 + (-0.12755826115608215) * gru_1_rev_t1_h_3 + (0.039959870278835297) * gru_1_rev_t1_h_4 + (0.38225078582763672) * gru_1_rev_t1_h_5 + (-0.31974899768829346) * gru_1_rev_t1_h_6 + (0.33341753482818604) * gru_1_rev_t1_h_7 + (0.79510176181793213) * gru_1_rev_t1_h_8 + (-0.20803791284561157) * gru_1_rev_t1_h_9 + (0.14263549447059631) * gru_1_rev_t1_h_10 + (-0.72649663686752319) * gru_1_rev_t1_h_11 + (0.16472034156322479) * gru_1_rev_t1_h_12 + (0.71067821979522705) * gru_1_rev_t1_h_13 + (-0.15214067697525024) * gru_1_rev_t1_h_14 + (-0.52577924728393555) * gru_1_rev_t1_h_15 + (0.17004294693470001) * gru_1_rev_t1_h_16 + (-0.10250711441040039) * gru_1_rev_t1_h_17 + (-0.93992489576339722) * gru_1_rev_t1_h_18 + (0.35368472337722778) * gru_1_rev_t1_h_19 + (-0.72099339962005615) * gru_1_rev_t1_h_20 + (0.015863260254263878) * gru_1_rev_t1_h_21 + (-0.92760348320007324) * gru_1_rev_t1_h_22 + (-1.0257201194763184) * gru_1_rev_t1_h_23 + (0.47216174006462097) * gru_1_rev_t1_h_24 + (-0.19633348286151886) * gru_1_rev_t1_h_25 + (-0.7544480562210083) * gru_1_rev_t1_h_26 + (-0.29674288630485535) * gru_1_rev_t1_h_27 + (0.7170296311378479) * gru_1_rev_t1_h_28 + (-0.14809201657772064) * gru_1_rev_t1_h_29 + (0.3736051619052887) * gru_1_rev_t1_h_30 + (0.32075369358062744) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_27 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_27;
    // h=28
    gate_r = sigmoid((0.38495266437530518) + (0.24517485499382019) * gru_0_out_t0_0 + (0.43384209275245667) * gru_0_out_t0_1 + (-0.34521183371543884) * gru_0_out_t0_2 + (-1.2785024642944336) * gru_0_out_t0_3 + (0.035775329917669296) * gru_0_out_t0_4 + (1.533103346824646) * gru_0_out_t0_5 + (0.8216392993927002) * gru_0_out_t0_6 + (1.3818939924240112) * gru_0_out_t0_7 + (0.062483824789524078) * gru_0_out_t0_8 + (2.6988174915313721) * gru_0_out_t0_9 + (0.17467106878757477) * gru_0_out_t0_10 + (0.012607855722308159) * gru_0_out_t0_11 + (-0.37592044472694397) * gru_0_out_t0_12 + (0.67778301239013672) * gru_0_out_t0_13 + (0.22810263931751251) * gru_0_out_t0_14 + (0.020402560010552406) * gru_0_out_t0_15 + (-0.080984756350517273) * gru_0_out_t0_16 + (0.36288097500801086) * gru_0_out_t0_17 + (-1.7684946060180664) * gru_0_out_t0_18 + (0.98190796375274658) * gru_0_out_t0_19 + (6.2056088447570801) * gru_0_out_t0_20 + (-0.059406399726867676) * gru_0_out_t0_21 + (-1.1386468410491943) * gru_0_out_t0_22 + (-0.16445112228393555) * gru_0_out_t0_23 + (7.9238858222961426) * gru_0_out_t0_24 + (0.38441357016563416) * gru_0_out_t0_25 + (-1.3391866683959961) * gru_0_out_t0_26 + (-0.23772802948951721) * gru_0_out_t0_27 + (-1.93971848487854) * gru_0_out_t0_28 + (2.1419475078582764) * gru_0_out_t0_29 + (0.1390129029750824) * gru_0_out_t0_30 + (-3.8627009391784668) * gru_0_out_t0_31 + (-0.67508494853973389) * gru_0_out_t0_32 + (-0.61689096689224243) * gru_0_out_t0_33 + (-0.76469635963439941) * gru_0_out_t0_34 + (0.73646599054336548) * gru_0_out_t0_35 + (-1.7570983171463013) * gru_0_out_t0_36 + (0.4429442286491394) * gru_0_out_t0_37 + (1.2157485485076904) * gru_0_out_t0_38 + (-0.48993882536888123) * gru_0_out_t0_39 + (-0.52398854494094849) * gru_0_out_t0_40 + (-0.1198851466178894) * gru_0_out_t0_41 + (1.7073931694030762) * gru_0_out_t0_42 + (-2.0276443958282471) * gru_0_out_t0_43 + (0.48097479343414307) * gru_0_out_t0_44 + (0.78069180250167847) * gru_0_out_t0_45 + (-0.82747107744216919) * gru_0_out_t0_46 + (0.52049124240875244) * gru_0_out_t0_47 + (1.7230833768844604) * gru_0_out_t0_48 + (-2.0977826118469238) * gru_0_out_t0_49 + (-0.58418577909469604) * gru_0_out_t0_50 + (2.037954568862915) * gru_0_out_t0_51 + (1.6894580125808716) * gru_0_out_t0_52 + (-0.11226963996887207) * gru_0_out_t0_53 + (-0.389029860496521) * gru_0_out_t0_54 + (-1.1335253715515137) * gru_0_out_t0_55 + (1.8562434911727905) * gru_0_out_t0_56 + (-1.3597702980041504) * gru_0_out_t0_57 + (-0.42686748504638672) * gru_0_out_t0_58 + (1.4028137922286987) * gru_0_out_t0_59 + (0.056015219539403915) * gru_0_out_t0_60 + (-0.085880830883979797) * gru_0_out_t0_61 + (0.036875121295452118) * gru_0_out_t0_62 + (-0.16856873035430908) * gru_0_out_t0_63 + (-0.58184975385665894) * gru_1_rev_t1_h_0 + (-0.24159583449363708) * gru_1_rev_t1_h_1 + (-0.10429973155260086) * gru_1_rev_t1_h_2 + (1.1584887504577637) * gru_1_rev_t1_h_3 + (-0.041181370615959167) * gru_1_rev_t1_h_4 + (-0.94562143087387085) * gru_1_rev_t1_h_5 + (-0.28043583035469055) * gru_1_rev_t1_h_6 + (0.60273563861846924) * gru_1_rev_t1_h_7 + (0.040203079581260681) * gru_1_rev_t1_h_8 + (0.13992607593536377) * gru_1_rev_t1_h_9 + (-0.52868258953094482) * gru_1_rev_t1_h_10 + (-3.9927210807800293) * gru_1_rev_t1_h_11 + (0.10332739353179932) * gru_1_rev_t1_h_12 + (-3.7586183547973633) * gru_1_rev_t1_h_13 + (2.1682198047637939) * gru_1_rev_t1_h_14 + (0.70560294389724731) * gru_1_rev_t1_h_15 + (1.6283551454544067) * gru_1_rev_t1_h_16 + (-2.4343774318695068) * gru_1_rev_t1_h_17 + (0.98010694980621338) * gru_1_rev_t1_h_18 + (-0.40035763382911682) * gru_1_rev_t1_h_19 + (-0.51121455430984497) * gru_1_rev_t1_h_20 + (0.33723956346511841) * gru_1_rev_t1_h_21 + (-0.74957460165023804) * gru_1_rev_t1_h_22 + (-0.82415205240249634) * gru_1_rev_t1_h_23 + (-1.5612708330154419) * gru_1_rev_t1_h_24 + (-0.066470667719841003) * gru_1_rev_t1_h_25 + (-0.27123963832855225) * gru_1_rev_t1_h_26 + (-1.5565893650054932) * gru_1_rev_t1_h_27 + (-3.0803158283233643) * gru_1_rev_t1_h_28 + (-0.22295172512531281) * gru_1_rev_t1_h_29 + (-1.6278361082077026) * gru_1_rev_t1_h_30 + (-0.10600800067186356) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((1.1635242700576782) + (0.46526461839675903) * gru_0_out_t0_0 + (-0.77334088087081909) * gru_0_out_t0_1 + (0.2253769189119339) * gru_0_out_t0_2 + (0.21902711689472198) * gru_0_out_t0_3 + (-0.0098206829279661179) * gru_0_out_t0_4 + (0.67492413520812988) * gru_0_out_t0_5 + (2.2120251655578613) * gru_0_out_t0_6 + (0.39467531442642212) * gru_0_out_t0_7 + (-0.092816315591335297) * gru_0_out_t0_8 + (0.16426098346710205) * gru_0_out_t0_9 + (0.81289893388748169) * gru_0_out_t0_10 + (0.79923534393310547) * gru_0_out_t0_11 + (-0.30268985033035278) * gru_0_out_t0_12 + (0.8558616042137146) * gru_0_out_t0_13 + (0.024393109604716301) * gru_0_out_t0_14 + (0.33802351355552673) * gru_0_out_t0_15 + (-0.30856144428253174) * gru_0_out_t0_16 + (-0.042766209691762924) * gru_0_out_t0_17 + (0.42629185318946838) * gru_0_out_t0_18 + (-3.1004993915557861) * gru_0_out_t0_19 + (0.02336634136736393) * gru_0_out_t0_20 + (-0.28578871488571167) * gru_0_out_t0_21 + (-0.22589519619941711) * gru_0_out_t0_22 + (-0.51130688190460205) * gru_0_out_t0_23 + (-0.4282987117767334) * gru_0_out_t0_24 + (0.39199721813201904) * gru_0_out_t0_25 + (0.18464250862598419) * gru_0_out_t0_26 + (-0.3822171688079834) * gru_0_out_t0_27 + (-0.79789787530899048) * gru_0_out_t0_28 + (-0.090598195791244507) * gru_0_out_t0_29 + (0.049423504620790482) * gru_0_out_t0_30 + (0.48325544595718384) * gru_0_out_t0_31 + (-0.071516074240207672) * gru_0_out_t0_32 + (0.8024824857711792) * gru_0_out_t0_33 + (0.29999503493309021) * gru_0_out_t0_34 + (0.32240206003189087) * gru_0_out_t0_35 + (0.11254841834306717) * gru_0_out_t0_36 + (0.74355006217956543) * gru_0_out_t0_37 + (-0.84019660949707031) * gru_0_out_t0_38 + (-0.10382818430662155) * gru_0_out_t0_39 + (0.19603891670703888) * gru_0_out_t0_40 + (-0.55069816112518311) * gru_0_out_t0_41 + (0.85013920068740845) * gru_0_out_t0_42 + (-0.67944049835205078) * gru_0_out_t0_43 + (0.49380853772163391) * gru_0_out_t0_44 + (0.14678692817687988) * gru_0_out_t0_45 + (0.40708866715431213) * gru_0_out_t0_46 + (-0.53360497951507568) * gru_0_out_t0_47 + (0.56696707010269165) * gru_0_out_t0_48 + (-0.75680959224700928) * gru_0_out_t0_49 + (-0.41956266760826111) * gru_0_out_t0_50 + (-0.10296233743429184) * gru_0_out_t0_51 + (0.65534496307373047) * gru_0_out_t0_52 + (0.19792743027210236) * gru_0_out_t0_53 + (-2.5934839248657227) * gru_0_out_t0_54 + (0.67565196752548218) * gru_0_out_t0_55 + (1.0444697141647339) * gru_0_out_t0_56 + (-0.78978055715560913) * gru_0_out_t0_57 + (1.1348870992660522) * gru_0_out_t0_58 + (1.1408712863922119) * gru_0_out_t0_59 + (0.0054184896871447563) * gru_0_out_t0_60 + (0.4826195240020752) * gru_0_out_t0_61 + (0.55679649114608765) * gru_0_out_t0_62 + (-0.30835694074630737) * gru_0_out_t0_63 + (-0.7360953688621521) * gru_1_rev_t1_h_0 + (-0.97027468681335449) * gru_1_rev_t1_h_1 + (1.4197783470153809) * gru_1_rev_t1_h_2 + (-1.1104809045791626) * gru_1_rev_t1_h_3 + (-0.11571197211742401) * gru_1_rev_t1_h_4 + (-1.0672018527984619) * gru_1_rev_t1_h_5 + (0.43117493391036987) * gru_1_rev_t1_h_6 + (0.019311966374516487) * gru_1_rev_t1_h_7 + (0.32989013195037842) * gru_1_rev_t1_h_8 + (-0.024389205500483513) * gru_1_rev_t1_h_9 + (-0.58137071132659912) * gru_1_rev_t1_h_10 + (-0.064952842891216278) * gru_1_rev_t1_h_11 + (0.16863101720809937) * gru_1_rev_t1_h_12 + (-1.7389678955078125) * gru_1_rev_t1_h_13 + (0.40751448273658752) * gru_1_rev_t1_h_14 + (0.90026932954788208) * gru_1_rev_t1_h_15 + (0.37842351198196411) * gru_1_rev_t1_h_16 + (-0.71322733163833618) * gru_1_rev_t1_h_17 + (-0.12247438728809357) * gru_1_rev_t1_h_18 + (0.65992963314056396) * gru_1_rev_t1_h_19 + (-0.28519454598426819) * gru_1_rev_t1_h_20 + (-0.34817719459533691) * gru_1_rev_t1_h_21 + (0.58168977499008179) * gru_1_rev_t1_h_22 + (-0.26330697536468506) * gru_1_rev_t1_h_23 + (-0.72273576259613037) * gru_1_rev_t1_h_24 + (-0.49771633744239807) * gru_1_rev_t1_h_25 + (-0.14488427340984344) * gru_1_rev_t1_h_26 + (-1.3244274854660034) * gru_1_rev_t1_h_27 + (-0.033292792737483978) * gru_1_rev_t1_h_28 + (-0.33947205543518066) * gru_1_rev_t1_h_29 + (-1.0981553792953491) * gru_1_rev_t1_h_30 + (-0.48396068811416626) * gru_1_rev_t1_h_31);
    gate_n = tanh((-0.14081251621246338) + (-0.47017627954483032) * gru_0_out_t0_0 + (0.28686550259590149) * gru_0_out_t0_1 + (0.19199033081531525) * gru_0_out_t0_2 + (0.28524833917617798) * gru_0_out_t0_3 + (0.20275498926639557) * gru_0_out_t0_4 + (0.30021563172340393) * gru_0_out_t0_5 + (-0.21653261780738831) * gru_0_out_t0_6 + (-0.15130066871643066) * gru_0_out_t0_7 + (0.089408949017524719) * gru_0_out_t0_8 + (-0.12699039280414581) * gru_0_out_t0_9 + (-0.98048233985900879) * gru_0_out_t0_10 + (-0.69065117835998535) * gru_0_out_t0_11 + (0.022636350244283676) * gru_0_out_t0_12 + (0.32052695751190186) * gru_0_out_t0_13 + (0.12180080264806747) * gru_0_out_t0_14 + (-0.035740692168474197) * gru_0_out_t0_15 + (0.12505139410495758) * gru_0_out_t0_16 + (0.051997914910316467) * gru_0_out_t0_17 + (0.52506595849990845) * gru_0_out_t0_18 + (0.56566125154495239) * gru_0_out_t0_19 + (0.015629788860678673) * gru_0_out_t0_20 + (0.053177043795585632) * gru_0_out_t0_21 + (-0.71265530586242676) * gru_0_out_t0_22 + (0.068835131824016571) * gru_0_out_t0_23 + (-0.18199162185192108) * gru_0_out_t0_24 + (-0.34626057744026184) * gru_0_out_t0_25 + (0.99873358011245728) * gru_0_out_t0_26 + (1.1697840690612793) * gru_0_out_t0_27 + (-0.42925849556922913) * gru_0_out_t0_28 + (-0.52829694747924805) * gru_0_out_t0_29 + (0.15616248548030853) * gru_0_out_t0_30 + (3.4068710803985596) * gru_0_out_t0_31 + (-0.41775748133659363) * gru_0_out_t0_32 + (-0.03997354581952095) * gru_0_out_t0_33 + (-0.48278787732124329) * gru_0_out_t0_34 + (-0.001750736148096621) * gru_0_out_t0_35 + (0.099546864628791809) * gru_0_out_t0_36 + (-0.054956115782260895) * gru_0_out_t0_37 + (0.50001817941665649) * gru_0_out_t0_38 + (0.38631236553192139) * gru_0_out_t0_39 + (-0.71737629175186157) * gru_0_out_t0_40 + (-0.04780496284365654) * gru_0_out_t0_41 + (1.1841582059860229) * gru_0_out_t0_42 + (0.25365343689918518) * gru_0_out_t0_43 + (-0.34332820773124695) * gru_0_out_t0_44 + (-0.16847324371337891) * gru_0_out_t0_45 + (0.73368000984191895) * gru_0_out_t0_46 + (-0.043232418596744537) * gru_0_out_t0_47 + (0.11815484613180161) * gru_0_out_t0_48 + (0.089505836367607117) * gru_0_out_t0_49 + (-0.24156701564788818) * gru_0_out_t0_50 + (-0.71883511543273926) * gru_0_out_t0_51 + (0.18286909162998199) * gru_0_out_t0_52 + (0.32831746339797974) * gru_0_out_t0_53 + (0.48485705256462097) * gru_0_out_t0_54 + (0.35323235392570496) * gru_0_out_t0_55 + (0.34469249844551086) * gru_0_out_t0_56 + (0.0038158309180289507) * gru_0_out_t0_57 + (0.84813112020492554) * gru_0_out_t0_58 + (-0.16826142370700836) * gru_0_out_t0_59 + (-0.51322788000106812) * gru_0_out_t0_60 + (0.12121559679508209) * gru_0_out_t0_61 + (-0.12166905403137207) * gru_0_out_t0_62 + (-0.33865022659301758) * gru_0_out_t0_63 + gate_r * ((-0.2034243643283844) + (-1.1063227653503418) * gru_1_rev_t1_h_0 + (-0.32183822989463806) * gru_1_rev_t1_h_1 + (-1.2291498184204102) * gru_1_rev_t1_h_2 + (1.8931022882461548) * gru_1_rev_t1_h_3 + (0.20090490579605103) * gru_1_rev_t1_h_4 + (-0.085786297917366028) * gru_1_rev_t1_h_5 + (0.16120660305023193) * gru_1_rev_t1_h_6 + (-0.10673391073942184) * gru_1_rev_t1_h_7 + (0.60725301504135132) * gru_1_rev_t1_h_8 + (-0.17193767428398132) * gru_1_rev_t1_h_9 + (1.3786369562149048) * gru_1_rev_t1_h_10 + (0.024405146017670631) * gru_1_rev_t1_h_11 + (0.69248580932617188) * gru_1_rev_t1_h_12 + (2.2421188354492188) * gru_1_rev_t1_h_13 + (-0.037626076489686966) * gru_1_rev_t1_h_14 + (1.1333873271942139) * gru_1_rev_t1_h_15 + (1.3318691253662109) * gru_1_rev_t1_h_16 + (-0.57494169473648071) * gru_1_rev_t1_h_17 + (0.4663064181804657) * gru_1_rev_t1_h_18 + (-0.91170614957809448) * gru_1_rev_t1_h_19 + (-0.10510260611772537) * gru_1_rev_t1_h_20 + (-0.18323059380054474) * gru_1_rev_t1_h_21 + (1.025905966758728) * gru_1_rev_t1_h_22 + (-0.37681496143341064) * gru_1_rev_t1_h_23 + (-2.5587248802185059) * gru_1_rev_t1_h_24 + (0.60318535566329956) * gru_1_rev_t1_h_25 + (0.090684302151203156) * gru_1_rev_t1_h_26 + (-0.81764441728591919) * gru_1_rev_t1_h_27 + (-0.75473809242248535) * gru_1_rev_t1_h_28 + (-0.4670332670211792) * gru_1_rev_t1_h_29 + (0.08533032238483429) * gru_1_rev_t1_h_30 + (-1.1759481430053711) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_28 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_28;
    // h=29
    gate_r = sigmoid((0.21502673625946045) + (-0.40601328015327454) * gru_0_out_t0_0 + (-0.097969777882099152) * gru_0_out_t0_1 + (0.85871726274490356) * gru_0_out_t0_2 + (-0.92955589294433594) * gru_0_out_t0_3 + (0.29914548993110657) * gru_0_out_t0_4 + (-0.57047760486602783) * gru_0_out_t0_5 + (-0.28610458970069885) * gru_0_out_t0_6 + (0.14064958691596985) * gru_0_out_t0_7 + (-1.1372116804122925) * gru_0_out_t0_8 + (1.0613241195678711) * gru_0_out_t0_9 + (-0.35227525234222412) * gru_0_out_t0_10 + (0.057069137692451477) * gru_0_out_t0_11 + (-0.25985458493232727) * gru_0_out_t0_12 + (0.079464465379714966) * gru_0_out_t0_13 + (-0.18415048718452454) * gru_0_out_t0_14 + (0.25093847513198853) * gru_0_out_t0_15 + (0.25747931003570557) * gru_0_out_t0_16 + (0.47546640038490295) * gru_0_out_t0_17 + (-0.31340852379798889) * gru_0_out_t0_18 + (1.1860820055007935) * gru_0_out_t0_19 + (0.44891336560249329) * gru_0_out_t0_20 + (-1.8879481554031372) * gru_0_out_t0_21 + (0.48409256339073181) * gru_0_out_t0_22 + (1.247367262840271) * gru_0_out_t0_23 + (0.029521184042096138) * gru_0_out_t0_24 + (0.15670068562030792) * gru_0_out_t0_25 + (-0.60761308670043945) * gru_0_out_t0_26 + (0.071603260934352875) * gru_0_out_t0_27 + (0.00053122371900826693) * gru_0_out_t0_28 + (0.42420899868011475) * gru_0_out_t0_29 + (0.20991963148117065) * gru_0_out_t0_30 + (0.049920126795768738) * gru_0_out_t0_31 + (-0.46352711319923401) * gru_0_out_t0_32 + (0.056479267776012421) * gru_0_out_t0_33 + (-0.10843802988529205) * gru_0_out_t0_34 + (0.21591271460056305) * gru_0_out_t0_35 + (0.073450095951557159) * gru_0_out_t0_36 + (-0.099546909332275391) * gru_0_out_t0_37 + (0.70637184381484985) * gru_0_out_t0_38 + (1.2784665822982788) * gru_0_out_t0_39 + (-2.2752499580383301) * gru_0_out_t0_40 + (0.33130553364753723) * gru_0_out_t0_41 + (0.79199206829071045) * gru_0_out_t0_42 + (0.23844544589519501) * gru_0_out_t0_43 + (-0.33926782011985779) * gru_0_out_t0_44 + (-0.22002914547920227) * gru_0_out_t0_45 + (1.2905511856079102) * gru_0_out_t0_46 + (-0.0076114586554467678) * gru_0_out_t0_47 + (0.057363107800483704) * gru_0_out_t0_48 + (-0.091546513140201569) * gru_0_out_t0_49 + (-1.2490360736846924) * gru_0_out_t0_50 + (0.50319486856460571) * gru_0_out_t0_51 + (0.51193273067474365) * gru_0_out_t0_52 + (-0.16754555702209473) * gru_0_out_t0_53 + (-0.49089622497558594) * gru_0_out_t0_54 + (0.63296902179718018) * gru_0_out_t0_55 + (1.4065903425216675) * gru_0_out_t0_56 + (-0.23820261657238007) * gru_0_out_t0_57 + (0.92519271373748779) * gru_0_out_t0_58 + (-0.59376132488250732) * gru_0_out_t0_59 + (1.3284118175506592) * gru_0_out_t0_60 + (-0.0095832860097289085) * gru_0_out_t0_61 + (0.7741013765335083) * gru_0_out_t0_62 + (-0.98127859830856323) * gru_0_out_t0_63 + (-0.49192506074905396) * gru_1_rev_t1_h_0 + (-2.0870704650878906) * gru_1_rev_t1_h_1 + (1.6191780567169189) * gru_1_rev_t1_h_2 + (-0.39195474982261658) * gru_1_rev_t1_h_3 + (0.74324136972427368) * gru_1_rev_t1_h_4 + (-0.050907514989376068) * gru_1_rev_t1_h_5 + (2.1409423351287842) * gru_1_rev_t1_h_6 + (0.7336389422416687) * gru_1_rev_t1_h_7 + (-0.48771172761917114) * gru_1_rev_t1_h_8 + (1.1810534000396729) * gru_1_rev_t1_h_9 + (-1.9674804210662842) * gru_1_rev_t1_h_10 + (-0.34298443794250488) * gru_1_rev_t1_h_11 + (-0.70673763751983643) * gru_1_rev_t1_h_12 + (-1.1082148551940918) * gru_1_rev_t1_h_13 + (-0.52169942855834961) * gru_1_rev_t1_h_14 + (0.35327443480491638) * gru_1_rev_t1_h_15 + (-0.30773234367370605) * gru_1_rev_t1_h_16 + (0.90633076429367065) * gru_1_rev_t1_h_17 + (-0.45464670658111572) * gru_1_rev_t1_h_18 + (1.9996049404144287) * gru_1_rev_t1_h_19 + (0.74124324321746826) * gru_1_rev_t1_h_20 + (0.42983216047286987) * gru_1_rev_t1_h_21 + (-0.067735128104686737) * gru_1_rev_t1_h_22 + (-1.5534031391143799) * gru_1_rev_t1_h_23 + (-1.7254632711410522) * gru_1_rev_t1_h_24 + (0.20811846852302551) * gru_1_rev_t1_h_25 + (-1.3834332227706909) * gru_1_rev_t1_h_26 + (-1.0439707040786743) * gru_1_rev_t1_h_27 + (-1.970583438873291) * gru_1_rev_t1_h_28 + (-0.14200207591056824) * gru_1_rev_t1_h_29 + (-0.06939367949962616) * gru_1_rev_t1_h_30 + (-0.74878323078155518) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.67309153079986572) + (0.10259202122688293) * gru_0_out_t0_0 + (-1.2646406888961792) * gru_0_out_t0_1 + (-2.1121339797973633) * gru_0_out_t0_2 + (-0.94939643144607544) * gru_0_out_t0_3 + (-0.49155789613723755) * gru_0_out_t0_4 + (-0.36567530035972595) * gru_0_out_t0_5 + (1.8015072345733643) * gru_0_out_t0_6 + (1.9041053056716919) * gru_0_out_t0_7 + (-0.20589712262153625) * gru_0_out_t0_8 + (-0.35524085164070129) * gru_0_out_t0_9 + (1.8606294393539429) * gru_0_out_t0_10 + (0.27462002635002136) * gru_0_out_t0_11 + (0.2128472775220871) * gru_0_out_t0_12 + (1.4536436796188354) * gru_0_out_t0_13 + (0.19666635990142822) * gru_0_out_t0_14 + (-0.38700997829437256) * gru_0_out_t0_15 + (-0.58077657222747803) * gru_0_out_t0_16 + (0.20213723182678223) * gru_0_out_t0_17 + (0.18831619620323181) * gru_0_out_t0_18 + (-1.2360872030258179) * gru_0_out_t0_19 + (-0.6745726466178894) * gru_0_out_t0_20 + (-1.1088112592697144) * gru_0_out_t0_21 + (0.51919955015182495) * gru_0_out_t0_22 + (1.437946081161499) * gru_0_out_t0_23 + (1.045720100402832) * gru_0_out_t0_24 + (-0.91910123825073242) * gru_0_out_t0_25 + (0.36706012487411499) * gru_0_out_t0_26 + (-0.27880692481994629) * gru_0_out_t0_27 + (-1.3676548004150391) * gru_0_out_t0_28 + (0.050083544105291367) * gru_0_out_t0_29 + (0.37140136957168579) * gru_0_out_t0_30 + (-1.6930934190750122) * gru_0_out_t0_31 + (0.23962110280990601) * gru_0_out_t0_32 + (0.25832691788673401) * gru_0_out_t0_33 + (-0.18632183969020844) * gru_0_out_t0_34 + (0.61712646484375) * gru_0_out_t0_35 + (0.19554808735847473) * gru_0_out_t0_36 + (-0.3100319504737854) * gru_0_out_t0_37 + (-0.19524195790290833) * gru_0_out_t0_38 + (0.33865600824356079) * gru_0_out_t0_39 + (2.5612778663635254) * gru_0_out_t0_40 + (0.061614066362380981) * gru_0_out_t0_41 + (-0.88045042753219604) * gru_0_out_t0_42 + (-0.196710005402565) * gru_0_out_t0_43 + (0.28933924436569214) * gru_0_out_t0_44 + (0.35075095295906067) * gru_0_out_t0_45 + (1.2756835222244263) * gru_0_out_t0_46 + (-0.35066723823547363) * gru_0_out_t0_47 + (0.27180531620979309) * gru_0_out_t0_48 + (0.099044241011142731) * gru_0_out_t0_49 + (-0.30049580335617065) * gru_0_out_t0_50 + (-0.20073506236076355) * gru_0_out_t0_51 + (-0.0014667947543784976) * gru_0_out_t0_52 + (0.58066356182098389) * gru_0_out_t0_53 + (0.22076267004013062) * gru_0_out_t0_54 + (0.90588110685348511) * gru_0_out_t0_55 + (0.62073498964309692) * gru_0_out_t0_56 + (-0.21829333901405334) * gru_0_out_t0_57 + (-0.42463773488998413) * gru_0_out_t0_58 + (0.11085380613803864) * gru_0_out_t0_59 + (0.17097228765487671) * gru_0_out_t0_60 + (1.7246203422546387) * gru_0_out_t0_61 + (0.87537813186645508) * gru_0_out_t0_62 + (1.7468832731246948) * gru_0_out_t0_63 + (0.19721262156963348) * gru_1_rev_t1_h_0 + (0.027827989310026169) * gru_1_rev_t1_h_1 + (-0.42645111680030823) * gru_1_rev_t1_h_2 + (0.79313915967941284) * gru_1_rev_t1_h_3 + (-0.6901431679725647) * gru_1_rev_t1_h_4 + (-0.62386375665664673) * gru_1_rev_t1_h_5 + (-0.073467567563056946) * gru_1_rev_t1_h_6 + (-0.46225538849830627) * gru_1_rev_t1_h_7 + (-0.29394426941871643) * gru_1_rev_t1_h_8 + (-0.14954963326454163) * gru_1_rev_t1_h_9 + (0.15387395024299622) * gru_1_rev_t1_h_10 + (0.50252634286880493) * gru_1_rev_t1_h_11 + (0.038032669574022293) * gru_1_rev_t1_h_12 + (-0.24083791673183441) * gru_1_rev_t1_h_13 + (0.33005350828170776) * gru_1_rev_t1_h_14 + (0.61342418193817139) * gru_1_rev_t1_h_15 + (1.1136883497238159) * gru_1_rev_t1_h_16 + (1.0958858728408813) * gru_1_rev_t1_h_17 + (0.31268852949142456) * gru_1_rev_t1_h_18 + (0.36710923910140991) * gru_1_rev_t1_h_19 + (-0.63343602418899536) * gru_1_rev_t1_h_20 + (0.63686668872833252) * gru_1_rev_t1_h_21 + (-0.66493654251098633) * gru_1_rev_t1_h_22 + (0.20904426276683807) * gru_1_rev_t1_h_23 + (-0.42113149166107178) * gru_1_rev_t1_h_24 + (-0.093368187546730042) * gru_1_rev_t1_h_25 + (-0.67437690496444702) * gru_1_rev_t1_h_26 + (-0.16489262878894806) * gru_1_rev_t1_h_27 + (-1.8634204864501953) * gru_1_rev_t1_h_28 + (-0.12889435887336731) * gru_1_rev_t1_h_29 + (-0.06814468652009964) * gru_1_rev_t1_h_30 + (-0.46242597699165344) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.13148400187492371) + (0.048074457794427872) * gru_0_out_t0_0 + (0.24856722354888916) * gru_0_out_t0_1 + (0.69820606708526611) * gru_0_out_t0_2 + (0.53871947526931763) * gru_0_out_t0_3 + (0.39280393719673157) * gru_0_out_t0_4 + (0.13331045210361481) * gru_0_out_t0_5 + (0.93594652414321899) * gru_0_out_t0_6 + (0.16193307936191559) * gru_0_out_t0_7 + (-1.2680048942565918) * gru_0_out_t0_8 + (-1.4774447679519653) * gru_0_out_t0_9 + (-0.52730667591094971) * gru_0_out_t0_10 + (0.13553179800510406) * gru_0_out_t0_11 + (-0.38394102454185486) * gru_0_out_t0_12 + (-0.36408752202987671) * gru_0_out_t0_13 + (0.29412955045700073) * gru_0_out_t0_14 + (0.086077392101287842) * gru_0_out_t0_15 + (-0.75713753700256348) * gru_0_out_t0_16 + (-0.22336678206920624) * gru_0_out_t0_17 + (-0.19519658386707306) * gru_0_out_t0_18 + (-0.40588206052780151) * gru_0_out_t0_19 + (0.71091991662979126) * gru_0_out_t0_20 + (-2.653040885925293) * gru_0_out_t0_21 + (0.14940784871578217) * gru_0_out_t0_22 + (0.90244674682617188) * gru_0_out_t0_23 + (-0.24565620720386505) * gru_0_out_t0_24 + (-0.11145949363708496) * gru_0_out_t0_25 + (-0.38311311602592468) * gru_0_out_t0_26 + (-0.16660372912883759) * gru_0_out_t0_27 + (0.23951300978660583) * gru_0_out_t0_28 + (-0.2302229106426239) * gru_0_out_t0_29 + (-0.10545958578586578) * gru_0_out_t0_30 + (-0.21753415465354919) * gru_0_out_t0_31 + (2.3672904968261719) * gru_0_out_t0_32 + (0.56052380800247192) * gru_0_out_t0_33 + (0.41656377911567688) * gru_0_out_t0_34 + (0.40945255756378174) * gru_0_out_t0_35 + (-0.098318979144096375) * gru_0_out_t0_36 + (-0.029935693368315697) * gru_0_out_t0_37 + (-0.23717382550239563) * gru_0_out_t0_38 + (-0.72892212867736816) * gru_0_out_t0_39 + (-0.079842247068881989) * gru_0_out_t0_40 + (0.51842379570007324) * gru_0_out_t0_41 + (0.74698877334594727) * gru_0_out_t0_42 + (-0.10745317488908768) * gru_0_out_t0_43 + (0.2335120290517807) * gru_0_out_t0_44 + (0.75212275981903076) * gru_0_out_t0_45 + (-0.10143916308879852) * gru_0_out_t0_46 + (-0.89907008409500122) * gru_0_out_t0_47 + (-0.20477205514907837) * gru_0_out_t0_48 + (0.2170599102973938) * gru_0_out_t0_49 + (1.6260881423950195) * gru_0_out_t0_50 + (0.07426055520772934) * gru_0_out_t0_51 + (0.071226753294467926) * gru_0_out_t0_52 + (0.7151983380317688) * gru_0_out_t0_53 + (-0.14541825652122498) * gru_0_out_t0_54 + (-0.53475254774093628) * gru_0_out_t0_55 + (-0.46197584271430969) * gru_0_out_t0_56 + (0.022221805527806282) * gru_0_out_t0_57 + (0.13503828644752502) * gru_0_out_t0_58 + (-0.18979109823703766) * gru_0_out_t0_59 + (-0.52279984951019287) * gru_0_out_t0_60 + (-0.36309480667114258) * gru_0_out_t0_61 + (-0.012288399040699005) * gru_0_out_t0_62 + (0.51911723613739014) * gru_0_out_t0_63 + gate_r * ((0.0013588299043476582) + (0.41391938924789429) * gru_1_rev_t1_h_0 + (1.373509407043457) * gru_1_rev_t1_h_1 + (-0.75845503807067871) * gru_1_rev_t1_h_2 + (-0.95289337635040283) * gru_1_rev_t1_h_3 + (1.6584351062774658) * gru_1_rev_t1_h_4 + (0.87250512838363647) * gru_1_rev_t1_h_5 + (-2.197955846786499) * gru_1_rev_t1_h_6 + (1.0226624011993408) * gru_1_rev_t1_h_7 + (-0.26242294907569885) * gru_1_rev_t1_h_8 + (0.54375976324081421) * gru_1_rev_t1_h_9 + (-1.1838041543960571) * gru_1_rev_t1_h_10 + (0.15622860193252563) * gru_1_rev_t1_h_11 + (0.14125631749629974) * gru_1_rev_t1_h_12 + (-0.072216205298900604) * gru_1_rev_t1_h_13 + (-0.66192048788070679) * gru_1_rev_t1_h_14 + (0.27665677666664124) * gru_1_rev_t1_h_15 + (-0.73894733190536499) * gru_1_rev_t1_h_16 + (-2.0791699886322021) * gru_1_rev_t1_h_17 + (0.22185227274894714) * gru_1_rev_t1_h_18 + (-1.0337995290756226) * gru_1_rev_t1_h_19 + (-0.86358082294464111) * gru_1_rev_t1_h_20 + (2.2028462886810303) * gru_1_rev_t1_h_21 + (-0.84903222322463989) * gru_1_rev_t1_h_22 + (-0.10651569068431854) * gru_1_rev_t1_h_23 + (2.3026671409606934) * gru_1_rev_t1_h_24 + (1.8932507038116455) * gru_1_rev_t1_h_25 + (0.99576646089553833) * gru_1_rev_t1_h_26 + (0.039755295962095261) * gru_1_rev_t1_h_27 + (0.13516265153884888) * gru_1_rev_t1_h_28 + (2.1378803253173828) * gru_1_rev_t1_h_29 + (-0.48830917477607727) * gru_1_rev_t1_h_30 + (3.7675611972808838) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_29 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_29;
    // h=30
    gate_r = sigmoid((0.85716193914413452) + (1.649543285369873) * gru_0_out_t0_0 + (0.45088303089141846) * gru_0_out_t0_1 + (-0.27718445658683777) * gru_0_out_t0_2 + (-0.61998218297958374) * gru_0_out_t0_3 + (-0.13106164336204529) * gru_0_out_t0_4 + (-0.97619658708572388) * gru_0_out_t0_5 + (3.111882209777832) * gru_0_out_t0_6 + (-0.87532556056976318) * gru_0_out_t0_7 + (-1.0475249290466309) * gru_0_out_t0_8 + (-1.3397421836853027) * gru_0_out_t0_9 + (-0.87532985210418701) * gru_0_out_t0_10 + (-0.025833267718553543) * gru_0_out_t0_11 + (1.002227783203125) * gru_0_out_t0_12 + (-2.5184757709503174) * gru_0_out_t0_13 + (1.9034723043441772) * gru_0_out_t0_14 + (-0.50497263669967651) * gru_0_out_t0_15 + (-2.0610408782958984) * gru_0_out_t0_16 + (-1.7017092704772949) * gru_0_out_t0_17 + (-0.87417680025100708) * gru_0_out_t0_18 + (1.6391714811325073) * gru_0_out_t0_19 + (0.49758973717689514) * gru_0_out_t0_20 + (-1.2953470945358276) * gru_0_out_t0_21 + (1.9915512800216675) * gru_0_out_t0_22 + (1.0057895183563232) * gru_0_out_t0_23 + (-1.0814905166625977) * gru_0_out_t0_24 + (0.17584118247032166) * gru_0_out_t0_25 + (2.9850382804870605) * gru_0_out_t0_26 + (-0.98339742422103882) * gru_0_out_t0_27 + (-1.4995357990264893) * gru_0_out_t0_28 + (1.9734455347061157) * gru_0_out_t0_29 + (0.28934454917907715) * gru_0_out_t0_30 + (6.8582983016967773) * gru_0_out_t0_31 + (-0.52590477466583252) * gru_0_out_t0_32 + (0.85930860042572021) * gru_0_out_t0_33 + (0.74450284242630005) * gru_0_out_t0_34 + (0.12054198980331421) * gru_0_out_t0_35 + (-1.8244819641113281) * gru_0_out_t0_36 + (2.277951717376709) * gru_0_out_t0_37 + (-0.68496119976043701) * gru_0_out_t0_38 + (-0.44774267077445984) * gru_0_out_t0_39 + (0.38161402940750122) * gru_0_out_t0_40 + (-0.1457248330116272) * gru_0_out_t0_41 + (-0.47726765275001526) * gru_0_out_t0_42 + (-0.96286976337432861) * gru_0_out_t0_43 + (-0.013196425512433052) * gru_0_out_t0_44 + (0.39577049016952515) * gru_0_out_t0_45 + (0.81023192405700684) * gru_0_out_t0_46 + (0.24970746040344238) * gru_0_out_t0_47 + (0.19124722480773926) * gru_0_out_t0_48 + (-0.10159099102020264) * gru_0_out_t0_49 + (-0.4481607973575592) * gru_0_out_t0_50 + (-0.62269479036331177) * gru_0_out_t0_51 + (-3.7736556529998779) * gru_0_out_t0_52 + (0.31949040293693542) * gru_0_out_t0_53 + (-0.70763826370239258) * gru_0_out_t0_54 + (-0.62920057773590088) * gru_0_out_t0_55 + (0.35399478673934937) * gru_0_out_t0_56 + (-0.0058800708502531052) * gru_0_out_t0_57 + (-0.32260569930076599) * gru_0_out_t0_58 + (0.65387481451034546) * gru_0_out_t0_59 + (-0.63343489170074463) * gru_0_out_t0_60 + (0.14838977158069611) * gru_0_out_t0_61 + (0.50209051370620728) * gru_0_out_t0_62 + (0.10247036814689636) * gru_0_out_t0_63 + (-1.8289417028427124) * gru_1_rev_t1_h_0 + (-0.13336770236492157) * gru_1_rev_t1_h_1 + (-0.13270542025566101) * gru_1_rev_t1_h_2 + (-0.65469801425933838) * gru_1_rev_t1_h_3 + (-0.85020792484283447) * gru_1_rev_t1_h_4 + (0.73639160394668579) * gru_1_rev_t1_h_5 + (0.014218850061297417) * gru_1_rev_t1_h_6 + (-0.60430967807769775) * gru_1_rev_t1_h_7 + (-0.88245111703872681) * gru_1_rev_t1_h_8 + (-0.68215394020080566) * gru_1_rev_t1_h_9 + (1.2907422780990601) * gru_1_rev_t1_h_10 + (-0.15736304223537445) * gru_1_rev_t1_h_11 + (0.41801920533180237) * gru_1_rev_t1_h_12 + (-0.63561326265335083) * gru_1_rev_t1_h_13 + (0.4857533872127533) * gru_1_rev_t1_h_14 + (-1.8187881708145142) * gru_1_rev_t1_h_15 + (0.38682323694229126) * gru_1_rev_t1_h_16 + (-0.71859484910964966) * gru_1_rev_t1_h_17 + (0.18281854689121246) * gru_1_rev_t1_h_18 + (-1.9922438859939575) * gru_1_rev_t1_h_19 + (-1.3174217939376831) * gru_1_rev_t1_h_20 + (0.020464414730668068) * gru_1_rev_t1_h_21 + (0.19182814657688141) * gru_1_rev_t1_h_22 + (-0.25705412030220032) * gru_1_rev_t1_h_23 + (0.8793521523475647) * gru_1_rev_t1_h_24 + (-0.43747323751449585) * gru_1_rev_t1_h_25 + (0.49686223268508911) * gru_1_rev_t1_h_26 + (1.5138499736785889) * gru_1_rev_t1_h_27 + (-4.5687127113342285) * gru_1_rev_t1_h_28 + (-1.3887350559234619) * gru_1_rev_t1_h_29 + (0.73412388563156128) * gru_1_rev_t1_h_30 + (0.53007608652114868) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((0.51611274480819702) + (0.22708803415298462) * gru_0_out_t0_0 + (0.036684650927782059) * gru_0_out_t0_1 + (0.31577715277671814) * gru_0_out_t0_2 + (-0.95264238119125366) * gru_0_out_t0_3 + (-0.7000727653503418) * gru_0_out_t0_4 + (0.16630235314369202) * gru_0_out_t0_5 + (2.0632691383361816) * gru_0_out_t0_6 + (2.0414032936096191) * gru_0_out_t0_7 + (0.72561746835708618) * gru_0_out_t0_8 + (0.32504880428314209) * gru_0_out_t0_9 + (-1.1182498931884766) * gru_0_out_t0_10 + (-0.64597666263580322) * gru_0_out_t0_11 + (0.18385662138462067) * gru_0_out_t0_12 + (-0.096333801746368408) * gru_0_out_t0_13 + (0.47771790623664856) * gru_0_out_t0_14 + (-0.19199702143669128) * gru_0_out_t0_15 + (-1.1163986921310425) * gru_0_out_t0_16 + (0.070315130054950714) * gru_0_out_t0_17 + (0.028666319325566292) * gru_0_out_t0_18 + (0.95718467235565186) * gru_0_out_t0_19 + (0.64090079069137573) * gru_0_out_t0_20 + (-1.8139890432357788) * gru_0_out_t0_21 + (0.48254719376564026) * gru_0_out_t0_22 + (0.46828603744506836) * gru_0_out_t0_23 + (-1.0449913740158081) * gru_0_out_t0_24 + (0.3517763614654541) * gru_0_out_t0_25 + (-0.42286396026611328) * gru_0_out_t0_26 + (-0.22348251938819885) * gru_0_out_t0_27 + (-0.29686412215232849) * gru_0_out_t0_28 + (0.87854999303817749) * gru_0_out_t0_29 + (0.41296565532684326) * gru_0_out_t0_30 + (-0.23116119205951691) * gru_0_out_t0_31 + (0.39755216240882874) * gru_0_out_t0_32 + (0.68386095762252808) * gru_0_out_t0_33 + (0.48814454674720764) * gru_0_out_t0_34 + (-0.09386858344078064) * gru_0_out_t0_35 + (0.33808150887489319) * gru_0_out_t0_36 + (-0.48398375511169434) * gru_0_out_t0_37 + (-0.23551404476165771) * gru_0_out_t0_38 + (0.42424923181533813) * gru_0_out_t0_39 + (0.087182268500328064) * gru_0_out_t0_40 + (-0.64929115772247314) * gru_0_out_t0_41 + (-0.89337903261184692) * gru_0_out_t0_42 + (-0.42241561412811279) * gru_0_out_t0_43 + (0.19373111426830292) * gru_0_out_t0_44 + (-0.36034497618675232) * gru_0_out_t0_45 + (0.81619042158126831) * gru_0_out_t0_46 + (-0.0015409109182655811) * gru_0_out_t0_47 + (0.54126572608947754) * gru_0_out_t0_48 + (-0.61879599094390869) * gru_0_out_t0_49 + (0.20354199409484863) * gru_0_out_t0_50 + (-0.2290412038564682) * gru_0_out_t0_51 + (-0.46708747744560242) * gru_0_out_t0_52 + (-0.33631902933120728) * gru_0_out_t0_53 + (0.033379718661308289) * gru_0_out_t0_54 + (0.72576892375946045) * gru_0_out_t0_55 + (0.78225451707839966) * gru_0_out_t0_56 + (-0.36133912205696106) * gru_0_out_t0_57 + (-0.23720811307430267) * gru_0_out_t0_58 + (2.6815047264099121) * gru_0_out_t0_59 + (0.47129055857658386) * gru_0_out_t0_60 + (0.70430088043212891) * gru_0_out_t0_61 + (0.16815133392810822) * gru_0_out_t0_62 + (-1.2784675359725952) * gru_0_out_t0_63 + (0.24068580567836761) * gru_1_rev_t1_h_0 + (0.13070201873779297) * gru_1_rev_t1_h_1 + (0.3264676034450531) * gru_1_rev_t1_h_2 + (-0.72935515642166138) * gru_1_rev_t1_h_3 + (0.38853806257247925) * gru_1_rev_t1_h_4 + (0.44815385341644287) * gru_1_rev_t1_h_5 + (-0.010806268081068993) * gru_1_rev_t1_h_6 + (-0.29390078783035278) * gru_1_rev_t1_h_7 + (0.1768365353345871) * gru_1_rev_t1_h_8 + (0.29849931597709656) * gru_1_rev_t1_h_9 + (0.58723509311676025) * gru_1_rev_t1_h_10 + (-0.7486303448677063) * gru_1_rev_t1_h_11 + (1.0636621713638306) * gru_1_rev_t1_h_12 + (1.1717221736907959) * gru_1_rev_t1_h_13 + (-0.04848029837012291) * gru_1_rev_t1_h_14 + (0.93759340047836304) * gru_1_rev_t1_h_15 + (-0.05463801696896553) * gru_1_rev_t1_h_16 + (-0.2824559211730957) * gru_1_rev_t1_h_17 + (-0.097557954490184784) * gru_1_rev_t1_h_18 + (0.84401881694793701) * gru_1_rev_t1_h_19 + (-1.0166242122650146) * gru_1_rev_t1_h_20 + (0.28890329599380493) * gru_1_rev_t1_h_21 + (-0.52912813425064087) * gru_1_rev_t1_h_22 + (0.2358674556016922) * gru_1_rev_t1_h_23 + (0.59409236907958984) * gru_1_rev_t1_h_24 + (0.14122110605239868) * gru_1_rev_t1_h_25 + (0.21271084249019623) * gru_1_rev_t1_h_26 + (0.78180390596389771) * gru_1_rev_t1_h_27 + (0.24963212013244629) * gru_1_rev_t1_h_28 + (0.20135380327701569) * gru_1_rev_t1_h_29 + (0.37729856371879578) * gru_1_rev_t1_h_30 + (-0.28824803233146667) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.22924134135246277) + (-0.50451838970184326) * gru_0_out_t0_0 + (0.41936236619949341) * gru_0_out_t0_1 + (0.34150728583335876) * gru_0_out_t0_2 + (-0.55084729194641113) * gru_0_out_t0_3 + (0.51659774780273438) * gru_0_out_t0_4 + (0.10549452155828476) * gru_0_out_t0_5 + (1.3371551036834717) * gru_0_out_t0_6 + (0.42776045203208923) * gru_0_out_t0_7 + (0.16935791075229645) * gru_0_out_t0_8 + (-0.55441683530807495) * gru_0_out_t0_9 + (-0.60458344221115112) * gru_0_out_t0_10 + (-0.6806262731552124) * gru_0_out_t0_11 + (-0.19063223898410797) * gru_0_out_t0_12 + (0.79175388813018799) * gru_0_out_t0_13 + (-0.99972623586654663) * gru_0_out_t0_14 + (-0.65215492248535156) * gru_0_out_t0_15 + (-0.16905416548252106) * gru_0_out_t0_16 + (0.64884060621261597) * gru_0_out_t0_17 + (0.54012417793273926) * gru_0_out_t0_18 + (0.66570198535919189) * gru_0_out_t0_19 + (0.83383089303970337) * gru_0_out_t0_20 + (-0.19423441588878632) * gru_0_out_t0_21 + (-0.14872634410858154) * gru_0_out_t0_22 + (-0.68760639429092407) * gru_0_out_t0_23 + (-1.379716157913208) * gru_0_out_t0_24 + (0.33245748281478882) * gru_0_out_t0_25 + (1.096098780632019) * gru_0_out_t0_26 + (0.52990186214447021) * gru_0_out_t0_27 + (-0.27782538533210754) * gru_0_out_t0_28 + (1.8925288915634155) * gru_0_out_t0_29 + (0.29745826125144958) * gru_0_out_t0_30 + (2.100780725479126) * gru_0_out_t0_31 + (0.27353081107139587) * gru_0_out_t0_32 + (-1.2037590742111206) * gru_0_out_t0_33 + (1.3473719358444214) * gru_0_out_t0_34 + (-1.338196873664856) * gru_0_out_t0_35 + (0.30669856071472168) * gru_0_out_t0_36 + (-1.1278975009918213) * gru_0_out_t0_37 + (0.49111238121986389) * gru_0_out_t0_38 + (1.2978067398071289) * gru_0_out_t0_39 + (0.46374866366386414) * gru_0_out_t0_40 + (-0.031063802540302277) * gru_0_out_t0_41 + (0.74358993768692017) * gru_0_out_t0_42 + (-0.53793752193450928) * gru_0_out_t0_43 + (0.077134490013122559) * gru_0_out_t0_44 + (-0.55197131633758545) * gru_0_out_t0_45 + (0.98787254095077515) * gru_0_out_t0_46 + (0.15084029734134674) * gru_0_out_t0_47 + (1.8568637371063232) * gru_0_out_t0_48 + (-1.6271584033966064) * gru_0_out_t0_49 + (0.34656858444213867) * gru_0_out_t0_50 + (-0.86839616298675537) * gru_0_out_t0_51 + (2.5582304000854492) * gru_0_out_t0_52 + (-0.12308415770530701) * gru_0_out_t0_53 + (-1.0661908388137817) * gru_0_out_t0_54 + (0.20816525816917419) * gru_0_out_t0_55 + (-0.83389878273010254) * gru_0_out_t0_56 + (-1.5924750566482544) * gru_0_out_t0_57 + (0.19064168632030487) * gru_0_out_t0_58 + (-0.47059336304664612) * gru_0_out_t0_59 + (0.05270574614405632) * gru_0_out_t0_60 + (0.83878022432327271) * gru_0_out_t0_61 + (0.26361614465713501) * gru_0_out_t0_62 + (0.7258831262588501) * gru_0_out_t0_63 + gate_r * ((1.6797351837158203) + (0.11638128012418747) * gru_1_rev_t1_h_0 + (0.71694105863571167) * gru_1_rev_t1_h_1 + (0.43218377232551575) * gru_1_rev_t1_h_2 + (-0.35854855179786682) * gru_1_rev_t1_h_3 + (1.1292591094970703) * gru_1_rev_t1_h_4 + (0.27341580390930176) * gru_1_rev_t1_h_5 + (-0.46340605616569519) * gru_1_rev_t1_h_6 + (-0.25662636756896973) * gru_1_rev_t1_h_7 + (-0.07856190949678421) * gru_1_rev_t1_h_8 + (1.1454125642776489) * gru_1_rev_t1_h_9 + (1.2836399078369141) * gru_1_rev_t1_h_10 + (1.6576181650161743) * gru_1_rev_t1_h_11 + (-0.20489834249019623) * gru_1_rev_t1_h_12 + (-1.2995989322662354) * gru_1_rev_t1_h_13 + (-1.3280289173126221) * gru_1_rev_t1_h_14 + (1.8126654624938965) * gru_1_rev_t1_h_15 + (0.059173241257667542) * gru_1_rev_t1_h_16 + (0.33619499206542969) * gru_1_rev_t1_h_17 + (1.5496997833251953) * gru_1_rev_t1_h_18 + (-0.07145284116268158) * gru_1_rev_t1_h_19 + (0.3755013644695282) * gru_1_rev_t1_h_20 + (0.16703319549560547) * gru_1_rev_t1_h_21 + (-0.4955742359161377) * gru_1_rev_t1_h_22 + (0.3444492518901825) * gru_1_rev_t1_h_23 + (-1.2621994018554688) * gru_1_rev_t1_h_24 + (0.64551210403442383) * gru_1_rev_t1_h_25 + (0.32480499148368835) * gru_1_rev_t1_h_26 + (-0.61869096755981445) * gru_1_rev_t1_h_27 + (1.3689392805099487) * gru_1_rev_t1_h_28 + (-0.13345751166343689) * gru_1_rev_t1_h_29 + (-0.56539428234100342) * gru_1_rev_t1_h_30 + (-0.25875064730644226) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_30 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_30;
    // h=31
    gate_r = sigmoid((-0.98557847738265991) + (-0.57001930475234985) * gru_0_out_t0_0 + (-0.35154679417610168) * gru_0_out_t0_1 + (0.10432462394237518) * gru_0_out_t0_2 + (0.35117658972740173) * gru_0_out_t0_3 + (-0.019616696983575821) * gru_0_out_t0_4 + (2.4098455905914307) * gru_0_out_t0_5 + (-0.77983909845352173) * gru_0_out_t0_6 + (-1.1174522638320923) * gru_0_out_t0_7 + (-0.78133088350296021) * gru_0_out_t0_8 + (-0.14760725200176239) * gru_0_out_t0_9 + (-0.024769900366663933) * gru_0_out_t0_10 + (0.240852952003479) * gru_0_out_t0_11 + (-0.16587091982364655) * gru_0_out_t0_12 + (0.11909255385398865) * gru_0_out_t0_13 + (-0.30178391933441162) * gru_0_out_t0_14 + (-0.17571985721588135) * gru_0_out_t0_15 + (-0.39979660511016846) * gru_0_out_t0_16 + (0.11788331717252731) * gru_0_out_t0_17 + (0.45817285776138306) * gru_0_out_t0_18 + (-0.97214162349700928) * gru_0_out_t0_19 + (-1.3138552904129028) * gru_0_out_t0_20 + (-3.144373893737793) * gru_0_out_t0_21 + (1.1638123989105225) * gru_0_out_t0_22 + (0.40527492761611938) * gru_0_out_t0_23 + (-1.349744439125061) * gru_0_out_t0_24 + (-0.29161128401756287) * gru_0_out_t0_25 + (0.9838789701461792) * gru_0_out_t0_26 + (0.40017032623291016) * gru_0_out_t0_27 + (1.0769093036651611) * gru_0_out_t0_28 + (-0.42304638028144836) * gru_0_out_t0_29 + (-0.039728749543428421) * gru_0_out_t0_30 + (0.65489012002944946) * gru_0_out_t0_31 + (0.41086083650588989) * gru_0_out_t0_32 + (-0.17747671902179718) * gru_0_out_t0_33 + (-0.26099306344985962) * gru_0_out_t0_34 + (-0.15206363797187805) * gru_0_out_t0_35 + (0.069185204803943634) * gru_0_out_t0_36 + (-0.12884795665740967) * gru_0_out_t0_37 + (0.17570154368877411) * gru_0_out_t0_38 + (-1.1146599054336548) * gru_0_out_t0_39 + (1.1497622728347778) * gru_0_out_t0_40 + (-0.17271503806114197) * gru_0_out_t0_41 + (-1.1614012718200684) * gru_0_out_t0_42 + (0.11741302162408829) * gru_0_out_t0_43 + (-0.62887835502624512) * gru_0_out_t0_44 + (0.33463692665100098) * gru_0_out_t0_45 + (1.28246009349823) * gru_0_out_t0_46 + (-0.33666315674781799) * gru_0_out_t0_47 + (-0.37943035364151001) * gru_0_out_t0_48 + (0.34155118465423584) * gru_0_out_t0_49 + (-0.26588797569274902) * gru_0_out_t0_50 + (0.0028470235411077738) * gru_0_out_t0_51 + (0.35706245899200439) * gru_0_out_t0_52 + (0.27461141347885132) * gru_0_out_t0_53 + (0.7130589485168457) * gru_0_out_t0_54 + (-0.2139023095369339) * gru_0_out_t0_55 + (0.90510344505310059) * gru_0_out_t0_56 + (0.43993806838989258) * gru_0_out_t0_57 + (0.591033935546875) * gru_0_out_t0_58 + (-0.36402034759521484) * gru_0_out_t0_59 + (0.4530339241027832) * gru_0_out_t0_60 + (3.1212844848632812) * gru_0_out_t0_61 + (0.24729430675506592) * gru_0_out_t0_62 + (0.61910051107406616) * gru_0_out_t0_63 + (-1.0665386915206909) * gru_1_rev_t1_h_0 + (-0.28836241364479065) * gru_1_rev_t1_h_1 + (0.65913307666778564) * gru_1_rev_t1_h_2 + (-0.46255064010620117) * gru_1_rev_t1_h_3 + (1.0547652244567871) * gru_1_rev_t1_h_4 + (-1.7123391628265381) * gru_1_rev_t1_h_5 + (0.19686447083950043) * gru_1_rev_t1_h_6 + (1.0052081346511841) * gru_1_rev_t1_h_7 + (0.28105196356773376) * gru_1_rev_t1_h_8 + (-0.81000250577926636) * gru_1_rev_t1_h_9 + (-2.408367395401001) * gru_1_rev_t1_h_10 + (1.5828473567962646) * gru_1_rev_t1_h_11 + (0.26879608631134033) * gru_1_rev_t1_h_12 + (0.44401097297668457) * gru_1_rev_t1_h_13 + (0.018761651590466499) * gru_1_rev_t1_h_14 + (-0.89160192012786865) * gru_1_rev_t1_h_15 + (1.4415880441665649) * gru_1_rev_t1_h_16 + (0.59578847885131836) * gru_1_rev_t1_h_17 + (-0.048765785992145538) * gru_1_rev_t1_h_18 + (0.98465847969055176) * gru_1_rev_t1_h_19 + (0.30099761486053467) * gru_1_rev_t1_h_20 + (-0.0095528606325387955) * gru_1_rev_t1_h_21 + (0.21286158263683319) * gru_1_rev_t1_h_22 + (-0.27618306875228882) * gru_1_rev_t1_h_23 + (1.1806737184524536) * gru_1_rev_t1_h_24 + (0.1493525505065918) * gru_1_rev_t1_h_25 + (-0.32428878545761108) * gru_1_rev_t1_h_26 + (0.47690919041633606) * gru_1_rev_t1_h_27 + (-3.3402020931243896) * gru_1_rev_t1_h_28 + (0.19403204321861267) * gru_1_rev_t1_h_29 + (-0.7463071346282959) * gru_1_rev_t1_h_30 + (0.35831201076507568) * gru_1_rev_t1_h_31);
    gate_z = sigmoid((-0.2909734845161438) + (0.32473564147949219) * gru_0_out_t0_0 + (-0.041842926293611526) * gru_0_out_t0_1 + (-0.05382344126701355) * gru_0_out_t0_2 + (0.39428138732910156) * gru_0_out_t0_3 + (0.32163208723068237) * gru_0_out_t0_4 + (-0.31057780981063843) * gru_0_out_t0_5 + (0.32698565721511841) * gru_0_out_t0_6 + (-0.18882457911968231) * gru_0_out_t0_7 + (0.68542063236236572) * gru_0_out_t0_8 + (0.92202413082122803) * gru_0_out_t0_9 + (-0.11150964349508286) * gru_0_out_t0_10 + (0.72921949625015259) * gru_0_out_t0_11 + (0.54567414522171021) * gru_0_out_t0_12 + (0.46798700094223022) * gru_0_out_t0_13 + (-1.3350894451141357) * gru_0_out_t0_14 + (0.3513941764831543) * gru_0_out_t0_15 + (0.94183695316314697) * gru_0_out_t0_16 + (1.3504635095596313) * gru_0_out_t0_17 + (-0.19672265648841858) * gru_0_out_t0_18 + (-0.83739352226257324) * gru_0_out_t0_19 + (0.027224553748965263) * gru_0_out_t0_20 + (-0.0093999719247221947) * gru_0_out_t0_21 + (0.95362061262130737) * gru_0_out_t0_22 + (-1.8471578359603882) * gru_0_out_t0_23 + (-0.3192552924156189) * gru_0_out_t0_24 + (0.00031467611552216113) * gru_0_out_t0_25 + (0.0054807355627417564) * gru_0_out_t0_26 + (0.37948691844940186) * gru_0_out_t0_27 + (-1.8738301992416382) * gru_0_out_t0_28 + (0.68953710794448853) * gru_0_out_t0_29 + (-0.12833678722381592) * gru_0_out_t0_30 + (0.51487106084823608) * gru_0_out_t0_31 + (0.3465462327003479) * gru_0_out_t0_32 + (-0.44558027386665344) * gru_0_out_t0_33 + (0.04008793830871582) * gru_0_out_t0_34 + (-0.10673493891954422) * gru_0_out_t0_35 + (-0.082206353545188904) * gru_0_out_t0_36 + (0.39172077178955078) * gru_0_out_t0_37 + (-0.1043899804353714) * gru_0_out_t0_38 + (0.74820905923843384) * gru_0_out_t0_39 + (1.4621125459671021) * gru_0_out_t0_40 + (0.068846963346004486) * gru_0_out_t0_41 + (0.17076753079891205) * gru_0_out_t0_42 + (-0.1556088775396347) * gru_0_out_t0_43 + (0.02686740830540657) * gru_0_out_t0_44 + (-0.61342614889144897) * gru_0_out_t0_45 + (0.34259906411170959) * gru_0_out_t0_46 + (-0.5014188289642334) * gru_0_out_t0_47 + (0.033381212502717972) * gru_0_out_t0_48 + (0.13173244893550873) * gru_0_out_t0_49 + (0.067189611494541168) * gru_0_out_t0_50 + (-0.69147717952728271) * gru_0_out_t0_51 + (0.26483070850372314) * gru_0_out_t0_52 + (0.69465166330337524) * gru_0_out_t0_53 + (0.15822289884090424) * gru_0_out_t0_54 + (0.5083349347114563) * gru_0_out_t0_55 + (-0.81061273813247681) * gru_0_out_t0_56 + (-0.20973744988441467) * gru_0_out_t0_57 + (1.3719931840896606) * gru_0_out_t0_58 + (-2.1541194915771484) * gru_0_out_t0_59 + (-0.44197630882263184) * gru_0_out_t0_60 + (-1.1619863510131836) * gru_0_out_t0_61 + (-0.99470162391662598) * gru_0_out_t0_62 + (-0.91743266582489014) * gru_0_out_t0_63 + (-0.19631260633468628) * gru_1_rev_t1_h_0 + (0.43105778098106384) * gru_1_rev_t1_h_1 + (-0.19833987951278687) * gru_1_rev_t1_h_2 + (0.081125907599925995) * gru_1_rev_t1_h_3 + (-0.50198847055435181) * gru_1_rev_t1_h_4 + (0.045934692025184631) * gru_1_rev_t1_h_5 + (0.40329831838607788) * gru_1_rev_t1_h_6 + (-0.1924348771572113) * gru_1_rev_t1_h_7 + (0.093145310878753662) * gru_1_rev_t1_h_8 + (-0.42420414090156555) * gru_1_rev_t1_h_9 + (-1.0381854772567749) * gru_1_rev_t1_h_10 + (0.66620093584060669) * gru_1_rev_t1_h_11 + (-0.21465878188610077) * gru_1_rev_t1_h_12 + (-0.27509391307830811) * gru_1_rev_t1_h_13 + (0.48978379368782043) * gru_1_rev_t1_h_14 + (0.94452959299087524) * gru_1_rev_t1_h_15 + (-0.9789193868637085) * gru_1_rev_t1_h_16 + (-0.51034855842590332) * gru_1_rev_t1_h_17 + (0.92878443002700806) * gru_1_rev_t1_h_18 + (2.8986659049987793) * gru_1_rev_t1_h_19 + (-0.82610905170440674) * gru_1_rev_t1_h_20 + (0.24784035980701447) * gru_1_rev_t1_h_21 + (-0.30891680717468262) * gru_1_rev_t1_h_22 + (-0.7636488676071167) * gru_1_rev_t1_h_23 + (-0.75402361154556274) * gru_1_rev_t1_h_24 + (-1.1052480936050415) * gru_1_rev_t1_h_25 + (0.61875826120376587) * gru_1_rev_t1_h_26 + (0.85503017902374268) * gru_1_rev_t1_h_27 + (-2.134047269821167) * gru_1_rev_t1_h_28 + (-0.71614706516265869) * gru_1_rev_t1_h_29 + (-1.1061947345733643) * gru_1_rev_t1_h_30 + (0.45499908924102783) * gru_1_rev_t1_h_31);
    gate_n = tanh((0.17665942013263702) + (0.01648641936480999) * gru_0_out_t0_0 + (-0.26165881752967834) * gru_0_out_t0_1 + (-0.66114318370819092) * gru_0_out_t0_2 + (0.5737336277961731) * gru_0_out_t0_3 + (-0.03213157132267952) * gru_0_out_t0_4 + (-1.1800439357757568) * gru_0_out_t0_5 + (0.41751754283905029) * gru_0_out_t0_6 + (-0.97069650888442993) * gru_0_out_t0_7 + (-0.86873745918273926) * gru_0_out_t0_8 + (-0.48883959650993347) * gru_0_out_t0_9 + (-0.26976341009140015) * gru_0_out_t0_10 + (-0.8067513108253479) * gru_0_out_t0_11 + (0.29970589280128479) * gru_0_out_t0_12 + (0.035179387778043747) * gru_0_out_t0_13 + (0.013108598068356514) * gru_0_out_t0_14 + (-0.26240602135658264) * gru_0_out_t0_15 + (-1.6582537889480591) * gru_0_out_t0_16 + (-1.0142879486083984) * gru_0_out_t0_17 + (0.071152396500110626) * gru_0_out_t0_18 + (-1.3084031343460083) * gru_0_out_t0_19 + (0.18800821900367737) * gru_0_out_t0_20 + (-0.79982244968414307) * gru_0_out_t0_21 + (0.016034698113799095) * gru_0_out_t0_22 + (1.7165931463241577) * gru_0_out_t0_23 + (0.339292973279953) * gru_0_out_t0_24 + (-0.90300899744033813) * gru_0_out_t0_25 + (-0.22457738220691681) * gru_0_out_t0_26 + (-0.11689282208681107) * gru_0_out_t0_27 + (-0.75630277395248413) * gru_0_out_t0_28 + (-0.46465310454368591) * gru_0_out_t0_29 + (0.28652399778366089) * gru_0_out_t0_30 + (0.4107556939125061) * gru_0_out_t0_31 + (0.94720196723937988) * gru_0_out_t0_32 + (-0.053141620010137558) * gru_0_out_t0_33 + (0.51892304420471191) * gru_0_out_t0_34 + (0.13718646764755249) * gru_0_out_t0_35 + (-0.16538721323013306) * gru_0_out_t0_36 + (0.20964382588863373) * gru_0_out_t0_37 + (-0.11333430558443069) * gru_0_out_t0_38 + (0.93258357048034668) * gru_0_out_t0_39 + (-1.2982161045074463) * gru_0_out_t0_40 + (0.87242937088012695) * gru_0_out_t0_41 + (-2.0130214691162109) * gru_0_out_t0_42 + (-0.12585063278675079) * gru_0_out_t0_43 + (0.5177839994430542) * gru_0_out_t0_44 + (0.26271334290504456) * gru_0_out_t0_45 + (-0.24234199523925781) * gru_0_out_t0_46 + (-0.25770381093025208) * gru_0_out_t0_47 + (-0.010344302281737328) * gru_0_out_t0_48 + (0.10489494353532791) * gru_0_out_t0_49 + (0.069803468883037567) * gru_0_out_t0_50 + (-0.051264781504869461) * gru_0_out_t0_51 + (-0.02555127814412117) * gru_0_out_t0_52 + (0.53907948732376099) * gru_0_out_t0_53 + (-0.33471527695655823) * gru_0_out_t0_54 + (0.77929776906967163) * gru_0_out_t0_55 + (-1.0024372339248657) * gru_0_out_t0_56 + (0.25550559163093567) * gru_0_out_t0_57 + (-0.019731847569346428) * gru_0_out_t0_58 + (-0.56956368684768677) * gru_0_out_t0_59 + (-0.18431814014911652) * gru_0_out_t0_60 + (-0.049358803778886795) * gru_0_out_t0_61 + (0.33418893814086914) * gru_0_out_t0_62 + (-0.15847030282020569) * gru_0_out_t0_63 + gate_r * ((-0.35027503967285156) + (0.12682047486305237) * gru_1_rev_t1_h_0 + (0.49305620789527893) * gru_1_rev_t1_h_1 + (-0.35291460156440735) * gru_1_rev_t1_h_2 + (0.19995740056037903) * gru_1_rev_t1_h_3 + (-0.062366444617509842) * gru_1_rev_t1_h_4 + (0.72309184074401855) * gru_1_rev_t1_h_5 + (0.2124248594045639) * gru_1_rev_t1_h_6 + (-0.34355464577674866) * gru_1_rev_t1_h_7 + (-0.15159454941749573) * gru_1_rev_t1_h_8 + (0.54663461446762085) * gru_1_rev_t1_h_9 + (-0.66338557004928589) * gru_1_rev_t1_h_10 + (-0.032460670918226242) * gru_1_rev_t1_h_11 + (-0.21329440176486969) * gru_1_rev_t1_h_12 + (0.32556816935539246) * gru_1_rev_t1_h_13 + (-0.22626769542694092) * gru_1_rev_t1_h_14 + (-0.95979189872741699) * gru_1_rev_t1_h_15 + (-0.10099168866872787) * gru_1_rev_t1_h_16 + (-0.20442976057529449) * gru_1_rev_t1_h_17 + (0.50563251972198486) * gru_1_rev_t1_h_18 + (1.7543375492095947) * gru_1_rev_t1_h_19 + (0.034563649445772171) * gru_1_rev_t1_h_20 + (-0.46983090043067932) * gru_1_rev_t1_h_21 + (-0.25320518016815186) * gru_1_rev_t1_h_22 + (-0.1592075526714325) * gru_1_rev_t1_h_23 + (-0.40631639957427979) * gru_1_rev_t1_h_24 + (0.81797534227371216) * gru_1_rev_t1_h_25 + (-0.25494658946990967) * gru_1_rev_t1_h_26 + (0.38209268450737) * gru_1_rev_t1_h_27 + (-0.89450091123580933) * gru_1_rev_t1_h_28 + (0.18882468342781067) * gru_1_rev_t1_h_29 + (0.37574642896652222) * gru_1_rev_t1_h_30 + (-1.1140655279159546) * gru_1_rev_t1_h_31));
    gru_1_rev_t0_h_31 = (1.0 - gate_z) * gate_n + gate_z * gru_1_rev_t1_h_31;

    gru_1_out_t0_0 = gru_1_fwd_t0_h_0;
    gru_1_out_t0_32 = gru_1_rev_t0_h_0;
    gru_1_out_t0_1 = gru_1_fwd_t0_h_1;
    gru_1_out_t0_33 = gru_1_rev_t0_h_1;
    gru_1_out_t0_2 = gru_1_fwd_t0_h_2;
    gru_1_out_t0_34 = gru_1_rev_t0_h_2;
    gru_1_out_t0_3 = gru_1_fwd_t0_h_3;
    gru_1_out_t0_35 = gru_1_rev_t0_h_3;
    gru_1_out_t0_4 = gru_1_fwd_t0_h_4;
    gru_1_out_t0_36 = gru_1_rev_t0_h_4;
    gru_1_out_t0_5 = gru_1_fwd_t0_h_5;
    gru_1_out_t0_37 = gru_1_rev_t0_h_5;
    gru_1_out_t0_6 = gru_1_fwd_t0_h_6;
    gru_1_out_t0_38 = gru_1_rev_t0_h_6;
    gru_1_out_t0_7 = gru_1_fwd_t0_h_7;
    gru_1_out_t0_39 = gru_1_rev_t0_h_7;
    gru_1_out_t0_8 = gru_1_fwd_t0_h_8;
    gru_1_out_t0_40 = gru_1_rev_t0_h_8;
    gru_1_out_t0_9 = gru_1_fwd_t0_h_9;
    gru_1_out_t0_41 = gru_1_rev_t0_h_9;
    gru_1_out_t0_10 = gru_1_fwd_t0_h_10;
    gru_1_out_t0_42 = gru_1_rev_t0_h_10;
    gru_1_out_t0_11 = gru_1_fwd_t0_h_11;
    gru_1_out_t0_43 = gru_1_rev_t0_h_11;
    gru_1_out_t0_12 = gru_1_fwd_t0_h_12;
    gru_1_out_t0_44 = gru_1_rev_t0_h_12;
    gru_1_out_t0_13 = gru_1_fwd_t0_h_13;
    gru_1_out_t0_45 = gru_1_rev_t0_h_13;
    gru_1_out_t0_14 = gru_1_fwd_t0_h_14;
    gru_1_out_t0_46 = gru_1_rev_t0_h_14;
    gru_1_out_t0_15 = gru_1_fwd_t0_h_15;
    gru_1_out_t0_47 = gru_1_rev_t0_h_15;
    gru_1_out_t0_16 = gru_1_fwd_t0_h_16;
    gru_1_out_t0_48 = gru_1_rev_t0_h_16;
    gru_1_out_t0_17 = gru_1_fwd_t0_h_17;
    gru_1_out_t0_49 = gru_1_rev_t0_h_17;
    gru_1_out_t0_18 = gru_1_fwd_t0_h_18;
    gru_1_out_t0_50 = gru_1_rev_t0_h_18;
    gru_1_out_t0_19 = gru_1_fwd_t0_h_19;
    gru_1_out_t0_51 = gru_1_rev_t0_h_19;
    gru_1_out_t0_20 = gru_1_fwd_t0_h_20;
    gru_1_out_t0_52 = gru_1_rev_t0_h_20;
    gru_1_out_t0_21 = gru_1_fwd_t0_h_21;
    gru_1_out_t0_53 = gru_1_rev_t0_h_21;
    gru_1_out_t0_22 = gru_1_fwd_t0_h_22;
    gru_1_out_t0_54 = gru_1_rev_t0_h_22;
    gru_1_out_t0_23 = gru_1_fwd_t0_h_23;
    gru_1_out_t0_55 = gru_1_rev_t0_h_23;
    gru_1_out_t0_24 = gru_1_fwd_t0_h_24;
    gru_1_out_t0_56 = gru_1_rev_t0_h_24;
    gru_1_out_t0_25 = gru_1_fwd_t0_h_25;
    gru_1_out_t0_57 = gru_1_rev_t0_h_25;
    gru_1_out_t0_26 = gru_1_fwd_t0_h_26;
    gru_1_out_t0_58 = gru_1_rev_t0_h_26;
    gru_1_out_t0_27 = gru_1_fwd_t0_h_27;
    gru_1_out_t0_59 = gru_1_rev_t0_h_27;
    gru_1_out_t0_28 = gru_1_fwd_t0_h_28;
    gru_1_out_t0_60 = gru_1_rev_t0_h_28;
    gru_1_out_t0_29 = gru_1_fwd_t0_h_29;
    gru_1_out_t0_61 = gru_1_rev_t0_h_29;
    gru_1_out_t0_30 = gru_1_fwd_t0_h_30;
    gru_1_out_t0_62 = gru_1_rev_t0_h_30;
    gru_1_out_t0_31 = gru_1_fwd_t0_h_31;
    gru_1_out_t0_63 = gru_1_rev_t0_h_31;
    gru_1_out_t1_0 = gru_1_fwd_t1_h_0;
    gru_1_out_t1_32 = gru_1_rev_t1_h_0;
    gru_1_out_t1_1 = gru_1_fwd_t1_h_1;
    gru_1_out_t1_33 = gru_1_rev_t1_h_1;
    gru_1_out_t1_2 = gru_1_fwd_t1_h_2;
    gru_1_out_t1_34 = gru_1_rev_t1_h_2;
    gru_1_out_t1_3 = gru_1_fwd_t1_h_3;
    gru_1_out_t1_35 = gru_1_rev_t1_h_3;
    gru_1_out_t1_4 = gru_1_fwd_t1_h_4;
    gru_1_out_t1_36 = gru_1_rev_t1_h_4;
    gru_1_out_t1_5 = gru_1_fwd_t1_h_5;
    gru_1_out_t1_37 = gru_1_rev_t1_h_5;
    gru_1_out_t1_6 = gru_1_fwd_t1_h_6;
    gru_1_out_t1_38 = gru_1_rev_t1_h_6;
    gru_1_out_t1_7 = gru_1_fwd_t1_h_7;
    gru_1_out_t1_39 = gru_1_rev_t1_h_7;
    gru_1_out_t1_8 = gru_1_fwd_t1_h_8;
    gru_1_out_t1_40 = gru_1_rev_t1_h_8;
    gru_1_out_t1_9 = gru_1_fwd_t1_h_9;
    gru_1_out_t1_41 = gru_1_rev_t1_h_9;
    gru_1_out_t1_10 = gru_1_fwd_t1_h_10;
    gru_1_out_t1_42 = gru_1_rev_t1_h_10;
    gru_1_out_t1_11 = gru_1_fwd_t1_h_11;
    gru_1_out_t1_43 = gru_1_rev_t1_h_11;
    gru_1_out_t1_12 = gru_1_fwd_t1_h_12;
    gru_1_out_t1_44 = gru_1_rev_t1_h_12;
    gru_1_out_t1_13 = gru_1_fwd_t1_h_13;
    gru_1_out_t1_45 = gru_1_rev_t1_h_13;
    gru_1_out_t1_14 = gru_1_fwd_t1_h_14;
    gru_1_out_t1_46 = gru_1_rev_t1_h_14;
    gru_1_out_t1_15 = gru_1_fwd_t1_h_15;
    gru_1_out_t1_47 = gru_1_rev_t1_h_15;
    gru_1_out_t1_16 = gru_1_fwd_t1_h_16;
    gru_1_out_t1_48 = gru_1_rev_t1_h_16;
    gru_1_out_t1_17 = gru_1_fwd_t1_h_17;
    gru_1_out_t1_49 = gru_1_rev_t1_h_17;
    gru_1_out_t1_18 = gru_1_fwd_t1_h_18;
    gru_1_out_t1_50 = gru_1_rev_t1_h_18;
    gru_1_out_t1_19 = gru_1_fwd_t1_h_19;
    gru_1_out_t1_51 = gru_1_rev_t1_h_19;
    gru_1_out_t1_20 = gru_1_fwd_t1_h_20;
    gru_1_out_t1_52 = gru_1_rev_t1_h_20;
    gru_1_out_t1_21 = gru_1_fwd_t1_h_21;
    gru_1_out_t1_53 = gru_1_rev_t1_h_21;
    gru_1_out_t1_22 = gru_1_fwd_t1_h_22;
    gru_1_out_t1_54 = gru_1_rev_t1_h_22;
    gru_1_out_t1_23 = gru_1_fwd_t1_h_23;
    gru_1_out_t1_55 = gru_1_rev_t1_h_23;
    gru_1_out_t1_24 = gru_1_fwd_t1_h_24;
    gru_1_out_t1_56 = gru_1_rev_t1_h_24;
    gru_1_out_t1_25 = gru_1_fwd_t1_h_25;
    gru_1_out_t1_57 = gru_1_rev_t1_h_25;
    gru_1_out_t1_26 = gru_1_fwd_t1_h_26;
    gru_1_out_t1_58 = gru_1_rev_t1_h_26;
    gru_1_out_t1_27 = gru_1_fwd_t1_h_27;
    gru_1_out_t1_59 = gru_1_rev_t1_h_27;
    gru_1_out_t1_28 = gru_1_fwd_t1_h_28;
    gru_1_out_t1_60 = gru_1_rev_t1_h_28;
    gru_1_out_t1_29 = gru_1_fwd_t1_h_29;
    gru_1_out_t1_61 = gru_1_rev_t1_h_29;
    gru_1_out_t1_30 = gru_1_fwd_t1_h_30;
    gru_1_out_t1_62 = gru_1_rev_t1_h_30;
    gru_1_out_t1_31 = gru_1_fwd_t1_h_31;
    gru_1_out_t1_63 = gru_1_rev_t1_h_31;
    gru_1_out_t2_0 = gru_1_fwd_t2_h_0;
    gru_1_out_t2_32 = gru_1_rev_t2_h_0;
    gru_1_out_t2_1 = gru_1_fwd_t2_h_1;
    gru_1_out_t2_33 = gru_1_rev_t2_h_1;
    gru_1_out_t2_2 = gru_1_fwd_t2_h_2;
    gru_1_out_t2_34 = gru_1_rev_t2_h_2;
    gru_1_out_t2_3 = gru_1_fwd_t2_h_3;
    gru_1_out_t2_35 = gru_1_rev_t2_h_3;
    gru_1_out_t2_4 = gru_1_fwd_t2_h_4;
    gru_1_out_t2_36 = gru_1_rev_t2_h_4;
    gru_1_out_t2_5 = gru_1_fwd_t2_h_5;
    gru_1_out_t2_37 = gru_1_rev_t2_h_5;
    gru_1_out_t2_6 = gru_1_fwd_t2_h_6;
    gru_1_out_t2_38 = gru_1_rev_t2_h_6;
    gru_1_out_t2_7 = gru_1_fwd_t2_h_7;
    gru_1_out_t2_39 = gru_1_rev_t2_h_7;
    gru_1_out_t2_8 = gru_1_fwd_t2_h_8;
    gru_1_out_t2_40 = gru_1_rev_t2_h_8;
    gru_1_out_t2_9 = gru_1_fwd_t2_h_9;
    gru_1_out_t2_41 = gru_1_rev_t2_h_9;
    gru_1_out_t2_10 = gru_1_fwd_t2_h_10;
    gru_1_out_t2_42 = gru_1_rev_t2_h_10;
    gru_1_out_t2_11 = gru_1_fwd_t2_h_11;
    gru_1_out_t2_43 = gru_1_rev_t2_h_11;
    gru_1_out_t2_12 = gru_1_fwd_t2_h_12;
    gru_1_out_t2_44 = gru_1_rev_t2_h_12;
    gru_1_out_t2_13 = gru_1_fwd_t2_h_13;
    gru_1_out_t2_45 = gru_1_rev_t2_h_13;
    gru_1_out_t2_14 = gru_1_fwd_t2_h_14;
    gru_1_out_t2_46 = gru_1_rev_t2_h_14;
    gru_1_out_t2_15 = gru_1_fwd_t2_h_15;
    gru_1_out_t2_47 = gru_1_rev_t2_h_15;
    gru_1_out_t2_16 = gru_1_fwd_t2_h_16;
    gru_1_out_t2_48 = gru_1_rev_t2_h_16;
    gru_1_out_t2_17 = gru_1_fwd_t2_h_17;
    gru_1_out_t2_49 = gru_1_rev_t2_h_17;
    gru_1_out_t2_18 = gru_1_fwd_t2_h_18;
    gru_1_out_t2_50 = gru_1_rev_t2_h_18;
    gru_1_out_t2_19 = gru_1_fwd_t2_h_19;
    gru_1_out_t2_51 = gru_1_rev_t2_h_19;
    gru_1_out_t2_20 = gru_1_fwd_t2_h_20;
    gru_1_out_t2_52 = gru_1_rev_t2_h_20;
    gru_1_out_t2_21 = gru_1_fwd_t2_h_21;
    gru_1_out_t2_53 = gru_1_rev_t2_h_21;
    gru_1_out_t2_22 = gru_1_fwd_t2_h_22;
    gru_1_out_t2_54 = gru_1_rev_t2_h_22;
    gru_1_out_t2_23 = gru_1_fwd_t2_h_23;
    gru_1_out_t2_55 = gru_1_rev_t2_h_23;
    gru_1_out_t2_24 = gru_1_fwd_t2_h_24;
    gru_1_out_t2_56 = gru_1_rev_t2_h_24;
    gru_1_out_t2_25 = gru_1_fwd_t2_h_25;
    gru_1_out_t2_57 = gru_1_rev_t2_h_25;
    gru_1_out_t2_26 = gru_1_fwd_t2_h_26;
    gru_1_out_t2_58 = gru_1_rev_t2_h_26;
    gru_1_out_t2_27 = gru_1_fwd_t2_h_27;
    gru_1_out_t2_59 = gru_1_rev_t2_h_27;
    gru_1_out_t2_28 = gru_1_fwd_t2_h_28;
    gru_1_out_t2_60 = gru_1_rev_t2_h_28;
    gru_1_out_t2_29 = gru_1_fwd_t2_h_29;
    gru_1_out_t2_61 = gru_1_rev_t2_h_29;
    gru_1_out_t2_30 = gru_1_fwd_t2_h_30;
    gru_1_out_t2_62 = gru_1_rev_t2_h_30;
    gru_1_out_t2_31 = gru_1_fwd_t2_h_31;
    gru_1_out_t2_63 = gru_1_rev_t2_h_31;
    gru_1_out_t3_0 = gru_1_fwd_t3_h_0;
    gru_1_out_t3_32 = gru_1_rev_t3_h_0;
    gru_1_out_t3_1 = gru_1_fwd_t3_h_1;
    gru_1_out_t3_33 = gru_1_rev_t3_h_1;
    gru_1_out_t3_2 = gru_1_fwd_t3_h_2;
    gru_1_out_t3_34 = gru_1_rev_t3_h_2;
    gru_1_out_t3_3 = gru_1_fwd_t3_h_3;
    gru_1_out_t3_35 = gru_1_rev_t3_h_3;
    gru_1_out_t3_4 = gru_1_fwd_t3_h_4;
    gru_1_out_t3_36 = gru_1_rev_t3_h_4;
    gru_1_out_t3_5 = gru_1_fwd_t3_h_5;
    gru_1_out_t3_37 = gru_1_rev_t3_h_5;
    gru_1_out_t3_6 = gru_1_fwd_t3_h_6;
    gru_1_out_t3_38 = gru_1_rev_t3_h_6;
    gru_1_out_t3_7 = gru_1_fwd_t3_h_7;
    gru_1_out_t3_39 = gru_1_rev_t3_h_7;
    gru_1_out_t3_8 = gru_1_fwd_t3_h_8;
    gru_1_out_t3_40 = gru_1_rev_t3_h_8;
    gru_1_out_t3_9 = gru_1_fwd_t3_h_9;
    gru_1_out_t3_41 = gru_1_rev_t3_h_9;
    gru_1_out_t3_10 = gru_1_fwd_t3_h_10;
    gru_1_out_t3_42 = gru_1_rev_t3_h_10;
    gru_1_out_t3_11 = gru_1_fwd_t3_h_11;
    gru_1_out_t3_43 = gru_1_rev_t3_h_11;
    gru_1_out_t3_12 = gru_1_fwd_t3_h_12;
    gru_1_out_t3_44 = gru_1_rev_t3_h_12;
    gru_1_out_t3_13 = gru_1_fwd_t3_h_13;
    gru_1_out_t3_45 = gru_1_rev_t3_h_13;
    gru_1_out_t3_14 = gru_1_fwd_t3_h_14;
    gru_1_out_t3_46 = gru_1_rev_t3_h_14;
    gru_1_out_t3_15 = gru_1_fwd_t3_h_15;
    gru_1_out_t3_47 = gru_1_rev_t3_h_15;
    gru_1_out_t3_16 = gru_1_fwd_t3_h_16;
    gru_1_out_t3_48 = gru_1_rev_t3_h_16;
    gru_1_out_t3_17 = gru_1_fwd_t3_h_17;
    gru_1_out_t3_49 = gru_1_rev_t3_h_17;
    gru_1_out_t3_18 = gru_1_fwd_t3_h_18;
    gru_1_out_t3_50 = gru_1_rev_t3_h_18;
    gru_1_out_t3_19 = gru_1_fwd_t3_h_19;
    gru_1_out_t3_51 = gru_1_rev_t3_h_19;
    gru_1_out_t3_20 = gru_1_fwd_t3_h_20;
    gru_1_out_t3_52 = gru_1_rev_t3_h_20;
    gru_1_out_t3_21 = gru_1_fwd_t3_h_21;
    gru_1_out_t3_53 = gru_1_rev_t3_h_21;
    gru_1_out_t3_22 = gru_1_fwd_t3_h_22;
    gru_1_out_t3_54 = gru_1_rev_t3_h_22;
    gru_1_out_t3_23 = gru_1_fwd_t3_h_23;
    gru_1_out_t3_55 = gru_1_rev_t3_h_23;
    gru_1_out_t3_24 = gru_1_fwd_t3_h_24;
    gru_1_out_t3_56 = gru_1_rev_t3_h_24;
    gru_1_out_t3_25 = gru_1_fwd_t3_h_25;
    gru_1_out_t3_57 = gru_1_rev_t3_h_25;
    gru_1_out_t3_26 = gru_1_fwd_t3_h_26;
    gru_1_out_t3_58 = gru_1_rev_t3_h_26;
    gru_1_out_t3_27 = gru_1_fwd_t3_h_27;
    gru_1_out_t3_59 = gru_1_rev_t3_h_27;
    gru_1_out_t3_28 = gru_1_fwd_t3_h_28;
    gru_1_out_t3_60 = gru_1_rev_t3_h_28;
    gru_1_out_t3_29 = gru_1_fwd_t3_h_29;
    gru_1_out_t3_61 = gru_1_rev_t3_h_29;
    gru_1_out_t3_30 = gru_1_fwd_t3_h_30;
    gru_1_out_t3_62 = gru_1_rev_t3_h_30;
    gru_1_out_t3_31 = gru_1_fwd_t3_h_31;
    gru_1_out_t3_63 = gru_1_rev_t3_h_31;
    gru_1_out_t4_0 = gru_1_fwd_t4_h_0;
    gru_1_out_t4_32 = gru_1_rev_t4_h_0;
    gru_1_out_t4_1 = gru_1_fwd_t4_h_1;
    gru_1_out_t4_33 = gru_1_rev_t4_h_1;
    gru_1_out_t4_2 = gru_1_fwd_t4_h_2;
    gru_1_out_t4_34 = gru_1_rev_t4_h_2;
    gru_1_out_t4_3 = gru_1_fwd_t4_h_3;
    gru_1_out_t4_35 = gru_1_rev_t4_h_3;
    gru_1_out_t4_4 = gru_1_fwd_t4_h_4;
    gru_1_out_t4_36 = gru_1_rev_t4_h_4;
    gru_1_out_t4_5 = gru_1_fwd_t4_h_5;
    gru_1_out_t4_37 = gru_1_rev_t4_h_5;
    gru_1_out_t4_6 = gru_1_fwd_t4_h_6;
    gru_1_out_t4_38 = gru_1_rev_t4_h_6;
    gru_1_out_t4_7 = gru_1_fwd_t4_h_7;
    gru_1_out_t4_39 = gru_1_rev_t4_h_7;
    gru_1_out_t4_8 = gru_1_fwd_t4_h_8;
    gru_1_out_t4_40 = gru_1_rev_t4_h_8;
    gru_1_out_t4_9 = gru_1_fwd_t4_h_9;
    gru_1_out_t4_41 = gru_1_rev_t4_h_9;
    gru_1_out_t4_10 = gru_1_fwd_t4_h_10;
    gru_1_out_t4_42 = gru_1_rev_t4_h_10;
    gru_1_out_t4_11 = gru_1_fwd_t4_h_11;
    gru_1_out_t4_43 = gru_1_rev_t4_h_11;
    gru_1_out_t4_12 = gru_1_fwd_t4_h_12;
    gru_1_out_t4_44 = gru_1_rev_t4_h_12;
    gru_1_out_t4_13 = gru_1_fwd_t4_h_13;
    gru_1_out_t4_45 = gru_1_rev_t4_h_13;
    gru_1_out_t4_14 = gru_1_fwd_t4_h_14;
    gru_1_out_t4_46 = gru_1_rev_t4_h_14;
    gru_1_out_t4_15 = gru_1_fwd_t4_h_15;
    gru_1_out_t4_47 = gru_1_rev_t4_h_15;
    gru_1_out_t4_16 = gru_1_fwd_t4_h_16;
    gru_1_out_t4_48 = gru_1_rev_t4_h_16;
    gru_1_out_t4_17 = gru_1_fwd_t4_h_17;
    gru_1_out_t4_49 = gru_1_rev_t4_h_17;
    gru_1_out_t4_18 = gru_1_fwd_t4_h_18;
    gru_1_out_t4_50 = gru_1_rev_t4_h_18;
    gru_1_out_t4_19 = gru_1_fwd_t4_h_19;
    gru_1_out_t4_51 = gru_1_rev_t4_h_19;
    gru_1_out_t4_20 = gru_1_fwd_t4_h_20;
    gru_1_out_t4_52 = gru_1_rev_t4_h_20;
    gru_1_out_t4_21 = gru_1_fwd_t4_h_21;
    gru_1_out_t4_53 = gru_1_rev_t4_h_21;
    gru_1_out_t4_22 = gru_1_fwd_t4_h_22;
    gru_1_out_t4_54 = gru_1_rev_t4_h_22;
    gru_1_out_t4_23 = gru_1_fwd_t4_h_23;
    gru_1_out_t4_55 = gru_1_rev_t4_h_23;
    gru_1_out_t4_24 = gru_1_fwd_t4_h_24;
    gru_1_out_t4_56 = gru_1_rev_t4_h_24;
    gru_1_out_t4_25 = gru_1_fwd_t4_h_25;
    gru_1_out_t4_57 = gru_1_rev_t4_h_25;
    gru_1_out_t4_26 = gru_1_fwd_t4_h_26;
    gru_1_out_t4_58 = gru_1_rev_t4_h_26;
    gru_1_out_t4_27 = gru_1_fwd_t4_h_27;
    gru_1_out_t4_59 = gru_1_rev_t4_h_27;
    gru_1_out_t4_28 = gru_1_fwd_t4_h_28;
    gru_1_out_t4_60 = gru_1_rev_t4_h_28;
    gru_1_out_t4_29 = gru_1_fwd_t4_h_29;
    gru_1_out_t4_61 = gru_1_rev_t4_h_29;
    gru_1_out_t4_30 = gru_1_fwd_t4_h_30;
    gru_1_out_t4_62 = gru_1_rev_t4_h_30;
    gru_1_out_t4_31 = gru_1_fwd_t4_h_31;
    gru_1_out_t4_63 = gru_1_rev_t4_h_31;

    // 2. BiGRU Layer 2
    // Forward sequence
    // FW step t=0
    // h=0
    gate_r = sigmoid((-0.18073664605617523) + (0.08729107677936554) * gru_1_out_t0_0 + (-0.039967507123947144) * gru_1_out_t0_1 + (-0.31522822380065918) * gru_1_out_t0_2 + (-0.69163823127746582) * gru_1_out_t0_3 + (0.19949781894683838) * gru_1_out_t0_4 + (-0.54117608070373535) * gru_1_out_t0_5 + (-1.066991925239563) * gru_1_out_t0_6 + (0.087276667356491089) * gru_1_out_t0_7 + (-0.20998075604438782) * gru_1_out_t0_8 + (0.21276704967021942) * gru_1_out_t0_9 + (0.2321389764547348) * gru_1_out_t0_10 + (0.37099918723106384) * gru_1_out_t0_11 + (-0.30260381102561951) * gru_1_out_t0_12 + (-0.75835436582565308) * gru_1_out_t0_13 + (-0.20154118537902832) * gru_1_out_t0_14 + (0.35377636551856995) * gru_1_out_t0_15 + (-0.43740832805633545) * gru_1_out_t0_16 + (0.62309902906417847) * gru_1_out_t0_17 + (0.24479377269744873) * gru_1_out_t0_18 + (0.8066563606262207) * gru_1_out_t0_19 + (-0.16237467527389526) * gru_1_out_t0_20 + (-0.37762981653213501) * gru_1_out_t0_21 + (-0.93802309036254883) * gru_1_out_t0_22 + (-1.7538044452667236) * gru_1_out_t0_23 + (-0.46073368191719055) * gru_1_out_t0_24 + (-0.37962305545806885) * gru_1_out_t0_25 + (0.67589527368545532) * gru_1_out_t0_26 + (-0.40321063995361328) * gru_1_out_t0_27 + (0.75434738397598267) * gru_1_out_t0_28 + (0.084689721465110779) * gru_1_out_t0_29 + (-1.8361772298812866) * gru_1_out_t0_30 + (-0.6105002760887146) * gru_1_out_t0_31 + (-0.94578909873962402) * gru_1_out_t0_32 + (0.87572675943374634) * gru_1_out_t0_33 + (-1.9358584880828857) * gru_1_out_t0_34 + (-0.46796771883964539) * gru_1_out_t0_35 + (-1.3884075880050659) * gru_1_out_t0_36 + (0.018412670120596886) * gru_1_out_t0_37 + (-0.29430624842643738) * gru_1_out_t0_38 + (0.47208642959594727) * gru_1_out_t0_39 + (1.1266782283782959) * gru_1_out_t0_40 + (-1.2007905244827271) * gru_1_out_t0_41 + (0.74026471376419067) * gru_1_out_t0_42 + (-1.5903787612915039) * gru_1_out_t0_43 + (-0.18990631401538849) * gru_1_out_t0_44 + (0.62702357769012451) * gru_1_out_t0_45 + (-0.69175237417221069) * gru_1_out_t0_46 + (-0.067822158336639404) * gru_1_out_t0_47 + (0.56201267242431641) * gru_1_out_t0_48 + (1.9739961624145508) * gru_1_out_t0_49 + (0.26549708843231201) * gru_1_out_t0_50 + (0.96722650527954102) * gru_1_out_t0_51 + (1.6199929714202881) * gru_1_out_t0_52 + (-0.16836661100387573) * gru_1_out_t0_53 + (0.43099343776702881) * gru_1_out_t0_54 + (1.9925323724746704) * gru_1_out_t0_55 + (-0.22745929658412933) * gru_1_out_t0_56 + (0.96157270669937134) * gru_1_out_t0_57 + (-0.096243835985660553) * gru_1_out_t0_58 + (1.6467574834823608) * gru_1_out_t0_59 + (1.2544323205947876) * gru_1_out_t0_60 + (0.075169563293457031) * gru_1_out_t0_61 + (0.23568360507488251) * gru_1_out_t0_62 + (-0.74118083715438843) * gru_1_out_t0_63);
    gate_z = sigmoid((-1.5950472354888916) + (-0.62472999095916748) * gru_1_out_t0_0 + (0.948569655418396) * gru_1_out_t0_1 + (-0.042311780154705048) * gru_1_out_t0_2 + (0.22679845988750458) * gru_1_out_t0_3 + (0.83300691843032837) * gru_1_out_t0_4 + (0.50348711013793945) * gru_1_out_t0_5 + (1.3434373140335083) * gru_1_out_t0_6 + (0.83106744289398193) * gru_1_out_t0_7 + (0.92984825372695923) * gru_1_out_t0_8 + (0.12885928153991699) * gru_1_out_t0_9 + (-0.048464119434356689) * gru_1_out_t0_10 + (0.47500133514404297) * gru_1_out_t0_11 + (0.4825613796710968) * gru_1_out_t0_12 + (0.31471467018127441) * gru_1_out_t0_13 + (0.48116114735603333) * gru_1_out_t0_14 + (0.6122782826423645) * gru_1_out_t0_15 + (-0.29530638456344604) * gru_1_out_t0_16 + (-0.67366528511047363) * gru_1_out_t0_17 + (-1.2825165987014771) * gru_1_out_t0_18 + (-0.061589740216732025) * gru_1_out_t0_19 + (0.55133748054504395) * gru_1_out_t0_20 + (-0.52434903383255005) * gru_1_out_t0_21 + (-0.097612567245960236) * gru_1_out_t0_22 + (0.80840730667114258) * gru_1_out_t0_23 + (-1.0388964414596558) * gru_1_out_t0_24 + (0.00016520694771315902) * gru_1_out_t0_25 + (0.32818588614463806) * gru_1_out_t0_26 + (2.0948443412780762) * gru_1_out_t0_27 + (-0.13348464667797089) * gru_1_out_t0_28 + (-0.56748682260513306) * gru_1_out_t0_29 + (-0.085060544312000275) * gru_1_out_t0_30 + (0.12882412970066071) * gru_1_out_t0_31 + (-0.2335030734539032) * gru_1_out_t0_32 + (0.15321582555770874) * gru_1_out_t0_33 + (-0.38789618015289307) * gru_1_out_t0_34 + (0.69416701793670654) * gru_1_out_t0_35 + (0.26861950755119324) * gru_1_out_t0_36 + (-0.40949362516403198) * gru_1_out_t0_37 + (-0.52702522277832031) * gru_1_out_t0_38 + (-0.20277976989746094) * gru_1_out_t0_39 + (-0.13890430331230164) * gru_1_out_t0_40 + (-0.018138354644179344) * gru_1_out_t0_41 + (0.5611148476600647) * gru_1_out_t0_42 + (0.26855477690696716) * gru_1_out_t0_43 + (-1.1389527320861816) * gru_1_out_t0_44 + (0.59090304374694824) * gru_1_out_t0_45 + (0.70569831132888794) * gru_1_out_t0_46 + (0.51646310091018677) * gru_1_out_t0_47 + (0.59123629331588745) * gru_1_out_t0_48 + (0.32796949148178101) * gru_1_out_t0_49 + (1.8620154857635498) * gru_1_out_t0_50 + (0.092217162251472473) * gru_1_out_t0_51 + (-1.0174065828323364) * gru_1_out_t0_52 + (0.001582387019880116) * gru_1_out_t0_53 + (0.58182430267333984) * gru_1_out_t0_54 + (-0.40918311476707458) * gru_1_out_t0_55 + (-1.0552144050598145) * gru_1_out_t0_56 + (0.31395998597145081) * gru_1_out_t0_57 + (0.2548229992389679) * gru_1_out_t0_58 + (-0.57632046937942505) * gru_1_out_t0_59 + (0.026836544275283813) * gru_1_out_t0_60 + (-0.59954369068145752) * gru_1_out_t0_61 + (0.71469402313232422) * gru_1_out_t0_62 + (-0.157891646027565) * gru_1_out_t0_63);
    gate_n = tanh((-0.89056885242462158) + (-0.15531931817531586) * gru_1_out_t0_0 + (0.039451684802770615) * gru_1_out_t0_1 + (0.15706862509250641) * gru_1_out_t0_2 + (0.30771991610527039) * gru_1_out_t0_3 + (0.14815370738506317) * gru_1_out_t0_4 + (-0.017183301970362663) * gru_1_out_t0_5 + (0.28388711810112) * gru_1_out_t0_6 + (-0.18915952742099762) * gru_1_out_t0_7 + (0.27618095278739929) * gru_1_out_t0_8 + (-0.24971669912338257) * gru_1_out_t0_9 + (-0.023962071165442467) * gru_1_out_t0_10 + (-0.66587674617767334) * gru_1_out_t0_11 + (0.30822166800498962) * gru_1_out_t0_12 + (-0.2512696385383606) * gru_1_out_t0_13 + (0.14788712561130524) * gru_1_out_t0_14 + (-0.28047487139701843) * gru_1_out_t0_15 + (-0.22166067361831665) * gru_1_out_t0_16 + (0.13373740017414093) * gru_1_out_t0_17 + (0.2893318235874176) * gru_1_out_t0_18 + (0.2883179783821106) * gru_1_out_t0_19 + (-0.30510246753692627) * gru_1_out_t0_20 + (0.18500968813896179) * gru_1_out_t0_21 + (0.60036975145339966) * gru_1_out_t0_22 + (0.69969487190246582) * gru_1_out_t0_23 + (0.3425222635269165) * gru_1_out_t0_24 + (-0.23267178237438202) * gru_1_out_t0_25 + (0.081159114837646484) * gru_1_out_t0_26 + (0.61552906036376953) * gru_1_out_t0_27 + (0.34244313836097717) * gru_1_out_t0_28 + (0.51718276739120483) * gru_1_out_t0_29 + (0.19291360676288605) * gru_1_out_t0_30 + (-0.70089727640151978) * gru_1_out_t0_31 + (0.66866022348403931) * gru_1_out_t0_32 + (0.69753736257553101) * gru_1_out_t0_33 + (-0.48435235023498535) * gru_1_out_t0_34 + (0.18863131105899811) * gru_1_out_t0_35 + (-0.44330805540084839) * gru_1_out_t0_36 + (-0.0068796528503298759) * gru_1_out_t0_37 + (0.38404324650764465) * gru_1_out_t0_38 + (-0.5873112678527832) * gru_1_out_t0_39 + (0.29154515266418457) * gru_1_out_t0_40 + (-0.25640428066253662) * gru_1_out_t0_41 + (-0.067580252885818481) * gru_1_out_t0_42 + (0.4244784414768219) * gru_1_out_t0_43 + (0.033369924873113632) * gru_1_out_t0_44 + (-0.19432789087295532) * gru_1_out_t0_45 + (-0.35623317956924438) * gru_1_out_t0_46 + (1.4397494792938232) * gru_1_out_t0_47 + (-0.53303670883178711) * gru_1_out_t0_48 + (0.15586227178573608) * gru_1_out_t0_49 + (0.34602692723274231) * gru_1_out_t0_50 + (0.62279218435287476) * gru_1_out_t0_51 + (0.094537675380706787) * gru_1_out_t0_52 + (0.08416420966386795) * gru_1_out_t0_53 + (0.17593678832054138) * gru_1_out_t0_54 + (-0.32541036605834961) * gru_1_out_t0_55 + (-0.17277508974075317) * gru_1_out_t0_56 + (0.046922165900468826) * gru_1_out_t0_57 + (-0.16812768578529358) * gru_1_out_t0_58 + (0.11006074398756027) * gru_1_out_t0_59 + (0.36323520541191101) * gru_1_out_t0_60 + (-0.14941711723804474) * gru_1_out_t0_61 + (-1.2971339225769043) * gru_1_out_t0_62 + (-0.21599899232387543) * gru_1_out_t0_63 + gate_r * (-0.24038051068782806));
    gru_2_fwd_t0_h_0 = (1.0 - gate_z) * gate_n;
    // h=1
    gate_r = sigmoid((-0.076955623924732208) + (2.4431288242340088) * gru_1_out_t0_0 + (1.1316577196121216) * gru_1_out_t0_1 + (-0.54076719284057617) * gru_1_out_t0_2 + (0.025410259142518044) * gru_1_out_t0_3 + (0.22690004110336304) * gru_1_out_t0_4 + (-0.16546677052974701) * gru_1_out_t0_5 + (0.88440799713134766) * gru_1_out_t0_6 + (-0.73617559671401978) * gru_1_out_t0_7 + (-0.19487325847148895) * gru_1_out_t0_8 + (-0.17700362205505371) * gru_1_out_t0_9 + (1.3849403858184814) * gru_1_out_t0_10 + (-1.1591407060623169) * gru_1_out_t0_11 + (0.45289126038551331) * gru_1_out_t0_12 + (1.1546627283096313) * gru_1_out_t0_13 + (-0.61455452442169189) * gru_1_out_t0_14 + (-1.0931040048599243) * gru_1_out_t0_15 + (-0.97985923290252686) * gru_1_out_t0_16 + (0.21307899057865143) * gru_1_out_t0_17 + (0.388753741979599) * gru_1_out_t0_18 + (0.22562903165817261) * gru_1_out_t0_19 + (-0.36337554454803467) * gru_1_out_t0_20 + (-0.27227422595024109) * gru_1_out_t0_21 + (0.26810759305953979) * gru_1_out_t0_22 + (0.41299206018447876) * gru_1_out_t0_23 + (2.8235538005828857) * gru_1_out_t0_24 + (-0.089105606079101562) * gru_1_out_t0_25 + (-0.81910771131515503) * gru_1_out_t0_26 + (-1.4307278394699097) * gru_1_out_t0_27 + (-0.076145388185977936) * gru_1_out_t0_28 + (0.13243740797042847) * gru_1_out_t0_29 + (4.5168619155883789) * gru_1_out_t0_30 + (0.12253942340612411) * gru_1_out_t0_31 + (0.08037259429693222) * gru_1_out_t0_32 + (0.49392515420913696) * gru_1_out_t0_33 + (-0.61467605829238892) * gru_1_out_t0_34 + (-0.32944786548614502) * gru_1_out_t0_35 + (-0.30708473920822144) * gru_1_out_t0_36 + (-0.63777190446853638) * gru_1_out_t0_37 + (-0.53033339977264404) * gru_1_out_t0_38 + (-0.61023086309432983) * gru_1_out_t0_39 + (-0.31139817833900452) * gru_1_out_t0_40 + (1.0876935720443726) * gru_1_out_t0_41 + (-0.15650591254234314) * gru_1_out_t0_42 + (-1.5625373125076294) * gru_1_out_t0_43 + (-0.50046622753143311) * gru_1_out_t0_44 + (-0.38554257154464722) * gru_1_out_t0_45 + (-1.7963999509811401) * gru_1_out_t0_46 + (1.2825547456741333) * gru_1_out_t0_47 + (1.1039333343505859) * gru_1_out_t0_48 + (1.5370361804962158) * gru_1_out_t0_49 + (0.327146977186203) * gru_1_out_t0_50 + (-0.38325658440589905) * gru_1_out_t0_51 + (-1.0803104639053345) * gru_1_out_t0_52 + (-0.13954035937786102) * gru_1_out_t0_53 + (0.96088105440139771) * gru_1_out_t0_54 + (-0.1835133284330368) * gru_1_out_t0_55 + (-0.54965561628341675) * gru_1_out_t0_56 + (1.8490413427352905) * gru_1_out_t0_57 + (-0.31863704323768616) * gru_1_out_t0_58 + (-0.97742187976837158) * gru_1_out_t0_59 + (0.2103441059589386) * gru_1_out_t0_60 + (0.35383233428001404) * gru_1_out_t0_61 + (1.1381590366363525) * gru_1_out_t0_62 + (0.32660749554634094) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.53590685129165649) + (0.14715632796287537) * gru_1_out_t0_0 + (0.21391016244888306) * gru_1_out_t0_1 + (0.77107900381088257) * gru_1_out_t0_2 + (0.73561185598373413) * gru_1_out_t0_3 + (0.10207085311412811) * gru_1_out_t0_4 + (0.83710801601409912) * gru_1_out_t0_5 + (0.74333930015563965) * gru_1_out_t0_6 + (-0.31950879096984863) * gru_1_out_t0_7 + (0.13774976134300232) * gru_1_out_t0_8 + (0.13335037231445312) * gru_1_out_t0_9 + (0.58584427833557129) * gru_1_out_t0_10 + (-0.021422304213047028) * gru_1_out_t0_11 + (0.35624438524246216) * gru_1_out_t0_12 + (0.076298832893371582) * gru_1_out_t0_13 + (-0.33925482630729675) * gru_1_out_t0_14 + (-0.850757896900177) * gru_1_out_t0_15 + (-0.14501842856407166) * gru_1_out_t0_16 + (0.44666123390197754) * gru_1_out_t0_17 + (-0.081198997795581818) * gru_1_out_t0_18 + (-0.88346284627914429) * gru_1_out_t0_19 + (0.69240283966064453) * gru_1_out_t0_20 + (0.40099161863327026) * gru_1_out_t0_21 + (0.18156024813652039) * gru_1_out_t0_22 + (0.54490387439727783) * gru_1_out_t0_23 + (-0.38224372267723083) * gru_1_out_t0_24 + (0.28607317805290222) * gru_1_out_t0_25 + (0.11676506698131561) * gru_1_out_t0_26 + (-0.26135024428367615) * gru_1_out_t0_27 + (0.2026161402463913) * gru_1_out_t0_28 + (-0.10886173695325851) * gru_1_out_t0_29 + (0.29166752099990845) * gru_1_out_t0_30 + (-0.31435507535934448) * gru_1_out_t0_31 + (0.69946563243865967) * gru_1_out_t0_32 + (-0.16277627646923065) * gru_1_out_t0_33 + (0.16130435466766357) * gru_1_out_t0_34 + (0.39183688163757324) * gru_1_out_t0_35 + (0.50352519750595093) * gru_1_out_t0_36 + (0.00019375012197997421) * gru_1_out_t0_37 + (0.26109817624092102) * gru_1_out_t0_38 + (-0.54404157400131226) * gru_1_out_t0_39 + (-0.28784483671188354) * gru_1_out_t0_40 + (0.09760892391204834) * gru_1_out_t0_41 + (-1.2587010860443115) * gru_1_out_t0_42 + (0.088212445378303528) * gru_1_out_t0_43 + (-0.20786267518997192) * gru_1_out_t0_44 + (-0.16868837177753448) * gru_1_out_t0_45 + (0.056641094386577606) * gru_1_out_t0_46 + (0.22310295701026917) * gru_1_out_t0_47 + (0.55202269554138184) * gru_1_out_t0_48 + (-0.50012212991714478) * gru_1_out_t0_49 + (0.40228304266929626) * gru_1_out_t0_50 + (-0.10257671028375626) * gru_1_out_t0_51 + (-1.2289341688156128) * gru_1_out_t0_52 + (-0.34043803811073303) * gru_1_out_t0_53 + (-0.40920534729957581) * gru_1_out_t0_54 + (0.35138455033302307) * gru_1_out_t0_55 + (-0.34417188167572021) * gru_1_out_t0_56 + (-0.31853753328323364) * gru_1_out_t0_57 + (-0.85867571830749512) * gru_1_out_t0_58 + (-0.058695182204246521) * gru_1_out_t0_59 + (-0.42712351679801941) * gru_1_out_t0_60 + (0.20578253269195557) * gru_1_out_t0_61 + (-1.0160008668899536) * gru_1_out_t0_62 + (0.61632812023162842) * gru_1_out_t0_63);
    gate_n = tanh((0.011742221191525459) + (-0.14176911115646362) * gru_1_out_t0_0 + (-0.32628181576728821) * gru_1_out_t0_1 + (-1.2002532482147217) * gru_1_out_t0_2 + (-0.21515153348445892) * gru_1_out_t0_3 + (-0.57778006792068481) * gru_1_out_t0_4 + (-0.96125108003616333) * gru_1_out_t0_5 + (0.835152268409729) * gru_1_out_t0_6 + (-0.047028686851263046) * gru_1_out_t0_7 + (-0.010958243161439896) * gru_1_out_t0_8 + (0.20726145803928375) * gru_1_out_t0_9 + (0.75067853927612305) * gru_1_out_t0_10 + (1.3154606819152832) * gru_1_out_t0_11 + (0.20858995616436005) * gru_1_out_t0_12 + (0.12168494611978531) * gru_1_out_t0_13 + (0.30838680267333984) * gru_1_out_t0_14 + (0.19065289199352264) * gru_1_out_t0_15 + (-0.29425638914108276) * gru_1_out_t0_16 + (-0.27644914388656616) * gru_1_out_t0_17 + (-0.42754250764846802) * gru_1_out_t0_18 + (0.46680092811584473) * gru_1_out_t0_19 + (-1.0461740493774414) * gru_1_out_t0_20 + (0.44357407093048096) * gru_1_out_t0_21 + (-0.089895457029342651) * gru_1_out_t0_22 + (-0.25110772252082825) * gru_1_out_t0_23 + (-0.14323833584785461) * gru_1_out_t0_24 + (-0.48257750272750854) * gru_1_out_t0_25 + (0.021155187860131264) * gru_1_out_t0_26 + (0.96519899368286133) * gru_1_out_t0_27 + (-1.2312343120574951) * gru_1_out_t0_28 + (0.60398197174072266) * gru_1_out_t0_29 + (-0.57691210508346558) * gru_1_out_t0_30 + (0.44014143943786621) * gru_1_out_t0_31 + (-0.14584413170814514) * gru_1_out_t0_32 + (-0.046179123222827911) * gru_1_out_t0_33 + (-0.21739661693572998) * gru_1_out_t0_34 + (-0.23909564316272736) * gru_1_out_t0_35 + (-0.57102829217910767) * gru_1_out_t0_36 + (0.20808514952659607) * gru_1_out_t0_37 + (0.22012417018413544) * gru_1_out_t0_38 + (0.21457329392433167) * gru_1_out_t0_39 + (0.48854649066925049) * gru_1_out_t0_40 + (0.12744259834289551) * gru_1_out_t0_41 + (-0.66340410709381104) * gru_1_out_t0_42 + (-0.45473042130470276) * gru_1_out_t0_43 + (-0.06278594583272934) * gru_1_out_t0_44 + (-0.35481023788452148) * gru_1_out_t0_45 + (0.25191023945808411) * gru_1_out_t0_46 + (-0.68430542945861816) * gru_1_out_t0_47 + (-0.021750569343566895) * gru_1_out_t0_48 + (0.40702882409095764) * gru_1_out_t0_49 + (0.087905839085578918) * gru_1_out_t0_50 + (0.70841377973556519) * gru_1_out_t0_51 + (0.416145920753479) * gru_1_out_t0_52 + (-0.32194927334785461) * gru_1_out_t0_53 + (0.15821196138858795) * gru_1_out_t0_54 + (0.30502107739448547) * gru_1_out_t0_55 + (-0.38511806726455688) * gru_1_out_t0_56 + (0.82361406087875366) * gru_1_out_t0_57 + (-0.086883880198001862) * gru_1_out_t0_58 + (-0.0837663933634758) * gru_1_out_t0_59 + (-0.63529461622238159) * gru_1_out_t0_60 + (0.16620606184005737) * gru_1_out_t0_61 + (0.48974329233169556) * gru_1_out_t0_62 + (-0.95967322587966919) * gru_1_out_t0_63 + gate_r * (-0.07211950421333313));
    gru_2_fwd_t0_h_1 = (1.0 - gate_z) * gate_n;
    // h=2
    gate_r = sigmoid((0.50211858749389648) + (0.03546181321144104) * gru_1_out_t0_0 + (0.62873119115829468) * gru_1_out_t0_1 + (-1.0873353481292725) * gru_1_out_t0_2 + (0.63914400339126587) * gru_1_out_t0_3 + (-0.93876582384109497) * gru_1_out_t0_4 + (-0.34794798493385315) * gru_1_out_t0_5 + (0.66910278797149658) * gru_1_out_t0_6 + (0.039201650768518448) * gru_1_out_t0_7 + (0.15264949202537537) * gru_1_out_t0_8 + (0.29613927006721497) * gru_1_out_t0_9 + (0.10930211097002029) * gru_1_out_t0_10 + (0.44008582830429077) * gru_1_out_t0_11 + (0.35598498582839966) * gru_1_out_t0_12 + (1.1214288473129272) * gru_1_out_t0_13 + (1.2225011587142944) * gru_1_out_t0_14 + (-0.89958316087722778) * gru_1_out_t0_15 + (-0.072695337235927582) * gru_1_out_t0_16 + (-0.12238204479217529) * gru_1_out_t0_17 + (-1.4389032125473022) * gru_1_out_t0_18 + (-0.1536562442779541) * gru_1_out_t0_19 + (-0.09212668240070343) * gru_1_out_t0_20 + (0.64947199821472168) * gru_1_out_t0_21 + (0.76614964008331299) * gru_1_out_t0_22 + (-0.62288469076156616) * gru_1_out_t0_23 + (-4.6255497932434082) * gru_1_out_t0_24 + (0.52996534109115601) * gru_1_out_t0_25 + (2.5337831974029541) * gru_1_out_t0_26 + (-0.21127556264400482) * gru_1_out_t0_27 + (0.37190786004066467) * gru_1_out_t0_28 + (0.66079443693161011) * gru_1_out_t0_29 + (-0.74088037014007568) * gru_1_out_t0_30 + (0.023888815194368362) * gru_1_out_t0_31 + (-0.21493926644325256) * gru_1_out_t0_32 + (-0.101666159927845) * gru_1_out_t0_33 + (-0.40452995896339417) * gru_1_out_t0_34 + (1.1669552326202393) * gru_1_out_t0_35 + (-0.42686870694160461) * gru_1_out_t0_36 + (-0.044576909393072128) * gru_1_out_t0_37 + (-0.039767984300851822) * gru_1_out_t0_38 + (0.44087648391723633) * gru_1_out_t0_39 + (-1.2241232395172119) * gru_1_out_t0_40 + (0.69230908155441284) * gru_1_out_t0_41 + (-0.24427288770675659) * gru_1_out_t0_42 + (-1.9307873249053955) * gru_1_out_t0_43 + (0.33678427338600159) * gru_1_out_t0_44 + (1.5299886465072632) * gru_1_out_t0_45 + (0.59511977434158325) * gru_1_out_t0_46 + (0.68475878238677979) * gru_1_out_t0_47 + (-0.41329070925712585) * gru_1_out_t0_48 + (-0.32078123092651367) * gru_1_out_t0_49 + (-3.2815837860107422) * gru_1_out_t0_50 + (0.85719376802444458) * gru_1_out_t0_51 + (-0.53820544481277466) * gru_1_out_t0_52 + (0.80256432294845581) * gru_1_out_t0_53 + (0.58206659555435181) * gru_1_out_t0_54 + (0.57309693098068237) * gru_1_out_t0_55 + (-0.67719942331314087) * gru_1_out_t0_56 + (-0.78663325309753418) * gru_1_out_t0_57 + (-0.5363471508026123) * gru_1_out_t0_58 + (-0.54640650749206543) * gru_1_out_t0_59 + (-0.90980690717697144) * gru_1_out_t0_60 + (-0.76898908615112305) * gru_1_out_t0_61 + (-2.3156499862670898) * gru_1_out_t0_62 + (-0.86252009868621826) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.68357980251312256) + (0.12803052365779877) * gru_1_out_t0_0 + (0.40708094835281372) * gru_1_out_t0_1 + (0.85545206069946289) * gru_1_out_t0_2 + (-1.2080405950546265) * gru_1_out_t0_3 + (0.96959924697875977) * gru_1_out_t0_4 + (-0.32866448163986206) * gru_1_out_t0_5 + (-0.23365324735641479) * gru_1_out_t0_6 + (0.13662146031856537) * gru_1_out_t0_7 + (-0.31608948111534119) * gru_1_out_t0_8 + (0.82108980417251587) * gru_1_out_t0_9 + (0.42730045318603516) * gru_1_out_t0_10 + (0.16828462481498718) * gru_1_out_t0_11 + (-0.21607854962348938) * gru_1_out_t0_12 + (0.8896600604057312) * gru_1_out_t0_13 + (-0.1087818443775177) * gru_1_out_t0_14 + (0.090991735458374023) * gru_1_out_t0_15 + (0.57311904430389404) * gru_1_out_t0_16 + (0.35667991638183594) * gru_1_out_t0_17 + (-0.016142876818776131) * gru_1_out_t0_18 + (0.62885987758636475) * gru_1_out_t0_19 + (0.18106868863105774) * gru_1_out_t0_20 + (0.83561939001083374) * gru_1_out_t0_21 + (0.55257529020309448) * gru_1_out_t0_22 + (-0.83427983522415161) * gru_1_out_t0_23 + (0.31884363293647766) * gru_1_out_t0_24 + (-0.14832493662834167) * gru_1_out_t0_25 + (-0.7495121955871582) * gru_1_out_t0_26 + (-0.93943387269973755) * gru_1_out_t0_27 + (-1.8790460824966431) * gru_1_out_t0_28 + (0.52488404512405396) * gru_1_out_t0_29 + (0.15908949077129364) * gru_1_out_t0_30 + (-0.22081409394741058) * gru_1_out_t0_31 + (0.1776355654001236) * gru_1_out_t0_32 + (0.058606185019016266) * gru_1_out_t0_33 + (0.3690791130065918) * gru_1_out_t0_34 + (0.67146778106689453) * gru_1_out_t0_35 + (0.17916281521320343) * gru_1_out_t0_36 + (1.0813432931900024) * gru_1_out_t0_37 + (0.40573602914810181) * gru_1_out_t0_38 + (0.36104458570480347) * gru_1_out_t0_39 + (0.093546964228153229) * gru_1_out_t0_40 + (0.28564289212226868) * gru_1_out_t0_41 + (0.45597571134567261) * gru_1_out_t0_42 + (-1.5643079280853271) * gru_1_out_t0_43 + (-0.94158744812011719) * gru_1_out_t0_44 + (0.41168996691703796) * gru_1_out_t0_45 + (-0.26828816533088684) * gru_1_out_t0_46 + (0.77027595043182373) * gru_1_out_t0_47 + (-1.1340701580047607) * gru_1_out_t0_48 + (0.12209813296794891) * gru_1_out_t0_49 + (-2.944129467010498) * gru_1_out_t0_50 + (0.077653594315052032) * gru_1_out_t0_51 + (-0.62413793802261353) * gru_1_out_t0_52 + (-0.036159172654151917) * gru_1_out_t0_53 + (0.75142937898635864) * gru_1_out_t0_54 + (0.84246450662612915) * gru_1_out_t0_55 + (1.1334981918334961) * gru_1_out_t0_56 + (1.1247165203094482) * gru_1_out_t0_57 + (-0.35293760895729065) * gru_1_out_t0_58 + (1.8673948049545288) * gru_1_out_t0_59 + (-1.2065820693969727) * gru_1_out_t0_60 + (-1.0828073024749756) * gru_1_out_t0_61 + (0.077044427394866943) * gru_1_out_t0_62 + (0.69414854049682617) * gru_1_out_t0_63);
    gate_n = tanh((0.28757476806640625) + (0.71206510066986084) * gru_1_out_t0_0 + (0.4673173725605011) * gru_1_out_t0_1 + (1.4996812343597412) * gru_1_out_t0_2 + (-0.37790834903717041) * gru_1_out_t0_3 + (-0.53326547145843506) * gru_1_out_t0_4 + (-1.3791050910949707) * gru_1_out_t0_5 + (-0.47763282060623169) * gru_1_out_t0_6 + (0.02427389845252037) * gru_1_out_t0_7 + (-0.77570384740829468) * gru_1_out_t0_8 + (-0.84844398498535156) * gru_1_out_t0_9 + (0.45537346601486206) * gru_1_out_t0_10 + (-0.29301983118057251) * gru_1_out_t0_11 + (-0.64142394065856934) * gru_1_out_t0_12 + (-1.2632129192352295) * gru_1_out_t0_13 + (-0.016080928966403008) * gru_1_out_t0_14 + (-0.66520142555236816) * gru_1_out_t0_15 + (-0.063035875558853149) * gru_1_out_t0_16 + (-0.26991292834281921) * gru_1_out_t0_17 + (0.32602483034133911) * gru_1_out_t0_18 + (0.10982970893383026) * gru_1_out_t0_19 + (-0.081058278679847717) * gru_1_out_t0_20 + (1.039059042930603) * gru_1_out_t0_21 + (0.72561758756637573) * gru_1_out_t0_22 + (-0.35857740044593811) * gru_1_out_t0_23 + (-4.0297713279724121) * gru_1_out_t0_24 + (1.114376425743103) * gru_1_out_t0_25 + (0.36551475524902344) * gru_1_out_t0_26 + (0.21977202594280243) * gru_1_out_t0_27 + (-1.2989488840103149) * gru_1_out_t0_28 + (0.59169560670852661) * gru_1_out_t0_29 + (1.5650513172149658) * gru_1_out_t0_30 + (0.024198234081268311) * gru_1_out_t0_31 + (0.61719894409179688) * gru_1_out_t0_32 + (-0.10701681673526764) * gru_1_out_t0_33 + (0.6430472731590271) * gru_1_out_t0_34 + (0.19275094568729401) * gru_1_out_t0_35 + (-0.23081982135772705) * gru_1_out_t0_36 + (0.0073824040591716766) * gru_1_out_t0_37 + (-0.087166845798492432) * gru_1_out_t0_38 + (-0.037914294749498367) * gru_1_out_t0_39 + (-0.91369789838790894) * gru_1_out_t0_40 + (-0.065582066774368286) * gru_1_out_t0_41 + (0.59199666976928711) * gru_1_out_t0_42 + (-0.93468165397644043) * gru_1_out_t0_43 + (-0.35326683521270752) * gru_1_out_t0_44 + (0.23191042244434357) * gru_1_out_t0_45 + (-0.33294910192489624) * gru_1_out_t0_46 + (0.8554108738899231) * gru_1_out_t0_47 + (-0.556385338306427) * gru_1_out_t0_48 + (-0.69082391262054443) * gru_1_out_t0_49 + (-2.0151240825653076) * gru_1_out_t0_50 + (-0.92921102046966553) * gru_1_out_t0_51 + (0.28535893559455872) * gru_1_out_t0_52 + (0.74024069309234619) * gru_1_out_t0_53 + (0.097009539604187012) * gru_1_out_t0_54 + (0.1110449805855751) * gru_1_out_t0_55 + (0.028389010578393936) * gru_1_out_t0_56 + (0.73824822902679443) * gru_1_out_t0_57 + (0.32105138897895813) * gru_1_out_t0_58 + (0.61800509691238403) * gru_1_out_t0_59 + (-0.45711445808410645) * gru_1_out_t0_60 + (-0.79884850978851318) * gru_1_out_t0_61 + (0.34846755862236023) * gru_1_out_t0_62 + (-0.24910500645637512) * gru_1_out_t0_63 + gate_r * (-1.3853403329849243));
    gru_2_fwd_t0_h_2 = (1.0 - gate_z) * gate_n;
    // h=3
    gate_r = sigmoid((0.41261222958564758) + (0.72942841053009033) * gru_1_out_t0_0 + (0.38550209999084473) * gru_1_out_t0_1 + (-0.63798558712005615) * gru_1_out_t0_2 + (-0.14824342727661133) * gru_1_out_t0_3 + (0.84214228391647339) * gru_1_out_t0_4 + (0.1656046062707901) * gru_1_out_t0_5 + (1.4234706163406372) * gru_1_out_t0_6 + (0.81613779067993164) * gru_1_out_t0_7 + (-0.97017115354537964) * gru_1_out_t0_8 + (0.6292722225189209) * gru_1_out_t0_9 + (0.52161121368408203) * gru_1_out_t0_10 + (0.22383072972297668) * gru_1_out_t0_11 + (-0.11007523536682129) * gru_1_out_t0_12 + (-0.32908898591995239) * gru_1_out_t0_13 + (1.3908857107162476) * gru_1_out_t0_14 + (-0.024728396907448769) * gru_1_out_t0_15 + (-0.79281550645828247) * gru_1_out_t0_16 + (-0.56877726316452026) * gru_1_out_t0_17 + (-1.6753993034362793) * gru_1_out_t0_18 + (-0.84166741371154785) * gru_1_out_t0_19 + (0.024605683982372284) * gru_1_out_t0_20 + (-0.95776212215423584) * gru_1_out_t0_21 + (-2.7483136653900146) * gru_1_out_t0_22 + (1.9871777296066284) * gru_1_out_t0_23 + (-2.3792378902435303) * gru_1_out_t0_24 + (0.1534494012594223) * gru_1_out_t0_25 + (-0.16596490144729614) * gru_1_out_t0_26 + (-0.77572166919708252) * gru_1_out_t0_27 + (-1.1204510927200317) * gru_1_out_t0_28 + (-0.44777011871337891) * gru_1_out_t0_29 + (2.7567574977874756) * gru_1_out_t0_30 + (-0.11186274886131287) * gru_1_out_t0_31 + (-0.46719008684158325) * gru_1_out_t0_32 + (-0.71171694993972778) * gru_1_out_t0_33 + (0.71587181091308594) * gru_1_out_t0_34 + (-0.40979489684104919) * gru_1_out_t0_35 + (-0.52391070127487183) * gru_1_out_t0_36 + (-1.7500942945480347) * gru_1_out_t0_37 + (-0.53590065240859985) * gru_1_out_t0_38 + (-0.94653069972991943) * gru_1_out_t0_39 + (-1.6560014486312866) * gru_1_out_t0_40 + (-1.602800726890564) * gru_1_out_t0_41 + (0.36195147037506104) * gru_1_out_t0_42 + (-0.94195222854614258) * gru_1_out_t0_43 + (0.24628740549087524) * gru_1_out_t0_44 + (0.099690847098827362) * gru_1_out_t0_45 + (0.78483396768569946) * gru_1_out_t0_46 + (0.33336693048477173) * gru_1_out_t0_47 + (-1.6328805685043335) * gru_1_out_t0_48 + (-0.11385563015937805) * gru_1_out_t0_49 + (-0.24276247620582581) * gru_1_out_t0_50 + (0.91271400451660156) * gru_1_out_t0_51 + (0.79640316963195801) * gru_1_out_t0_52 + (0.58678543567657471) * gru_1_out_t0_53 + (0.86790448427200317) * gru_1_out_t0_54 + (-0.4847625195980072) * gru_1_out_t0_55 + (-0.073861971497535706) * gru_1_out_t0_56 + (-0.21071159839630127) * gru_1_out_t0_57 + (0.79096812009811401) * gru_1_out_t0_58 + (-0.60564130544662476) * gru_1_out_t0_59 + (0.93330693244934082) * gru_1_out_t0_60 + (1.2217531204223633) * gru_1_out_t0_61 + (0.085313372313976288) * gru_1_out_t0_62 + (-0.27823451161384583) * gru_1_out_t0_63);
    gate_z = sigmoid((0.10861821472644806) + (-0.072362400591373444) * gru_1_out_t0_0 + (-0.14582943916320801) * gru_1_out_t0_1 + (-0.22234088182449341) * gru_1_out_t0_2 + (0.52766579389572144) * gru_1_out_t0_3 + (-0.29092076420783997) * gru_1_out_t0_4 + (0.22481533885002136) * gru_1_out_t0_5 + (0.18621611595153809) * gru_1_out_t0_6 + (-0.18299438059329987) * gru_1_out_t0_7 + (0.47815492749214172) * gru_1_out_t0_8 + (0.008816177025437355) * gru_1_out_t0_9 + (0.28043878078460693) * gru_1_out_t0_10 + (0.46134102344512939) * gru_1_out_t0_11 + (0.27801001071929932) * gru_1_out_t0_12 + (0.45674625039100647) * gru_1_out_t0_13 + (0.17261607944965363) * gru_1_out_t0_14 + (0.31748270988464355) * gru_1_out_t0_15 + (0.56196624040603638) * gru_1_out_t0_16 + (0.11457680910825729) * gru_1_out_t0_17 + (-0.12096874415874481) * gru_1_out_t0_18 + (-0.38423669338226318) * gru_1_out_t0_19 + (0.26074352860450745) * gru_1_out_t0_20 + (0.27436098456382751) * gru_1_out_t0_21 + (0.38730975985527039) * gru_1_out_t0_22 + (-0.31610646843910217) * gru_1_out_t0_23 + (-0.1670653223991394) * gru_1_out_t0_24 + (0.28659391403198242) * gru_1_out_t0_25 + (0.31898173689842224) * gru_1_out_t0_26 + (0.29817718267440796) * gru_1_out_t0_27 + (0.13456575572490692) * gru_1_out_t0_28 + (-0.040615741163492203) * gru_1_out_t0_29 + (-0.080182239413261414) * gru_1_out_t0_30 + (-0.35858172178268433) * gru_1_out_t0_31 + (-0.25488370656967163) * gru_1_out_t0_32 + (-0.24240991473197937) * gru_1_out_t0_33 + (0.12383075803518295) * gru_1_out_t0_34 + (-0.071949094533920288) * gru_1_out_t0_35 + (0.12261031568050385) * gru_1_out_t0_36 + (-0.66831469535827637) * gru_1_out_t0_37 + (0.13482841849327087) * gru_1_out_t0_38 + (-0.13715457916259766) * gru_1_out_t0_39 + (-0.044348180294036865) * gru_1_out_t0_40 + (0.029283713549375534) * gru_1_out_t0_41 + (0.061948411166667938) * gru_1_out_t0_42 + (-0.067897208034992218) * gru_1_out_t0_43 + (0.44317933917045593) * gru_1_out_t0_44 + (0.11477281898260117) * gru_1_out_t0_45 + (0.016164485365152359) * gru_1_out_t0_46 + (-0.083964817225933075) * gru_1_out_t0_47 + (-0.039537832140922546) * gru_1_out_t0_48 + (-0.6622546911239624) * gru_1_out_t0_49 + (-0.0093990787863731384) * gru_1_out_t0_50 + (-0.013591255992650986) * gru_1_out_t0_51 + (-0.39146813750267029) * gru_1_out_t0_52 + (0.045659981667995453) * gru_1_out_t0_53 + (0.035790111869573593) * gru_1_out_t0_54 + (0.36386647820472717) * gru_1_out_t0_55 + (0.040862035006284714) * gru_1_out_t0_56 + (0.018575785681605339) * gru_1_out_t0_57 + (-0.011885021813213825) * gru_1_out_t0_58 + (-0.066452346742153168) * gru_1_out_t0_59 + (-0.1718003898859024) * gru_1_out_t0_60 + (0.049989845603704453) * gru_1_out_t0_61 + (0.06366875022649765) * gru_1_out_t0_62 + (0.05543908104300499) * gru_1_out_t0_63);
    gate_n = tanh((-0.40311375260353088) + (0.16965155303478241) * gru_1_out_t0_0 + (-0.39619007706642151) * gru_1_out_t0_1 + (-0.25950157642364502) * gru_1_out_t0_2 + (-0.061753205955028534) * gru_1_out_t0_3 + (-0.49852883815765381) * gru_1_out_t0_4 + (-0.24298186600208282) * gru_1_out_t0_5 + (0.63767510652542114) * gru_1_out_t0_6 + (-0.86279875040054321) * gru_1_out_t0_7 + (-0.10701220482587814) * gru_1_out_t0_8 + (0.40588292479515076) * gru_1_out_t0_9 + (0.23909635841846466) * gru_1_out_t0_10 + (0.28834742307662964) * gru_1_out_t0_11 + (0.8522987961769104) * gru_1_out_t0_12 + (-0.7016262412071228) * gru_1_out_t0_13 + (0.39218124747276306) * gru_1_out_t0_14 + (1.1855034828186035) * gru_1_out_t0_15 + (1.1779153347015381) * gru_1_out_t0_16 + (0.35253360867500305) * gru_1_out_t0_17 + (1.0141201019287109) * gru_1_out_t0_18 + (0.174885094165802) * gru_1_out_t0_19 + (0.29363581538200378) * gru_1_out_t0_20 + (0.81994199752807617) * gru_1_out_t0_21 + (0.79149377346038818) * gru_1_out_t0_22 + (0.48218715190887451) * gru_1_out_t0_23 + (-1.1135436296463013) * gru_1_out_t0_24 + (0.20517396926879883) * gru_1_out_t0_25 + (-0.81459778547286987) * gru_1_out_t0_26 + (-0.33148488402366638) * gru_1_out_t0_27 + (1.2521886825561523) * gru_1_out_t0_28 + (0.095828570425510406) * gru_1_out_t0_29 + (-0.49771708250045776) * gru_1_out_t0_30 + (-0.81859296560287476) * gru_1_out_t0_31 + (-0.032601334154605865) * gru_1_out_t0_32 + (0.10070813447237015) * gru_1_out_t0_33 + (-0.079929709434509277) * gru_1_out_t0_34 + (0.378752201795578) * gru_1_out_t0_35 + (0.11629186570644379) * gru_1_out_t0_36 + (0.47991591691970825) * gru_1_out_t0_37 + (0.43927496671676636) * gru_1_out_t0_38 + (-0.56944125890731812) * gru_1_out_t0_39 + (-0.46402114629745483) * gru_1_out_t0_40 + (-0.31372597813606262) * gru_1_out_t0_41 + (-0.18972760438919067) * gru_1_out_t0_42 + (0.27249845862388611) * gru_1_out_t0_43 + (0.42713436484336853) * gru_1_out_t0_44 + (-0.24359169602394104) * gru_1_out_t0_45 + (-0.01479648519307375) * gru_1_out_t0_46 + (0.40999552607536316) * gru_1_out_t0_47 + (-0.71661859750747681) * gru_1_out_t0_48 + (-0.16231091320514679) * gru_1_out_t0_49 + (0.31256157159805298) * gru_1_out_t0_50 + (0.14024022221565247) * gru_1_out_t0_51 + (-0.32426643371582031) * gru_1_out_t0_52 + (-0.15458835661411285) * gru_1_out_t0_53 + (0.096960172057151794) * gru_1_out_t0_54 + (0.3034197986125946) * gru_1_out_t0_55 + (0.070376425981521606) * gru_1_out_t0_56 + (0.43235820531845093) * gru_1_out_t0_57 + (-0.50902485847473145) * gru_1_out_t0_58 + (-0.11449965089559555) * gru_1_out_t0_59 + (0.26572126150131226) * gru_1_out_t0_60 + (-0.45414629578590393) * gru_1_out_t0_61 + (-0.39853715896606445) * gru_1_out_t0_62 + (-0.33547863364219666) * gru_1_out_t0_63 + gate_r * (-0.60734128952026367));
    gru_2_fwd_t0_h_3 = (1.0 - gate_z) * gate_n;
    // h=4
    gate_r = sigmoid((1.1615561246871948) + (-0.51844322681427002) * gru_1_out_t0_0 + (-0.11482474952936172) * gru_1_out_t0_1 + (-0.79032421112060547) * gru_1_out_t0_2 + (0.35529571771621704) * gru_1_out_t0_3 + (-1.3858778476715088) * gru_1_out_t0_4 + (1.040509819984436) * gru_1_out_t0_5 + (1.1563373804092407) * gru_1_out_t0_6 + (-1.3189194202423096) * gru_1_out_t0_7 + (0.46318355202674866) * gru_1_out_t0_8 + (-0.24252569675445557) * gru_1_out_t0_9 + (0.09466148167848587) * gru_1_out_t0_10 + (-1.3704898357391357) * gru_1_out_t0_11 + (-0.6669003963470459) * gru_1_out_t0_12 + (-2.6385173797607422) * gru_1_out_t0_13 + (-0.09086880087852478) * gru_1_out_t0_14 + (1.3733655214309692) * gru_1_out_t0_15 + (0.35340481996536255) * gru_1_out_t0_16 + (-2.0000805854797363) * gru_1_out_t0_17 + (1.2164291143417358) * gru_1_out_t0_18 + (-0.005813920870423317) * gru_1_out_t0_19 + (-1.1854885816574097) * gru_1_out_t0_20 + (-0.34444290399551392) * gru_1_out_t0_21 + (2.6697027683258057) * gru_1_out_t0_22 + (-1.2855449914932251) * gru_1_out_t0_23 + (-1.6002296209335327) * gru_1_out_t0_24 + (-1.3803770542144775) * gru_1_out_t0_25 + (1.2097533941268921) * gru_1_out_t0_26 + (0.16466657817363739) * gru_1_out_t0_27 + (0.55906915664672852) * gru_1_out_t0_28 + (0.36143714189529419) * gru_1_out_t0_29 + (-0.2141263484954834) * gru_1_out_t0_30 + (-0.011483338661491871) * gru_1_out_t0_31 + (0.33926612138748169) * gru_1_out_t0_32 + (0.73889440298080444) * gru_1_out_t0_33 + (-0.051806099712848663) * gru_1_out_t0_34 + (0.95604509115219116) * gru_1_out_t0_35 + (0.89442086219787598) * gru_1_out_t0_36 + (-0.078334502875804901) * gru_1_out_t0_37 + (0.081081442534923553) * gru_1_out_t0_38 + (0.011801640503108501) * gru_1_out_t0_39 + (-1.6659096479415894) * gru_1_out_t0_40 + (0.50042414665222168) * gru_1_out_t0_41 + (-0.12676838040351868) * gru_1_out_t0_42 + (-0.32862663269042969) * gru_1_out_t0_43 + (0.31236335635185242) * gru_1_out_t0_44 + (-0.17431282997131348) * gru_1_out_t0_45 + (0.34155973792076111) * gru_1_out_t0_46 + (-0.37792819738388062) * gru_1_out_t0_47 + (1.5381574630737305) * gru_1_out_t0_48 + (1.3252875804901123) * gru_1_out_t0_49 + (-0.40328294038772583) * gru_1_out_t0_50 + (2.7833759784698486) * gru_1_out_t0_51 + (-1.1841946840286255) * gru_1_out_t0_52 + (-0.11905388534069061) * gru_1_out_t0_53 + (-0.19529622793197632) * gru_1_out_t0_54 + (1.063428521156311) * gru_1_out_t0_55 + (-0.085169576108455658) * gru_1_out_t0_56 + (0.029804887250065804) * gru_1_out_t0_57 + (-1.0386730432510376) * gru_1_out_t0_58 + (-1.6423882246017456) * gru_1_out_t0_59 + (-2.170102596282959) * gru_1_out_t0_60 + (0.21117527782917023) * gru_1_out_t0_61 + (-0.19859708845615387) * gru_1_out_t0_62 + (-0.002856808714568615) * gru_1_out_t0_63);
    gate_z = sigmoid((-1.5012381076812744) + (-0.090260140597820282) * gru_1_out_t0_0 + (-0.51019179821014404) * gru_1_out_t0_1 + (0.45153239369392395) * gru_1_out_t0_2 + (0.33191755414009094) * gru_1_out_t0_3 + (0.74110662937164307) * gru_1_out_t0_4 + (0.20983575284481049) * gru_1_out_t0_5 + (-1.1701817512512207) * gru_1_out_t0_6 + (0.87492460012435913) * gru_1_out_t0_7 + (-0.26237618923187256) * gru_1_out_t0_8 + (0.3124658465385437) * gru_1_out_t0_9 + (-0.35517290234565735) * gru_1_out_t0_10 + (-0.6383519172668457) * gru_1_out_t0_11 + (0.24760214984416962) * gru_1_out_t0_12 + (-0.686348557472229) * gru_1_out_t0_13 + (-0.19736781716346741) * gru_1_out_t0_14 + (-0.43084129691123962) * gru_1_out_t0_15 + (-0.55540889501571655) * gru_1_out_t0_16 + (0.78783559799194336) * gru_1_out_t0_17 + (0.1855214536190033) * gru_1_out_t0_18 + (0.040669701993465424) * gru_1_out_t0_19 + (0.34320768713951111) * gru_1_out_t0_20 + (-0.047083575278520584) * gru_1_out_t0_21 + (1.3501702547073364) * gru_1_out_t0_22 + (-0.021317632868885994) * gru_1_out_t0_23 + (-2.9332995414733887) * gru_1_out_t0_24 + (-0.010865963995456696) * gru_1_out_t0_25 + (0.48027893900871277) * gru_1_out_t0_26 + (-0.73094803094863892) * gru_1_out_t0_27 + (-0.61756813526153564) * gru_1_out_t0_28 + (-0.074868053197860718) * gru_1_out_t0_29 + (0.51946008205413818) * gru_1_out_t0_30 + (0.4941883385181427) * gru_1_out_t0_31 + (1.9998337030410767) * gru_1_out_t0_32 + (0.97811120748519897) * gru_1_out_t0_33 + (-0.82199478149414062) * gru_1_out_t0_34 + (-0.091997280716896057) * gru_1_out_t0_35 + (0.32988613843917847) * gru_1_out_t0_36 + (-0.61462670564651489) * gru_1_out_t0_37 + (0.6313815712928772) * gru_1_out_t0_38 + (0.033465661108493805) * gru_1_out_t0_39 + (0.15542499721050262) * gru_1_out_t0_40 + (0.055372130125761032) * gru_1_out_t0_41 + (-0.74968910217285156) * gru_1_out_t0_42 + (-0.2316993772983551) * gru_1_out_t0_43 + (-0.14244987070560455) * gru_1_out_t0_44 + (-0.44546821713447571) * gru_1_out_t0_45 + (-1.158564567565918) * gru_1_out_t0_46 + (-0.28312653303146362) * gru_1_out_t0_47 + (-0.83777326345443726) * gru_1_out_t0_48 + (0.91363400220870972) * gru_1_out_t0_49 + (1.8630989789962769) * gru_1_out_t0_50 + (-0.35776501893997192) * gru_1_out_t0_51 + (-0.50659769773483276) * gru_1_out_t0_52 + (-0.25242751836776733) * gru_1_out_t0_53 + (4.4223661422729492) * gru_1_out_t0_54 + (-0.74356538057327271) * gru_1_out_t0_55 + (-0.90062415599822998) * gru_1_out_t0_56 + (0.85552388429641724) * gru_1_out_t0_57 + (-0.053231123834848404) * gru_1_out_t0_58 + (-0.12265348434448242) * gru_1_out_t0_59 + (-0.42789122462272644) * gru_1_out_t0_60 + (-0.61891001462936401) * gru_1_out_t0_61 + (-0.071408189833164215) * gru_1_out_t0_62 + (-0.22053249180316925) * gru_1_out_t0_63);
    gate_n = tanh((0.85538822412490845) + (0.19673387706279755) * gru_1_out_t0_0 + (0.11977367848157883) * gru_1_out_t0_1 + (0.063396431505680084) * gru_1_out_t0_2 + (-0.41546061635017395) * gru_1_out_t0_3 + (-0.15652617812156677) * gru_1_out_t0_4 + (-1.2004828453063965) * gru_1_out_t0_5 + (1.1472791433334351) * gru_1_out_t0_6 + (-0.26816442608833313) * gru_1_out_t0_7 + (0.017762506380677223) * gru_1_out_t0_8 + (-0.3614155650138855) * gru_1_out_t0_9 + (-0.047723103314638138) * gru_1_out_t0_10 + (0.42768698930740356) * gru_1_out_t0_11 + (0.2514096200466156) * gru_1_out_t0_12 + (0.42082792520523071) * gru_1_out_t0_13 + (0.09148591011762619) * gru_1_out_t0_14 + (0.30986016988754272) * gru_1_out_t0_15 + (-0.12835897505283356) * gru_1_out_t0_16 + (-0.19608929753303528) * gru_1_out_t0_17 + (0.11906805634498596) * gru_1_out_t0_18 + (0.62790709733963013) * gru_1_out_t0_19 + (0.5753358006477356) * gru_1_out_t0_20 + (0.029715133830904961) * gru_1_out_t0_21 + (0.15036506950855255) * gru_1_out_t0_22 + (-0.12864398956298828) * gru_1_out_t0_23 + (-0.62744659185409546) * gru_1_out_t0_24 + (0.29793563485145569) * gru_1_out_t0_25 + (-0.73527175188064575) * gru_1_out_t0_26 + (0.15115538239479065) * gru_1_out_t0_27 + (0.17663122713565826) * gru_1_out_t0_28 + (-0.049297083169221878) * gru_1_out_t0_29 + (0.195863276720047) * gru_1_out_t0_30 + (0.058776926249265671) * gru_1_out_t0_31 + (0.048784065991640091) * gru_1_out_t0_32 + (0.38595929741859436) * gru_1_out_t0_33 + (-0.047970928251743317) * gru_1_out_t0_34 + (0.24445968866348267) * gru_1_out_t0_35 + (-0.067700996994972229) * gru_1_out_t0_36 + (-0.01674736849963665) * gru_1_out_t0_37 + (0.037927005439996719) * gru_1_out_t0_38 + (0.35046076774597168) * gru_1_out_t0_39 + (0.37761974334716797) * gru_1_out_t0_40 + (-0.16018760204315186) * gru_1_out_t0_41 + (0.12947246432304382) * gru_1_out_t0_42 + (-0.035048563033342361) * gru_1_out_t0_43 + (-0.056990411132574081) * gru_1_out_t0_44 + (0.20321349799633026) * gru_1_out_t0_45 + (-0.07716648280620575) * gru_1_out_t0_46 + (0.087729446589946747) * gru_1_out_t0_47 + (-0.077342361211776733) * gru_1_out_t0_48 + (0.024145988747477531) * gru_1_out_t0_49 + (-0.14626742899417877) * gru_1_out_t0_50 + (0.08624953031539917) * gru_1_out_t0_51 + (0.045424610376358032) * gru_1_out_t0_52 + (-0.2783111035823822) * gru_1_out_t0_53 + (-0.038239572197198868) * gru_1_out_t0_54 + (0.21428817510604858) * gru_1_out_t0_55 + (-0.040556322783231735) * gru_1_out_t0_56 + (0.20445281267166138) * gru_1_out_t0_57 + (0.34343084692955017) * gru_1_out_t0_58 + (0.0035412514116615057) * gru_1_out_t0_59 + (0.12956574559211731) * gru_1_out_t0_60 + (-0.61528134346008301) * gru_1_out_t0_61 + (-0.012186108157038689) * gru_1_out_t0_62 + (-0.06433415412902832) * gru_1_out_t0_63 + gate_r * (0.27616366744041443));
    gru_2_fwd_t0_h_4 = (1.0 - gate_z) * gate_n;
    // h=5
    gate_r = sigmoid((-0.42992255091667175) + (0.67963588237762451) * gru_1_out_t0_0 + (-1.6832897663116455) * gru_1_out_t0_1 + (0.4866260290145874) * gru_1_out_t0_2 + (-0.465606689453125) * gru_1_out_t0_3 + (0.32731667160987854) * gru_1_out_t0_4 + (-0.21527102589607239) * gru_1_out_t0_5 + (-0.38889089226722717) * gru_1_out_t0_6 + (0.53676134347915649) * gru_1_out_t0_7 + (-0.56792247295379639) * gru_1_out_t0_8 + (-0.69941884279251099) * gru_1_out_t0_9 + (1.2024531364440918) * gru_1_out_t0_10 + (0.3083244264125824) * gru_1_out_t0_11 + (0.11429350823163986) * gru_1_out_t0_12 + (1.3619794845581055) * gru_1_out_t0_13 + (-0.45003393292427063) * gru_1_out_t0_14 + (-0.22319296002388) * gru_1_out_t0_15 + (-0.016822177916765213) * gru_1_out_t0_16 + (0.20408381521701813) * gru_1_out_t0_17 + (0.044011548161506653) * gru_1_out_t0_18 + (-0.4178009033203125) * gru_1_out_t0_19 + (0.24989792704582214) * gru_1_out_t0_20 + (-0.56839162111282349) * gru_1_out_t0_21 + (-0.470661461353302) * gru_1_out_t0_22 + (-1.4121370315551758) * gru_1_out_t0_23 + (1.1373801231384277) * gru_1_out_t0_24 + (-0.32759776711463928) * gru_1_out_t0_25 + (-1.3112614154815674) * gru_1_out_t0_26 + (-0.69000411033630371) * gru_1_out_t0_27 + (1.1643517017364502) * gru_1_out_t0_28 + (0.60771787166595459) * gru_1_out_t0_29 + (-0.92976629734039307) * gru_1_out_t0_30 + (1.9021216630935669) * gru_1_out_t0_31 + (-0.25808629393577576) * gru_1_out_t0_32 + (1.5772418975830078) * gru_1_out_t0_33 + (-0.16185177862644196) * gru_1_out_t0_34 + (-0.09121645987033844) * gru_1_out_t0_35 + (-0.23729954659938812) * gru_1_out_t0_36 + (0.49252086877822876) * gru_1_out_t0_37 + (-0.75839030742645264) * gru_1_out_t0_38 + (1.0958569049835205) * gru_1_out_t0_39 + (0.14803045988082886) * gru_1_out_t0_40 + (0.77791619300842285) * gru_1_out_t0_41 + (0.91667449474334717) * gru_1_out_t0_42 + (-0.68460291624069214) * gru_1_out_t0_43 + (0.25986561179161072) * gru_1_out_t0_44 + (2.3789253234863281) * gru_1_out_t0_45 + (-0.47316932678222656) * gru_1_out_t0_46 + (-0.69995498657226562) * gru_1_out_t0_47 + (-1.0102299451828003) * gru_1_out_t0_48 + (-1.1653497219085693) * gru_1_out_t0_49 + (-0.54118329286575317) * gru_1_out_t0_50 + (0.18025098741054535) * gru_1_out_t0_51 + (-1.6580793857574463) * gru_1_out_t0_52 + (-1.5496077537536621) * gru_1_out_t0_53 + (0.40459966659545898) * gru_1_out_t0_54 + (1.4956268072128296) * gru_1_out_t0_55 + (-1.7405233383178711) * gru_1_out_t0_56 + (1.1070117950439453) * gru_1_out_t0_57 + (0.033076286315917969) * gru_1_out_t0_58 + (1.4205800294876099) * gru_1_out_t0_59 + (-0.76700496673583984) * gru_1_out_t0_60 + (-1.4320125579833984) * gru_1_out_t0_61 + (-0.79529893398284912) * gru_1_out_t0_62 + (0.10739266872406006) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.43059298396110535) + (-0.56319117546081543) * gru_1_out_t0_0 + (-0.21736080944538116) * gru_1_out_t0_1 + (0.010400814935564995) * gru_1_out_t0_2 + (1.0401800870895386) * gru_1_out_t0_3 + (0.34559795260429382) * gru_1_out_t0_4 + (0.45638459920883179) * gru_1_out_t0_5 + (0.98442840576171875) * gru_1_out_t0_6 + (-0.045096974819898605) * gru_1_out_t0_7 + (0.36673802137374878) * gru_1_out_t0_8 + (-0.0050246352329850197) * gru_1_out_t0_9 + (0.1920294314622879) * gru_1_out_t0_10 + (0.6155734658241272) * gru_1_out_t0_11 + (0.17660273611545563) * gru_1_out_t0_12 + (0.52284836769104004) * gru_1_out_t0_13 + (0.66303378343582153) * gru_1_out_t0_14 + (-1.0026397705078125) * gru_1_out_t0_15 + (-0.6136023998260498) * gru_1_out_t0_16 + (0.22710001468658447) * gru_1_out_t0_17 + (-0.71945619583129883) * gru_1_out_t0_18 + (-0.726185142993927) * gru_1_out_t0_19 + (0.46539214253425598) * gru_1_out_t0_20 + (0.2733309268951416) * gru_1_out_t0_21 + (0.75763916969299316) * gru_1_out_t0_22 + (0.3782271146774292) * gru_1_out_t0_23 + (0.42483130097389221) * gru_1_out_t0_24 + (0.77455621957778931) * gru_1_out_t0_25 + (-0.2756933867931366) * gru_1_out_t0_26 + (-0.15287299454212189) * gru_1_out_t0_27 + (0.7524145245552063) * gru_1_out_t0_28 + (-0.30605560541152954) * gru_1_out_t0_29 + (-0.59794425964355469) * gru_1_out_t0_30 + (-0.51937156915664673) * gru_1_out_t0_31 + (0.74451029300689697) * gru_1_out_t0_32 + (0.68875014781951904) * gru_1_out_t0_33 + (-0.30366736650466919) * gru_1_out_t0_34 + (0.10843696445226669) * gru_1_out_t0_35 + (0.4886176586151123) * gru_1_out_t0_36 + (-0.66675907373428345) * gru_1_out_t0_37 + (-0.27668344974517822) * gru_1_out_t0_38 + (-0.65460604429244995) * gru_1_out_t0_39 + (0.35061237215995789) * gru_1_out_t0_40 + (-0.061380442231893539) * gru_1_out_t0_41 + (0.14394007623195648) * gru_1_out_t0_42 + (-0.059178367257118225) * gru_1_out_t0_43 + (0.14818419516086578) * gru_1_out_t0_44 + (-0.37072604894638062) * gru_1_out_t0_45 + (0.14275464415550232) * gru_1_out_t0_46 + (0.40884333848953247) * gru_1_out_t0_47 + (-0.0069664325565099716) * gru_1_out_t0_48 + (-0.67902755737304688) * gru_1_out_t0_49 + (0.26287287473678589) * gru_1_out_t0_50 + (0.058754086494445801) * gru_1_out_t0_51 + (-0.46438431739807129) * gru_1_out_t0_52 + (-0.13688458502292633) * gru_1_out_t0_53 + (0.36525174975395203) * gru_1_out_t0_54 + (-0.52490788698196411) * gru_1_out_t0_55 + (0.37054762244224548) * gru_1_out_t0_56 + (0.036829430609941483) * gru_1_out_t0_57 + (-0.36196622252464294) * gru_1_out_t0_58 + (0.02387058362364769) * gru_1_out_t0_59 + (-0.11637367308139801) * gru_1_out_t0_60 + (-0.25493159890174866) * gru_1_out_t0_61 + (-1.101844310760498) * gru_1_out_t0_62 + (0.54478806257247925) * gru_1_out_t0_63);
    gate_n = tanh((-0.38997277617454529) + (0.30987763404846191) * gru_1_out_t0_0 + (-1.1875820159912109) * gru_1_out_t0_1 + (-0.90843808650970459) * gru_1_out_t0_2 + (-0.085120365023612976) * gru_1_out_t0_3 + (-0.22600211203098297) * gru_1_out_t0_4 + (0.032841295003890991) * gru_1_out_t0_5 + (0.11430556327104568) * gru_1_out_t0_6 + (0.23872591555118561) * gru_1_out_t0_7 + (0.72304600477218628) * gru_1_out_t0_8 + (-0.076739832758903503) * gru_1_out_t0_9 + (0.51064598560333252) * gru_1_out_t0_10 + (1.5105327367782593) * gru_1_out_t0_11 + (0.38314765691757202) * gru_1_out_t0_12 + (-0.66766607761383057) * gru_1_out_t0_13 + (0.99268341064453125) * gru_1_out_t0_14 + (0.41303658485412598) * gru_1_out_t0_15 + (-0.51761919260025024) * gru_1_out_t0_16 + (-0.15797455608844757) * gru_1_out_t0_17 + (0.09660552442073822) * gru_1_out_t0_18 + (0.56043291091918945) * gru_1_out_t0_19 + (-0.82565903663635254) * gru_1_out_t0_20 + (-0.92259138822555542) * gru_1_out_t0_21 + (0.70856344699859619) * gru_1_out_t0_22 + (-0.69606637954711914) * gru_1_out_t0_23 + (0.49122524261474609) * gru_1_out_t0_24 + (-0.2270774245262146) * gru_1_out_t0_25 + (0.23694086074829102) * gru_1_out_t0_26 + (-0.27720162272453308) * gru_1_out_t0_27 + (1.0943255424499512) * gru_1_out_t0_28 + (0.78282362222671509) * gru_1_out_t0_29 + (-1.136067271232605) * gru_1_out_t0_30 + (-0.10719147324562073) * gru_1_out_t0_31 + (0.030723810195922852) * gru_1_out_t0_32 + (0.072261981666088104) * gru_1_out_t0_33 + (-0.4073948860168457) * gru_1_out_t0_34 + (1.1946412324905396) * gru_1_out_t0_35 + (0.58331620693206787) * gru_1_out_t0_36 + (-0.22593428194522858) * gru_1_out_t0_37 + (-0.29051223397254944) * gru_1_out_t0_38 + (-0.18918986618518829) * gru_1_out_t0_39 + (-0.26611790060997009) * gru_1_out_t0_40 + (-0.3156568706035614) * gru_1_out_t0_41 + (0.16253079473972321) * gru_1_out_t0_42 + (-0.26033109426498413) * gru_1_out_t0_43 + (-0.62451320886611938) * gru_1_out_t0_44 + (0.220931276679039) * gru_1_out_t0_45 + (-0.045115150511264801) * gru_1_out_t0_46 + (0.51381462812423706) * gru_1_out_t0_47 + (-0.92573493719100952) * gru_1_out_t0_48 + (0.78107285499572754) * gru_1_out_t0_49 + (0.296531081199646) * gru_1_out_t0_50 + (-0.45764133334159851) * gru_1_out_t0_51 + (-0.41901159286499023) * gru_1_out_t0_52 + (-0.91993319988250732) * gru_1_out_t0_53 + (0.2944258451461792) * gru_1_out_t0_54 + (0.083768747746944427) * gru_1_out_t0_55 + (-1.2087869644165039) * gru_1_out_t0_56 + (-0.12474789470434189) * gru_1_out_t0_57 + (0.11702824383974075) * gru_1_out_t0_58 + (-0.84011894464492798) * gru_1_out_t0_59 + (0.13155271112918854) * gru_1_out_t0_60 + (0.0074300589039921761) * gru_1_out_t0_61 + (-0.63244551420211792) * gru_1_out_t0_62 + (-0.66695588827133179) * gru_1_out_t0_63 + gate_r * (0.044182155281305313));
    gru_2_fwd_t0_h_5 = (1.0 - gate_z) * gate_n;
    // h=6
    gate_r = sigmoid((0.99238145351409912) + (0.97941190004348755) * gru_1_out_t0_0 + (1.9051604270935059) * gru_1_out_t0_1 + (-0.60982710123062134) * gru_1_out_t0_2 + (0.63175636529922485) * gru_1_out_t0_3 + (-0.49296796321868896) * gru_1_out_t0_4 + (0.51251834630966187) * gru_1_out_t0_5 + (-1.0902179479598999) * gru_1_out_t0_6 + (-0.24423442780971527) * gru_1_out_t0_7 + (-1.4805543422698975) * gru_1_out_t0_8 + (-0.77883583307266235) * gru_1_out_t0_9 + (0.61803019046783447) * gru_1_out_t0_10 + (0.79252749681472778) * gru_1_out_t0_11 + (0.30760139226913452) * gru_1_out_t0_12 + (0.99963343143463135) * gru_1_out_t0_13 + (0.99913442134857178) * gru_1_out_t0_14 + (-0.12514501810073853) * gru_1_out_t0_15 + (0.24538297951221466) * gru_1_out_t0_16 + (-1.3237224817276001) * gru_1_out_t0_17 + (0.41924157738685608) * gru_1_out_t0_18 + (-0.55750066041946411) * gru_1_out_t0_19 + (-0.1436622142791748) * gru_1_out_t0_20 + (0.86449950933456421) * gru_1_out_t0_21 + (-0.42343845963478088) * gru_1_out_t0_22 + (-1.3686064481735229) * gru_1_out_t0_23 + (2.7032325267791748) * gru_1_out_t0_24 + (1.0904897451400757) * gru_1_out_t0_25 + (1.0178974866867065) * gru_1_out_t0_26 + (0.0051362873055040836) * gru_1_out_t0_27 + (-0.11446412652730942) * gru_1_out_t0_28 + (-0.12069904804229736) * gru_1_out_t0_29 + (0.97054064273834229) * gru_1_out_t0_30 + (0.53837144374847412) * gru_1_out_t0_31 + (1.0813800096511841) * gru_1_out_t0_32 + (0.58504593372344971) * gru_1_out_t0_33 + (0.2685428261756897) * gru_1_out_t0_34 + (-0.29954433441162109) * gru_1_out_t0_35 + (0.7777177095413208) * gru_1_out_t0_36 + (0.039266772568225861) * gru_1_out_t0_37 + (-0.33155432343482971) * gru_1_out_t0_38 + (-0.1743304431438446) * gru_1_out_t0_39 + (-0.1693054735660553) * gru_1_out_t0_40 + (0.29454773664474487) * gru_1_out_t0_41 + (0.66117006540298462) * gru_1_out_t0_42 + (0.39358705282211304) * gru_1_out_t0_43 + (-0.13294480741024017) * gru_1_out_t0_44 + (0.68236023187637329) * gru_1_out_t0_45 + (0.30608677864074707) * gru_1_out_t0_46 + (-0.5872156023979187) * gru_1_out_t0_47 + (-0.74446231126785278) * gru_1_out_t0_48 + (0.95984375476837158) * gru_1_out_t0_49 + (0.99742645025253296) * gru_1_out_t0_50 + (0.56305491924285889) * gru_1_out_t0_51 + (-0.060103707015514374) * gru_1_out_t0_52 + (-0.034640897065401077) * gru_1_out_t0_53 + (-1.6142456531524658) * gru_1_out_t0_54 + (0.87334632873535156) * gru_1_out_t0_55 + (-1.0147285461425781) * gru_1_out_t0_56 + (0.36967334151268005) * gru_1_out_t0_57 + (-0.56437057256698608) * gru_1_out_t0_58 + (-0.64732939004898071) * gru_1_out_t0_59 + (-2.1714291572570801) * gru_1_out_t0_60 + (-0.32412993907928467) * gru_1_out_t0_61 + (1.7252355813980103) * gru_1_out_t0_62 + (-0.036716390401124954) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.15887005627155304) + (-0.72471684217453003) * gru_1_out_t0_0 + (-0.48633319139480591) * gru_1_out_t0_1 + (-0.43803763389587402) * gru_1_out_t0_2 + (0.42213571071624756) * gru_1_out_t0_3 + (0.0088470736518502235) * gru_1_out_t0_4 + (-0.16528171300888062) * gru_1_out_t0_5 + (2.2088873386383057) * gru_1_out_t0_6 + (0.2117859423160553) * gru_1_out_t0_7 + (0.23211970925331116) * gru_1_out_t0_8 + (0.34945672750473022) * gru_1_out_t0_9 + (0.063945971429347992) * gru_1_out_t0_10 + (-1.0151585340499878) * gru_1_out_t0_11 + (-0.16469350457191467) * gru_1_out_t0_12 + (-0.56130427122116089) * gru_1_out_t0_13 + (-0.1305549293756485) * gru_1_out_t0_14 + (-0.15692748129367828) * gru_1_out_t0_15 + (0.79616332054138184) * gru_1_out_t0_16 + (-0.62406086921691895) * gru_1_out_t0_17 + (-0.79074519872665405) * gru_1_out_t0_18 + (0.14874286949634552) * gru_1_out_t0_19 + (-0.24758745729923248) * gru_1_out_t0_20 + (1.0391430854797363) * gru_1_out_t0_21 + (-0.49141255021095276) * gru_1_out_t0_22 + (0.85845279693603516) * gru_1_out_t0_23 + (2.2941417694091797) * gru_1_out_t0_24 + (-0.423595130443573) * gru_1_out_t0_25 + (0.14678360521793365) * gru_1_out_t0_26 + (0.70135873556137085) * gru_1_out_t0_27 + (-0.30797651410102844) * gru_1_out_t0_28 + (-0.3422141969203949) * gru_1_out_t0_29 + (-1.2962141036987305) * gru_1_out_t0_30 + (-0.31097346544265747) * gru_1_out_t0_31 + (-0.46404397487640381) * gru_1_out_t0_32 + (-1.0470227003097534) * gru_1_out_t0_33 + (-1.0417500734329224) * gru_1_out_t0_34 + (1.5855774879455566) * gru_1_out_t0_35 + (0.018771134316921234) * gru_1_out_t0_36 + (-0.24097840487957001) * gru_1_out_t0_37 + (1.0948796272277832) * gru_1_out_t0_38 + (-1.0532113313674927) * gru_1_out_t0_39 + (1.3148645162582397) * gru_1_out_t0_40 + (-0.39999336004257202) * gru_1_out_t0_41 + (0.28015926480293274) * gru_1_out_t0_42 + (0.12160661816596985) * gru_1_out_t0_43 + (0.098121039569377899) * gru_1_out_t0_44 + (-0.12054173648357391) * gru_1_out_t0_45 + (0.0071843313053250313) * gru_1_out_t0_46 + (1.4575604200363159) * gru_1_out_t0_47 + (1.4373639822006226) * gru_1_out_t0_48 + (-0.53084522485733032) * gru_1_out_t0_49 + (-0.16599802672863007) * gru_1_out_t0_50 + (0.17999744415283203) * gru_1_out_t0_51 + (-0.10605581104755402) * gru_1_out_t0_52 + (-0.29012593626976013) * gru_1_out_t0_53 + (-0.43322914838790894) * gru_1_out_t0_54 + (0.34951236844062805) * gru_1_out_t0_55 + (-0.5737689733505249) * gru_1_out_t0_56 + (-1.0190738439559937) * gru_1_out_t0_57 + (-0.091982178390026093) * gru_1_out_t0_58 + (0.64190882444381714) * gru_1_out_t0_59 + (-0.20702961087226868) * gru_1_out_t0_60 + (-0.37210381031036377) * gru_1_out_t0_61 + (0.76966589689254761) * gru_1_out_t0_62 + (-0.86343324184417725) * gru_1_out_t0_63);
    gate_n = tanh((-0.38073989748954773) + (-0.069888316094875336) * gru_1_out_t0_0 + (-0.2414863258600235) * gru_1_out_t0_1 + (-0.62227034568786621) * gru_1_out_t0_2 + (-0.7356073260307312) * gru_1_out_t0_3 + (0.088059499859809875) * gru_1_out_t0_4 + (-0.67130643129348755) * gru_1_out_t0_5 + (-0.84127843379974365) * gru_1_out_t0_6 + (-0.18782402575016022) * gru_1_out_t0_7 + (-0.19532755017280579) * gru_1_out_t0_8 + (0.17948193848133087) * gru_1_out_t0_9 + (0.13035029172897339) * gru_1_out_t0_10 + (0.37686276435852051) * gru_1_out_t0_11 + (-0.13486675918102264) * gru_1_out_t0_12 + (0.46430742740631104) * gru_1_out_t0_13 + (-0.5601038932800293) * gru_1_out_t0_14 + (0.7103990912437439) * gru_1_out_t0_15 + (-0.98155832290649414) * gru_1_out_t0_16 + (-0.30917298793792725) * gru_1_out_t0_17 + (-0.1572728157043457) * gru_1_out_t0_18 + (0.066305853426456451) * gru_1_out_t0_19 + (0.047919288277626038) * gru_1_out_t0_20 + (0.075065046548843384) * gru_1_out_t0_21 + (0.23333732783794403) * gru_1_out_t0_22 + (0.4488789439201355) * gru_1_out_t0_23 + (-0.22282376885414124) * gru_1_out_t0_24 + (-0.30130714178085327) * gru_1_out_t0_25 + (-0.014877819456160069) * gru_1_out_t0_26 + (0.14033789932727814) * gru_1_out_t0_27 + (0.10877938568592072) * gru_1_out_t0_28 + (-0.4529661238193512) * gru_1_out_t0_29 + (-0.083255298435688019) * gru_1_out_t0_30 + (0.71279716491699219) * gru_1_out_t0_31 + (0.30829378962516785) * gru_1_out_t0_32 + (0.12226396054029465) * gru_1_out_t0_33 + (-0.087489128112792969) * gru_1_out_t0_34 + (-0.075500346720218658) * gru_1_out_t0_35 + (-0.15269826352596283) * gru_1_out_t0_36 + (0.43252423405647278) * gru_1_out_t0_37 + (0.009540473110973835) * gru_1_out_t0_38 + (-0.5790170431137085) * gru_1_out_t0_39 + (0.41713187098503113) * gru_1_out_t0_40 + (-0.091455988585948944) * gru_1_out_t0_41 + (0.4325605034828186) * gru_1_out_t0_42 + (-0.57300513982772827) * gru_1_out_t0_43 + (0.22971288859844208) * gru_1_out_t0_44 + (0.12160023301839828) * gru_1_out_t0_45 + (-0.25573226809501648) * gru_1_out_t0_46 + (-0.048875294625759125) * gru_1_out_t0_47 + (-0.13737761974334717) * gru_1_out_t0_48 + (-0.23275421559810638) * gru_1_out_t0_49 + (0.19752825796604156) * gru_1_out_t0_50 + (-0.18723508715629578) * gru_1_out_t0_51 + (0.36962774395942688) * gru_1_out_t0_52 + (0.18754303455352783) * gru_1_out_t0_53 + (0.067695558071136475) * gru_1_out_t0_54 + (-0.5221942663192749) * gru_1_out_t0_55 + (0.20494328439235687) * gru_1_out_t0_56 + (-0.045121807605028152) * gru_1_out_t0_57 + (0.48538091778755188) * gru_1_out_t0_58 + (-0.084261290729045868) * gru_1_out_t0_59 + (0.19997870922088623) * gru_1_out_t0_60 + (-0.23550234735012054) * gru_1_out_t0_61 + (0.035868816077709198) * gru_1_out_t0_62 + (0.16396276652812958) * gru_1_out_t0_63 + gate_r * (-0.28456246852874756));
    gru_2_fwd_t0_h_6 = (1.0 - gate_z) * gate_n;
    // h=7
    gate_r = sigmoid((-0.62197017669677734) + (0.10606128722429276) * gru_1_out_t0_0 + (2.5488266944885254) * gru_1_out_t0_1 + (-1.4843736886978149) * gru_1_out_t0_2 + (0.35048002004623413) * gru_1_out_t0_3 + (-0.4260120689868927) * gru_1_out_t0_4 + (2.2575030326843262) * gru_1_out_t0_5 + (2.2194697856903076) * gru_1_out_t0_6 + (-0.11634258925914764) * gru_1_out_t0_7 + (-0.3215067982673645) * gru_1_out_t0_8 + (-0.67384010553359985) * gru_1_out_t0_9 + (0.74993818998336792) * gru_1_out_t0_10 + (-0.59708577394485474) * gru_1_out_t0_11 + (-0.015302901156246662) * gru_1_out_t0_12 + (-0.070593178272247314) * gru_1_out_t0_13 + (0.56934881210327148) * gru_1_out_t0_14 + (-0.59768384695053101) * gru_1_out_t0_15 + (-0.44555187225341797) * gru_1_out_t0_16 + (-0.18213480710983276) * gru_1_out_t0_17 + (0.59250104427337646) * gru_1_out_t0_18 + (-0.38874515891075134) * gru_1_out_t0_19 + (-0.071320079267024994) * gru_1_out_t0_20 + (-0.82715123891830444) * gru_1_out_t0_21 + (-0.65167057514190674) * gru_1_out_t0_22 + (0.0074586817063391209) * gru_1_out_t0_23 + (-0.99457579851150513) * gru_1_out_t0_24 + (0.27512049674987793) * gru_1_out_t0_25 + (-0.65382099151611328) * gru_1_out_t0_26 + (-1.4781731367111206) * gru_1_out_t0_27 + (-0.86624646186828613) * gru_1_out_t0_28 + (-0.62023651599884033) * gru_1_out_t0_29 + (-0.84566342830657959) * gru_1_out_t0_30 + (-0.27118068933486938) * gru_1_out_t0_31 + (-1.6714849472045898) * gru_1_out_t0_32 + (-1.4434305429458618) * gru_1_out_t0_33 + (2.3194448947906494) * gru_1_out_t0_34 + (0.30631107091903687) * gru_1_out_t0_35 + (-1.2566306591033936) * gru_1_out_t0_36 + (-0.34590819478034973) * gru_1_out_t0_37 + (-0.063884533941745758) * gru_1_out_t0_38 + (-0.28741663694381714) * gru_1_out_t0_39 + (-1.0691723823547363) * gru_1_out_t0_40 + (0.42472741007804871) * gru_1_out_t0_41 + (-0.31156787276268005) * gru_1_out_t0_42 + (3.0809240341186523) * gru_1_out_t0_43 + (-0.21261155605316162) * gru_1_out_t0_44 + (0.069369584321975708) * gru_1_out_t0_45 + (0.24070744216442108) * gru_1_out_t0_46 + (-0.31690332293510437) * gru_1_out_t0_47 + (-0.89229744672775269) * gru_1_out_t0_48 + (-0.16281262040138245) * gru_1_out_t0_49 + (1.5589324235916138) * gru_1_out_t0_50 + (0.33524227142333984) * gru_1_out_t0_51 + (-0.95937418937683105) * gru_1_out_t0_52 + (-0.5072479248046875) * gru_1_out_t0_53 + (0.75587660074234009) * gru_1_out_t0_54 + (2.8644340038299561) * gru_1_out_t0_55 + (-1.1837942600250244) * gru_1_out_t0_56 + (0.5380062460899353) * gru_1_out_t0_57 + (0.98161321878433228) * gru_1_out_t0_58 + (1.2194415330886841) * gru_1_out_t0_59 + (0.98128432035446167) * gru_1_out_t0_60 + (1.7099440097808838) * gru_1_out_t0_61 + (0.045954499393701553) * gru_1_out_t0_62 + (1.4897309541702271) * gru_1_out_t0_63);
    gate_z = sigmoid((0.96685171127319336) + (0.012206170707941055) * gru_1_out_t0_0 + (-1.7312475442886353) * gru_1_out_t0_1 + (0.66134369373321533) * gru_1_out_t0_2 + (0.83093476295471191) * gru_1_out_t0_3 + (-0.81004118919372559) * gru_1_out_t0_4 + (0.20667769014835358) * gru_1_out_t0_5 + (-0.32482859492301941) * gru_1_out_t0_6 + (0.086760997772216797) * gru_1_out_t0_7 + (0.82007551193237305) * gru_1_out_t0_8 + (-0.27801385521888733) * gru_1_out_t0_9 + (-0.24740634858608246) * gru_1_out_t0_10 + (-0.028964810073375702) * gru_1_out_t0_11 + (0.0013547611888498068) * gru_1_out_t0_12 + (0.45537617802619934) * gru_1_out_t0_13 + (-0.0027167184744030237) * gru_1_out_t0_14 + (-0.8789563775062561) * gru_1_out_t0_15 + (0.51275146007537842) * gru_1_out_t0_16 + (0.5159115195274353) * gru_1_out_t0_17 + (0.16361212730407715) * gru_1_out_t0_18 + (-0.54619032144546509) * gru_1_out_t0_19 + (0.052597768604755402) * gru_1_out_t0_20 + (-0.81271541118621826) * gru_1_out_t0_21 + (1.1113190650939941) * gru_1_out_t0_22 + (1.0679113864898682) * gru_1_out_t0_23 + (-1.2912274599075317) * gru_1_out_t0_24 + (0.09121336042881012) * gru_1_out_t0_25 + (-0.63428980112075806) * gru_1_out_t0_26 + (0.34954008460044861) * gru_1_out_t0_27 + (-0.03144533559679985) * gru_1_out_t0_28 + (0.27489036321640015) * gru_1_out_t0_29 + (-0.015525013208389282) * gru_1_out_t0_30 + (-0.54355871677398682) * gru_1_out_t0_31 + (-0.27052107453346252) * gru_1_out_t0_32 + (0.052014395594596863) * gru_1_out_t0_33 + (-0.31858307123184204) * gru_1_out_t0_34 + (-0.39337372779846191) * gru_1_out_t0_35 + (0.95989447832107544) * gru_1_out_t0_36 + (-0.26006212830543518) * gru_1_out_t0_37 + (0.074188292026519775) * gru_1_out_t0_38 + (0.13213072717189789) * gru_1_out_t0_39 + (-0.27316227555274963) * gru_1_out_t0_40 + (-0.21921087801456451) * gru_1_out_t0_41 + (-0.78826171159744263) * gru_1_out_t0_42 + (-0.077395103871822357) * gru_1_out_t0_43 + (0.38001447916030884) * gru_1_out_t0_44 + (-0.26316031813621521) * gru_1_out_t0_45 + (0.10834713280200958) * gru_1_out_t0_46 + (0.13354608416557312) * gru_1_out_t0_47 + (0.0061753229238092899) * gru_1_out_t0_48 + (-0.95196187496185303) * gru_1_out_t0_49 + (0.23414483666419983) * gru_1_out_t0_50 + (0.94790107011795044) * gru_1_out_t0_51 + (0.225624680519104) * gru_1_out_t0_52 + (0.96818536520004272) * gru_1_out_t0_53 + (-1.7600637674331665) * gru_1_out_t0_54 + (-0.05408448725938797) * gru_1_out_t0_55 + (0.49943855404853821) * gru_1_out_t0_56 + (-0.23487582802772522) * gru_1_out_t0_57 + (0.64191347360610962) * gru_1_out_t0_58 + (0.10321272164583206) * gru_1_out_t0_59 + (0.37663841247558594) * gru_1_out_t0_60 + (0.52203500270843506) * gru_1_out_t0_61 + (0.48036238551139832) * gru_1_out_t0_62 + (0.4523547887802124) * gru_1_out_t0_63);
    gate_n = tanh((0.16772949695587158) + (1.0952954292297363) * gru_1_out_t0_0 + (-0.6741948127746582) * gru_1_out_t0_1 + (-1.1881314516067505) * gru_1_out_t0_2 + (-0.71068853139877319) * gru_1_out_t0_3 + (0.02962360717356205) * gru_1_out_t0_4 + (1.2724641561508179) * gru_1_out_t0_5 + (0.018698837608098984) * gru_1_out_t0_6 + (-0.18740774691104889) * gru_1_out_t0_7 + (0.64471220970153809) * gru_1_out_t0_8 + (-0.75354892015457153) * gru_1_out_t0_9 + (1.4643434286117554) * gru_1_out_t0_10 + (-0.50647121667861938) * gru_1_out_t0_11 + (0.63769596815109253) * gru_1_out_t0_12 + (0.65903520584106445) * gru_1_out_t0_13 + (1.2687849998474121) * gru_1_out_t0_14 + (0.36564844846725464) * gru_1_out_t0_15 + (-0.28932645916938782) * gru_1_out_t0_16 + (0.4631996750831604) * gru_1_out_t0_17 + (-0.75679153203964233) * gru_1_out_t0_18 + (-0.40215137600898743) * gru_1_out_t0_19 + (0.60795396566390991) * gru_1_out_t0_20 + (-0.12811829149723053) * gru_1_out_t0_21 + (0.44376468658447266) * gru_1_out_t0_22 + (0.64267253875732422) * gru_1_out_t0_23 + (1.0837119817733765) * gru_1_out_t0_24 + (0.76343041658401489) * gru_1_out_t0_25 + (0.11084635555744171) * gru_1_out_t0_26 + (-1.2510532140731812) * gru_1_out_t0_27 + (0.57588160037994385) * gru_1_out_t0_28 + (0.23647917807102203) * gru_1_out_t0_29 + (-0.24430578947067261) * gru_1_out_t0_30 + (-0.3114495575428009) * gru_1_out_t0_31 + (-0.43070966005325317) * gru_1_out_t0_32 + (0.48690155148506165) * gru_1_out_t0_33 + (-0.13391916453838348) * gru_1_out_t0_34 + (1.5850821733474731) * gru_1_out_t0_35 + (-0.13425683975219727) * gru_1_out_t0_36 + (0.48748385906219482) * gru_1_out_t0_37 + (0.31754869222640991) * gru_1_out_t0_38 + (0.11707057803869247) * gru_1_out_t0_39 + (0.013748683966696262) * gru_1_out_t0_40 + (0.53161734342575073) * gru_1_out_t0_41 + (0.23816487193107605) * gru_1_out_t0_42 + (1.3095252513885498) * gru_1_out_t0_43 + (0.72958159446716309) * gru_1_out_t0_44 + (0.64956575632095337) * gru_1_out_t0_45 + (0.0056460793130099773) * gru_1_out_t0_46 + (0.94144123792648315) * gru_1_out_t0_47 + (0.6393735408782959) * gru_1_out_t0_48 + (0.77151209115982056) * gru_1_out_t0_49 + (0.66855651140213013) * gru_1_out_t0_50 + (0.0080999704077839851) * gru_1_out_t0_51 + (-1.3328602313995361) * gru_1_out_t0_52 + (-0.056517761200666428) * gru_1_out_t0_53 + (-0.31408938765525818) * gru_1_out_t0_54 + (0.12478691339492798) * gru_1_out_t0_55 + (-0.14910398423671722) * gru_1_out_t0_56 + (0.2223050445318222) * gru_1_out_t0_57 + (-0.5043831467628479) * gru_1_out_t0_58 + (-0.06169326975941658) * gru_1_out_t0_59 + (-0.62208932638168335) * gru_1_out_t0_60 + (-0.060615688562393188) * gru_1_out_t0_61 + (-0.22841568291187286) * gru_1_out_t0_62 + (-0.78983438014984131) * gru_1_out_t0_63 + gate_r * (0.13742536306381226));
    gru_2_fwd_t0_h_7 = (1.0 - gate_z) * gate_n;
    // h=8
    gate_r = sigmoid((-0.53908532857894897) + (0.078634321689605713) * gru_1_out_t0_0 + (2.0536425113677979) * gru_1_out_t0_1 + (-0.96540969610214233) * gru_1_out_t0_2 + (0.30416128039360046) * gru_1_out_t0_3 + (0.60399931669235229) * gru_1_out_t0_4 + (0.058909893035888672) * gru_1_out_t0_5 + (2.5095283985137939) * gru_1_out_t0_6 + (-0.042866971343755722) * gru_1_out_t0_7 + (-0.52229130268096924) * gru_1_out_t0_8 + (1.1680225133895874) * gru_1_out_t0_9 + (-0.12274897843599319) * gru_1_out_t0_10 + (-0.36791682243347168) * gru_1_out_t0_11 + (-0.3688347339630127) * gru_1_out_t0_12 + (-1.2192187309265137) * gru_1_out_t0_13 + (0.37666884064674377) * gru_1_out_t0_14 + (-0.94372445344924927) * gru_1_out_t0_15 + (1.1495617628097534) * gru_1_out_t0_16 + (-0.56097263097763062) * gru_1_out_t0_17 + (0.82514744997024536) * gru_1_out_t0_18 + (0.69741863012313843) * gru_1_out_t0_19 + (0.10346744209527969) * gru_1_out_t0_20 + (0.35990425944328308) * gru_1_out_t0_21 + (-2.8436679840087891) * gru_1_out_t0_22 + (0.1426994651556015) * gru_1_out_t0_23 + (-0.54870116710662842) * gru_1_out_t0_24 + (-0.05660228431224823) * gru_1_out_t0_25 + (-0.22061625123023987) * gru_1_out_t0_26 + (0.88734716176986694) * gru_1_out_t0_27 + (0.33472704887390137) * gru_1_out_t0_28 + (-0.25292253494262695) * gru_1_out_t0_29 + (-1.6953027248382568) * gru_1_out_t0_30 + (1.0126359462738037) * gru_1_out_t0_31 + (-0.35613980889320374) * gru_1_out_t0_32 + (-0.89255213737487793) * gru_1_out_t0_33 + (-0.0028074497822672129) * gru_1_out_t0_34 + (0.65458059310913086) * gru_1_out_t0_35 + (0.43885055184364319) * gru_1_out_t0_36 + (0.83492010831832886) * gru_1_out_t0_37 + (-0.29144129157066345) * gru_1_out_t0_38 + (0.16315062344074249) * gru_1_out_t0_39 + (-1.8205474615097046) * gru_1_out_t0_40 + (-0.55876225233078003) * gru_1_out_t0_41 + (-0.83146709203720093) * gru_1_out_t0_42 + (-1.0345338582992554) * gru_1_out_t0_43 + (-1.076459527015686) * gru_1_out_t0_44 + (1.2964736223220825) * gru_1_out_t0_45 + (0.97564423084259033) * gru_1_out_t0_46 + (0.99439311027526855) * gru_1_out_t0_47 + (0.03395390510559082) * gru_1_out_t0_48 + (1.0589445829391479) * gru_1_out_t0_49 + (-0.057525143027305603) * gru_1_out_t0_50 + (-0.3094896674156189) * gru_1_out_t0_51 + (0.067988887429237366) * gru_1_out_t0_52 + (0.28435409069061279) * gru_1_out_t0_53 + (-1.0499585866928101) * gru_1_out_t0_54 + (1.0331951379776001) * gru_1_out_t0_55 + (-0.5763738751411438) * gru_1_out_t0_56 + (0.034764725714921951) * gru_1_out_t0_57 + (-0.25446009635925293) * gru_1_out_t0_58 + (0.15532650053501129) * gru_1_out_t0_59 + (-0.92661362886428833) * gru_1_out_t0_60 + (-0.15858826041221619) * gru_1_out_t0_61 + (2.2558729648590088) * gru_1_out_t0_62 + (-0.23864836990833282) * gru_1_out_t0_63);
    gate_z = sigmoid((0.30447965860366821) + (0.19288501143455505) * gru_1_out_t0_0 + (0.16414806246757507) * gru_1_out_t0_1 + (-0.30927088856697083) * gru_1_out_t0_2 + (0.085337221622467041) * gru_1_out_t0_3 + (-0.10658828914165497) * gru_1_out_t0_4 + (-0.49309277534484863) * gru_1_out_t0_5 + (0.16548995673656464) * gru_1_out_t0_6 + (0.27559152245521545) * gru_1_out_t0_7 + (0.27526000142097473) * gru_1_out_t0_8 + (0.24473078548908234) * gru_1_out_t0_9 + (0.099203504621982574) * gru_1_out_t0_10 + (1.2784748077392578) * gru_1_out_t0_11 + (1.2376636266708374) * gru_1_out_t0_12 + (-0.024852164089679718) * gru_1_out_t0_13 + (0.49689561128616333) * gru_1_out_t0_14 + (0.36183759570121765) * gru_1_out_t0_15 + (-0.3678620457649231) * gru_1_out_t0_16 + (-0.49078550934791565) * gru_1_out_t0_17 + (0.90503126382827759) * gru_1_out_t0_18 + (-0.044006705284118652) * gru_1_out_t0_19 + (-0.55865907669067383) * gru_1_out_t0_20 + (-0.27482780814170837) * gru_1_out_t0_21 + (-0.14106933772563934) * gru_1_out_t0_22 + (-0.042704034596681595) * gru_1_out_t0_23 + (0.10288488119840622) * gru_1_out_t0_24 + (0.66289716958999634) * gru_1_out_t0_25 + (0.28080996870994568) * gru_1_out_t0_26 + (-0.55461633205413818) * gru_1_out_t0_27 + (0.55825525522232056) * gru_1_out_t0_28 + (0.0084897512570023537) * gru_1_out_t0_29 + (-0.98858010768890381) * gru_1_out_t0_30 + (0.029864830896258354) * gru_1_out_t0_31 + (0.69501322507858276) * gru_1_out_t0_32 + (0.10555534064769745) * gru_1_out_t0_33 + (0.09830956906080246) * gru_1_out_t0_34 + (0.35971704125404358) * gru_1_out_t0_35 + (0.37289887666702271) * gru_1_out_t0_36 + (-0.47766527533531189) * gru_1_out_t0_37 + (-0.063151910901069641) * gru_1_out_t0_38 + (-0.92066001892089844) * gru_1_out_t0_39 + (-0.6994621753692627) * gru_1_out_t0_40 + (-0.10258133709430695) * gru_1_out_t0_41 + (-0.54435199499130249) * gru_1_out_t0_42 + (-0.22806635499000549) * gru_1_out_t0_43 + (0.15118521451950073) * gru_1_out_t0_44 + (0.66831475496292114) * gru_1_out_t0_45 + (-0.20658956468105316) * gru_1_out_t0_46 + (-0.099997662007808685) * gru_1_out_t0_47 + (1.0328670740127563) * gru_1_out_t0_48 + (-0.048194747418165207) * gru_1_out_t0_49 + (-0.63098102807998657) * gru_1_out_t0_50 + (-0.45617866516113281) * gru_1_out_t0_51 + (-0.70968443155288696) * gru_1_out_t0_52 + (-0.35214874148368835) * gru_1_out_t0_53 + (0.36654022336006165) * gru_1_out_t0_54 + (0.060495857149362564) * gru_1_out_t0_55 + (-1.1463649272918701) * gru_1_out_t0_56 + (-0.42861640453338623) * gru_1_out_t0_57 + (-0.071352899074554443) * gru_1_out_t0_58 + (0.56755810976028442) * gru_1_out_t0_59 + (1.0881471633911133) * gru_1_out_t0_60 + (-0.40841835737228394) * gru_1_out_t0_61 + (-0.11229383200407028) * gru_1_out_t0_62 + (0.06819094717502594) * gru_1_out_t0_63);
    gate_n = tanh((-0.055655688047409058) + (-0.016797928139567375) * gru_1_out_t0_0 + (-0.075077153742313385) * gru_1_out_t0_1 + (0.40730956196784973) * gru_1_out_t0_2 + (-1.0813908576965332) * gru_1_out_t0_3 + (0.51369673013687134) * gru_1_out_t0_4 + (-0.38735407590866089) * gru_1_out_t0_5 + (0.32982203364372253) * gru_1_out_t0_6 + (0.15628142654895782) * gru_1_out_t0_7 + (-0.12502457201480865) * gru_1_out_t0_8 + (0.27023062109947205) * gru_1_out_t0_9 + (-0.03850395604968071) * gru_1_out_t0_10 + (0.10016777366399765) * gru_1_out_t0_11 + (-0.9997870922088623) * gru_1_out_t0_12 + (0.041368529200553894) * gru_1_out_t0_13 + (0.090797379612922668) * gru_1_out_t0_14 + (-0.48800671100616455) * gru_1_out_t0_15 + (-0.15780968964099884) * gru_1_out_t0_16 + (-0.19997213780879974) * gru_1_out_t0_17 + (-0.37419059872627258) * gru_1_out_t0_18 + (0.25626039505004883) * gru_1_out_t0_19 + (0.24937050044536591) * gru_1_out_t0_20 + (-0.0050323675386607647) * gru_1_out_t0_21 + (0.087856695055961609) * gru_1_out_t0_22 + (-0.11046905070543289) * gru_1_out_t0_23 + (-0.36441168189048767) * gru_1_out_t0_24 + (-0.1878090500831604) * gru_1_out_t0_25 + (0.099239043891429901) * gru_1_out_t0_26 + (0.073255211114883423) * gru_1_out_t0_27 + (-0.027451835572719574) * gru_1_out_t0_28 + (0.14343157410621643) * gru_1_out_t0_29 + (0.045601692050695419) * gru_1_out_t0_30 + (0.11708865314722061) * gru_1_out_t0_31 + (0.13609884679317474) * gru_1_out_t0_32 + (-0.25147533416748047) * gru_1_out_t0_33 + (0.30359148979187012) * gru_1_out_t0_34 + (-0.19323043525218964) * gru_1_out_t0_35 + (0.32059803605079651) * gru_1_out_t0_36 + (0.25422936677932739) * gru_1_out_t0_37 + (-0.18780280649662018) * gru_1_out_t0_38 + (0.65962326526641846) * gru_1_out_t0_39 + (-0.2968585193157196) * gru_1_out_t0_40 + (0.11966401338577271) * gru_1_out_t0_41 + (0.44959843158721924) * gru_1_out_t0_42 + (-0.14553603529930115) * gru_1_out_t0_43 + (-0.2625100314617157) * gru_1_out_t0_44 + (0.09806554764509201) * gru_1_out_t0_45 + (-0.269957035779953) * gru_1_out_t0_46 + (0.057726453989744186) * gru_1_out_t0_47 + (-0.19046621024608612) * gru_1_out_t0_48 + (0.37847214937210083) * gru_1_out_t0_49 + (-0.065119437873363495) * gru_1_out_t0_50 + (-0.61015766859054565) * gru_1_out_t0_51 + (0.50586223602294922) * gru_1_out_t0_52 + (0.082689382135868073) * gru_1_out_t0_53 + (0.11679784953594208) * gru_1_out_t0_54 + (0.20894849300384521) * gru_1_out_t0_55 + (-0.2432241290807724) * gru_1_out_t0_56 + (-0.24553763866424561) * gru_1_out_t0_57 + (0.37193861603736877) * gru_1_out_t0_58 + (0.023829592391848564) * gru_1_out_t0_59 + (-0.39855670928955078) * gru_1_out_t0_60 + (-0.039706315845251083) * gru_1_out_t0_61 + (0.50039315223693848) * gru_1_out_t0_62 + (0.044628221541643143) * gru_1_out_t0_63 + gate_r * (-0.39641654491424561));
    gru_2_fwd_t0_h_8 = (1.0 - gate_z) * gate_n;
    // h=9
    gate_r = sigmoid((0.014598826877772808) + (-0.46345117688179016) * gru_1_out_t0_0 + (-0.48719778656959534) * gru_1_out_t0_1 + (-1.0049848556518555) * gru_1_out_t0_2 + (-0.099054776132106781) * gru_1_out_t0_3 + (0.14393486082553864) * gru_1_out_t0_4 + (-0.21178200840950012) * gru_1_out_t0_5 + (-0.31770572066307068) * gru_1_out_t0_6 + (-0.37354984879493713) * gru_1_out_t0_7 + (0.68031573295593262) * gru_1_out_t0_8 + (0.51085525751113892) * gru_1_out_t0_9 + (-0.32035186886787415) * gru_1_out_t0_10 + (0.24460971355438232) * gru_1_out_t0_11 + (0.28930282592773438) * gru_1_out_t0_12 + (1.0542950630187988) * gru_1_out_t0_13 + (-0.48809534311294556) * gru_1_out_t0_14 + (0.37523487210273743) * gru_1_out_t0_15 + (0.59806299209594727) * gru_1_out_t0_16 + (-0.79957163333892822) * gru_1_out_t0_17 + (-1.8025393486022949) * gru_1_out_t0_18 + (-1.147591233253479) * gru_1_out_t0_19 + (-1.6719909906387329) * gru_1_out_t0_20 + (0.30019605159759521) * gru_1_out_t0_21 + (0.017319349572062492) * gru_1_out_t0_22 + (-0.041806060820817947) * gru_1_out_t0_23 + (0.40679079294204712) * gru_1_out_t0_24 + (1.1455427408218384) * gru_1_out_t0_25 + (-0.13862590491771698) * gru_1_out_t0_26 + (0.053010284900665283) * gru_1_out_t0_27 + (0.87356585264205933) * gru_1_out_t0_28 + (-0.37017935514450073) * gru_1_out_t0_29 + (-0.65110969543457031) * gru_1_out_t0_30 + (-0.5382312536239624) * gru_1_out_t0_31 + (1.3739076852798462) * gru_1_out_t0_32 + (0.56226533651351929) * gru_1_out_t0_33 + (-1.1075671911239624) * gru_1_out_t0_34 + (-0.55554085969924927) * gru_1_out_t0_35 + (-2.491192102432251) * gru_1_out_t0_36 + (1.1740829944610596) * gru_1_out_t0_37 + (0.13902252912521362) * gru_1_out_t0_38 + (-0.20352411270141602) * gru_1_out_t0_39 + (0.5467524528503418) * gru_1_out_t0_40 + (-0.23037214577198029) * gru_1_out_t0_41 + (0.97516632080078125) * gru_1_out_t0_42 + (0.92362809181213379) * gru_1_out_t0_43 + (-0.023969637230038643) * gru_1_out_t0_44 + (-0.80143368244171143) * gru_1_out_t0_45 + (0.28786575794219971) * gru_1_out_t0_46 + (1.6128722429275513) * gru_1_out_t0_47 + (1.4692742824554443) * gru_1_out_t0_48 + (0.20076000690460205) * gru_1_out_t0_49 + (-0.24042515456676483) * gru_1_out_t0_50 + (0.21900592744350433) * gru_1_out_t0_51 + (-1.0475177764892578) * gru_1_out_t0_52 + (-0.41773787140846252) * gru_1_out_t0_53 + (-1.1150989532470703) * gru_1_out_t0_54 + (0.53581899404525757) * gru_1_out_t0_55 + (0.40333741903305054) * gru_1_out_t0_56 + (-0.52914345264434814) * gru_1_out_t0_57 + (-0.052777830511331558) * gru_1_out_t0_58 + (0.07998320460319519) * gru_1_out_t0_59 + (0.71382761001586914) * gru_1_out_t0_60 + (0.5724366307258606) * gru_1_out_t0_61 + (1.8979524374008179) * gru_1_out_t0_62 + (-0.080285154283046722) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.34925282001495361) + (0.21860124170780182) * gru_1_out_t0_0 + (-1.2750535011291504) * gru_1_out_t0_1 + (0.48629972338676453) * gru_1_out_t0_2 + (1.1838271617889404) * gru_1_out_t0_3 + (1.0813385248184204) * gru_1_out_t0_4 + (-0.048997972160577774) * gru_1_out_t0_5 + (0.14296154677867889) * gru_1_out_t0_6 + (0.56945502758026123) * gru_1_out_t0_7 + (-0.38403001427650452) * gru_1_out_t0_8 + (-0.0064780316315591335) * gru_1_out_t0_9 + (-1.2874466180801392) * gru_1_out_t0_10 + (-0.9462820291519165) * gru_1_out_t0_11 + (0.11361563950777054) * gru_1_out_t0_12 + (-0.78455573320388794) * gru_1_out_t0_13 + (-0.5625959038734436) * gru_1_out_t0_14 + (0.42606377601623535) * gru_1_out_t0_15 + (-0.40487810969352722) * gru_1_out_t0_16 + (-0.35480734705924988) * gru_1_out_t0_17 + (-1.1558396816253662) * gru_1_out_t0_18 + (-0.28579071164131165) * gru_1_out_t0_19 + (0.24619176983833313) * gru_1_out_t0_20 + (0.8626895546913147) * gru_1_out_t0_21 + (-0.91276955604553223) * gru_1_out_t0_22 + (1.1313618421554565) * gru_1_out_t0_23 + (1.3128281831741333) * gru_1_out_t0_24 + (0.011046985164284706) * gru_1_out_t0_25 + (0.48031297326087952) * gru_1_out_t0_26 + (0.44386860728263855) * gru_1_out_t0_27 + (-1.8145660161972046) * gru_1_out_t0_28 + (-0.93205726146697998) * gru_1_out_t0_29 + (1.4230136871337891) * gru_1_out_t0_30 + (-0.39190006256103516) * gru_1_out_t0_31 + (1.905376672744751) * gru_1_out_t0_32 + (-0.12040308117866516) * gru_1_out_t0_33 + (-0.69080924987792969) * gru_1_out_t0_34 + (-0.32722079753875732) * gru_1_out_t0_35 + (-0.51767683029174805) * gru_1_out_t0_36 + (-0.79373836517333984) * gru_1_out_t0_37 + (0.16315026581287384) * gru_1_out_t0_38 + (-1.0651921033859253) * gru_1_out_t0_39 + (0.15370947122573853) * gru_1_out_t0_40 + (0.35539710521697998) * gru_1_out_t0_41 + (0.20755097270011902) * gru_1_out_t0_42 + (0.030037375167012215) * gru_1_out_t0_43 + (-0.27422261238098145) * gru_1_out_t0_44 + (1.5664864778518677) * gru_1_out_t0_45 + (-0.54654353857040405) * gru_1_out_t0_46 + (1.3033120632171631) * gru_1_out_t0_47 + (-0.11546861380338669) * gru_1_out_t0_48 + (0.60384708642959595) * gru_1_out_t0_49 + (0.13742566108703613) * gru_1_out_t0_50 + (0.4729074239730835) * gru_1_out_t0_51 + (-1.3827089071273804) * gru_1_out_t0_52 + (-0.64250373840332031) * gru_1_out_t0_53 + (0.61232507228851318) * gru_1_out_t0_54 + (-1.3600777387619019) * gru_1_out_t0_55 + (-0.59187108278274536) * gru_1_out_t0_56 + (0.46893236041069031) * gru_1_out_t0_57 + (-0.13582022488117218) * gru_1_out_t0_58 + (0.89733457565307617) * gru_1_out_t0_59 + (-0.01153002493083477) * gru_1_out_t0_60 + (-0.60632634162902832) * gru_1_out_t0_61 + (-1.6640650033950806) * gru_1_out_t0_62 + (-0.32998523116111755) * gru_1_out_t0_63);
    gate_n = tanh((-0.80344879627227783) + (-0.64380866289138794) * gru_1_out_t0_0 + (0.11013287305831909) * gru_1_out_t0_1 + (0.26833003759384155) * gru_1_out_t0_2 + (0.32167172431945801) * gru_1_out_t0_3 + (0.35860463976860046) * gru_1_out_t0_4 + (-0.055242553353309631) * gru_1_out_t0_5 + (0.21447136998176575) * gru_1_out_t0_6 + (-0.30164352059364319) * gru_1_out_t0_7 + (-0.46121618151664734) * gru_1_out_t0_8 + (0.28518933057785034) * gru_1_out_t0_9 + (0.44683313369750977) * gru_1_out_t0_10 + (-0.18195399641990662) * gru_1_out_t0_11 + (-0.17171569168567657) * gru_1_out_t0_12 + (0.39640405774116516) * gru_1_out_t0_13 + (0.092429131269454956) * gru_1_out_t0_14 + (-0.15170484781265259) * gru_1_out_t0_15 + (-0.23539412021636963) * gru_1_out_t0_16 + (0.55429273843765259) * gru_1_out_t0_17 + (-0.1483212411403656) * gru_1_out_t0_18 + (0.45779016613960266) * gru_1_out_t0_19 + (-0.27864551544189453) * gru_1_out_t0_20 + (0.33824288845062256) * gru_1_out_t0_21 + (0.11755144596099854) * gru_1_out_t0_22 + (1.0912950038909912) * gru_1_out_t0_23 + (-0.22760289907455444) * gru_1_out_t0_24 + (-0.32826676964759827) * gru_1_out_t0_25 + (0.63522970676422119) * gru_1_out_t0_26 + (1.0378645658493042) * gru_1_out_t0_27 + (0.13981203734874725) * gru_1_out_t0_28 + (0.1481294184923172) * gru_1_out_t0_29 + (0.040944594889879227) * gru_1_out_t0_30 + (-0.89607501029968262) * gru_1_out_t0_31 + (0.019776660948991776) * gru_1_out_t0_32 + (0.036020226776599884) * gru_1_out_t0_33 + (0.33428165316581726) * gru_1_out_t0_34 + (0.23375742137432098) * gru_1_out_t0_35 + (0.050345737487077713) * gru_1_out_t0_36 + (-0.37424233555793762) * gru_1_out_t0_37 + (0.24384459853172302) * gru_1_out_t0_38 + (-0.57826662063598633) * gru_1_out_t0_39 + (-0.49773132801055908) * gru_1_out_t0_40 + (-0.0046318983659148216) * gru_1_out_t0_41 + (-0.42140865325927734) * gru_1_out_t0_42 + (0.16592682898044586) * gru_1_out_t0_43 + (0.78766995668411255) * gru_1_out_t0_44 + (0.33680889010429382) * gru_1_out_t0_45 + (0.11337278783321381) * gru_1_out_t0_46 + (0.83117175102233887) * gru_1_out_t0_47 + (0.84275215864181519) * gru_1_out_t0_48 + (-1.3008768558502197) * gru_1_out_t0_49 + (1.1068893671035767) * gru_1_out_t0_50 + (0.19907830655574799) * gru_1_out_t0_51 + (-1.1841285228729248) * gru_1_out_t0_52 + (-0.39561006426811218) * gru_1_out_t0_53 + (-0.068834610283374786) * gru_1_out_t0_54 + (-0.22703126072883606) * gru_1_out_t0_55 + (-0.16854365170001984) * gru_1_out_t0_56 + (-0.66313433647155762) * gru_1_out_t0_57 + (-0.65600341558456421) * gru_1_out_t0_58 + (0.40982499718666077) * gru_1_out_t0_59 + (0.33726418018341064) * gru_1_out_t0_60 + (0.41010606288909912) * gru_1_out_t0_61 + (-0.16902558505535126) * gru_1_out_t0_62 + (-0.32097172737121582) * gru_1_out_t0_63 + gate_r * (-0.62511301040649414));
    gru_2_fwd_t0_h_9 = (1.0 - gate_z) * gate_n;
    // h=10
    gate_r = sigmoid((0.44536903500556946) + (-0.15248978137969971) * gru_1_out_t0_0 + (0.92094850540161133) * gru_1_out_t0_1 + (-0.98063910007476807) * gru_1_out_t0_2 + (0.5776253342628479) * gru_1_out_t0_3 + (-1.3961191177368164) * gru_1_out_t0_4 + (-0.24139736592769623) * gru_1_out_t0_5 + (-0.63182979822158813) * gru_1_out_t0_6 + (-0.35972502827644348) * gru_1_out_t0_7 + (-0.4462527334690094) * gru_1_out_t0_8 + (-0.34732300043106079) * gru_1_out_t0_9 + (-0.21891233325004578) * gru_1_out_t0_10 + (-1.2111337184906006) * gru_1_out_t0_11 + (0.31912559270858765) * gru_1_out_t0_12 + (0.93710601329803467) * gru_1_out_t0_13 + (0.18243077397346497) * gru_1_out_t0_14 + (1.1565296649932861) * gru_1_out_t0_15 + (0.15809237957000732) * gru_1_out_t0_16 + (0.6617431640625) * gru_1_out_t0_17 + (0.17017355561256409) * gru_1_out_t0_18 + (-0.27918380498886108) * gru_1_out_t0_19 + (0.12361466884613037) * gru_1_out_t0_20 + (-0.48508039116859436) * gru_1_out_t0_21 + (1.208611011505127) * gru_1_out_t0_22 + (-0.54648900032043457) * gru_1_out_t0_23 + (-1.1438624858856201) * gru_1_out_t0_24 + (0.54043018817901611) * gru_1_out_t0_25 + (-0.78726708889007568) * gru_1_out_t0_26 + (-1.315508246421814) * gru_1_out_t0_27 + (0.60852181911468506) * gru_1_out_t0_28 + (0.040603779256343842) * gru_1_out_t0_29 + (-2.5212314128875732) * gru_1_out_t0_30 + (-0.97399181127548218) * gru_1_out_t0_31 + (0.95968502759933472) * gru_1_out_t0_32 + (0.3698577880859375) * gru_1_out_t0_33 + (-0.86713564395904541) * gru_1_out_t0_34 + (0.89397609233856201) * gru_1_out_t0_35 + (-0.34393507242202759) * gru_1_out_t0_36 + (-0.34098154306411743) * gru_1_out_t0_37 + (-0.47595596313476562) * gru_1_out_t0_38 + (-0.0019806693308055401) * gru_1_out_t0_39 + (0.21634963154792786) * gru_1_out_t0_40 + (1.1169687509536743) * gru_1_out_t0_41 + (0.63790333271026611) * gru_1_out_t0_42 + (1.546076774597168) * gru_1_out_t0_43 + (-0.11709080636501312) * gru_1_out_t0_44 + (0.34887036681175232) * gru_1_out_t0_45 + (-0.92307180166244507) * gru_1_out_t0_46 + (0.73388785123825073) * gru_1_out_t0_47 + (0.35861092805862427) * gru_1_out_t0_48 + (-0.39312419295310974) * gru_1_out_t0_49 + (-1.677613377571106) * gru_1_out_t0_50 + (-1.0073592662811279) * gru_1_out_t0_51 + (-0.80260628461837769) * gru_1_out_t0_52 + (-0.14163786172866821) * gru_1_out_t0_53 + (-0.22179156541824341) * gru_1_out_t0_54 + (-0.41148746013641357) * gru_1_out_t0_55 + (-0.79305785894393921) * gru_1_out_t0_56 + (1.0043095350265503) * gru_1_out_t0_57 + (-0.23402369022369385) * gru_1_out_t0_58 + (-0.79154568910598755) * gru_1_out_t0_59 + (-1.0322027206420898) * gru_1_out_t0_60 + (-1.4576647281646729) * gru_1_out_t0_61 + (0.21463465690612793) * gru_1_out_t0_62 + (-0.36339756846427917) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.88238400220870972) + (0.54812383651733398) * gru_1_out_t0_0 + (0.084309190511703491) * gru_1_out_t0_1 + (-0.91612529754638672) * gru_1_out_t0_2 + (0.15114417672157288) * gru_1_out_t0_3 + (-0.41414344310760498) * gru_1_out_t0_4 + (-0.54133445024490356) * gru_1_out_t0_5 + (-0.61206787824630737) * gru_1_out_t0_6 + (-0.81620889902114868) * gru_1_out_t0_7 + (-0.22451880574226379) * gru_1_out_t0_8 + (0.064619705080986023) * gru_1_out_t0_9 + (1.0050715208053589) * gru_1_out_t0_10 + (0.57450103759765625) * gru_1_out_t0_11 + (0.35685262084007263) * gru_1_out_t0_12 + (0.19002583622932434) * gru_1_out_t0_13 + (0.024446228519082069) * gru_1_out_t0_14 + (0.52690279483795166) * gru_1_out_t0_15 + (-0.31265348196029663) * gru_1_out_t0_16 + (0.33025014400482178) * gru_1_out_t0_17 + (-0.083484441041946411) * gru_1_out_t0_18 + (0.5114629864692688) * gru_1_out_t0_19 + (-1.0977698564529419) * gru_1_out_t0_20 + (-1.7362722158432007) * gru_1_out_t0_21 + (0.47086581587791443) * gru_1_out_t0_22 + (-0.74862158298492432) * gru_1_out_t0_23 + (0.064501389861106873) * gru_1_out_t0_24 + (0.28271842002868652) * gru_1_out_t0_25 + (-0.30696329474449158) * gru_1_out_t0_26 + (0.60209017992019653) * gru_1_out_t0_27 + (-0.50003504753112793) * gru_1_out_t0_28 + (0.4604681134223938) * gru_1_out_t0_29 + (0.35494977235794067) * gru_1_out_t0_30 + (-0.74329143762588501) * gru_1_out_t0_31 + (-0.4901297390460968) * gru_1_out_t0_32 + (0.0024981463793665171) * gru_1_out_t0_33 + (-0.44576945900917053) * gru_1_out_t0_34 + (0.38223811984062195) * gru_1_out_t0_35 + (-0.56463086605072021) * gru_1_out_t0_36 + (-0.09386848658323288) * gru_1_out_t0_37 + (0.3850269615650177) * gru_1_out_t0_38 + (-0.61358171701431274) * gru_1_out_t0_39 + (-0.28007173538208008) * gru_1_out_t0_40 + (0.14258691668510437) * gru_1_out_t0_41 + (0.18060921132564545) * gru_1_out_t0_42 + (-0.29128935933113098) * gru_1_out_t0_43 + (-0.81453126668930054) * gru_1_out_t0_44 + (-0.58044469356536865) * gru_1_out_t0_45 + (-0.056896299123764038) * gru_1_out_t0_46 + (1.4222674369812012) * gru_1_out_t0_47 + (0.92971593141555786) * gru_1_out_t0_48 + (0.27866071462631226) * gru_1_out_t0_49 + (-0.27328094840049744) * gru_1_out_t0_50 + (0.16380684077739716) * gru_1_out_t0_51 + (-0.45412525534629822) * gru_1_out_t0_52 + (-0.36207464337348938) * gru_1_out_t0_53 + (0.96603852510452271) * gru_1_out_t0_54 + (0.97490638494491577) * gru_1_out_t0_55 + (-0.29322290420532227) * gru_1_out_t0_56 + (0.13680242002010345) * gru_1_out_t0_57 + (-0.67447847127914429) * gru_1_out_t0_58 + (0.5320127010345459) * gru_1_out_t0_59 + (0.65005010366439819) * gru_1_out_t0_60 + (-0.1081901416182518) * gru_1_out_t0_61 + (1.9185484647750854) * gru_1_out_t0_62 + (-1.0644124746322632) * gru_1_out_t0_63);
    gate_n = tanh((0.35566678643226624) + (0.94106805324554443) * gru_1_out_t0_0 + (-0.066037826240062714) * gru_1_out_t0_1 + (0.24671831727027893) * gru_1_out_t0_2 + (0.145344078540802) * gru_1_out_t0_3 + (-0.15700626373291016) * gru_1_out_t0_4 + (0.3973090648651123) * gru_1_out_t0_5 + (-1.2051212787628174) * gru_1_out_t0_6 + (-0.11817455291748047) * gru_1_out_t0_7 + (0.54677766561508179) * gru_1_out_t0_8 + (-0.33398649096488953) * gru_1_out_t0_9 + (-0.75343042612075806) * gru_1_out_t0_10 + (-0.42171290516853333) * gru_1_out_t0_11 + (0.26459354162216187) * gru_1_out_t0_12 + (0.16092820465564728) * gru_1_out_t0_13 + (-0.42130136489868164) * gru_1_out_t0_14 + (0.14636470377445221) * gru_1_out_t0_15 + (0.5872846245765686) * gru_1_out_t0_16 + (-0.45223715901374817) * gru_1_out_t0_17 + (0.27623280882835388) * gru_1_out_t0_18 + (0.35441708564758301) * gru_1_out_t0_19 + (-0.025506824254989624) * gru_1_out_t0_20 + (0.69608736038208008) * gru_1_out_t0_21 + (-0.083216339349746704) * gru_1_out_t0_22 + (0.30782043933868408) * gru_1_out_t0_23 + (-0.18888427317142487) * gru_1_out_t0_24 + (0.54519766569137573) * gru_1_out_t0_25 + (-0.33170685172080994) * gru_1_out_t0_26 + (-0.78278219699859619) * gru_1_out_t0_27 + (0.56635093688964844) * gru_1_out_t0_28 + (0.1023222953081131) * gru_1_out_t0_29 + (0.046122174710035324) * gru_1_out_t0_30 + (-0.73408049345016479) * gru_1_out_t0_31 + (-0.065085716545581818) * gru_1_out_t0_32 + (-0.037244178354740143) * gru_1_out_t0_33 + (0.17389422655105591) * gru_1_out_t0_34 + (-0.079805254936218262) * gru_1_out_t0_35 + (0.17589746415615082) * gru_1_out_t0_36 + (0.2332797646522522) * gru_1_out_t0_37 + (0.52086710929870605) * gru_1_out_t0_38 + (0.54039144515991211) * gru_1_out_t0_39 + (-0.028402138501405716) * gru_1_out_t0_40 + (-0.68552398681640625) * gru_1_out_t0_41 + (0.20650230348110199) * gru_1_out_t0_42 + (-0.089282922446727753) * gru_1_out_t0_43 + (0.19378629326820374) * gru_1_out_t0_44 + (0.55057907104492188) * gru_1_out_t0_45 + (0.18966677784919739) * gru_1_out_t0_46 + (0.14235572516918182) * gru_1_out_t0_47 + (0.46433690190315247) * gru_1_out_t0_48 + (0.35699918866157532) * gru_1_out_t0_49 + (0.11929582059383392) * gru_1_out_t0_50 + (0.16253997385501862) * gru_1_out_t0_51 + (-0.81926834583282471) * gru_1_out_t0_52 + (0.068933933973312378) * gru_1_out_t0_53 + (-0.18813998997211456) * gru_1_out_t0_54 + (0.43585476279258728) * gru_1_out_t0_55 + (-0.097333721816539764) * gru_1_out_t0_56 + (0.019198009744286537) * gru_1_out_t0_57 + (-0.11591122299432755) * gru_1_out_t0_58 + (0.17620737850666046) * gru_1_out_t0_59 + (-0.23682054877281189) * gru_1_out_t0_60 + (-0.21652029454708099) * gru_1_out_t0_61 + (-0.68645107746124268) * gru_1_out_t0_62 + (0.014901396818459034) * gru_1_out_t0_63 + gate_r * (0.9399944543838501));
    gru_2_fwd_t0_h_10 = (1.0 - gate_z) * gate_n;
    // h=11
    gate_r = sigmoid((0.71028310060501099) + (-0.83996015787124634) * gru_1_out_t0_0 + (1.5419596433639526) * gru_1_out_t0_1 + (-0.96208059787750244) * gru_1_out_t0_2 + (-0.054532419890165329) * gru_1_out_t0_3 + (-0.26417332887649536) * gru_1_out_t0_4 + (-1.5139000415802002) * gru_1_out_t0_5 + (0.18807902932167053) * gru_1_out_t0_6 + (-0.47800993919372559) * gru_1_out_t0_7 + (0.21385866403579712) * gru_1_out_t0_8 + (1.2038860321044922) * gru_1_out_t0_9 + (-0.32816877961158752) * gru_1_out_t0_10 + (-0.58010858297348022) * gru_1_out_t0_11 + (0.0021395066287368536) * gru_1_out_t0_12 + (0.56034433841705322) * gru_1_out_t0_13 + (0.95709019899368286) * gru_1_out_t0_14 + (0.20203155279159546) * gru_1_out_t0_15 + (1.0667481422424316) * gru_1_out_t0_16 + (-0.57491368055343628) * gru_1_out_t0_17 + (1.2813822031021118) * gru_1_out_t0_18 + (-0.45364183187484741) * gru_1_out_t0_19 + (-0.17162497341632843) * gru_1_out_t0_20 + (0.055248130112886429) * gru_1_out_t0_21 + (-0.21997605264186859) * gru_1_out_t0_22 + (-2.344430685043335) * gru_1_out_t0_23 + (-1.2996143102645874) * gru_1_out_t0_24 + (-0.33946925401687622) * gru_1_out_t0_25 + (-0.49170005321502686) * gru_1_out_t0_26 + (1.4311840534210205) * gru_1_out_t0_27 + (-3.148322582244873) * gru_1_out_t0_28 + (-0.69096815586090088) * gru_1_out_t0_29 + (1.2870415449142456) * gru_1_out_t0_30 + (-0.45125603675842285) * gru_1_out_t0_31 + (0.59137845039367676) * gru_1_out_t0_32 + (-0.90605807304382324) * gru_1_out_t0_33 + (-1.218586802482605) * gru_1_out_t0_34 + (0.29383832216262817) * gru_1_out_t0_35 + (-0.94658523797988892) * gru_1_out_t0_36 + (-0.27812725305557251) * gru_1_out_t0_37 + (-0.42589494585990906) * gru_1_out_t0_38 + (-0.18495330214500427) * gru_1_out_t0_39 + (-0.62374496459960938) * gru_1_out_t0_40 + (-0.15251928567886353) * gru_1_out_t0_41 + (0.12462680786848068) * gru_1_out_t0_42 + (-1.5815494060516357) * gru_1_out_t0_43 + (-0.42662155628204346) * gru_1_out_t0_44 + (-2.3648474216461182) * gru_1_out_t0_45 + (0.21347709000110626) * gru_1_out_t0_46 + (-0.97115224599838257) * gru_1_out_t0_47 + (1.8645026683807373) * gru_1_out_t0_48 + (1.5548909902572632) * gru_1_out_t0_49 + (-0.75367039442062378) * gru_1_out_t0_50 + (-0.83520799875259399) * gru_1_out_t0_51 + (1.0573383569717407) * gru_1_out_t0_52 + (0.62131202220916748) * gru_1_out_t0_53 + (-0.67312783002853394) * gru_1_out_t0_54 + (0.75321972370147705) * gru_1_out_t0_55 + (0.68122094869613647) * gru_1_out_t0_56 + (0.83286255598068237) * gru_1_out_t0_57 + (0.56078672409057617) * gru_1_out_t0_58 + (-0.27470174431800842) * gru_1_out_t0_59 + (-0.73646223545074463) * gru_1_out_t0_60 + (0.74550455808639526) * gru_1_out_t0_61 + (-0.59570944309234619) * gru_1_out_t0_62 + (0.2224527895450592) * gru_1_out_t0_63);
    gate_z = sigmoid((0.73565912246704102) + (0.26593995094299316) * gru_1_out_t0_0 + (0.28301367163658142) * gru_1_out_t0_1 + (0.2748180627822876) * gru_1_out_t0_2 + (0.12277515232563019) * gru_1_out_t0_3 + (-0.46206530928611755) * gru_1_out_t0_4 + (0.27133607864379883) * gru_1_out_t0_5 + (0.79030650854110718) * gru_1_out_t0_6 + (0.17061728239059448) * gru_1_out_t0_7 + (0.91447573900222778) * gru_1_out_t0_8 + (-0.17776878178119659) * gru_1_out_t0_9 + (-0.24259807169437408) * gru_1_out_t0_10 + (-0.26630765199661255) * gru_1_out_t0_11 + (-0.021615404635667801) * gru_1_out_t0_12 + (0.561920166015625) * gru_1_out_t0_13 + (-0.092182137072086334) * gru_1_out_t0_14 + (-0.71178197860717773) * gru_1_out_t0_15 + (0.098088458180427551) * gru_1_out_t0_16 + (0.13264790177345276) * gru_1_out_t0_17 + (0.013573003932833672) * gru_1_out_t0_18 + (-0.13946543633937836) * gru_1_out_t0_19 + (0.44717216491699219) * gru_1_out_t0_20 + (-0.087236933410167694) * gru_1_out_t0_21 + (0.24030435085296631) * gru_1_out_t0_22 + (0.02089337445795536) * gru_1_out_t0_23 + (1.2692074775695801) * gru_1_out_t0_24 + (0.074585273861885071) * gru_1_out_t0_25 + (-0.54299432039260864) * gru_1_out_t0_26 + (0.51531338691711426) * gru_1_out_t0_27 + (-0.41715079545974731) * gru_1_out_t0_28 + (0.21265485882759094) * gru_1_out_t0_29 + (-0.21530379354953766) * gru_1_out_t0_30 + (0.095630176365375519) * gru_1_out_t0_31 + (-0.18261751532554626) * gru_1_out_t0_32 + (-0.32730227708816528) * gru_1_out_t0_33 + (0.41703435778617859) * gru_1_out_t0_34 + (-0.083711452782154083) * gru_1_out_t0_35 + (0.55411499738693237) * gru_1_out_t0_36 + (0.26425608992576599) * gru_1_out_t0_37 + (0.13559646904468536) * gru_1_out_t0_38 + (0.094243183732032776) * gru_1_out_t0_39 + (0.073382675647735596) * gru_1_out_t0_40 + (-0.007708392571657896) * gru_1_out_t0_41 + (-0.18327382206916809) * gru_1_out_t0_42 + (-0.085040457546710968) * gru_1_out_t0_43 + (1.4355136156082153) * gru_1_out_t0_44 + (0.0088088121265172958) * gru_1_out_t0_45 + (0.10632161796092987) * gru_1_out_t0_46 + (-0.44252419471740723) * gru_1_out_t0_47 + (0.095471382141113281) * gru_1_out_t0_48 + (-0.59066635370254517) * gru_1_out_t0_49 + (-0.12557344138622284) * gru_1_out_t0_50 + (0.96079212427139282) * gru_1_out_t0_51 + (0.11721780151128769) * gru_1_out_t0_52 + (0.5942961573600769) * gru_1_out_t0_53 + (-0.95836359262466431) * gru_1_out_t0_54 + (0.10378184169530869) * gru_1_out_t0_55 + (-0.15621998906135559) * gru_1_out_t0_56 + (-0.11517500132322311) * gru_1_out_t0_57 + (0.098687276244163513) * gru_1_out_t0_58 + (-0.11182619631290436) * gru_1_out_t0_59 + (-0.020097123458981514) * gru_1_out_t0_60 + (0.12254822254180908) * gru_1_out_t0_61 + (-0.076486557722091675) * gru_1_out_t0_62 + (0.15851952135562897) * gru_1_out_t0_63);
    gate_n = tanh((-0.14023476839065552) + (0.058073867112398148) * gru_1_out_t0_0 + (0.70706421136856079) * gru_1_out_t0_1 + (-0.19553154706954956) * gru_1_out_t0_2 + (0.46549299359321594) * gru_1_out_t0_3 + (0.30654379725456238) * gru_1_out_t0_4 + (0.81120693683624268) * gru_1_out_t0_5 + (0.92728346586227417) * gru_1_out_t0_6 + (-0.18344761431217194) * gru_1_out_t0_7 + (1.1044149398803711) * gru_1_out_t0_8 + (-0.13537603616714478) * gru_1_out_t0_9 + (0.34179496765136719) * gru_1_out_t0_10 + (1.5467379093170166) * gru_1_out_t0_11 + (-0.053349196910858154) * gru_1_out_t0_12 + (-0.18914373219013214) * gru_1_out_t0_13 + (1.5539519786834717) * gru_1_out_t0_14 + (0.47488477826118469) * gru_1_out_t0_15 + (-0.52079653739929199) * gru_1_out_t0_16 + (0.72775042057037354) * gru_1_out_t0_17 + (-0.16225852072238922) * gru_1_out_t0_18 + (-0.16197341680526733) * gru_1_out_t0_19 + (0.1226925328373909) * gru_1_out_t0_20 + (-0.086470738053321838) * gru_1_out_t0_21 + (0.37024402618408203) * gru_1_out_t0_22 + (-1.5784671306610107) * gru_1_out_t0_23 + (0.011948865838348866) * gru_1_out_t0_24 + (-0.1413331925868988) * gru_1_out_t0_25 + (-0.24740421772003174) * gru_1_out_t0_26 + (0.46115055680274963) * gru_1_out_t0_27 + (0.51180166006088257) * gru_1_out_t0_28 + (0.69201815128326416) * gru_1_out_t0_29 + (0.088272146880626678) * gru_1_out_t0_30 + (0.34620165824890137) * gru_1_out_t0_31 + (0.48045808076858521) * gru_1_out_t0_32 + (0.35436505079269409) * gru_1_out_t0_33 + (-0.34909811615943909) * gru_1_out_t0_34 + (1.3249396085739136) * gru_1_out_t0_35 + (0.4026930034160614) * gru_1_out_t0_36 + (0.097475104033946991) * gru_1_out_t0_37 + (-0.74467146396636963) * gru_1_out_t0_38 + (0.097402691841125488) * gru_1_out_t0_39 + (-0.43768754601478577) * gru_1_out_t0_40 + (-0.72482675313949585) * gru_1_out_t0_41 + (-0.22686120867729187) * gru_1_out_t0_42 + (-1.1801185607910156) * gru_1_out_t0_43 + (0.28824687004089355) * gru_1_out_t0_44 + (0.85371267795562744) * gru_1_out_t0_45 + (-0.017333131283521652) * gru_1_out_t0_46 + (0.66903722286224365) * gru_1_out_t0_47 + (0.44529411196708679) * gru_1_out_t0_48 + (0.048261910676956177) * gru_1_out_t0_49 + (1.0577747821807861) * gru_1_out_t0_50 + (0.12862180173397064) * gru_1_out_t0_51 + (-0.4780285656452179) * gru_1_out_t0_52 + (0.49589827656745911) * gru_1_out_t0_53 + (-0.87748497724533081) * gru_1_out_t0_54 + (-0.37231689691543579) * gru_1_out_t0_55 + (-0.69035500288009644) * gru_1_out_t0_56 + (0.48057383298873901) * gru_1_out_t0_57 + (0.54685330390930176) * gru_1_out_t0_58 + (-0.99246877431869507) * gru_1_out_t0_59 + (1.2096695899963379) * gru_1_out_t0_60 + (0.69128912687301636) * gru_1_out_t0_61 + (0.22728896141052246) * gru_1_out_t0_62 + (-0.066954329609870911) * gru_1_out_t0_63 + gate_r * (0.33495897054672241));
    gru_2_fwd_t0_h_11 = (1.0 - gate_z) * gate_n;
    // h=12
    gate_r = sigmoid((0.16944818198680878) + (-0.12486344575881958) * gru_1_out_t0_0 + (-0.39577034115791321) * gru_1_out_t0_1 + (-0.01969623751938343) * gru_1_out_t0_2 + (-1.1788871288299561) * gru_1_out_t0_3 + (1.9825429916381836) * gru_1_out_t0_4 + (-0.56212025880813599) * gru_1_out_t0_5 + (-0.17878864705562592) * gru_1_out_t0_6 + (0.065333619713783264) * gru_1_out_t0_7 + (0.19333800673484802) * gru_1_out_t0_8 + (0.40821775794029236) * gru_1_out_t0_9 + (0.21370121836662292) * gru_1_out_t0_10 + (0.25890830159187317) * gru_1_out_t0_11 + (-1.0001566410064697) * gru_1_out_t0_12 + (-0.3463628888130188) * gru_1_out_t0_13 + (-0.8949323296546936) * gru_1_out_t0_14 + (0.018693855032324791) * gru_1_out_t0_15 + (0.6659361720085144) * gru_1_out_t0_16 + (0.21315869688987732) * gru_1_out_t0_17 + (-0.39742454886436462) * gru_1_out_t0_18 + (-0.062339514493942261) * gru_1_out_t0_19 + (-0.088531464338302612) * gru_1_out_t0_20 + (2.2655074596405029) * gru_1_out_t0_21 + (-0.040691744536161423) * gru_1_out_t0_22 + (-1.2116712331771851) * gru_1_out_t0_23 + (-2.2831156253814697) * gru_1_out_t0_24 + (-1.3653132915496826) * gru_1_out_t0_25 + (2.1884491443634033) * gru_1_out_t0_26 + (0.83096086978912354) * gru_1_out_t0_27 + (-0.7224200963973999) * gru_1_out_t0_28 + (-0.16125762462615967) * gru_1_out_t0_29 + (-2.0918986797332764) * gru_1_out_t0_30 + (-0.29180845618247986) * gru_1_out_t0_31 + (-0.45749121904373169) * gru_1_out_t0_32 + (0.064095199108123779) * gru_1_out_t0_33 + (-0.9104352593421936) * gru_1_out_t0_34 + (0.29645594954490662) * gru_1_out_t0_35 + (-0.77248489856719971) * gru_1_out_t0_36 + (0.15088008344173431) * gru_1_out_t0_37 + (0.20478323101997375) * gru_1_out_t0_38 + (0.27986016869544983) * gru_1_out_t0_39 + (-0.91094493865966797) * gru_1_out_t0_40 + (-0.84689486026763916) * gru_1_out_t0_41 + (0.24468572437763214) * gru_1_out_t0_42 + (0.41699951887130737) * gru_1_out_t0_43 + (-1.9613479375839233) * gru_1_out_t0_44 + (0.60784876346588135) * gru_1_out_t0_45 + (-0.48926475644111633) * gru_1_out_t0_46 + (-0.22175435721874237) * gru_1_out_t0_47 + (1.7299975156784058) * gru_1_out_t0_48 + (0.83812934160232544) * gru_1_out_t0_49 + (0.23894590139389038) * gru_1_out_t0_50 + (0.52884012460708618) * gru_1_out_t0_51 + (0.86915493011474609) * gru_1_out_t0_52 + (-0.84197431802749634) * gru_1_out_t0_53 + (1.1738929748535156) * gru_1_out_t0_54 + (0.81961363554000854) * gru_1_out_t0_55 + (-0.354066401720047) * gru_1_out_t0_56 + (-0.12924318015575409) * gru_1_out_t0_57 + (0.60333359241485596) * gru_1_out_t0_58 + (0.31821498274803162) * gru_1_out_t0_59 + (-1.0185444355010986) * gru_1_out_t0_60 + (-0.099782928824424744) * gru_1_out_t0_61 + (0.22052285075187683) * gru_1_out_t0_62 + (0.17596466839313507) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.57786369323730469) + (-0.60864448547363281) * gru_1_out_t0_0 + (-0.017517786473035812) * gru_1_out_t0_1 + (-0.82356137037277222) * gru_1_out_t0_2 + (-0.18064939975738525) * gru_1_out_t0_3 + (-0.22550281882286072) * gru_1_out_t0_4 + (0.069524630904197693) * gru_1_out_t0_5 + (2.1962754726409912) * gru_1_out_t0_6 + (0.15070310235023499) * gru_1_out_t0_7 + (0.014049737714231014) * gru_1_out_t0_8 + (-0.011441241018474102) * gru_1_out_t0_9 + (-1.0584559440612793) * gru_1_out_t0_10 + (-0.23150518536567688) * gru_1_out_t0_11 + (0.45249152183532715) * gru_1_out_t0_12 + (-0.10931191593408585) * gru_1_out_t0_13 + (-0.13492612540721893) * gru_1_out_t0_14 + (0.17500287294387817) * gru_1_out_t0_15 + (0.59077572822570801) * gru_1_out_t0_16 + (-0.70482563972473145) * gru_1_out_t0_17 + (-0.27810665965080261) * gru_1_out_t0_18 + (0.25267183780670166) * gru_1_out_t0_19 + (-0.38585171103477478) * gru_1_out_t0_20 + (-0.8814551830291748) * gru_1_out_t0_21 + (0.98714715242385864) * gru_1_out_t0_22 + (-0.77360385656356812) * gru_1_out_t0_23 + (-0.50132650136947632) * gru_1_out_t0_24 + (-1.0730962753295898) * gru_1_out_t0_25 + (-0.51046669483184814) * gru_1_out_t0_26 + (-0.29229408502578735) * gru_1_out_t0_27 + (-0.41826218366622925) * gru_1_out_t0_28 + (-0.62948566675186157) * gru_1_out_t0_29 + (0.20202898979187012) * gru_1_out_t0_30 + (-0.26992246508598328) * gru_1_out_t0_31 + (0.65060925483703613) * gru_1_out_t0_32 + (-0.95093011856079102) * gru_1_out_t0_33 + (0.37174814939498901) * gru_1_out_t0_34 + (-0.26865768432617188) * gru_1_out_t0_35 + (0.23131240904331207) * gru_1_out_t0_36 + (-0.41164043545722961) * gru_1_out_t0_37 + (0.15115579962730408) * gru_1_out_t0_38 + (0.094592176377773285) * gru_1_out_t0_39 + (0.84358417987823486) * gru_1_out_t0_40 + (0.33718061447143555) * gru_1_out_t0_41 + (-0.23821233212947845) * gru_1_out_t0_42 + (-0.084829315543174744) * gru_1_out_t0_43 + (0.60788112878799438) * gru_1_out_t0_44 + (-0.36908531188964844) * gru_1_out_t0_45 + (0.24948056042194366) * gru_1_out_t0_46 + (-0.82072854042053223) * gru_1_out_t0_47 + (0.3065912127494812) * gru_1_out_t0_48 + (-0.43936115503311157) * gru_1_out_t0_49 + (0.14315697550773621) * gru_1_out_t0_50 + (1.0350942611694336) * gru_1_out_t0_51 + (0.096012115478515625) * gru_1_out_t0_52 + (-0.086434409022331238) * gru_1_out_t0_53 + (-0.28666988015174866) * gru_1_out_t0_54 + (0.21033938229084015) * gru_1_out_t0_55 + (0.99119830131530762) * gru_1_out_t0_56 + (-0.45626047253608704) * gru_1_out_t0_57 + (0.01981942355632782) * gru_1_out_t0_58 + (-0.22449560463428497) * gru_1_out_t0_59 + (0.80450272560119629) * gru_1_out_t0_60 + (0.44981980323791504) * gru_1_out_t0_61 + (-0.35846447944641113) * gru_1_out_t0_62 + (-0.35080140829086304) * gru_1_out_t0_63);
    gate_n = tanh((-0.29970332980155945) + (-0.44496503472328186) * gru_1_out_t0_0 + (-0.0005186786875128746) * gru_1_out_t0_1 + (-0.48829889297485352) * gru_1_out_t0_2 + (-0.1639300137758255) * gru_1_out_t0_3 + (-1.1259713172912598) * gru_1_out_t0_4 + (0.22130830585956573) * gru_1_out_t0_5 + (-0.021031465381383896) * gru_1_out_t0_6 + (-0.64112013578414917) * gru_1_out_t0_7 + (-0.44724154472351074) * gru_1_out_t0_8 + (0.5440903902053833) * gru_1_out_t0_9 + (-0.1784345805644989) * gru_1_out_t0_10 + (-0.10796526074409485) * gru_1_out_t0_11 + (0.65705198049545288) * gru_1_out_t0_12 + (-0.079550959169864655) * gru_1_out_t0_13 + (0.21311438083648682) * gru_1_out_t0_14 + (0.40743371844291687) * gru_1_out_t0_15 + (0.40913146734237671) * gru_1_out_t0_16 + (-0.1480453759431839) * gru_1_out_t0_17 + (-0.42454320192337036) * gru_1_out_t0_18 + (-0.36511766910552979) * gru_1_out_t0_19 + (-0.49843883514404297) * gru_1_out_t0_20 + (-0.33435735106468201) * gru_1_out_t0_21 + (-0.56484413146972656) * gru_1_out_t0_22 + (0.15568198263645172) * gru_1_out_t0_23 + (-0.55973106622695923) * gru_1_out_t0_24 + (-0.4586336612701416) * gru_1_out_t0_25 + (0.22200039029121399) * gru_1_out_t0_26 + (-0.27939838171005249) * gru_1_out_t0_27 + (-0.38253003358840942) * gru_1_out_t0_28 + (0.013186918571591377) * gru_1_out_t0_29 + (0.54752540588378906) * gru_1_out_t0_30 + (0.065439067780971527) * gru_1_out_t0_31 + (-0.53140830993652344) * gru_1_out_t0_32 + (-0.27809426188468933) * gru_1_out_t0_33 + (-0.46909552812576294) * gru_1_out_t0_34 + (-0.019086932763457298) * gru_1_out_t0_35 + (0.3334602415561676) * gru_1_out_t0_36 + (0.2777235209941864) * gru_1_out_t0_37 + (-0.078772246837615967) * gru_1_out_t0_38 + (0.93463265895843506) * gru_1_out_t0_39 + (0.37432646751403809) * gru_1_out_t0_40 + (-0.34424552321434021) * gru_1_out_t0_41 + (0.54839217662811279) * gru_1_out_t0_42 + (0.36816906929016113) * gru_1_out_t0_43 + (-0.055137209594249725) * gru_1_out_t0_44 + (0.14570610225200653) * gru_1_out_t0_45 + (0.12467057257890701) * gru_1_out_t0_46 + (-1.2442675828933716) * gru_1_out_t0_47 + (-0.10150041431188583) * gru_1_out_t0_48 + (0.06904572993516922) * gru_1_out_t0_49 + (0.46346005797386169) * gru_1_out_t0_50 + (0.41625890135765076) * gru_1_out_t0_51 + (0.14457127451896667) * gru_1_out_t0_52 + (0.24122712016105652) * gru_1_out_t0_53 + (-0.17262168228626251) * gru_1_out_t0_54 + (0.032582052052021027) * gru_1_out_t0_55 + (0.22182133793830872) * gru_1_out_t0_56 + (-0.24559138715267181) * gru_1_out_t0_57 + (0.43298283219337463) * gru_1_out_t0_58 + (-0.82850897312164307) * gru_1_out_t0_59 + (-0.2982783317565918) * gru_1_out_t0_60 + (-0.053848475217819214) * gru_1_out_t0_61 + (-0.24340607225894928) * gru_1_out_t0_62 + (-1.0994828939437866) * gru_1_out_t0_63 + gate_r * (-0.60516649484634399));
    gru_2_fwd_t0_h_12 = (1.0 - gate_z) * gate_n;
    // h=13
    gate_r = sigmoid((0.58357876539230347) + (1.1281019449234009) * gru_1_out_t0_0 + (-4.3545136451721191) * gru_1_out_t0_1 + (-0.028746830299496651) * gru_1_out_t0_2 + (-1.4622278213500977) * gru_1_out_t0_3 + (1.0358291864395142) * gru_1_out_t0_4 + (0.085302330553531647) * gru_1_out_t0_5 + (-2.3746373653411865) * gru_1_out_t0_6 + (0.042948536574840546) * gru_1_out_t0_7 + (-0.65025204420089722) * gru_1_out_t0_8 + (0.13461531698703766) * gru_1_out_t0_9 + (1.1833635568618774) * gru_1_out_t0_10 + (-0.047106128185987473) * gru_1_out_t0_11 + (-0.65092867612838745) * gru_1_out_t0_12 + (0.71844297647476196) * gru_1_out_t0_13 + (-0.69646787643432617) * gru_1_out_t0_14 + (0.8043675422668457) * gru_1_out_t0_15 + (-0.015815131366252899) * gru_1_out_t0_16 + (-0.039989586919546127) * gru_1_out_t0_17 + (1.6538022756576538) * gru_1_out_t0_18 + (-0.46865123510360718) * gru_1_out_t0_19 + (-0.054507546126842499) * gru_1_out_t0_20 + (1.846894383430481) * gru_1_out_t0_21 + (-1.2045470476150513) * gru_1_out_t0_22 + (0.56519848108291626) * gru_1_out_t0_23 + (0.076363563537597656) * gru_1_out_t0_24 + (1.1889606714248657) * gru_1_out_t0_25 + (-0.58372193574905396) * gru_1_out_t0_26 + (-0.60534626245498657) * gru_1_out_t0_27 + (0.91214346885681152) * gru_1_out_t0_28 + (-0.31178292632102966) * gru_1_out_t0_29 + (-2.7099626064300537) * gru_1_out_t0_30 + (3.3020329475402832) * gru_1_out_t0_31 + (1.6349533796310425) * gru_1_out_t0_32 + (0.28871718049049377) * gru_1_out_t0_33 + (-0.26864612102508545) * gru_1_out_t0_34 + (-0.035945907235145569) * gru_1_out_t0_35 + (1.0172573328018188) * gru_1_out_t0_36 + (0.2415238618850708) * gru_1_out_t0_37 + (-0.63226383924484253) * gru_1_out_t0_38 + (-0.021328158676624298) * gru_1_out_t0_39 + (1.1333166360855103) * gru_1_out_t0_40 + (0.91912311315536499) * gru_1_out_t0_41 + (0.16389310359954834) * gru_1_out_t0_42 + (-0.97838801145553589) * gru_1_out_t0_43 + (-1.6217736005783081) * gru_1_out_t0_44 + (-1.0375542640686035) * gru_1_out_t0_45 + (0.34061920642852783) * gru_1_out_t0_46 + (-0.26960462331771851) * gru_1_out_t0_47 + (1.2321298122406006) * gru_1_out_t0_48 + (0.27740246057510376) * gru_1_out_t0_49 + (0.26954036951065063) * gru_1_out_t0_50 + (-1.0854111909866333) * gru_1_out_t0_51 + (0.49599489569664001) * gru_1_out_t0_52 + (-0.26682591438293457) * gru_1_out_t0_53 + (-1.1858416795730591) * gru_1_out_t0_54 + (-0.63467973470687866) * gru_1_out_t0_55 + (0.34969666600227356) * gru_1_out_t0_56 + (0.17027886211872101) * gru_1_out_t0_57 + (-0.50631201267242432) * gru_1_out_t0_58 + (0.69311511516571045) * gru_1_out_t0_59 + (-3.2410986423492432) * gru_1_out_t0_60 + (0.4111352264881134) * gru_1_out_t0_61 + (-0.76168477535247803) * gru_1_out_t0_62 + (0.64697265625) * gru_1_out_t0_63);
    gate_z = sigmoid((2.3440382480621338) + (0.7941243052482605) * gru_1_out_t0_0 + (-0.66928517818450928) * gru_1_out_t0_1 + (-0.65344846248626709) * gru_1_out_t0_2 + (0.99833381175994873) * gru_1_out_t0_3 + (0.4059087336063385) * gru_1_out_t0_4 + (0.31285414099693298) * gru_1_out_t0_5 + (0.060495432466268539) * gru_1_out_t0_6 + (0.21695375442504883) * gru_1_out_t0_7 + (-0.24969978630542755) * gru_1_out_t0_8 + (-0.20102301239967346) * gru_1_out_t0_9 + (0.67921507358551025) * gru_1_out_t0_10 + (0.86142796277999878) * gru_1_out_t0_11 + (0.024288145825266838) * gru_1_out_t0_12 + (0.61233413219451904) * gru_1_out_t0_13 + (0.63706952333450317) * gru_1_out_t0_14 + (0.57511115074157715) * gru_1_out_t0_15 + (0.61346167325973511) * gru_1_out_t0_16 + (-0.23942200839519501) * gru_1_out_t0_17 + (0.78175461292266846) * gru_1_out_t0_18 + (-1.5223969221115112) * gru_1_out_t0_19 + (-0.89622026681900024) * gru_1_out_t0_20 + (0.58509862422943115) * gru_1_out_t0_21 + (-1.9178315401077271) * gru_1_out_t0_22 + (-0.37459582090377808) * gru_1_out_t0_23 + (0.58132565021514893) * gru_1_out_t0_24 + (0.29683622717857361) * gru_1_out_t0_25 + (0.33866101503372192) * gru_1_out_t0_26 + (0.13932916522026062) * gru_1_out_t0_27 + (0.082974612712860107) * gru_1_out_t0_28 + (-0.41129359602928162) * gru_1_out_t0_29 + (-0.17147199809551239) * gru_1_out_t0_30 + (0.077110446989536285) * gru_1_out_t0_31 + (-0.0060683977790176868) * gru_1_out_t0_32 + (-0.17414176464080811) * gru_1_out_t0_33 + (-0.010814065113663673) * gru_1_out_t0_34 + (-0.074156299233436584) * gru_1_out_t0_35 + (-0.085169285535812378) * gru_1_out_t0_36 + (0.40667077898979187) * gru_1_out_t0_37 + (-0.13684412837028503) * gru_1_out_t0_38 + (-0.045399866998195648) * gru_1_out_t0_39 + (-0.075841836631298065) * gru_1_out_t0_40 + (0.35185173153877258) * gru_1_out_t0_41 + (0.074312120676040649) * gru_1_out_t0_42 + (-0.15621732175350189) * gru_1_out_t0_43 + (0.12405303865671158) * gru_1_out_t0_44 + (0.17935959994792938) * gru_1_out_t0_45 + (0.2023332267999649) * gru_1_out_t0_46 + (-0.66039204597473145) * gru_1_out_t0_47 + (-0.099667035043239594) * gru_1_out_t0_48 + (-1.0546422004699707) * gru_1_out_t0_49 + (0.4203721284866333) * gru_1_out_t0_50 + (-0.072544008493423462) * gru_1_out_t0_51 + (0.51997613906860352) * gru_1_out_t0_52 + (0.019310932606458664) * gru_1_out_t0_53 + (0.24334980547428131) * gru_1_out_t0_54 + (0.028162442147731781) * gru_1_out_t0_55 + (0.35136678814888) * gru_1_out_t0_56 + (0.0016895328881219029) * gru_1_out_t0_57 + (0.32972878217697144) * gru_1_out_t0_58 + (0.10589949786663055) * gru_1_out_t0_59 + (-0.38969123363494873) * gru_1_out_t0_60 + (0.13938790559768677) * gru_1_out_t0_61 + (0.81767535209655762) * gru_1_out_t0_62 + (0.32526087760925293) * gru_1_out_t0_63);
    gate_n = tanh((0.46342349052429199) + (0.26516634225845337) * gru_1_out_t0_0 + (1.8463733196258545) * gru_1_out_t0_1 + (0.15156488120555878) * gru_1_out_t0_2 + (0.086181998252868652) * gru_1_out_t0_3 + (-1.3136317729949951) * gru_1_out_t0_4 + (0.54682731628417969) * gru_1_out_t0_5 + (-0.62087732553482056) * gru_1_out_t0_6 + (0.076718270778656006) * gru_1_out_t0_7 + (-0.48709267377853394) * gru_1_out_t0_8 + (0.21047528088092804) * gru_1_out_t0_9 + (-1.1409760713577271) * gru_1_out_t0_10 + (-0.66302108764648438) * gru_1_out_t0_11 + (0.0011276218574494123) * gru_1_out_t0_12 + (0.64898586273193359) * gru_1_out_t0_13 + (-0.05031174048781395) * gru_1_out_t0_14 + (0.058718264102935791) * gru_1_out_t0_15 + (-0.48503977060317993) * gru_1_out_t0_16 + (-1.1007044315338135) * gru_1_out_t0_17 + (-1.7090333700180054) * gru_1_out_t0_18 + (0.91622114181518555) * gru_1_out_t0_19 + (0.41768369078636169) * gru_1_out_t0_20 + (-0.84451639652252197) * gru_1_out_t0_21 + (-0.2069636732339859) * gru_1_out_t0_22 + (0.1722533255815506) * gru_1_out_t0_23 + (1.1315822601318359) * gru_1_out_t0_24 + (-1.1866620779037476) * gru_1_out_t0_25 + (-0.25504264235496521) * gru_1_out_t0_26 + (-0.72916257381439209) * gru_1_out_t0_27 + (0.58248788118362427) * gru_1_out_t0_28 + (-0.43827703595161438) * gru_1_out_t0_29 + (-0.38158699870109558) * gru_1_out_t0_30 + (-1.4783724546432495) * gru_1_out_t0_31 + (-0.43459323048591614) * gru_1_out_t0_32 + (0.031790439039468765) * gru_1_out_t0_33 + (-0.30355739593505859) * gru_1_out_t0_34 + (-0.058721300214529037) * gru_1_out_t0_35 + (-0.19545979797840118) * gru_1_out_t0_36 + (0.090653561055660248) * gru_1_out_t0_37 + (-0.1964404284954071) * gru_1_out_t0_38 + (0.16292805969715118) * gru_1_out_t0_39 + (-0.045594815164804459) * gru_1_out_t0_40 + (-0.0021998565644025803) * gru_1_out_t0_41 + (-0.030373634770512581) * gru_1_out_t0_42 + (1.853370189666748) * gru_1_out_t0_43 + (0.71527975797653198) * gru_1_out_t0_44 + (-0.066338703036308289) * gru_1_out_t0_45 + (-0.56568241119384766) * gru_1_out_t0_46 + (0.062515199184417725) * gru_1_out_t0_47 + (-0.8251081109046936) * gru_1_out_t0_48 + (0.2407473623752594) * gru_1_out_t0_49 + (-0.9809688925743103) * gru_1_out_t0_50 + (0.59228110313415527) * gru_1_out_t0_51 + (0.097626097500324249) * gru_1_out_t0_52 + (0.20746088027954102) * gru_1_out_t0_53 + (1.3023968935012817) * gru_1_out_t0_54 + (-0.049411233514547348) * gru_1_out_t0_55 + (-0.4488634467124939) * gru_1_out_t0_56 + (-0.036257930099964142) * gru_1_out_t0_57 + (-0.18765246868133545) * gru_1_out_t0_58 + (-0.17007966339588165) * gru_1_out_t0_59 + (-0.19284471869468689) * gru_1_out_t0_60 + (-0.25067079067230225) * gru_1_out_t0_61 + (-0.054696328938007355) * gru_1_out_t0_62 + (0.15899783372879028) * gru_1_out_t0_63 + gate_r * (-1.7568490505218506));
    gru_2_fwd_t0_h_13 = (1.0 - gate_z) * gate_n;
    // h=14
    gate_r = sigmoid((-0.98139077425003052) + (-0.74998462200164795) * gru_1_out_t0_0 + (-1.3388795852661133) * gru_1_out_t0_1 + (-0.43307632207870483) * gru_1_out_t0_2 + (-0.16048702597618103) * gru_1_out_t0_3 + (0.5432475209236145) * gru_1_out_t0_4 + (0.77344310283660889) * gru_1_out_t0_5 + (-2.3996045589447021) * gru_1_out_t0_6 + (-0.072904191911220551) * gru_1_out_t0_7 + (-1.0170365571975708) * gru_1_out_t0_8 + (1.7237399816513062) * gru_1_out_t0_9 + (-0.25805240869522095) * gru_1_out_t0_10 + (-0.021846771240234375) * gru_1_out_t0_11 + (0.55676466226577759) * gru_1_out_t0_12 + (-0.41091802716255188) * gru_1_out_t0_13 + (1.4661507606506348) * gru_1_out_t0_14 + (2.3193440437316895) * gru_1_out_t0_15 + (-0.014090403914451599) * gru_1_out_t0_16 + (-1.4649800062179565) * gru_1_out_t0_17 + (-1.6641650199890137) * gru_1_out_t0_18 + (-0.14033980667591095) * gru_1_out_t0_19 + (-0.33689019083976746) * gru_1_out_t0_20 + (0.81885111331939697) * gru_1_out_t0_21 + (-0.50070983171463013) * gru_1_out_t0_22 + (-0.46968346834182739) * gru_1_out_t0_23 + (-2.7372636795043945) * gru_1_out_t0_24 + (0.12237231433391571) * gru_1_out_t0_25 + (-0.87489020824432373) * gru_1_out_t0_26 + (-1.5685356855392456) * gru_1_out_t0_27 + (1.1608496904373169) * gru_1_out_t0_28 + (-0.99908220767974854) * gru_1_out_t0_29 + (1.488121509552002) * gru_1_out_t0_30 + (-0.012814423069357872) * gru_1_out_t0_31 + (-0.13238587975502014) * gru_1_out_t0_32 + (0.7904784083366394) * gru_1_out_t0_33 + (-0.21361206471920013) * gru_1_out_t0_34 + (-0.46903231739997864) * gru_1_out_t0_35 + (-1.5758050680160522) * gru_1_out_t0_36 + (-1.1758370399475098) * gru_1_out_t0_37 + (-0.93818920850753784) * gru_1_out_t0_38 + (0.14996646344661713) * gru_1_out_t0_39 + (0.41417360305786133) * gru_1_out_t0_40 + (-0.056054897606372833) * gru_1_out_t0_41 + (0.10248541831970215) * gru_1_out_t0_42 + (-1.8501461744308472) * gru_1_out_t0_43 + (-1.5185614824295044) * gru_1_out_t0_44 + (-0.34556546807289124) * gru_1_out_t0_45 + (-1.0113381147384644) * gru_1_out_t0_46 + (-0.61341804265975952) * gru_1_out_t0_47 + (-0.91043996810913086) * gru_1_out_t0_48 + (2.0446052551269531) * gru_1_out_t0_49 + (0.38389742374420166) * gru_1_out_t0_50 + (1.0793395042419434) * gru_1_out_t0_51 + (0.65876740217208862) * gru_1_out_t0_52 + (-1.2009749412536621) * gru_1_out_t0_53 + (-1.8363161087036133) * gru_1_out_t0_54 + (0.5354684591293335) * gru_1_out_t0_55 + (-0.16373626887798309) * gru_1_out_t0_56 + (-0.2314186692237854) * gru_1_out_t0_57 + (1.1765966415405273) * gru_1_out_t0_58 + (-1.10466468334198) * gru_1_out_t0_59 + (-0.56136083602905273) * gru_1_out_t0_60 + (0.15566833317279816) * gru_1_out_t0_61 + (0.18278312683105469) * gru_1_out_t0_62 + (-0.63151061534881592) * gru_1_out_t0_63);
    gate_z = sigmoid((1.0423792600631714) + (0.021000631153583527) * gru_1_out_t0_0 + (1.3824746608734131) * gru_1_out_t0_1 + (0.31484860181808472) * gru_1_out_t0_2 + (-0.016365399584174156) * gru_1_out_t0_3 + (-0.45040136575698853) * gru_1_out_t0_4 + (-0.61881518363952637) * gru_1_out_t0_5 + (0.12952439486980438) * gru_1_out_t0_6 + (0.33494681119918823) * gru_1_out_t0_7 + (0.98191052675247192) * gru_1_out_t0_8 + (-0.59603935480117798) * gru_1_out_t0_9 + (-0.31447547674179077) * gru_1_out_t0_10 + (-0.35928982496261597) * gru_1_out_t0_11 + (0.18593215942382812) * gru_1_out_t0_12 + (0.60739558935165405) * gru_1_out_t0_13 + (-0.082366921007633209) * gru_1_out_t0_14 + (-0.58186668157577515) * gru_1_out_t0_15 + (0.44452422857284546) * gru_1_out_t0_16 + (0.55906140804290771) * gru_1_out_t0_17 + (0.014633565209805965) * gru_1_out_t0_18 + (-0.1656610369682312) * gru_1_out_t0_19 + (0.079040065407752991) * gru_1_out_t0_20 + (0.060663316398859024) * gru_1_out_t0_21 + (0.16725210845470428) * gru_1_out_t0_22 + (0.92463403940200806) * gru_1_out_t0_23 + (0.70227277278900146) * gru_1_out_t0_24 + (-0.1242244690656662) * gru_1_out_t0_25 + (0.23429940640926361) * gru_1_out_t0_26 + (0.9362180233001709) * gru_1_out_t0_27 + (1.0253115892410278) * gru_1_out_t0_28 + (0.42605692148208618) * gru_1_out_t0_29 + (-0.51889073848724365) * gru_1_out_t0_30 + (-0.45226845145225525) * gru_1_out_t0_31 + (-0.901722252368927) * gru_1_out_t0_32 + (0.36771422624588013) * gru_1_out_t0_33 + (0.082478977739810944) * gru_1_out_t0_34 + (0.082225747406482697) * gru_1_out_t0_35 + (0.87587028741836548) * gru_1_out_t0_36 + (-0.4644700288772583) * gru_1_out_t0_37 + (-0.22296789288520813) * gru_1_out_t0_38 + (1.1790435314178467) * gru_1_out_t0_39 + (-0.11536389589309692) * gru_1_out_t0_40 + (-0.18256057798862457) * gru_1_out_t0_41 + (-0.43633949756622314) * gru_1_out_t0_42 + (-0.22431366145610809) * gru_1_out_t0_43 + (-0.17111416161060333) * gru_1_out_t0_44 + (0.64983868598937988) * gru_1_out_t0_45 + (0.36111035943031311) * gru_1_out_t0_46 + (-0.75304019451141357) * gru_1_out_t0_47 + (-0.13904079794883728) * gru_1_out_t0_48 + (0.08305281400680542) * gru_1_out_t0_49 + (-0.25970306992530823) * gru_1_out_t0_50 + (0.2253347784280777) * gru_1_out_t0_51 + (0.32220935821533203) * gru_1_out_t0_52 + (0.63635009527206421) * gru_1_out_t0_53 + (-0.023965567350387573) * gru_1_out_t0_54 + (0.022707341238856316) * gru_1_out_t0_55 + (-0.049300424754619598) * gru_1_out_t0_56 + (0.071198165416717529) * gru_1_out_t0_57 + (0.53670716285705566) * gru_1_out_t0_58 + (0.072037220001220703) * gru_1_out_t0_59 + (1.1177161931991577) * gru_1_out_t0_60 + (-0.0826244056224823) * gru_1_out_t0_61 + (-0.56415063142776489) * gru_1_out_t0_62 + (-0.086961790919303894) * gru_1_out_t0_63);
    gate_n = tanh((0.23825021088123322) + (0.51395541429519653) * gru_1_out_t0_0 + (-0.43904915452003479) * gru_1_out_t0_1 + (0.82733821868896484) * gru_1_out_t0_2 + (0.68133127689361572) * gru_1_out_t0_3 + (0.076934933662414551) * gru_1_out_t0_4 + (0.142491415143013) * gru_1_out_t0_5 + (1.0678343772888184) * gru_1_out_t0_6 + (0.24392658472061157) * gru_1_out_t0_7 + (1.7820557355880737) * gru_1_out_t0_8 + (-0.34137812256813049) * gru_1_out_t0_9 + (0.26822444796562195) * gru_1_out_t0_10 + (1.6940315961837769) * gru_1_out_t0_11 + (-0.074917733669281006) * gru_1_out_t0_12 + (-0.32225856184959412) * gru_1_out_t0_13 + (-0.19260354340076447) * gru_1_out_t0_14 + (0.15028496086597443) * gru_1_out_t0_15 + (0.11283267289400101) * gru_1_out_t0_16 + (0.21302258968353271) * gru_1_out_t0_17 + (0.88799256086349487) * gru_1_out_t0_18 + (0.80354249477386475) * gru_1_out_t0_19 + (-0.082227028906345367) * gru_1_out_t0_20 + (0.59974509477615356) * gru_1_out_t0_21 + (0.86238092184066772) * gru_1_out_t0_22 + (-0.99863582849502563) * gru_1_out_t0_23 + (1.1465914249420166) * gru_1_out_t0_24 + (0.71095019578933716) * gru_1_out_t0_25 + (0.25409621000289917) * gru_1_out_t0_26 + (-0.33735069632530212) * gru_1_out_t0_27 + (1.0455405712127686) * gru_1_out_t0_28 + (-0.021693490445613861) * gru_1_out_t0_29 + (-0.085634618997573853) * gru_1_out_t0_30 + (-0.24612683057785034) * gru_1_out_t0_31 + (0.31446382403373718) * gru_1_out_t0_32 + (-0.19118747115135193) * gru_1_out_t0_33 + (-0.19599288702011108) * gru_1_out_t0_34 + (-0.10619448870420456) * gru_1_out_t0_35 + (-0.14368438720703125) * gru_1_out_t0_36 + (-0.11794870346784592) * gru_1_out_t0_37 + (0.53405451774597168) * gru_1_out_t0_38 + (0.24758447706699371) * gru_1_out_t0_39 + (0.46824371814727783) * gru_1_out_t0_40 + (-0.63576102256774902) * gru_1_out_t0_41 + (0.47674140334129333) * gru_1_out_t0_42 + (-0.52700865268707275) * gru_1_out_t0_43 + (1.1428416967391968) * gru_1_out_t0_44 + (0.47241896390914917) * gru_1_out_t0_45 + (0.70649915933609009) * gru_1_out_t0_46 + (0.35031053423881531) * gru_1_out_t0_47 + (0.037763513624668121) * gru_1_out_t0_48 + (0.39182326197624207) * gru_1_out_t0_49 + (0.82539749145507812) * gru_1_out_t0_50 + (-0.090322777628898621) * gru_1_out_t0_51 + (0.33325541019439697) * gru_1_out_t0_52 + (0.14795644581317902) * gru_1_out_t0_53 + (1.0950382947921753) * gru_1_out_t0_54 + (-0.021626479923725128) * gru_1_out_t0_55 + (-0.32992562651634216) * gru_1_out_t0_56 + (0.67823189496994019) * gru_1_out_t0_57 + (0.015067306347191334) * gru_1_out_t0_58 + (-0.64715796709060669) * gru_1_out_t0_59 + (-0.027330566197633743) * gru_1_out_t0_60 + (-0.22805818915367126) * gru_1_out_t0_61 + (0.13398614525794983) * gru_1_out_t0_62 + (-0.12789927423000336) * gru_1_out_t0_63 + gate_r * (0.44422870874404907));
    gru_2_fwd_t0_h_14 = (1.0 - gate_z) * gate_n;
    // h=15
    gate_r = sigmoid((-0.099712938070297241) + (1.2344439029693604) * gru_1_out_t0_0 + (-0.35967421531677246) * gru_1_out_t0_1 + (-0.75983840227127075) * gru_1_out_t0_2 + (-0.5682671070098877) * gru_1_out_t0_3 + (-0.2700234055519104) * gru_1_out_t0_4 + (-2.307659387588501) * gru_1_out_t0_5 + (0.13333913683891296) * gru_1_out_t0_6 + (0.035674404352903366) * gru_1_out_t0_7 + (-0.7839047908782959) * gru_1_out_t0_8 + (0.80947846174240112) * gru_1_out_t0_9 + (-0.15220116078853607) * gru_1_out_t0_10 + (1.2643662691116333) * gru_1_out_t0_11 + (-0.65820610523223877) * gru_1_out_t0_12 + (0.36703968048095703) * gru_1_out_t0_13 + (0.60569053888320923) * gru_1_out_t0_14 + (-1.2507985830307007) * gru_1_out_t0_15 + (-0.58726435899734497) * gru_1_out_t0_16 + (-0.219014972448349) * gru_1_out_t0_17 + (1.2312827110290527) * gru_1_out_t0_18 + (-0.8131830096244812) * gru_1_out_t0_19 + (-0.70312595367431641) * gru_1_out_t0_20 + (-0.31020039319992065) * gru_1_out_t0_21 + (0.19150495529174805) * gru_1_out_t0_22 + (2.0266785621643066) * gru_1_out_t0_23 + (-1.3777910470962524) * gru_1_out_t0_24 + (1.1463949680328369) * gru_1_out_t0_25 + (0.13773041963577271) * gru_1_out_t0_26 + (-0.80282574892044067) * gru_1_out_t0_27 + (-0.34118011593818665) * gru_1_out_t0_28 + (0.52024710178375244) * gru_1_out_t0_29 + (2.0119740962982178) * gru_1_out_t0_30 + (-0.059225980192422867) * gru_1_out_t0_31 + (1.4174985885620117) * gru_1_out_t0_32 + (-0.57981628179550171) * gru_1_out_t0_33 + (0.39372158050537109) * gru_1_out_t0_34 + (0.24586416780948639) * gru_1_out_t0_35 + (-0.15991027653217316) * gru_1_out_t0_36 + (0.018095873296260834) * gru_1_out_t0_37 + (-0.019025521352887154) * gru_1_out_t0_38 + (1.0612548589706421) * gru_1_out_t0_39 + (-0.99318736791610718) * gru_1_out_t0_40 + (0.34218975901603699) * gru_1_out_t0_41 + (-1.5380276441574097) * gru_1_out_t0_42 + (-0.58356624841690063) * gru_1_out_t0_43 + (-1.7112160921096802) * gru_1_out_t0_44 + (-0.30877140164375305) * gru_1_out_t0_45 + (-0.79361695051193237) * gru_1_out_t0_46 + (1.9081676006317139) * gru_1_out_t0_47 + (-1.345948338508606) * gru_1_out_t0_48 + (-1.0362606048583984) * gru_1_out_t0_49 + (-0.62014001607894897) * gru_1_out_t0_50 + (-1.4615205526351929) * gru_1_out_t0_51 + (1.874022364616394) * gru_1_out_t0_52 + (1.3949344158172607) * gru_1_out_t0_53 + (1.1434203386306763) * gru_1_out_t0_54 + (-0.48745942115783691) * gru_1_out_t0_55 + (-0.17977717518806458) * gru_1_out_t0_56 + (0.0013087195111438632) * gru_1_out_t0_57 + (0.98865282535552979) * gru_1_out_t0_58 + (-0.91762733459472656) * gru_1_out_t0_59 + (2.85614013671875) * gru_1_out_t0_60 + (-1.0421533584594727) * gru_1_out_t0_61 + (0.77237915992736816) * gru_1_out_t0_62 + (1.2689826488494873) * gru_1_out_t0_63);
    gate_z = sigmoid((0.86796432733535767) + (-0.3674314022064209) * gru_1_out_t0_0 + (0.011421734467148781) * gru_1_out_t0_1 + (-0.39588817954063416) * gru_1_out_t0_2 + (0.91233503818511963) * gru_1_out_t0_3 + (-0.69349545240402222) * gru_1_out_t0_4 + (0.62558883428573608) * gru_1_out_t0_5 + (0.22403493523597717) * gru_1_out_t0_6 + (-0.0051159174181520939) * gru_1_out_t0_7 + (0.40518206357955933) * gru_1_out_t0_8 + (-0.63209110498428345) * gru_1_out_t0_9 + (-0.17349937558174133) * gru_1_out_t0_10 + (-0.011373948305845261) * gru_1_out_t0_11 + (0.4693157970905304) * gru_1_out_t0_12 + (0.57174569368362427) * gru_1_out_t0_13 + (-0.11404962837696075) * gru_1_out_t0_14 + (-1.1810101270675659) * gru_1_out_t0_15 + (0.14403370022773743) * gru_1_out_t0_16 + (0.036192141473293304) * gru_1_out_t0_17 + (0.23284029960632324) * gru_1_out_t0_18 + (-0.13251702487468719) * gru_1_out_t0_19 + (-0.50567537546157837) * gru_1_out_t0_20 + (-0.67273867130279541) * gru_1_out_t0_21 + (0.19810812175273895) * gru_1_out_t0_22 + (0.17150084674358368) * gru_1_out_t0_23 + (1.4766669273376465) * gru_1_out_t0_24 + (-0.080309294164180756) * gru_1_out_t0_25 + (1.140605092048645) * gru_1_out_t0_26 + (0.20950727164745331) * gru_1_out_t0_27 + (-0.44454452395439148) * gru_1_out_t0_28 + (0.21902097761631012) * gru_1_out_t0_29 + (-0.43202382326126099) * gru_1_out_t0_30 + (-0.68993079662322998) * gru_1_out_t0_31 + (1.2918044328689575) * gru_1_out_t0_32 + (-0.40467995405197144) * gru_1_out_t0_33 + (-0.19459633529186249) * gru_1_out_t0_34 + (0.21746960282325745) * gru_1_out_t0_35 + (-0.31528300046920776) * gru_1_out_t0_36 + (-0.35935661196708679) * gru_1_out_t0_37 + (0.49077177047729492) * gru_1_out_t0_38 + (-0.98359978199005127) * gru_1_out_t0_39 + (0.19479916989803314) * gru_1_out_t0_40 + (-1.466838002204895) * gru_1_out_t0_41 + (-0.27959537506103516) * gru_1_out_t0_42 + (-1.0416791439056396) * gru_1_out_t0_43 + (-0.16814090311527252) * gru_1_out_t0_44 + (1.1341265439987183) * gru_1_out_t0_45 + (1.3218027353286743) * gru_1_out_t0_46 + (-0.15987001359462738) * gru_1_out_t0_47 + (-0.71389615535736084) * gru_1_out_t0_48 + (-0.57847762107849121) * gru_1_out_t0_49 + (-0.66114902496337891) * gru_1_out_t0_50 + (-0.60167890787124634) * gru_1_out_t0_51 + (-0.419292151927948) * gru_1_out_t0_52 + (0.11893682926893234) * gru_1_out_t0_53 + (0.9930456280708313) * gru_1_out_t0_54 + (-0.27176764607429504) * gru_1_out_t0_55 + (-0.25265571475028992) * gru_1_out_t0_56 + (-0.41597244143486023) * gru_1_out_t0_57 + (-0.64117783308029175) * gru_1_out_t0_58 + (0.3081170916557312) * gru_1_out_t0_59 + (-0.3865586519241333) * gru_1_out_t0_60 + (0.20725463330745697) * gru_1_out_t0_61 + (0.0024640315677970648) * gru_1_out_t0_62 + (0.19030804932117462) * gru_1_out_t0_63);
    gate_n = tanh((0.1986270397901535) + (-0.23109325766563416) * gru_1_out_t0_0 + (0.51752477884292603) * gru_1_out_t0_1 + (-0.19213198125362396) * gru_1_out_t0_2 + (-0.64243149757385254) * gru_1_out_t0_3 + (0.68001085519790649) * gru_1_out_t0_4 + (-0.30074447393417358) * gru_1_out_t0_5 + (-0.13066530227661133) * gru_1_out_t0_6 + (-0.031194902956485748) * gru_1_out_t0_7 + (0.47297501564025879) * gru_1_out_t0_8 + (-0.036317475140094757) * gru_1_out_t0_9 + (0.31469443440437317) * gru_1_out_t0_10 + (0.48222297430038452) * gru_1_out_t0_11 + (0.62522095441818237) * gru_1_out_t0_12 + (0.11308009177446365) * gru_1_out_t0_13 + (0.56571656465530396) * gru_1_out_t0_14 + (0.24551582336425781) * gru_1_out_t0_15 + (0.098780326545238495) * gru_1_out_t0_16 + (-0.071407467126846313) * gru_1_out_t0_17 + (0.086097754538059235) * gru_1_out_t0_18 + (0.61664283275604248) * gru_1_out_t0_19 + (-0.77060234546661377) * gru_1_out_t0_20 + (-0.38191735744476318) * gru_1_out_t0_21 + (-0.13671413064002991) * gru_1_out_t0_22 + (0.50795853137969971) * gru_1_out_t0_23 + (-0.42212957143783569) * gru_1_out_t0_24 + (0.074501588940620422) * gru_1_out_t0_25 + (-0.51492083072662354) * gru_1_out_t0_26 + (0.0097360657528042793) * gru_1_out_t0_27 + (0.28733626008033752) * gru_1_out_t0_28 + (0.6192963719367981) * gru_1_out_t0_29 + (0.47168126702308655) * gru_1_out_t0_30 + (0.19138269126415253) * gru_1_out_t0_31 + (1.1573127508163452) * gru_1_out_t0_32 + (-0.1367620974779129) * gru_1_out_t0_33 + (-0.08304731547832489) * gru_1_out_t0_34 + (-0.036361042410135269) * gru_1_out_t0_35 + (0.080528482794761658) * gru_1_out_t0_36 + (-0.1844211220741272) * gru_1_out_t0_37 + (1.0513179302215576) * gru_1_out_t0_38 + (-0.88202488422393799) * gru_1_out_t0_39 + (1.4967111349105835) * gru_1_out_t0_40 + (-0.10946391522884369) * gru_1_out_t0_41 + (1.2225415706634521) * gru_1_out_t0_42 + (0.083228208124637604) * gru_1_out_t0_43 + (0.34085822105407715) * gru_1_out_t0_44 + (-0.5102570652961731) * gru_1_out_t0_45 + (1.5460896492004395) * gru_1_out_t0_46 + (1.3498759269714355) * gru_1_out_t0_47 + (-0.58923941850662231) * gru_1_out_t0_48 + (0.85878586769104004) * gru_1_out_t0_49 + (1.7695879936218262) * gru_1_out_t0_50 + (-0.17635637521743774) * gru_1_out_t0_51 + (1.068307638168335) * gru_1_out_t0_52 + (-0.057781409472227097) * gru_1_out_t0_53 + (-0.98460006713867188) * gru_1_out_t0_54 + (0.13444608449935913) * gru_1_out_t0_55 + (-0.36470049619674683) * gru_1_out_t0_56 + (0.11647451668977737) * gru_1_out_t0_57 + (-1.2428932189941406) * gru_1_out_t0_58 + (0.59699571132659912) * gru_1_out_t0_59 + (0.25991621613502502) * gru_1_out_t0_60 + (0.26686671376228333) * gru_1_out_t0_61 + (-0.70623713731765747) * gru_1_out_t0_62 + (-0.6790015697479248) * gru_1_out_t0_63 + gate_r * (0.237383633852005));
    gru_2_fwd_t0_h_15 = (1.0 - gate_z) * gate_n;
    // h=16
    gate_r = sigmoid((1.7873998880386353) + (1.3126356601715088) * gru_1_out_t0_0 + (-0.58859282732009888) * gru_1_out_t0_1 + (-0.82331961393356323) * gru_1_out_t0_2 + (1.2347263097763062) * gru_1_out_t0_3 + (0.35785713791847229) * gru_1_out_t0_4 + (-0.67393743991851807) * gru_1_out_t0_5 + (-0.9873199462890625) * gru_1_out_t0_6 + (-0.0049171210266649723) * gru_1_out_t0_7 + (-0.2172614187002182) * gru_1_out_t0_8 + (0.63182747364044189) * gru_1_out_t0_9 + (0.26017823815345764) * gru_1_out_t0_10 + (-0.034069560468196869) * gru_1_out_t0_11 + (0.36782541871070862) * gru_1_out_t0_12 + (-0.46455869078636169) * gru_1_out_t0_13 + (-0.1541820615530014) * gru_1_out_t0_14 + (-0.040552899241447449) * gru_1_out_t0_15 + (-0.29707229137420654) * gru_1_out_t0_16 + (0.66204005479812622) * gru_1_out_t0_17 + (1.115532398223877) * gru_1_out_t0_18 + (-1.680785059928894) * gru_1_out_t0_19 + (-0.077288322150707245) * gru_1_out_t0_20 + (4.5616583824157715) * gru_1_out_t0_21 + (-0.44867894053459167) * gru_1_out_t0_22 + (-1.5006905794143677) * gru_1_out_t0_23 + (-2.8946139812469482) * gru_1_out_t0_24 + (0.27125060558319092) * gru_1_out_t0_25 + (0.47125473618507385) * gru_1_out_t0_26 + (0.90841460227966309) * gru_1_out_t0_27 + (-2.78855299949646) * gru_1_out_t0_28 + (1.1035343408584595) * gru_1_out_t0_29 + (2.833336353302002) * gru_1_out_t0_30 + (1.5856872797012329) * gru_1_out_t0_31 + (-0.022020237520337105) * gru_1_out_t0_32 + (-1.2235409021377563) * gru_1_out_t0_33 + (0.89237582683563232) * gru_1_out_t0_34 + (-0.19660596549510956) * gru_1_out_t0_35 + (0.40795698761940002) * gru_1_out_t0_36 + (1.339573860168457) * gru_1_out_t0_37 + (0.33744588494300842) * gru_1_out_t0_38 + (0.92059528827667236) * gru_1_out_t0_39 + (1.7253440618515015) * gru_1_out_t0_40 + (0.7359539270401001) * gru_1_out_t0_41 + (0.036698125302791595) * gru_1_out_t0_42 + (-1.8781143426895142) * gru_1_out_t0_43 + (0.25500890612602234) * gru_1_out_t0_44 + (0.066969923675060272) * gru_1_out_t0_45 + (0.083649009466171265) * gru_1_out_t0_46 + (0.26683929562568665) * gru_1_out_t0_47 + (-0.045093800872564316) * gru_1_out_t0_48 + (-1.0591150522232056) * gru_1_out_t0_49 + (0.27210056781768799) * gru_1_out_t0_50 + (0.29128417372703552) * gru_1_out_t0_51 + (0.31252390146255493) * gru_1_out_t0_52 + (0.59472763538360596) * gru_1_out_t0_53 + (-0.41199100017547607) * gru_1_out_t0_54 + (-1.0675783157348633) * gru_1_out_t0_55 + (-0.12863641977310181) * gru_1_out_t0_56 + (-0.52616250514984131) * gru_1_out_t0_57 + (0.5592682957649231) * gru_1_out_t0_58 + (0.52084195613861084) * gru_1_out_t0_59 + (-2.0192315578460693) * gru_1_out_t0_60 + (-0.56120169162750244) * gru_1_out_t0_61 + (-0.70859295129776001) * gru_1_out_t0_62 + (0.17687548696994781) * gru_1_out_t0_63);
    gate_z = sigmoid((1.2640155553817749) + (-0.0671420618891716) * gru_1_out_t0_0 + (0.28772816061973572) * gru_1_out_t0_1 + (-0.03068389929831028) * gru_1_out_t0_2 + (0.40514740347862244) * gru_1_out_t0_3 + (0.42106547951698303) * gru_1_out_t0_4 + (-0.34062743186950684) * gru_1_out_t0_5 + (-0.041167601943016052) * gru_1_out_t0_6 + (0.56179851293563843) * gru_1_out_t0_7 + (-0.096378535032272339) * gru_1_out_t0_8 + (-0.59453177452087402) * gru_1_out_t0_9 + (-0.53731375932693481) * gru_1_out_t0_10 + (-0.21018564701080322) * gru_1_out_t0_11 + (0.068409450352191925) * gru_1_out_t0_12 + (-0.43984830379486084) * gru_1_out_t0_13 + (-1.7673325538635254) * gru_1_out_t0_14 + (-1.3707312345504761) * gru_1_out_t0_15 + (0.55483329296112061) * gru_1_out_t0_16 + (0.48506870865821838) * gru_1_out_t0_17 + (1.099915623664856) * gru_1_out_t0_18 + (-0.3957417905330658) * gru_1_out_t0_19 + (-0.12372412532567978) * gru_1_out_t0_20 + (-0.61775726079940796) * gru_1_out_t0_21 + (-0.80864226818084717) * gru_1_out_t0_22 + (0.55945420265197754) * gru_1_out_t0_23 + (-1.0479463338851929) * gru_1_out_t0_24 + (-0.10157300531864166) * gru_1_out_t0_25 + (-0.90567028522491455) * gru_1_out_t0_26 + (-0.34403130412101746) * gru_1_out_t0_27 + (1.0289782285690308) * gru_1_out_t0_28 + (-0.41504812240600586) * gru_1_out_t0_29 + (0.11227728426456451) * gru_1_out_t0_30 + (-0.45069333910942078) * gru_1_out_t0_31 + (0.36732080578804016) * gru_1_out_t0_32 + (-0.29652902483940125) * gru_1_out_t0_33 + (-0.33530133962631226) * gru_1_out_t0_34 + (-0.40733945369720459) * gru_1_out_t0_35 + (0.25787913799285889) * gru_1_out_t0_36 + (-0.10050442814826965) * gru_1_out_t0_37 + (-0.47376492619514465) * gru_1_out_t0_38 + (-0.20894291996955872) * gru_1_out_t0_39 + (0.020375235006213188) * gru_1_out_t0_40 + (-0.011454002931714058) * gru_1_out_t0_41 + (-0.29088589549064636) * gru_1_out_t0_42 + (-0.45224791765213013) * gru_1_out_t0_43 + (0.38449180126190186) * gru_1_out_t0_44 + (-0.011588858440518379) * gru_1_out_t0_45 + (0.20585186779499054) * gru_1_out_t0_46 + (-0.069687396287918091) * gru_1_out_t0_47 + (-1.1842204332351685) * gru_1_out_t0_48 + (-1.480518102645874) * gru_1_out_t0_49 + (-0.27727410197257996) * gru_1_out_t0_50 + (1.1781233549118042) * gru_1_out_t0_51 + (-0.055218491703271866) * gru_1_out_t0_52 + (1.3247201442718506) * gru_1_out_t0_53 + (0.39163029193878174) * gru_1_out_t0_54 + (-0.042490608990192413) * gru_1_out_t0_55 + (0.3819720447063446) * gru_1_out_t0_56 + (0.3999468982219696) * gru_1_out_t0_57 + (-0.12590512633323669) * gru_1_out_t0_58 + (0.037637617439031601) * gru_1_out_t0_59 + (-0.077690266072750092) * gru_1_out_t0_60 + (0.035045601427555084) * gru_1_out_t0_61 + (0.17848971486091614) * gru_1_out_t0_62 + (0.48950237035751343) * gru_1_out_t0_63);
    gate_n = tanh((0.55826348066329956) + (0.7710883617401123) * gru_1_out_t0_0 + (-0.32697170972824097) * gru_1_out_t0_1 + (-0.27190622687339783) * gru_1_out_t0_2 + (0.46493300795555115) * gru_1_out_t0_3 + (0.80890876054763794) * gru_1_out_t0_4 + (0.309588223695755) * gru_1_out_t0_5 + (-0.067042231559753418) * gru_1_out_t0_6 + (0.44742298126220703) * gru_1_out_t0_7 + (0.094808705151081085) * gru_1_out_t0_8 + (0.35704442858695984) * gru_1_out_t0_9 + (0.49628141522407532) * gru_1_out_t0_10 + (0.4585416316986084) * gru_1_out_t0_11 + (-0.50555562973022461) * gru_1_out_t0_12 + (0.83318668603897095) * gru_1_out_t0_13 + (1.2871850728988647) * gru_1_out_t0_14 + (0.35534572601318359) * gru_1_out_t0_15 + (-0.79684364795684814) * gru_1_out_t0_16 + (-0.084903903305530548) * gru_1_out_t0_17 + (0.58116745948791504) * gru_1_out_t0_18 + (-0.014914519153535366) * gru_1_out_t0_19 + (-0.86654835939407349) * gru_1_out_t0_20 + (0.75671917200088501) * gru_1_out_t0_21 + (-0.4514213502407074) * gru_1_out_t0_22 + (-2.6153500080108643) * gru_1_out_t0_23 + (-1.3519439697265625) * gru_1_out_t0_24 + (-0.33903306722640991) * gru_1_out_t0_25 + (-0.0037989325355738401) * gru_1_out_t0_26 + (1.8440482616424561) * gru_1_out_t0_27 + (-2.5571906566619873) * gru_1_out_t0_28 + (0.57401752471923828) * gru_1_out_t0_29 + (0.58255726099014282) * gru_1_out_t0_30 + (-0.030146947130560875) * gru_1_out_t0_31 + (0.81557643413543701) * gru_1_out_t0_32 + (-0.29959991574287415) * gru_1_out_t0_33 + (0.82623940706253052) * gru_1_out_t0_34 + (0.68084812164306641) * gru_1_out_t0_35 + (0.13912205398082733) * gru_1_out_t0_36 + (-0.12137956917285919) * gru_1_out_t0_37 + (0.56575262546539307) * gru_1_out_t0_38 + (-0.25468525290489197) * gru_1_out_t0_39 + (-0.1403089314699173) * gru_1_out_t0_40 + (0.11636773496866226) * gru_1_out_t0_41 + (1.0021591186523438) * gru_1_out_t0_42 + (-0.50693094730377197) * gru_1_out_t0_43 + (-1.4354323148727417) * gru_1_out_t0_44 + (0.38763821125030518) * gru_1_out_t0_45 + (-0.049890018999576569) * gru_1_out_t0_46 + (0.48659119009971619) * gru_1_out_t0_47 + (0.40167069435119629) * gru_1_out_t0_48 + (0.7770230770111084) * gru_1_out_t0_49 + (-0.58251804113388062) * gru_1_out_t0_50 + (-0.84253066778182983) * gru_1_out_t0_51 + (0.22889725863933563) * gru_1_out_t0_52 + (-1.0875504016876221) * gru_1_out_t0_53 + (-1.5019323825836182) * gru_1_out_t0_54 + (-0.51297628879547119) * gru_1_out_t0_55 + (0.067249171435832977) * gru_1_out_t0_56 + (0.49136623740196228) * gru_1_out_t0_57 + (0.8640817403793335) * gru_1_out_t0_58 + (-0.12335313111543655) * gru_1_out_t0_59 + (0.94900137186050415) * gru_1_out_t0_60 + (0.58288627862930298) * gru_1_out_t0_61 + (-0.18927489221096039) * gru_1_out_t0_62 + (0.32711243629455566) * gru_1_out_t0_63 + gate_r * (0.85728716850280762));
    gru_2_fwd_t0_h_16 = (1.0 - gate_z) * gate_n;
    // h=17
    gate_r = sigmoid((0.021549340337514877) + (1.2636804580688477) * gru_1_out_t0_0 + (0.16169597208499908) * gru_1_out_t0_1 + (0.24536940455436707) * gru_1_out_t0_2 + (0.71913111209869385) * gru_1_out_t0_3 + (-0.5736272931098938) * gru_1_out_t0_4 + (1.4281376600265503) * gru_1_out_t0_5 + (-0.12270449101924896) * gru_1_out_t0_6 + (0.67721343040466309) * gru_1_out_t0_7 + (-0.98408913612365723) * gru_1_out_t0_8 + (-0.21522223949432373) * gru_1_out_t0_9 + (1.9800719022750854) * gru_1_out_t0_10 + (1.0803093910217285) * gru_1_out_t0_11 + (-0.45104026794433594) * gru_1_out_t0_12 + (-0.74236249923706055) * gru_1_out_t0_13 + (-0.91018128395080566) * gru_1_out_t0_14 + (-1.2221018075942993) * gru_1_out_t0_15 + (-1.2330448627471924) * gru_1_out_t0_16 + (1.1542905569076538) * gru_1_out_t0_17 + (0.20149163901805878) * gru_1_out_t0_18 + (-0.47856271266937256) * gru_1_out_t0_19 + (-0.043388538062572479) * gru_1_out_t0_20 + (0.78447186946868896) * gru_1_out_t0_21 + (-0.99291074275970459) * gru_1_out_t0_22 + (2.2875189781188965) * gru_1_out_t0_23 + (-1.4739151000976562) * gru_1_out_t0_24 + (-0.33991304039955139) * gru_1_out_t0_25 + (1.7563220262527466) * gru_1_out_t0_26 + (0.5214959979057312) * gru_1_out_t0_27 + (0.16614103317260742) * gru_1_out_t0_28 + (0.1799643486738205) * gru_1_out_t0_29 + (1.8873052597045898) * gru_1_out_t0_30 + (-1.9207322597503662) * gru_1_out_t0_31 + (0.55558162927627563) * gru_1_out_t0_32 + (0.78628832101821899) * gru_1_out_t0_33 + (0.0024437264073640108) * gru_1_out_t0_34 + (0.37056535482406616) * gru_1_out_t0_35 + (-0.53878086805343628) * gru_1_out_t0_36 + (0.1283235102891922) * gru_1_out_t0_37 + (0.041197609156370163) * gru_1_out_t0_38 + (0.21605655550956726) * gru_1_out_t0_39 + (0.93911826610565186) * gru_1_out_t0_40 + (-0.023716617375612259) * gru_1_out_t0_41 + (-0.59846317768096924) * gru_1_out_t0_42 + (-0.97551470994949341) * gru_1_out_t0_43 + (1.4631307125091553) * gru_1_out_t0_44 + (0.2849629819393158) * gru_1_out_t0_45 + (-0.70415252447128296) * gru_1_out_t0_46 + (-0.525687575340271) * gru_1_out_t0_47 + (-0.34513044357299805) * gru_1_out_t0_48 + (-0.42007172107696533) * gru_1_out_t0_49 + (0.86923795938491821) * gru_1_out_t0_50 + (2.6697864532470703) * gru_1_out_t0_51 + (-0.13386932015419006) * gru_1_out_t0_52 + (-0.30250141024589539) * gru_1_out_t0_53 + (-0.68215465545654297) * gru_1_out_t0_54 + (-0.6602853536605835) * gru_1_out_t0_55 + (-0.52853685617446899) * gru_1_out_t0_56 + (0.27203124761581421) * gru_1_out_t0_57 + (-0.24475856125354767) * gru_1_out_t0_58 + (-0.49960228800773621) * gru_1_out_t0_59 + (3.5556061267852783) * gru_1_out_t0_60 + (-0.64135253429412842) * gru_1_out_t0_61 + (-1.352180004119873) * gru_1_out_t0_62 + (-0.096296228468418121) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.23630239069461823) + (-0.16652904450893402) * gru_1_out_t0_0 + (0.15863227844238281) * gru_1_out_t0_1 + (-0.75610631704330444) * gru_1_out_t0_2 + (0.46987912058830261) * gru_1_out_t0_3 + (-0.15256865322589874) * gru_1_out_t0_4 + (0.78844845294952393) * gru_1_out_t0_5 + (0.71722584962844849) * gru_1_out_t0_6 + (-0.45786184072494507) * gru_1_out_t0_7 + (0.11892122775316238) * gru_1_out_t0_8 + (-0.059163175523281097) * gru_1_out_t0_9 + (-0.34564051032066345) * gru_1_out_t0_10 + (1.3903465270996094) * gru_1_out_t0_11 + (1.0134483575820923) * gru_1_out_t0_12 + (0.38107964396476746) * gru_1_out_t0_13 + (0.69851970672607422) * gru_1_out_t0_14 + (-0.69377315044403076) * gru_1_out_t0_15 + (-0.11982888728380203) * gru_1_out_t0_16 + (0.041333489120006561) * gru_1_out_t0_17 + (-0.13584223389625549) * gru_1_out_t0_18 + (-0.090033248066902161) * gru_1_out_t0_19 + (0.20484891533851624) * gru_1_out_t0_20 + (-0.05002916231751442) * gru_1_out_t0_21 + (0.96704256534576416) * gru_1_out_t0_22 + (-1.321276068687439) * gru_1_out_t0_23 + (0.12812498211860657) * gru_1_out_t0_24 + (0.42011177539825439) * gru_1_out_t0_25 + (-1.0923572778701782) * gru_1_out_t0_26 + (-0.17544260621070862) * gru_1_out_t0_27 + (-0.62958014011383057) * gru_1_out_t0_28 + (0.092493988573551178) * gru_1_out_t0_29 + (-0.58007127046585083) * gru_1_out_t0_30 + (-0.4226250946521759) * gru_1_out_t0_31 + (-0.2568916380405426) * gru_1_out_t0_32 + (0.091812878847122192) * gru_1_out_t0_33 + (0.18751995265483856) * gru_1_out_t0_34 + (0.060393389314413071) * gru_1_out_t0_35 + (0.35314089059829712) * gru_1_out_t0_36 + (-0.11833905428647995) * gru_1_out_t0_37 + (-0.18323914706707001) * gru_1_out_t0_38 + (-0.24519811570644379) * gru_1_out_t0_39 + (0.14984457194805145) * gru_1_out_t0_40 + (0.21662570536136627) * gru_1_out_t0_41 + (-0.16619804501533508) * gru_1_out_t0_42 + (0.17088386416435242) * gru_1_out_t0_43 + (0.017262261360883713) * gru_1_out_t0_44 + (0.12087768316268921) * gru_1_out_t0_45 + (-0.3103451132774353) * gru_1_out_t0_46 + (-0.080620661377906799) * gru_1_out_t0_47 + (0.43480792641639709) * gru_1_out_t0_48 + (-0.40495580434799194) * gru_1_out_t0_49 + (0.027710899710655212) * gru_1_out_t0_50 + (0.16922628879547119) * gru_1_out_t0_51 + (-1.2342755794525146) * gru_1_out_t0_52 + (0.10955343395471573) * gru_1_out_t0_53 + (-0.27639266848564148) * gru_1_out_t0_54 + (-0.80080634355545044) * gru_1_out_t0_55 + (0.24041570723056793) * gru_1_out_t0_56 + (0.15113784372806549) * gru_1_out_t0_57 + (-0.67512649297714233) * gru_1_out_t0_58 + (0.23366011679172516) * gru_1_out_t0_59 + (0.018135072663426399) * gru_1_out_t0_60 + (-0.30419430136680603) * gru_1_out_t0_61 + (0.15037168562412262) * gru_1_out_t0_62 + (-0.20471686124801636) * gru_1_out_t0_63);
    gate_n = tanh((0.41642266511917114) + (0.11714036017656326) * gru_1_out_t0_0 + (0.5222594141960144) * gru_1_out_t0_1 + (0.76402127742767334) * gru_1_out_t0_2 + (-0.29072558879852295) * gru_1_out_t0_3 + (1.0969754457473755) * gru_1_out_t0_4 + (-0.98854696750640869) * gru_1_out_t0_5 + (0.17492711544036865) * gru_1_out_t0_6 + (0.46315410733222961) * gru_1_out_t0_7 + (-0.4145064651966095) * gru_1_out_t0_8 + (-0.01855962723493576) * gru_1_out_t0_9 + (-0.42074564099311829) * gru_1_out_t0_10 + (-0.33555522561073303) * gru_1_out_t0_11 + (-0.090121261775493622) * gru_1_out_t0_12 + (-0.092883355915546417) * gru_1_out_t0_13 + (-0.96939307451248169) * gru_1_out_t0_14 + (-0.15521591901779175) * gru_1_out_t0_15 + (0.32812392711639404) * gru_1_out_t0_16 + (-0.67072278261184692) * gru_1_out_t0_17 + (-0.44426119327545166) * gru_1_out_t0_18 + (-0.40832117199897766) * gru_1_out_t0_19 + (0.10177379101514816) * gru_1_out_t0_20 + (-0.066158764064311981) * gru_1_out_t0_21 + (-0.71039706468582153) * gru_1_out_t0_22 + (0.23189535737037659) * gru_1_out_t0_23 + (-1.36479651927948) * gru_1_out_t0_24 + (-0.36136558651924133) * gru_1_out_t0_25 + (-1.1804836988449097) * gru_1_out_t0_26 + (0.15850247442722321) * gru_1_out_t0_27 + (-1.5394659042358398) * gru_1_out_t0_28 + (-0.36666017770767212) * gru_1_out_t0_29 + (-0.46622428297996521) * gru_1_out_t0_30 + (0.37768560647964478) * gru_1_out_t0_31 + (-2.4645829200744629) * gru_1_out_t0_32 + (-0.01847931370139122) * gru_1_out_t0_33 + (0.61493504047393799) * gru_1_out_t0_34 + (-0.55340856313705444) * gru_1_out_t0_35 + (-0.023607080802321434) * gru_1_out_t0_36 + (0.76896941661834717) * gru_1_out_t0_37 + (-0.64609497785568237) * gru_1_out_t0_38 + (0.64323264360427856) * gru_1_out_t0_39 + (-0.54122722148895264) * gru_1_out_t0_40 + (-0.38456413149833679) * gru_1_out_t0_41 + (-0.39147546887397766) * gru_1_out_t0_42 + (-0.73891347646713257) * gru_1_out_t0_43 + (-0.61506515741348267) * gru_1_out_t0_44 + (-0.13199800252914429) * gru_1_out_t0_45 + (0.54029601812362671) * gru_1_out_t0_46 + (-1.0548179149627686) * gru_1_out_t0_47 + (-0.5677449107170105) * gru_1_out_t0_48 + (-0.29357495903968811) * gru_1_out_t0_49 + (-0.33273968100547791) * gru_1_out_t0_50 + (-0.77738118171691895) * gru_1_out_t0_51 + (1.2557326555252075) * gru_1_out_t0_52 + (0.13370299339294434) * gru_1_out_t0_53 + (-0.26614496111869812) * gru_1_out_t0_54 + (0.14113572239875793) * gru_1_out_t0_55 + (-0.30691847205162048) * gru_1_out_t0_56 + (-0.38899561762809753) * gru_1_out_t0_57 + (0.47738951444625854) * gru_1_out_t0_58 + (-0.042010292410850525) * gru_1_out_t0_59 + (-0.37414801120758057) * gru_1_out_t0_60 + (0.4288632869720459) * gru_1_out_t0_61 + (1.0886400938034058) * gru_1_out_t0_62 + (-0.47426879405975342) * gru_1_out_t0_63 + gate_r * (-0.16186384856700897));
    gru_2_fwd_t0_h_17 = (1.0 - gate_z) * gate_n;
    // h=18
    gate_r = sigmoid((1.6537623405456543) + (0.14032736420631409) * gru_1_out_t0_0 + (-0.82460731267929077) * gru_1_out_t0_1 + (-0.81588965654373169) * gru_1_out_t0_2 + (0.028317209333181381) * gru_1_out_t0_3 + (0.38674828410148621) * gru_1_out_t0_4 + (-1.7346780300140381) * gru_1_out_t0_5 + (-0.57491976022720337) * gru_1_out_t0_6 + (-0.045937430113554001) * gru_1_out_t0_7 + (-0.62407964468002319) * gru_1_out_t0_8 + (0.040837205946445465) * gru_1_out_t0_9 + (0.36525526642799377) * gru_1_out_t0_10 + (0.58658301830291748) * gru_1_out_t0_11 + (-0.39318588376045227) * gru_1_out_t0_12 + (0.17779988050460815) * gru_1_out_t0_13 + (-0.43312537670135498) * gru_1_out_t0_14 + (-0.14125637710094452) * gru_1_out_t0_15 + (-0.96216362714767456) * gru_1_out_t0_16 + (1.0204846858978271) * gru_1_out_t0_17 + (1.0388555526733398) * gru_1_out_t0_18 + (0.82015854120254517) * gru_1_out_t0_19 + (-0.29440736770629883) * gru_1_out_t0_20 + (-2.0000736713409424) * gru_1_out_t0_21 + (0.62953346967697144) * gru_1_out_t0_22 + (-0.86841762065887451) * gru_1_out_t0_23 + (0.29648840427398682) * gru_1_out_t0_24 + (0.59554940462112427) * gru_1_out_t0_25 + (1.8569091558456421) * gru_1_out_t0_26 + (2.2288055419921875) * gru_1_out_t0_27 + (-0.18814773857593536) * gru_1_out_t0_28 + (0.37637963891029358) * gru_1_out_t0_29 + (-0.16659910976886749) * gru_1_out_t0_30 + (-1.45667564868927) * gru_1_out_t0_31 + (-0.3779035210609436) * gru_1_out_t0_32 + (1.4947949647903442) * gru_1_out_t0_33 + (-0.37525996565818787) * gru_1_out_t0_34 + (-0.037181925028562546) * gru_1_out_t0_35 + (0.43332582712173462) * gru_1_out_t0_36 + (-1.1162011623382568) * gru_1_out_t0_37 + (-0.25860664248466492) * gru_1_out_t0_38 + (-0.67701929807662964) * gru_1_out_t0_39 + (-0.38020309805870056) * gru_1_out_t0_40 + (0.58804643154144287) * gru_1_out_t0_41 + (-0.45220386981964111) * gru_1_out_t0_42 + (-1.4146767854690552) * gru_1_out_t0_43 + (-0.91696518659591675) * gru_1_out_t0_44 + (-1.18896484375) * gru_1_out_t0_45 + (-0.79334461688995361) * gru_1_out_t0_46 + (-0.72255170345306396) * gru_1_out_t0_47 + (-0.92481344938278198) * gru_1_out_t0_48 + (2.778430700302124) * gru_1_out_t0_49 + (0.37811192870140076) * gru_1_out_t0_50 + (0.23819118738174438) * gru_1_out_t0_51 + (-0.7206997275352478) * gru_1_out_t0_52 + (-1.4153844118118286) * gru_1_out_t0_53 + (0.04668227955698967) * gru_1_out_t0_54 + (-0.72015529870986938) * gru_1_out_t0_55 + (2.1135594844818115) * gru_1_out_t0_56 + (0.23865814507007599) * gru_1_out_t0_57 + (0.80568933486938477) * gru_1_out_t0_58 + (-0.70690619945526123) * gru_1_out_t0_59 + (-2.0822029113769531) * gru_1_out_t0_60 + (1.0345476865768433) * gru_1_out_t0_61 + (-0.90774935483932495) * gru_1_out_t0_62 + (0.28050273656845093) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.1553758829832077) + (-1.2147040367126465) * gru_1_out_t0_0 + (-0.39048600196838379) * gru_1_out_t0_1 + (-0.041542172431945801) * gru_1_out_t0_2 + (-0.79396843910217285) * gru_1_out_t0_3 + (0.90189856290817261) * gru_1_out_t0_4 + (-0.085298493504524231) * gru_1_out_t0_5 + (-0.84412044286727905) * gru_1_out_t0_6 + (0.46545085310935974) * gru_1_out_t0_7 + (0.54792451858520508) * gru_1_out_t0_8 + (-0.034488048404455185) * gru_1_out_t0_9 + (0.39200380444526672) * gru_1_out_t0_10 + (1.8015854358673096) * gru_1_out_t0_11 + (0.43239209055900574) * gru_1_out_t0_12 + (0.95036458969116211) * gru_1_out_t0_13 + (0.59072768688201904) * gru_1_out_t0_14 + (0.49409019947052002) * gru_1_out_t0_15 + (0.26906085014343262) * gru_1_out_t0_16 + (-0.98732542991638184) * gru_1_out_t0_17 + (-0.0030904433224350214) * gru_1_out_t0_18 + (0.47917729616165161) * gru_1_out_t0_19 + (0.12843906879425049) * gru_1_out_t0_20 + (-0.80814170837402344) * gru_1_out_t0_21 + (-0.1979982852935791) * gru_1_out_t0_22 + (-0.0013349559158086777) * gru_1_out_t0_23 + (-2.8546137809753418) * gru_1_out_t0_24 + (0.41883385181427002) * gru_1_out_t0_25 + (0.69233506917953491) * gru_1_out_t0_26 + (0.68680316209793091) * gru_1_out_t0_27 + (1.0072536468505859) * gru_1_out_t0_28 + (-0.047480713576078415) * gru_1_out_t0_29 + (0.94622278213500977) * gru_1_out_t0_30 + (-0.70551216602325439) * gru_1_out_t0_31 + (-1.016222357749939) * gru_1_out_t0_32 + (-0.024237683042883873) * gru_1_out_t0_33 + (0.47041937708854675) * gru_1_out_t0_34 + (0.077269189059734344) * gru_1_out_t0_35 + (0.62714570760726929) * gru_1_out_t0_36 + (0.90259367227554321) * gru_1_out_t0_37 + (0.95460641384124756) * gru_1_out_t0_38 + (0.49607834219932556) * gru_1_out_t0_39 + (-1.0926554203033447) * gru_1_out_t0_40 + (-0.90540981292724609) * gru_1_out_t0_41 + (0.84869223833084106) * gru_1_out_t0_42 + (0.17650653421878815) * gru_1_out_t0_43 + (-0.13000354170799255) * gru_1_out_t0_44 + (-0.2221125066280365) * gru_1_out_t0_45 + (0.10668648779392242) * gru_1_out_t0_46 + (1.4696515798568726) * gru_1_out_t0_47 + (-1.0813385248184204) * gru_1_out_t0_48 + (-0.50821095705032349) * gru_1_out_t0_49 + (-0.39519026875495911) * gru_1_out_t0_50 + (-1.9377769231796265) * gru_1_out_t0_51 + (0.34250363707542419) * gru_1_out_t0_52 + (-0.67615938186645508) * gru_1_out_t0_53 + (0.28203338384628296) * gru_1_out_t0_54 + (0.54079598188400269) * gru_1_out_t0_55 + (-1.9021377563476562) * gru_1_out_t0_56 + (-0.41894125938415527) * gru_1_out_t0_57 + (-0.21807673573493958) * gru_1_out_t0_58 + (0.16892686486244202) * gru_1_out_t0_59 + (0.85537362098693848) * gru_1_out_t0_60 + (0.10158512741327286) * gru_1_out_t0_61 + (1.1488193273544312) * gru_1_out_t0_62 + (-0.4339354932308197) * gru_1_out_t0_63);
    gate_n = tanh((-1.0693172216415405) + (-0.25192573666572571) * gru_1_out_t0_0 + (-0.28266581892967224) * gru_1_out_t0_1 + (0.83579695224761963) * gru_1_out_t0_2 + (-0.44305452704429626) * gru_1_out_t0_3 + (1.4684075117111206) * gru_1_out_t0_4 + (-0.19693005084991455) * gru_1_out_t0_5 + (0.23710620403289795) * gru_1_out_t0_6 + (0.49320673942565918) * gru_1_out_t0_7 + (-0.33207571506500244) * gru_1_out_t0_8 + (0.5565524697303772) * gru_1_out_t0_9 + (0.04459710419178009) * gru_1_out_t0_10 + (-0.23437049984931946) * gru_1_out_t0_11 + (-0.25436654686927795) * gru_1_out_t0_12 + (0.17508456110954285) * gru_1_out_t0_13 + (0.03863060474395752) * gru_1_out_t0_14 + (-0.17095041275024414) * gru_1_out_t0_15 + (0.14404350519180298) * gru_1_out_t0_16 + (-0.47490984201431274) * gru_1_out_t0_17 + (0.16544297337532043) * gru_1_out_t0_18 + (0.533866286277771) * gru_1_out_t0_19 + (0.34124881029129028) * gru_1_out_t0_20 + (-0.12221422046422958) * gru_1_out_t0_21 + (2.2402713298797607) * gru_1_out_t0_22 + (0.98390913009643555) * gru_1_out_t0_23 + (-1.4166406393051147) * gru_1_out_t0_24 + (-0.36884057521820068) * gru_1_out_t0_25 + (0.49567002058029175) * gru_1_out_t0_26 + (0.18790601193904877) * gru_1_out_t0_27 + (-0.35605815052986145) * gru_1_out_t0_28 + (1.37518310546875) * gru_1_out_t0_29 + (-0.59660941362380981) * gru_1_out_t0_30 + (-0.047309335321187973) * gru_1_out_t0_31 + (-0.10433258861303329) * gru_1_out_t0_32 + (0.093743637204170227) * gru_1_out_t0_33 + (-0.38484188914299011) * gru_1_out_t0_34 + (0.44660535454750061) * gru_1_out_t0_35 + (-0.57084095478057861) * gru_1_out_t0_36 + (0.65078091621398926) * gru_1_out_t0_37 + (0.63564378023147583) * gru_1_out_t0_38 + (0.21412527561187744) * gru_1_out_t0_39 + (-0.11687731742858887) * gru_1_out_t0_40 + (-0.084363862872123718) * gru_1_out_t0_41 + (0.2136380523443222) * gru_1_out_t0_42 + (-0.13535203039646149) * gru_1_out_t0_43 + (-1.6679602861404419) * gru_1_out_t0_44 + (0.92061978578567505) * gru_1_out_t0_45 + (0.12794570624828339) * gru_1_out_t0_46 + (0.88302642107009888) * gru_1_out_t0_47 + (0.39956328272819519) * gru_1_out_t0_48 + (0.37883219122886658) * gru_1_out_t0_49 + (0.34840700030326843) * gru_1_out_t0_50 + (-0.20495675504207611) * gru_1_out_t0_51 + (0.25870072841644287) * gru_1_out_t0_52 + (-0.97806596755981445) * gru_1_out_t0_53 + (0.37642383575439453) * gru_1_out_t0_54 + (-0.464681476354599) * gru_1_out_t0_55 + (-1.2760758399963379) * gru_1_out_t0_56 + (-0.045984264463186264) * gru_1_out_t0_57 + (0.15920679271221161) * gru_1_out_t0_58 + (0.99638074636459351) * gru_1_out_t0_59 + (-0.62279713153839111) * gru_1_out_t0_60 + (-0.71863508224487305) * gru_1_out_t0_61 + (0.51895487308502197) * gru_1_out_t0_62 + (-0.9066203236579895) * gru_1_out_t0_63 + gate_r * (-1.4315930604934692));
    gru_2_fwd_t0_h_18 = (1.0 - gate_z) * gate_n;
    // h=19
    gate_r = sigmoid((-0.082705333828926086) + (-0.44868692755699158) * gru_1_out_t0_0 + (-0.28306975960731506) * gru_1_out_t0_1 + (0.39466974139213562) * gru_1_out_t0_2 + (-1.0755223035812378) * gru_1_out_t0_3 + (0.10705868154764175) * gru_1_out_t0_4 + (1.5740941762924194) * gru_1_out_t0_5 + (2.279353141784668) * gru_1_out_t0_6 + (0.53292948007583618) * gru_1_out_t0_7 + (0.2357281893491745) * gru_1_out_t0_8 + (0.097594976425170898) * gru_1_out_t0_9 + (0.16091369092464447) * gru_1_out_t0_10 + (1.2094660997390747) * gru_1_out_t0_11 + (-0.14277607202529907) * gru_1_out_t0_12 + (0.2116868793964386) * gru_1_out_t0_13 + (1.4425392150878906) * gru_1_out_t0_14 + (-3.6258003711700439) * gru_1_out_t0_15 + (0.70254504680633545) * gru_1_out_t0_16 + (1.2153282165527344) * gru_1_out_t0_17 + (-1.5287282466888428) * gru_1_out_t0_18 + (-0.18310651183128357) * gru_1_out_t0_19 + (0.9697914719581604) * gru_1_out_t0_20 + (0.0671854168176651) * gru_1_out_t0_21 + (3.0409255027770996) * gru_1_out_t0_22 + (0.33833596110343933) * gru_1_out_t0_23 + (0.98040390014648438) * gru_1_out_t0_24 + (-0.96533691883087158) * gru_1_out_t0_25 + (-0.86658221483230591) * gru_1_out_t0_26 + (0.27932292222976685) * gru_1_out_t0_27 + (0.080482609570026398) * gru_1_out_t0_28 + (3.1375911235809326) * gru_1_out_t0_29 + (-0.4937853217124939) * gru_1_out_t0_30 + (1.1026943922042847) * gru_1_out_t0_31 + (-1.1479597091674805) * gru_1_out_t0_32 + (0.17000123858451843) * gru_1_out_t0_33 + (1.6744221448898315) * gru_1_out_t0_34 + (0.42256233096122742) * gru_1_out_t0_35 + (-0.78615760803222656) * gru_1_out_t0_36 + (2.0286450386047363) * gru_1_out_t0_37 + (-1.8184469938278198) * gru_1_out_t0_38 + (4.1371059417724609) * gru_1_out_t0_39 + (-2.855588436126709) * gru_1_out_t0_40 + (0.17215509712696075) * gru_1_out_t0_41 + (-1.5880502462387085) * gru_1_out_t0_42 + (1.2891795635223389) * gru_1_out_t0_43 + (-1.599605917930603) * gru_1_out_t0_44 + (-0.16723747551441193) * gru_1_out_t0_45 + (-0.86345744132995605) * gru_1_out_t0_46 + (-1.8756604194641113) * gru_1_out_t0_47 + (0.7484060525894165) * gru_1_out_t0_48 + (-1.6269928216934204) * gru_1_out_t0_49 + (-2.4983439445495605) * gru_1_out_t0_50 + (-0.14081129431724548) * gru_1_out_t0_51 + (0.61693716049194336) * gru_1_out_t0_52 + (-1.3924973011016846) * gru_1_out_t0_53 + (0.89373761415481567) * gru_1_out_t0_54 + (1.9406865835189819) * gru_1_out_t0_55 + (-1.5794007778167725) * gru_1_out_t0_56 + (0.05786069855093956) * gru_1_out_t0_57 + (1.7485240697860718) * gru_1_out_t0_58 + (0.30989328026771545) * gru_1_out_t0_59 + (2.2391476631164551) * gru_1_out_t0_60 + (-0.27561572194099426) * gru_1_out_t0_61 + (-0.41094547510147095) * gru_1_out_t0_62 + (0.7239764928817749) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.077814921736717224) + (0.63697302341461182) * gru_1_out_t0_0 + (-0.14346611499786377) * gru_1_out_t0_1 + (-0.61499226093292236) * gru_1_out_t0_2 + (-0.17845933139324188) * gru_1_out_t0_3 + (-0.15711662173271179) * gru_1_out_t0_4 + (0.22258754074573517) * gru_1_out_t0_5 + (0.54833728075027466) * gru_1_out_t0_6 + (-0.43454524874687195) * gru_1_out_t0_7 + (1.115496039390564) * gru_1_out_t0_8 + (0.29394704103469849) * gru_1_out_t0_9 + (-0.17762929201126099) * gru_1_out_t0_10 + (1.7007285356521606) * gru_1_out_t0_11 + (0.089686118066310883) * gru_1_out_t0_12 + (1.1293877363204956) * gru_1_out_t0_13 + (1.3469816446304321) * gru_1_out_t0_14 + (0.31393662095069885) * gru_1_out_t0_15 + (0.036681924015283585) * gru_1_out_t0_16 + (0.18968114256858826) * gru_1_out_t0_17 + (-0.75905084609985352) * gru_1_out_t0_18 + (0.47812896966934204) * gru_1_out_t0_19 + (-0.36430403590202332) * gru_1_out_t0_20 + (-1.0855014324188232) * gru_1_out_t0_21 + (-0.090647734701633453) * gru_1_out_t0_22 + (-0.13151374459266663) * gru_1_out_t0_23 + (0.26169553399085999) * gru_1_out_t0_24 + (-0.73688894510269165) * gru_1_out_t0_25 + (-0.82528340816497803) * gru_1_out_t0_26 + (-0.20312047004699707) * gru_1_out_t0_27 + (0.74607276916503906) * gru_1_out_t0_28 + (-0.09418071061372757) * gru_1_out_t0_29 + (0.32526910305023193) * gru_1_out_t0_30 + (0.48001095652580261) * gru_1_out_t0_31 + (1.3767868280410767) * gru_1_out_t0_32 + (0.21025243401527405) * gru_1_out_t0_33 + (-0.097300238907337189) * gru_1_out_t0_34 + (0.45277690887451172) * gru_1_out_t0_35 + (0.09323476254940033) * gru_1_out_t0_36 + (0.14149963855743408) * gru_1_out_t0_37 + (-0.4833509624004364) * gru_1_out_t0_38 + (-0.005415765568614006) * gru_1_out_t0_39 + (-0.13088269531726837) * gru_1_out_t0_40 + (-0.71513211727142334) * gru_1_out_t0_41 + (-0.28043821454048157) * gru_1_out_t0_42 + (0.0096608102321624756) * gru_1_out_t0_43 + (-0.9255407452583313) * gru_1_out_t0_44 + (0.23069167137145996) * gru_1_out_t0_45 + (0.48643982410430908) * gru_1_out_t0_46 + (0.7568279504776001) * gru_1_out_t0_47 + (-0.62649154663085938) * gru_1_out_t0_48 + (0.097206979990005493) * gru_1_out_t0_49 + (-0.77470576763153076) * gru_1_out_t0_50 + (-0.80738407373428345) * gru_1_out_t0_51 + (0.027657566592097282) * gru_1_out_t0_52 + (-0.072382919490337372) * gru_1_out_t0_53 + (0.27506515383720398) * gru_1_out_t0_54 + (0.11952124536037445) * gru_1_out_t0_55 + (0.20059414207935333) * gru_1_out_t0_56 + (-0.0045003066770732403) * gru_1_out_t0_57 + (-0.10113246738910675) * gru_1_out_t0_58 + (-0.59726989269256592) * gru_1_out_t0_59 + (-0.7995036244392395) * gru_1_out_t0_60 + (-0.142447829246521) * gru_1_out_t0_61 + (-1.048808217048645) * gru_1_out_t0_62 + (0.80408585071563721) * gru_1_out_t0_63);
    gate_n = tanh((-0.2189779132604599) + (0.28241917490959167) * gru_1_out_t0_0 + (0.14336580038070679) * gru_1_out_t0_1 + (-0.11900131404399872) * gru_1_out_t0_2 + (0.73004865646362305) * gru_1_out_t0_3 + (-0.20443500578403473) * gru_1_out_t0_4 + (-0.65724611282348633) * gru_1_out_t0_5 + (0.21926289796829224) * gru_1_out_t0_6 + (-0.63763439655303955) * gru_1_out_t0_7 + (0.52324783802032471) * gru_1_out_t0_8 + (0.35108381509780884) * gru_1_out_t0_9 + (0.48143661022186279) * gru_1_out_t0_10 + (-0.32312384247779846) * gru_1_out_t0_11 + (-0.53880029916763306) * gru_1_out_t0_12 + (0.17210212349891663) * gru_1_out_t0_13 + (0.0029475190676748753) * gru_1_out_t0_14 + (-0.41520342230796814) * gru_1_out_t0_15 + (0.73619061708450317) * gru_1_out_t0_16 + (-0.23945744335651398) * gru_1_out_t0_17 + (-0.14811220765113831) * gru_1_out_t0_18 + (-0.11190328747034073) * gru_1_out_t0_19 + (-0.35382670164108276) * gru_1_out_t0_20 + (-0.59973633289337158) * gru_1_out_t0_21 + (0.35083898901939392) * gru_1_out_t0_22 + (-0.36267709732055664) * gru_1_out_t0_23 + (-1.000982403755188) * gru_1_out_t0_24 + (-0.42616382241249084) * gru_1_out_t0_25 + (0.23261532187461853) * gru_1_out_t0_26 + (-0.51029223203659058) * gru_1_out_t0_27 + (0.43212315440177917) * gru_1_out_t0_28 + (-0.13898201286792755) * gru_1_out_t0_29 + (-0.35991212725639343) * gru_1_out_t0_30 + (0.28611940145492554) * gru_1_out_t0_31 + (-0.45761317014694214) * gru_1_out_t0_32 + (-0.42480877041816711) * gru_1_out_t0_33 + (-0.62117081880569458) * gru_1_out_t0_34 + (0.4993039071559906) * gru_1_out_t0_35 + (-0.84717541933059692) * gru_1_out_t0_36 + (0.027043642476201057) * gru_1_out_t0_37 + (0.23083744943141937) * gru_1_out_t0_38 + (-1.1353816986083984) * gru_1_out_t0_39 + (1.1306647062301636) * gru_1_out_t0_40 + (-0.81602990627288818) * gru_1_out_t0_41 + (-0.21536360681056976) * gru_1_out_t0_42 + (-0.10289443284273148) * gru_1_out_t0_43 + (0.34699112176895142) * gru_1_out_t0_44 + (-0.44609174132347107) * gru_1_out_t0_45 + (0.33727052807807922) * gru_1_out_t0_46 + (1.5131398439407349) * gru_1_out_t0_47 + (1.4810941219329834) * gru_1_out_t0_48 + (0.52498430013656616) * gru_1_out_t0_49 + (1.033739447593689) * gru_1_out_t0_50 + (0.29555109143257141) * gru_1_out_t0_51 + (0.82265746593475342) * gru_1_out_t0_52 + (-0.693572998046875) * gru_1_out_t0_53 + (-0.92421633005142212) * gru_1_out_t0_54 + (0.21460285782814026) * gru_1_out_t0_55 + (-0.30563285946846008) * gru_1_out_t0_56 + (-0.21716932952404022) * gru_1_out_t0_57 + (-0.72355765104293823) * gru_1_out_t0_58 + (0.4334336519241333) * gru_1_out_t0_59 + (-0.16294553875923157) * gru_1_out_t0_60 + (-0.068285718560218811) * gru_1_out_t0_61 + (-0.46519619226455688) * gru_1_out_t0_62 + (-0.12500730156898499) * gru_1_out_t0_63 + gate_r * (-1.1310220956802368));
    gru_2_fwd_t0_h_19 = (1.0 - gate_z) * gate_n;
    // h=20
    gate_r = sigmoid((-0.54950141906738281) + (-0.028445389121770859) * gru_1_out_t0_0 + (0.57196241617202759) * gru_1_out_t0_1 + (-0.50093179941177368) * gru_1_out_t0_2 + (0.26136931777000427) * gru_1_out_t0_3 + (0.3020966649055481) * gru_1_out_t0_4 + (1.9116518497467041) * gru_1_out_t0_5 + (0.22054798901081085) * gru_1_out_t0_6 + (0.33286646008491516) * gru_1_out_t0_7 + (-0.6626552939414978) * gru_1_out_t0_8 + (0.49234423041343689) * gru_1_out_t0_9 + (0.52370560169219971) * gru_1_out_t0_10 + (0.83678722381591797) * gru_1_out_t0_11 + (0.35026296973228455) * gru_1_out_t0_12 + (-0.090534418821334839) * gru_1_out_t0_13 + (1.550236701965332) * gru_1_out_t0_14 + (0.077510654926300049) * gru_1_out_t0_15 + (-0.37721270322799683) * gru_1_out_t0_16 + (-0.58988785743713379) * gru_1_out_t0_17 + (2.7447240352630615) * gru_1_out_t0_18 + (0.81646060943603516) * gru_1_out_t0_19 + (0.33356153964996338) * gru_1_out_t0_20 + (0.034706629812717438) * gru_1_out_t0_21 + (-0.81010270118713379) * gru_1_out_t0_22 + (0.17419612407684326) * gru_1_out_t0_23 + (0.20880831778049469) * gru_1_out_t0_24 + (1.4312137365341187) * gru_1_out_t0_25 + (-1.1675388813018799) * gru_1_out_t0_26 + (-0.36679494380950928) * gru_1_out_t0_27 + (1.3015670776367188) * gru_1_out_t0_28 + (-0.36824396252632141) * gru_1_out_t0_29 + (1.0616594552993774) * gru_1_out_t0_30 + (-0.51430642604827881) * gru_1_out_t0_31 + (1.0237991809844971) * gru_1_out_t0_32 + (-0.24000565707683563) * gru_1_out_t0_33 + (0.053305529057979584) * gru_1_out_t0_34 + (0.33375972509384155) * gru_1_out_t0_35 + (0.11531641334295273) * gru_1_out_t0_36 + (-0.18261176347732544) * gru_1_out_t0_37 + (-1.4991185665130615) * gru_1_out_t0_38 + (-1.2624297142028809) * gru_1_out_t0_39 + (-0.25946754217147827) * gru_1_out_t0_40 + (-0.3450121283531189) * gru_1_out_t0_41 + (-0.86790657043457031) * gru_1_out_t0_42 + (-1.8249920606613159) * gru_1_out_t0_43 + (0.066522583365440369) * gru_1_out_t0_44 + (-0.90345519781112671) * gru_1_out_t0_45 + (-0.88409566879272461) * gru_1_out_t0_46 + (1.9973428249359131) * gru_1_out_t0_47 + (-0.58855032920837402) * gru_1_out_t0_48 + (0.14236220717430115) * gru_1_out_t0_49 + (1.2005610466003418) * gru_1_out_t0_50 + (0.19945915043354034) * gru_1_out_t0_51 + (1.3491890430450439) * gru_1_out_t0_52 + (0.25910690426826477) * gru_1_out_t0_53 + (0.055810887366533279) * gru_1_out_t0_54 + (1.1401735544204712) * gru_1_out_t0_55 + (-1.3563051223754883) * gru_1_out_t0_56 + (-0.1248633861541748) * gru_1_out_t0_57 + (-0.41845488548278809) * gru_1_out_t0_58 + (-0.77469700574874878) * gru_1_out_t0_59 + (1.8920108079910278) * gru_1_out_t0_60 + (-0.082910694181919098) * gru_1_out_t0_61 + (-0.70680689811706543) * gru_1_out_t0_62 + (-0.15654665231704712) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.21540595591068268) + (-0.062447085976600647) * gru_1_out_t0_0 + (0.19710658490657806) * gru_1_out_t0_1 + (0.22304537892341614) * gru_1_out_t0_2 + (-0.22655822336673737) * gru_1_out_t0_3 + (-0.28544896841049194) * gru_1_out_t0_4 + (-0.79141074419021606) * gru_1_out_t0_5 + (-0.076427921652793884) * gru_1_out_t0_6 + (-0.65295261144638062) * gru_1_out_t0_7 + (0.078971602022647858) * gru_1_out_t0_8 + (0.12620921432971954) * gru_1_out_t0_9 + (-0.16612808406352997) * gru_1_out_t0_10 + (-0.50807523727416992) * gru_1_out_t0_11 + (0.58610707521438599) * gru_1_out_t0_12 + (-0.21289952099323273) * gru_1_out_t0_13 + (0.33254772424697876) * gru_1_out_t0_14 + (0.29820331931114197) * gru_1_out_t0_15 + (0.6394156813621521) * gru_1_out_t0_16 + (-0.76382273435592651) * gru_1_out_t0_17 + (-0.40327426791191101) * gru_1_out_t0_18 + (0.026292705908417702) * gru_1_out_t0_19 + (-0.83958137035369873) * gru_1_out_t0_20 + (-0.29140341281890869) * gru_1_out_t0_21 + (0.420453280210495) * gru_1_out_t0_22 + (0.16636776924133301) * gru_1_out_t0_23 + (-0.84373712539672852) * gru_1_out_t0_24 + (0.73724222183227539) * gru_1_out_t0_25 + (-0.52726453542709351) * gru_1_out_t0_26 + (0.42343917489051819) * gru_1_out_t0_27 + (0.31719768047332764) * gru_1_out_t0_28 + (0.09289916604757309) * gru_1_out_t0_29 + (-1.0459674596786499) * gru_1_out_t0_30 + (0.17842990159988403) * gru_1_out_t0_31 + (0.74463635683059692) * gru_1_out_t0_32 + (0.25899797677993774) * gru_1_out_t0_33 + (-0.22104665637016296) * gru_1_out_t0_34 + (0.21321561932563782) * gru_1_out_t0_35 + (0.56181502342224121) * gru_1_out_t0_36 + (0.0037053248379379511) * gru_1_out_t0_37 + (0.3996836245059967) * gru_1_out_t0_38 + (1.4589189291000366) * gru_1_out_t0_39 + (0.011392473243176937) * gru_1_out_t0_40 + (-0.33374163508415222) * gru_1_out_t0_41 + (0.4011085033416748) * gru_1_out_t0_42 + (-1.2922153472900391) * gru_1_out_t0_43 + (0.14770334959030151) * gru_1_out_t0_44 + (0.21554625034332275) * gru_1_out_t0_45 + (0.25629574060440063) * gru_1_out_t0_46 + (-1.9022254943847656) * gru_1_out_t0_47 + (1.5334067344665527) * gru_1_out_t0_48 + (0.15874797105789185) * gru_1_out_t0_49 + (1.9202425479888916) * gru_1_out_t0_50 + (-0.5647767186164856) * gru_1_out_t0_51 + (-0.77475357055664062) * gru_1_out_t0_52 + (-0.12867213785648346) * gru_1_out_t0_53 + (0.5648958683013916) * gru_1_out_t0_54 + (-0.043451651930809021) * gru_1_out_t0_55 + (-0.24236686527729034) * gru_1_out_t0_56 + (-0.41896262764930725) * gru_1_out_t0_57 + (0.37943923473358154) * gru_1_out_t0_58 + (-1.7419379949569702) * gru_1_out_t0_59 + (0.96148163080215454) * gru_1_out_t0_60 + (-0.95176470279693604) * gru_1_out_t0_61 + (-1.1861317157745361) * gru_1_out_t0_62 + (-0.45780137181282043) * gru_1_out_t0_63);
    gate_n = tanh((0.17752301692962646) + (0.29254907369613647) * gru_1_out_t0_0 + (0.10081542283296585) * gru_1_out_t0_1 + (-0.303974449634552) * gru_1_out_t0_2 + (0.76221704483032227) * gru_1_out_t0_3 + (-0.057978946715593338) * gru_1_out_t0_4 + (0.27594807744026184) * gru_1_out_t0_5 + (-0.0094996290281414986) * gru_1_out_t0_6 + (-0.28469234704971313) * gru_1_out_t0_7 + (0.33654379844665527) * gru_1_out_t0_8 + (0.1726241409778595) * gru_1_out_t0_9 + (0.61838001012802124) * gru_1_out_t0_10 + (-0.088928341865539551) * gru_1_out_t0_11 + (0.77576011419296265) * gru_1_out_t0_12 + (-0.21127665042877197) * gru_1_out_t0_13 + (0.5637965202331543) * gru_1_out_t0_14 + (0.33355829119682312) * gru_1_out_t0_15 + (0.37436410784721375) * gru_1_out_t0_16 + (-0.17695207893848419) * gru_1_out_t0_17 + (0.22815875709056854) * gru_1_out_t0_18 + (0.28944399952888489) * gru_1_out_t0_19 + (0.13347424566745758) * gru_1_out_t0_20 + (-0.088616825640201569) * gru_1_out_t0_21 + (0.040927562862634659) * gru_1_out_t0_22 + (0.86185109615325928) * gru_1_out_t0_23 + (-1.0314691066741943) * gru_1_out_t0_24 + (-0.1365770548582077) * gru_1_out_t0_25 + (-0.18390278518199921) * gru_1_out_t0_26 + (-0.31354370713233948) * gru_1_out_t0_27 + (0.52801614999771118) * gru_1_out_t0_28 + (0.63795608282089233) * gru_1_out_t0_29 + (0.084013171494007111) * gru_1_out_t0_30 + (-0.52091085910797119) * gru_1_out_t0_31 + (0.052964821457862854) * gru_1_out_t0_32 + (-0.057234033942222595) * gru_1_out_t0_33 + (-0.72388136386871338) * gru_1_out_t0_34 + (0.16734346747398376) * gru_1_out_t0_35 + (-0.36760926246643066) * gru_1_out_t0_36 + (0.25334513187408447) * gru_1_out_t0_37 + (-0.25233516097068787) * gru_1_out_t0_38 + (-1.1464488506317139) * gru_1_out_t0_39 + (0.92114537954330444) * gru_1_out_t0_40 + (0.068244293332099915) * gru_1_out_t0_41 + (-0.77219057083129883) * gru_1_out_t0_42 + (0.35374173521995544) * gru_1_out_t0_43 + (0.33089959621429443) * gru_1_out_t0_44 + (-0.032683189958333969) * gru_1_out_t0_45 + (-0.23952262103557587) * gru_1_out_t0_46 + (0.054491549730300903) * gru_1_out_t0_47 + (0.63443905115127563) * gru_1_out_t0_48 + (-0.27270302176475525) * gru_1_out_t0_49 + (-0.10325831174850464) * gru_1_out_t0_50 + (0.61181533336639404) * gru_1_out_t0_51 + (-0.44981294870376587) * gru_1_out_t0_52 + (-0.011557241901755333) * gru_1_out_t0_53 + (-0.44994375109672546) * gru_1_out_t0_54 + (0.3322223424911499) * gru_1_out_t0_55 + (-0.069231607019901276) * gru_1_out_t0_56 + (-0.087306849658489227) * gru_1_out_t0_57 + (-0.40325802564620972) * gru_1_out_t0_58 + (0.17556558549404144) * gru_1_out_t0_59 + (0.45482334494590759) * gru_1_out_t0_60 + (0.13832241296768188) * gru_1_out_t0_61 + (-0.022683195769786835) * gru_1_out_t0_62 + (-0.026869719848036766) * gru_1_out_t0_63 + gate_r * (0.19364142417907715));
    gru_2_fwd_t0_h_20 = (1.0 - gate_z) * gate_n;
    // h=21
    gate_r = sigmoid((-0.41085311770439148) + (-2.1175956726074219) * gru_1_out_t0_0 + (-1.1514532566070557) * gru_1_out_t0_1 + (0.094657540321350098) * gru_1_out_t0_2 + (1.6376582384109497) * gru_1_out_t0_3 + (0.0092540895566344261) * gru_1_out_t0_4 + (-0.61162590980529785) * gru_1_out_t0_5 + (0.023723404854536057) * gru_1_out_t0_6 + (-0.30057612061500549) * gru_1_out_t0_7 + (0.081637457013130188) * gru_1_out_t0_8 + (-0.26221883296966553) * gru_1_out_t0_9 + (-0.091787755489349365) * gru_1_out_t0_10 + (-1.593367338180542) * gru_1_out_t0_11 + (-0.15290087461471558) * gru_1_out_t0_12 + (0.042701311409473419) * gru_1_out_t0_13 + (-1.3093334436416626) * gru_1_out_t0_14 + (0.96090096235275269) * gru_1_out_t0_15 + (-0.085761912167072296) * gru_1_out_t0_16 + (0.84867358207702637) * gru_1_out_t0_17 + (-1.1734315156936646) * gru_1_out_t0_18 + (-0.024421337991952896) * gru_1_out_t0_19 + (-0.30884519219398499) * gru_1_out_t0_20 + (-0.45355877280235291) * gru_1_out_t0_21 + (-0.2222890704870224) * gru_1_out_t0_22 + (0.74104291200637817) * gru_1_out_t0_23 + (2.4034206867218018) * gru_1_out_t0_24 + (-1.2558438777923584) * gru_1_out_t0_25 + (1.173764705657959) * gru_1_out_t0_26 + (0.41259211301803589) * gru_1_out_t0_27 + (-1.4630422592163086) * gru_1_out_t0_28 + (0.73190182447433472) * gru_1_out_t0_29 + (2.6868343353271484) * gru_1_out_t0_30 + (-0.64959311485290527) * gru_1_out_t0_31 + (-0.25143396854400635) * gru_1_out_t0_32 + (0.067020617425441742) * gru_1_out_t0_33 + (-0.67796045541763306) * gru_1_out_t0_34 + (0.2792288064956665) * gru_1_out_t0_35 + (0.3562634289264679) * gru_1_out_t0_36 + (0.45980337262153625) * gru_1_out_t0_37 + (0.48201665282249451) * gru_1_out_t0_38 + (-0.24847054481506348) * gru_1_out_t0_39 + (-0.16669709980487823) * gru_1_out_t0_40 + (0.59393149614334106) * gru_1_out_t0_41 + (-1.0901809930801392) * gru_1_out_t0_42 + (-0.37497356534004211) * gru_1_out_t0_43 + (0.13409458100795746) * gru_1_out_t0_44 + (-0.8338092565536499) * gru_1_out_t0_45 + (-0.030050069093704224) * gru_1_out_t0_46 + (-1.5882831811904907) * gru_1_out_t0_47 + (-0.86539983749389648) * gru_1_out_t0_48 + (-0.14470085501670837) * gru_1_out_t0_49 + (-0.70560336112976074) * gru_1_out_t0_50 + (-0.14211806654930115) * gru_1_out_t0_51 + (-0.8625836968421936) * gru_1_out_t0_52 + (0.98606777191162109) * gru_1_out_t0_53 + (-0.52155745029449463) * gru_1_out_t0_54 + (0.28513112664222717) * gru_1_out_t0_55 + (0.27814251184463501) * gru_1_out_t0_56 + (0.28228330612182617) * gru_1_out_t0_57 + (-0.61640787124633789) * gru_1_out_t0_58 + (0.28103050589561462) * gru_1_out_t0_59 + (1.7513893842697144) * gru_1_out_t0_60 + (-0.35556471347808838) * gru_1_out_t0_61 + (-0.81709831953048706) * gru_1_out_t0_62 + (-0.98777240514755249) * gru_1_out_t0_63);
    gate_z = sigmoid((0.51385629177093506) + (0.37207534909248352) * gru_1_out_t0_0 + (0.064254149794578552) * gru_1_out_t0_1 + (0.26732233166694641) * gru_1_out_t0_2 + (0.19992221891880035) * gru_1_out_t0_3 + (0.62904804944992065) * gru_1_out_t0_4 + (1.0610771179199219) * gru_1_out_t0_5 + (0.70428496599197388) * gru_1_out_t0_6 + (-0.51096951961517334) * gru_1_out_t0_7 + (-0.13854178786277771) * gru_1_out_t0_8 + (-0.26161259412765503) * gru_1_out_t0_9 + (0.6707492470741272) * gru_1_out_t0_10 + (1.1317105293273926) * gru_1_out_t0_11 + (0.29354628920555115) * gru_1_out_t0_12 + (-0.095147401094436646) * gru_1_out_t0_13 + (0.41109606623649597) * gru_1_out_t0_14 + (-0.39471754431724548) * gru_1_out_t0_15 + (-0.83567184209823608) * gru_1_out_t0_16 + (1.1051061153411865) * gru_1_out_t0_17 + (0.40588855743408203) * gru_1_out_t0_18 + (-0.24876336753368378) * gru_1_out_t0_19 + (-0.24655218422412872) * gru_1_out_t0_20 + (-0.18733631074428558) * gru_1_out_t0_21 + (-1.0518691539764404) * gru_1_out_t0_22 + (0.036488857120275497) * gru_1_out_t0_23 + (-0.25321963429450989) * gru_1_out_t0_24 + (-0.14605914056301117) * gru_1_out_t0_25 + (0.60077190399169922) * gru_1_out_t0_26 + (-0.44268479943275452) * gru_1_out_t0_27 + (0.2769855260848999) * gru_1_out_t0_28 + (-0.30815371870994568) * gru_1_out_t0_29 + (-1.0396198034286499) * gru_1_out_t0_30 + (-0.43569073081016541) * gru_1_out_t0_31 + (0.28526023030281067) * gru_1_out_t0_32 + (0.29230201244354248) * gru_1_out_t0_33 + (-0.36811593174934387) * gru_1_out_t0_34 + (0.25433000922203064) * gru_1_out_t0_35 + (-0.31234708428382874) * gru_1_out_t0_36 + (0.045589979737997055) * gru_1_out_t0_37 + (-0.26722455024719238) * gru_1_out_t0_38 + (-0.57158881425857544) * gru_1_out_t0_39 + (-0.071148693561553955) * gru_1_out_t0_40 + (-0.14104351401329041) * gru_1_out_t0_41 + (-0.055966898798942566) * gru_1_out_t0_42 + (0.51795631647109985) * gru_1_out_t0_43 + (-0.058084852993488312) * gru_1_out_t0_44 + (0.0042424555867910385) * gru_1_out_t0_45 + (-0.810097336769104) * gru_1_out_t0_46 + (-0.65428382158279419) * gru_1_out_t0_47 + (-0.74085313081741333) * gru_1_out_t0_48 + (0.069331623613834381) * gru_1_out_t0_49 + (-0.89539563655853271) * gru_1_out_t0_50 + (-0.29942682385444641) * gru_1_out_t0_51 + (-0.78762316703796387) * gru_1_out_t0_52 + (-0.11654308438301086) * gru_1_out_t0_53 + (0.0073445714078843594) * gru_1_out_t0_54 + (0.28068861365318298) * gru_1_out_t0_55 + (-1.6662617921829224) * gru_1_out_t0_56 + (-0.45449215173721313) * gru_1_out_t0_57 + (0.4044097363948822) * gru_1_out_t0_58 + (0.19018487632274628) * gru_1_out_t0_59 + (0.54402840137481689) * gru_1_out_t0_60 + (0.038217648863792419) * gru_1_out_t0_61 + (0.14708909392356873) * gru_1_out_t0_62 + (0.31532546877861023) * gru_1_out_t0_63);
    gate_n = tanh((0.059235170483589172) + (-0.10768552124500275) * gru_1_out_t0_0 + (0.15082165598869324) * gru_1_out_t0_1 + (-0.013013914227485657) * gru_1_out_t0_2 + (0.91154938936233521) * gru_1_out_t0_3 + (-0.50300794839859009) * gru_1_out_t0_4 + (0.30522522330284119) * gru_1_out_t0_5 + (0.10518790036439896) * gru_1_out_t0_6 + (0.10219262540340424) * gru_1_out_t0_7 + (0.22126960754394531) * gru_1_out_t0_8 + (-0.24762572348117828) * gru_1_out_t0_9 + (0.35280948877334595) * gru_1_out_t0_10 + (0.26572495698928833) * gru_1_out_t0_11 + (0.27837687730789185) * gru_1_out_t0_12 + (0.34346190094947815) * gru_1_out_t0_13 + (-0.4190080463886261) * gru_1_out_t0_14 + (0.27260169386863708) * gru_1_out_t0_15 + (-0.092596128582954407) * gru_1_out_t0_16 + (0.14537501335144043) * gru_1_out_t0_17 + (0.62817716598510742) * gru_1_out_t0_18 + (-0.066940642893314362) * gru_1_out_t0_19 + (-0.22865478694438934) * gru_1_out_t0_20 + (-0.3251737654209137) * gru_1_out_t0_21 + (0.11933120340108871) * gru_1_out_t0_22 + (-0.055363524705171585) * gru_1_out_t0_23 + (0.50039225816726685) * gru_1_out_t0_24 + (-0.068058423697948456) * gru_1_out_t0_25 + (0.025690998882055283) * gru_1_out_t0_26 + (-0.17750999331474304) * gru_1_out_t0_27 + (-0.33152246475219727) * gru_1_out_t0_28 + (-0.072450898587703705) * gru_1_out_t0_29 + (0.15496557950973511) * gru_1_out_t0_30 + (-0.51674586534500122) * gru_1_out_t0_31 + (-0.29137897491455078) * gru_1_out_t0_32 + (-0.03144783154129982) * gru_1_out_t0_33 + (-0.0065676020458340645) * gru_1_out_t0_34 + (0.23378379642963409) * gru_1_out_t0_35 + (-0.098160631954669952) * gru_1_out_t0_36 + (-0.060915708541870117) * gru_1_out_t0_37 + (0.030496232211589813) * gru_1_out_t0_38 + (-0.27100232243537903) * gru_1_out_t0_39 + (-0.18794271349906921) * gru_1_out_t0_40 + (0.27447286248207092) * gru_1_out_t0_41 + (0.26050710678100586) * gru_1_out_t0_42 + (0.062046151608228683) * gru_1_out_t0_43 + (0.62349343299865723) * gru_1_out_t0_44 + (-0.17839114367961884) * gru_1_out_t0_45 + (-0.017422376200556755) * gru_1_out_t0_46 + (-0.3473602831363678) * gru_1_out_t0_47 + (0.96528112888336182) * gru_1_out_t0_48 + (0.056087784469127655) * gru_1_out_t0_49 + (0.1062556654214859) * gru_1_out_t0_50 + (0.047943904995918274) * gru_1_out_t0_51 + (-0.10951235890388489) * gru_1_out_t0_52 + (-0.2179199755191803) * gru_1_out_t0_53 + (0.023238880559802055) * gru_1_out_t0_54 + (0.036984365433454514) * gru_1_out_t0_55 + (-0.26362663507461548) * gru_1_out_t0_56 + (-0.23231934010982513) * gru_1_out_t0_57 + (-0.13068868219852448) * gru_1_out_t0_58 + (-0.41759991645812988) * gru_1_out_t0_59 + (-0.047218676656484604) * gru_1_out_t0_60 + (-0.11818970739841461) * gru_1_out_t0_61 + (-0.63378679752349854) * gru_1_out_t0_62 + (-0.31481730937957764) * gru_1_out_t0_63 + gate_r * (0.53255921602249146));
    gru_2_fwd_t0_h_21 = (1.0 - gate_z) * gate_n;
    // h=22
    gate_r = sigmoid((2.0746722221374512) + (0.25101163983345032) * gru_1_out_t0_0 + (-0.60227686166763306) * gru_1_out_t0_1 + (0.25599274039268494) * gru_1_out_t0_2 + (0.33706963062286377) * gru_1_out_t0_3 + (-0.52215588092803955) * gru_1_out_t0_4 + (-0.88232928514480591) * gru_1_out_t0_5 + (-0.44416841864585876) * gru_1_out_t0_6 + (0.39813128113746643) * gru_1_out_t0_7 + (1.2596918344497681) * gru_1_out_t0_8 + (-0.084983848035335541) * gru_1_out_t0_9 + (-0.18221040070056915) * gru_1_out_t0_10 + (-0.44675564765930176) * gru_1_out_t0_11 + (0.84645849466323853) * gru_1_out_t0_12 + (-1.4450067281723022) * gru_1_out_t0_13 + (-0.17330382764339447) * gru_1_out_t0_14 + (0.55864948034286499) * gru_1_out_t0_15 + (-0.53564882278442383) * gru_1_out_t0_16 + (0.29013726115226746) * gru_1_out_t0_17 + (0.23183004558086395) * gru_1_out_t0_18 + (-0.15396611392498016) * gru_1_out_t0_19 + (0.12737785279750824) * gru_1_out_t0_20 + (1.5095975399017334) * gru_1_out_t0_21 + (0.23359082639217377) * gru_1_out_t0_22 + (0.71496415138244629) * gru_1_out_t0_23 + (0.0038493233732879162) * gru_1_out_t0_24 + (-0.097147755324840546) * gru_1_out_t0_25 + (0.1518254280090332) * gru_1_out_t0_26 + (-0.15905162692070007) * gru_1_out_t0_27 + (0.97296661138534546) * gru_1_out_t0_28 + (0.46421292424201965) * gru_1_out_t0_29 + (1.1318730115890503) * gru_1_out_t0_30 + (0.0012410178314894438) * gru_1_out_t0_31 + (0.43683835864067078) * gru_1_out_t0_32 + (0.40905389189720154) * gru_1_out_t0_33 + (-0.65777236223220825) * gru_1_out_t0_34 + (1.2982580661773682) * gru_1_out_t0_35 + (1.3712904453277588) * gru_1_out_t0_36 + (0.39106607437133789) * gru_1_out_t0_37 + (-0.067429102957248688) * gru_1_out_t0_38 + (0.63399028778076172) * gru_1_out_t0_39 + (-1.3093798160552979) * gru_1_out_t0_40 + (0.94386583566665649) * gru_1_out_t0_41 + (0.88779395818710327) * gru_1_out_t0_42 + (-2.5344448089599609) * gru_1_out_t0_43 + (1.0624871253967285) * gru_1_out_t0_44 + (-1.8341507911682129) * gru_1_out_t0_45 + (0.44010511040687561) * gru_1_out_t0_46 + (0.9182397723197937) * gru_1_out_t0_47 + (0.22666558623313904) * gru_1_out_t0_48 + (-0.45270946621894836) * gru_1_out_t0_49 + (-0.42759788036346436) * gru_1_out_t0_50 + (0.35173124074935913) * gru_1_out_t0_51 + (0.046317264437675476) * gru_1_out_t0_52 + (0.31908741593360901) * gru_1_out_t0_53 + (-0.25950795412063599) * gru_1_out_t0_54 + (0.67543625831604004) * gru_1_out_t0_55 + (1.809598445892334) * gru_1_out_t0_56 + (0.48504635691642761) * gru_1_out_t0_57 + (0.5902666449546814) * gru_1_out_t0_58 + (0.45628821849822998) * gru_1_out_t0_59 + (1.8319989442825317) * gru_1_out_t0_60 + (0.62336850166320801) * gru_1_out_t0_61 + (-0.64004701375961304) * gru_1_out_t0_62 + (-0.12148680537939072) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.13255952298641205) + (-0.55883419513702393) * gru_1_out_t0_0 + (0.14030671119689941) * gru_1_out_t0_1 + (-0.25962820649147034) * gru_1_out_t0_2 + (0.49126142263412476) * gru_1_out_t0_3 + (0.3657798171043396) * gru_1_out_t0_4 + (0.48353138566017151) * gru_1_out_t0_5 + (-1.3399809598922729) * gru_1_out_t0_6 + (0.14969098567962646) * gru_1_out_t0_7 + (0.84376102685928345) * gru_1_out_t0_8 + (-0.28111258149147034) * gru_1_out_t0_9 + (0.332344651222229) * gru_1_out_t0_10 + (0.23340348899364471) * gru_1_out_t0_11 + (0.71632260084152222) * gru_1_out_t0_12 + (-0.080833494663238525) * gru_1_out_t0_13 + (-0.26049193739891052) * gru_1_out_t0_14 + (0.2281792014837265) * gru_1_out_t0_15 + (-0.61934494972229004) * gru_1_out_t0_16 + (-0.1803562194108963) * gru_1_out_t0_17 + (-0.50407940149307251) * gru_1_out_t0_18 + (-0.31688818335533142) * gru_1_out_t0_19 + (0.14714577794075012) * gru_1_out_t0_20 + (0.1356513500213623) * gru_1_out_t0_21 + (-0.28133454918861389) * gru_1_out_t0_22 + (0.76639950275421143) * gru_1_out_t0_23 + (-0.45733624696731567) * gru_1_out_t0_24 + (0.63386327028274536) * gru_1_out_t0_25 + (0.24382221698760986) * gru_1_out_t0_26 + (-0.49925675988197327) * gru_1_out_t0_27 + (0.060152303427457809) * gru_1_out_t0_28 + (-0.68578505516052246) * gru_1_out_t0_29 + (-0.017029440030455589) * gru_1_out_t0_30 + (0.11803505569696426) * gru_1_out_t0_31 + (1.1626839637756348) * gru_1_out_t0_32 + (0.38862785696983337) * gru_1_out_t0_33 + (-0.15951475501060486) * gru_1_out_t0_34 + (0.16251328587532043) * gru_1_out_t0_35 + (-0.53205138444900513) * gru_1_out_t0_36 + (0.085023634135723114) * gru_1_out_t0_37 + (-0.20326483249664307) * gru_1_out_t0_38 + (0.40539881587028503) * gru_1_out_t0_39 + (0.46895354986190796) * gru_1_out_t0_40 + (0.20888559520244598) * gru_1_out_t0_41 + (1.0912764072418213) * gru_1_out_t0_42 + (0.069236606359481812) * gru_1_out_t0_43 + (-0.098227694630622864) * gru_1_out_t0_44 + (0.31580546498298645) * gru_1_out_t0_45 + (0.31177857518196106) * gru_1_out_t0_46 + (0.63868939876556396) * gru_1_out_t0_47 + (0.21140366792678833) * gru_1_out_t0_48 + (0.17980995774269104) * gru_1_out_t0_49 + (0.46596798300743103) * gru_1_out_t0_50 + (-2.1383142471313477) * gru_1_out_t0_51 + (-0.75013530254364014) * gru_1_out_t0_52 + (0.49293678998947144) * gru_1_out_t0_53 + (0.83143013715744019) * gru_1_out_t0_54 + (0.015607022680342197) * gru_1_out_t0_55 + (-0.73226642608642578) * gru_1_out_t0_56 + (0.17624768614768982) * gru_1_out_t0_57 + (0.060565326362848282) * gru_1_out_t0_58 + (1.1314330101013184) * gru_1_out_t0_59 + (0.30861937999725342) * gru_1_out_t0_60 + (0.060700394213199615) * gru_1_out_t0_61 + (0.10355164110660553) * gru_1_out_t0_62 + (0.17478218674659729) * gru_1_out_t0_63);
    gate_n = tanh((-0.41778099536895752) + (0.0095594227313995361) * gru_1_out_t0_0 + (-1.3231042623519897) * gru_1_out_t0_1 + (0.15466630458831787) * gru_1_out_t0_2 + (-0.025127293542027473) * gru_1_out_t0_3 + (0.048250522464513779) * gru_1_out_t0_4 + (0.1969936192035675) * gru_1_out_t0_5 + (-1.916151762008667) * gru_1_out_t0_6 + (-0.10891006141901016) * gru_1_out_t0_7 + (-0.28521513938903809) * gru_1_out_t0_8 + (-0.15668825805187225) * gru_1_out_t0_9 + (-0.053943119943141937) * gru_1_out_t0_10 + (-0.090261049568653107) * gru_1_out_t0_11 + (-0.11900219321250916) * gru_1_out_t0_12 + (0.061616137623786926) * gru_1_out_t0_13 + (0.061735823750495911) * gru_1_out_t0_14 + (0.15280231833457947) * gru_1_out_t0_15 + (-0.2402796745300293) * gru_1_out_t0_16 + (-0.22904171049594879) * gru_1_out_t0_17 + (0.31377232074737549) * gru_1_out_t0_18 + (-0.18095405399799347) * gru_1_out_t0_19 + (-0.089521989226341248) * gru_1_out_t0_20 + (-0.88325875997543335) * gru_1_out_t0_21 + (0.41251394152641296) * gru_1_out_t0_22 + (0.091502927243709564) * gru_1_out_t0_23 + (0.51780575513839722) * gru_1_out_t0_24 + (-0.38825365900993347) * gru_1_out_t0_25 + (-0.31793114542961121) * gru_1_out_t0_26 + (-0.49099335074424744) * gru_1_out_t0_27 + (0.255170077085495) * gru_1_out_t0_28 + (0.27161711454391479) * gru_1_out_t0_29 + (-1.6192402839660645) * gru_1_out_t0_30 + (0.85144037008285522) * gru_1_out_t0_31 + (0.3300652801990509) * gru_1_out_t0_32 + (0.19546380639076233) * gru_1_out_t0_33 + (-0.21378576755523682) * gru_1_out_t0_34 + (1.1446200609207153) * gru_1_out_t0_35 + (-1.1469582319259644) * gru_1_out_t0_36 + (-0.052663493901491165) * gru_1_out_t0_37 + (-0.59846252202987671) * gru_1_out_t0_38 + (0.15347051620483398) * gru_1_out_t0_39 + (0.66116821765899658) * gru_1_out_t0_40 + (-0.097912363708019257) * gru_1_out_t0_41 + (0.63647204637527466) * gru_1_out_t0_42 + (0.61152142286300659) * gru_1_out_t0_43 + (-0.79150170087814331) * gru_1_out_t0_44 + (0.031156096607446671) * gru_1_out_t0_45 + (0.43415549397468567) * gru_1_out_t0_46 + (0.43316754698753357) * gru_1_out_t0_47 + (0.020345848053693771) * gru_1_out_t0_48 + (0.38068872690200806) * gru_1_out_t0_49 + (0.48539495468139648) * gru_1_out_t0_50 + (-0.90086746215820312) * gru_1_out_t0_51 + (-0.66446137428283691) * gru_1_out_t0_52 + (-0.28305345773696899) * gru_1_out_t0_53 + (-0.30623158812522888) * gru_1_out_t0_54 + (0.59654539823532104) * gru_1_out_t0_55 + (-0.45147988200187683) * gru_1_out_t0_56 + (-0.32875630259513855) * gru_1_out_t0_57 + (0.37799277901649475) * gru_1_out_t0_58 + (0.48912498354911804) * gru_1_out_t0_59 + (0.62139350175857544) * gru_1_out_t0_60 + (-0.11775408685207367) * gru_1_out_t0_61 + (0.53859543800354004) * gru_1_out_t0_62 + (0.55621296167373657) * gru_1_out_t0_63 + gate_r * (-0.64109975099563599));
    gru_2_fwd_t0_h_22 = (1.0 - gate_z) * gate_n;
    // h=23
    gate_r = sigmoid((1.3856973648071289) + (0.78917241096496582) * gru_1_out_t0_0 + (-1.2410851716995239) * gru_1_out_t0_1 + (-0.44381237030029297) * gru_1_out_t0_2 + (-0.62441092729568481) * gru_1_out_t0_3 + (-0.91051661968231201) * gru_1_out_t0_4 + (1.4601631164550781) * gru_1_out_t0_5 + (-3.4535882472991943) * gru_1_out_t0_6 + (-0.45458415150642395) * gru_1_out_t0_7 + (-0.49291566014289856) * gru_1_out_t0_8 + (-0.84441125392913818) * gru_1_out_t0_9 + (-0.04696110263466835) * gru_1_out_t0_10 + (-1.3350522518157959) * gru_1_out_t0_11 + (-0.28869199752807617) * gru_1_out_t0_12 + (-0.89669430255889893) * gru_1_out_t0_13 + (-0.47325077652931213) * gru_1_out_t0_14 + (0.021392161026597023) * gru_1_out_t0_15 + (-0.39350202679634094) * gru_1_out_t0_16 + (1.3474031686782837) * gru_1_out_t0_17 + (-0.097958572208881378) * gru_1_out_t0_18 + (-0.94190323352813721) * gru_1_out_t0_19 + (-0.32520270347595215) * gru_1_out_t0_20 + (1.1677086353302002) * gru_1_out_t0_21 + (0.50687336921691895) * gru_1_out_t0_22 + (1.9845380783081055) * gru_1_out_t0_23 + (0.084130242466926575) * gru_1_out_t0_24 + (1.452276349067688) * gru_1_out_t0_25 + (0.1216854453086853) * gru_1_out_t0_26 + (-0.62771636247634888) * gru_1_out_t0_27 + (1.4205021858215332) * gru_1_out_t0_28 + (-0.34562093019485474) * gru_1_out_t0_29 + (-2.0372970104217529) * gru_1_out_t0_30 + (0.58200746774673462) * gru_1_out_t0_31 + (0.35316601395606995) * gru_1_out_t0_32 + (0.93197321891784668) * gru_1_out_t0_33 + (1.3245409727096558) * gru_1_out_t0_34 + (-0.13875153660774231) * gru_1_out_t0_35 + (-0.84670549631118774) * gru_1_out_t0_36 + (-0.38243004679679871) * gru_1_out_t0_37 + (-0.80935955047607422) * gru_1_out_t0_38 + (0.96766942739486694) * gru_1_out_t0_39 + (0.62332040071487427) * gru_1_out_t0_40 + (0.59718614816665649) * gru_1_out_t0_41 + (3.4287214279174805) * gru_1_out_t0_42 + (0.41077601909637451) * gru_1_out_t0_43 + (-0.90998506546020508) * gru_1_out_t0_44 + (0.4972166121006012) * gru_1_out_t0_45 + (0.45989957451820374) * gru_1_out_t0_46 + (-0.21847198903560638) * gru_1_out_t0_47 + (1.8623566627502441) * gru_1_out_t0_48 + (0.71135604381561279) * gru_1_out_t0_49 + (0.25240659713745117) * gru_1_out_t0_50 + (-0.53833550214767456) * gru_1_out_t0_51 + (-0.86469793319702148) * gru_1_out_t0_52 + (-0.40980842709541321) * gru_1_out_t0_53 + (-0.37177255749702454) * gru_1_out_t0_54 + (0.63687354326248169) * gru_1_out_t0_55 + (-1.8544310331344604) * gru_1_out_t0_56 + (-0.20980633795261383) * gru_1_out_t0_57 + (-0.64017903804779053) * gru_1_out_t0_58 + (0.41707900166511536) * gru_1_out_t0_59 + (-3.6738555431365967) * gru_1_out_t0_60 + (-2.4399979114532471) * gru_1_out_t0_61 + (1.0465980768203735) * gru_1_out_t0_62 + (1.2781497240066528) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.080896459519863129) + (-0.20545960962772369) * gru_1_out_t0_0 + (0.14881576597690582) * gru_1_out_t0_1 + (-0.39357256889343262) * gru_1_out_t0_2 + (0.40238288044929504) * gru_1_out_t0_3 + (0.30182197690010071) * gru_1_out_t0_4 + (0.31502607464790344) * gru_1_out_t0_5 + (1.0386515855789185) * gru_1_out_t0_6 + (-0.087774969637393951) * gru_1_out_t0_7 + (1.2227314710617065) * gru_1_out_t0_8 + (0.20022973418235779) * gru_1_out_t0_9 + (-0.24202157557010651) * gru_1_out_t0_10 + (0.28753301501274109) * gru_1_out_t0_11 + (0.40048006176948547) * gru_1_out_t0_12 + (-0.14606863260269165) * gru_1_out_t0_13 + (0.066339954733848572) * gru_1_out_t0_14 + (-0.31292611360549927) * gru_1_out_t0_15 + (0.49535605311393738) * gru_1_out_t0_16 + (0.25644275546073914) * gru_1_out_t0_17 + (-0.096026875078678131) * gru_1_out_t0_18 + (-0.4971981942653656) * gru_1_out_t0_19 + (0.038691829890012741) * gru_1_out_t0_20 + (0.80434513092041016) * gru_1_out_t0_21 + (-0.28771570324897766) * gru_1_out_t0_22 + (-0.23809598386287689) * gru_1_out_t0_23 + (0.67181688547134399) * gru_1_out_t0_24 + (-0.19987352192401886) * gru_1_out_t0_25 + (0.14188650250434875) * gru_1_out_t0_26 + (0.8021395206451416) * gru_1_out_t0_27 + (0.084606409072875977) * gru_1_out_t0_28 + (0.17685984075069427) * gru_1_out_t0_29 + (-0.61622422933578491) * gru_1_out_t0_30 + (-0.25802761316299438) * gru_1_out_t0_31 + (-0.37795373797416687) * gru_1_out_t0_32 + (0.23507475852966309) * gru_1_out_t0_33 + (0.11875605583190918) * gru_1_out_t0_34 + (-0.099364154040813446) * gru_1_out_t0_35 + (0.048919301480054855) * gru_1_out_t0_36 + (-0.48844832181930542) * gru_1_out_t0_37 + (0.28651678562164307) * gru_1_out_t0_38 + (-0.37144291400909424) * gru_1_out_t0_39 + (-0.0076654711738228798) * gru_1_out_t0_40 + (-0.097399845719337463) * gru_1_out_t0_41 + (-0.072898395359516144) * gru_1_out_t0_42 + (-0.088562138378620148) * gru_1_out_t0_43 + (0.49557170271873474) * gru_1_out_t0_44 + (0.18197828531265259) * gru_1_out_t0_45 + (0.28375735878944397) * gru_1_out_t0_46 + (0.087862707674503326) * gru_1_out_t0_47 + (-0.71973758935928345) * gru_1_out_t0_48 + (-0.6486620306968689) * gru_1_out_t0_49 + (-0.067816421389579773) * gru_1_out_t0_50 + (-0.25859501957893372) * gru_1_out_t0_51 + (-0.48113244771957397) * gru_1_out_t0_52 + (-0.035905629396438599) * gru_1_out_t0_53 + (-0.13010518252849579) * gru_1_out_t0_54 + (-0.05888792872428894) * gru_1_out_t0_55 + (-0.26724854111671448) * gru_1_out_t0_56 + (-0.13134163618087769) * gru_1_out_t0_57 + (-0.30570566654205322) * gru_1_out_t0_58 + (0.68446052074432373) * gru_1_out_t0_59 + (0.57993996143341064) * gru_1_out_t0_60 + (0.14256468415260315) * gru_1_out_t0_61 + (-0.27642518281936646) * gru_1_out_t0_62 + (0.21511463820934296) * gru_1_out_t0_63);
    gate_n = tanh((0.31493040919303894) + (0.018777238205075264) * gru_1_out_t0_0 + (0.50696581602096558) * gru_1_out_t0_1 + (0.30875474214553833) * gru_1_out_t0_2 + (0.25567901134490967) * gru_1_out_t0_3 + (0.13182616233825684) * gru_1_out_t0_4 + (-0.54735320806503296) * gru_1_out_t0_5 + (0.74286353588104248) * gru_1_out_t0_6 + (1.0754051208496094) * gru_1_out_t0_7 + (-1.1093050241470337) * gru_1_out_t0_8 + (0.060750111937522888) * gru_1_out_t0_9 + (-0.035665538161993027) * gru_1_out_t0_10 + (-0.39539241790771484) * gru_1_out_t0_11 + (-1.3770726919174194) * gru_1_out_t0_12 + (0.11891638487577438) * gru_1_out_t0_13 + (-0.66599047183990479) * gru_1_out_t0_14 + (-0.78592091798782349) * gru_1_out_t0_15 + (0.1618727445602417) * gru_1_out_t0_16 + (-0.184160515666008) * gru_1_out_t0_17 + (-0.82605141401290894) * gru_1_out_t0_18 + (-0.82823818922042847) * gru_1_out_t0_19 + (0.2318238765001297) * gru_1_out_t0_20 + (-0.69148629903793335) * gru_1_out_t0_21 + (-0.16078698635101318) * gru_1_out_t0_22 + (0.35650956630706787) * gru_1_out_t0_23 + (-1.3228468894958496) * gru_1_out_t0_24 + (-0.52429455518722534) * gru_1_out_t0_25 + (0.66069978475570679) * gru_1_out_t0_26 + (-0.17782846093177795) * gru_1_out_t0_27 + (0.0034028857480734587) * gru_1_out_t0_28 + (-0.70381134748458862) * gru_1_out_t0_29 + (-0.21602743864059448) * gru_1_out_t0_30 + (0.063544310629367828) * gru_1_out_t0_31 + (-0.081784456968307495) * gru_1_out_t0_32 + (-0.11678104102611542) * gru_1_out_t0_33 + (0.73069536685943604) * gru_1_out_t0_34 + (-0.53177756071090698) * gru_1_out_t0_35 + (0.55734020471572876) * gru_1_out_t0_36 + (-0.038893535733222961) * gru_1_out_t0_37 + (-0.55576860904693604) * gru_1_out_t0_38 + (-0.69039314985275269) * gru_1_out_t0_39 + (-0.070776268839836121) * gru_1_out_t0_40 + (0.095408782362937927) * gru_1_out_t0_41 + (-0.092817328870296478) * gru_1_out_t0_42 + (-0.079312272369861603) * gru_1_out_t0_43 + (0.028020810335874557) * gru_1_out_t0_44 + (1.2750213146209717) * gru_1_out_t0_45 + (0.44376742839813232) * gru_1_out_t0_46 + (-0.59220367670059204) * gru_1_out_t0_47 + (0.617725670337677) * gru_1_out_t0_48 + (-0.24988606572151184) * gru_1_out_t0_49 + (-0.67080461978912354) * gru_1_out_t0_50 + (0.44045558571815491) * gru_1_out_t0_51 + (0.44244968891143799) * gru_1_out_t0_52 + (0.23436546325683594) * gru_1_out_t0_53 + (-0.55162256956100464) * gru_1_out_t0_54 + (-0.27711427211761475) * gru_1_out_t0_55 + (0.16119007766246796) * gru_1_out_t0_56 + (0.1161620244383812) * gru_1_out_t0_57 + (0.064772926270961761) * gru_1_out_t0_58 + (-0.22830305993556976) * gru_1_out_t0_59 + (-1.9725714921951294) * gru_1_out_t0_60 + (1.070024847984314) * gru_1_out_t0_61 + (0.068062342703342438) * gru_1_out_t0_62 + (0.91617178916931152) * gru_1_out_t0_63 + gate_r * (0.14955808222293854));
    gru_2_fwd_t0_h_23 = (1.0 - gate_z) * gate_n;
    // h=24
    gate_r = sigmoid((0.4673646092414856) + (0.35247558355331421) * gru_1_out_t0_0 + (0.93637698888778687) * gru_1_out_t0_1 + (-0.10327769070863724) * gru_1_out_t0_2 + (-0.53679114580154419) * gru_1_out_t0_3 + (0.50518035888671875) * gru_1_out_t0_4 + (-0.23685111105442047) * gru_1_out_t0_5 + (-0.62549865245819092) * gru_1_out_t0_6 + (0.2070385068655014) * gru_1_out_t0_7 + (-1.6941090822219849) * gru_1_out_t0_8 + (0.50846403837203979) * gru_1_out_t0_9 + (0.165358766913414) * gru_1_out_t0_10 + (-0.19876578450202942) * gru_1_out_t0_11 + (-0.5457313060760498) * gru_1_out_t0_12 + (-1.3513485193252563) * gru_1_out_t0_13 + (-1.9118117094039917) * gru_1_out_t0_14 + (0.54784864187240601) * gru_1_out_t0_15 + (-0.3699662983417511) * gru_1_out_t0_16 + (-0.36923018097877502) * gru_1_out_t0_17 + (-1.0070182085037231) * gru_1_out_t0_18 + (-0.57311230897903442) * gru_1_out_t0_19 + (0.30371510982513428) * gru_1_out_t0_20 + (-0.37247595191001892) * gru_1_out_t0_21 + (-1.4043493270874023) * gru_1_out_t0_22 + (-0.7820127010345459) * gru_1_out_t0_23 + (-2.5950231552124023) * gru_1_out_t0_24 + (0.60855066776275635) * gru_1_out_t0_25 + (1.0422152280807495) * gru_1_out_t0_26 + (0.46932479739189148) * gru_1_out_t0_27 + (0.31901875138282776) * gru_1_out_t0_28 + (0.81940335035324097) * gru_1_out_t0_29 + (1.4390691518783569) * gru_1_out_t0_30 + (-0.36960998177528381) * gru_1_out_t0_31 + (-0.033101551234722137) * gru_1_out_t0_32 + (-1.1895773410797119) * gru_1_out_t0_33 + (-1.2625670433044434) * gru_1_out_t0_34 + (-0.8538815975189209) * gru_1_out_t0_35 + (1.5695781707763672) * gru_1_out_t0_36 + (0.58618497848510742) * gru_1_out_t0_37 + (-0.12650814652442932) * gru_1_out_t0_38 + (1.0394401550292969) * gru_1_out_t0_39 + (-0.56169015169143677) * gru_1_out_t0_40 + (-0.55560541152954102) * gru_1_out_t0_41 + (-0.16931378841400146) * gru_1_out_t0_42 + (1.2329567670822144) * gru_1_out_t0_43 + (-0.52986359596252441) * gru_1_out_t0_44 + (-1.3312066793441772) * gru_1_out_t0_45 + (0.129588782787323) * gru_1_out_t0_46 + (0.06193215399980545) * gru_1_out_t0_47 + (0.15378542244434357) * gru_1_out_t0_48 + (1.0861635208129883) * gru_1_out_t0_49 + (0.73000043630599976) * gru_1_out_t0_50 + (0.71545624732971191) * gru_1_out_t0_51 + (2.1046969890594482) * gru_1_out_t0_52 + (-0.26057237386703491) * gru_1_out_t0_53 + (-0.43234702944755554) * gru_1_out_t0_54 + (0.076704211533069611) * gru_1_out_t0_55 + (-1.0309680700302124) * gru_1_out_t0_56 + (-0.48905754089355469) * gru_1_out_t0_57 + (0.45485660433769226) * gru_1_out_t0_58 + (0.74517810344696045) * gru_1_out_t0_59 + (0.81629610061645508) * gru_1_out_t0_60 + (0.44307166337966919) * gru_1_out_t0_61 + (-0.52546089887619019) * gru_1_out_t0_62 + (1.8187072277069092) * gru_1_out_t0_63);
    gate_z = sigmoid((0.37149518728256226) + (-0.2052067369222641) * gru_1_out_t0_0 + (-1.2925759553909302) * gru_1_out_t0_1 + (-0.40121445059776306) * gru_1_out_t0_2 + (-0.69402873516082764) * gru_1_out_t0_3 + (-0.44430088996887207) * gru_1_out_t0_4 + (0.16407832503318787) * gru_1_out_t0_5 + (-0.41145831346511841) * gru_1_out_t0_6 + (-0.54956787824630737) * gru_1_out_t0_7 + (0.12248726934194565) * gru_1_out_t0_8 + (-0.36311957240104675) * gru_1_out_t0_9 + (-0.79786151647567749) * gru_1_out_t0_10 + (1.7965935468673706) * gru_1_out_t0_11 + (-0.20941263437271118) * gru_1_out_t0_12 + (0.75773108005523682) * gru_1_out_t0_13 + (0.89026725292205811) * gru_1_out_t0_14 + (0.12352640926837921) * gru_1_out_t0_15 + (0.70307439565658569) * gru_1_out_t0_16 + (-0.34771144390106201) * gru_1_out_t0_17 + (-0.34768441319465637) * gru_1_out_t0_18 + (-0.29592216014862061) * gru_1_out_t0_19 + (-0.21788641810417175) * gru_1_out_t0_20 + (-0.70787304639816284) * gru_1_out_t0_21 + (-0.17936478555202484) * gru_1_out_t0_22 + (0.22118335962295532) * gru_1_out_t0_23 + (-1.2784970998764038) * gru_1_out_t0_24 + (0.86480796337127686) * gru_1_out_t0_25 + (-0.041989702731370926) * gru_1_out_t0_26 + (-0.28476044535636902) * gru_1_out_t0_27 + (1.7493894100189209) * gru_1_out_t0_28 + (0.43033179640769958) * gru_1_out_t0_29 + (-0.77521729469299316) * gru_1_out_t0_30 + (0.18207255005836487) * gru_1_out_t0_31 + (1.1679642200469971) * gru_1_out_t0_32 + (-0.18111643195152283) * gru_1_out_t0_33 + (-0.39127439260482788) * gru_1_out_t0_34 + (0.79954278469085693) * gru_1_out_t0_35 + (0.61915451288223267) * gru_1_out_t0_36 + (-0.163176029920578) * gru_1_out_t0_37 + (-0.41251266002655029) * gru_1_out_t0_38 + (-0.10857484489679337) * gru_1_out_t0_39 + (-0.12926287949085236) * gru_1_out_t0_40 + (-1.0561610460281372) * gru_1_out_t0_41 + (-0.74949777126312256) * gru_1_out_t0_42 + (-0.84209901094436646) * gru_1_out_t0_43 + (-0.50763434171676636) * gru_1_out_t0_44 + (0.85890847444534302) * gru_1_out_t0_45 + (0.29788768291473389) * gru_1_out_t0_46 + (0.39198786020278931) * gru_1_out_t0_47 + (-0.65973258018493652) * gru_1_out_t0_48 + (0.12766410410404205) * gru_1_out_t0_49 + (1.3862347602844238) * gru_1_out_t0_50 + (-0.42722794413566589) * gru_1_out_t0_51 + (-1.0731182098388672) * gru_1_out_t0_52 + (0.52443969249725342) * gru_1_out_t0_53 + (-0.43356230854988098) * gru_1_out_t0_54 + (0.19522799551486969) * gru_1_out_t0_55 + (-1.1219958066940308) * gru_1_out_t0_56 + (-0.21781663596630096) * gru_1_out_t0_57 + (-0.75443059206008911) * gru_1_out_t0_58 + (-0.96104425191879272) * gru_1_out_t0_59 + (-0.10029629617929459) * gru_1_out_t0_60 + (0.062160231173038483) * gru_1_out_t0_61 + (-0.66717654466629028) * gru_1_out_t0_62 + (-0.033043622970581055) * gru_1_out_t0_63);
    gate_n = tanh((0.52527981996536255) + (0.028285833075642586) * gru_1_out_t0_0 + (-0.45029869675636292) * gru_1_out_t0_1 + (-0.55895769596099854) * gru_1_out_t0_2 + (-0.56304472684860229) * gru_1_out_t0_3 + (-0.30793404579162598) * gru_1_out_t0_4 + (0.18651273846626282) * gru_1_out_t0_5 + (-0.61046671867370605) * gru_1_out_t0_6 + (-0.10623575001955032) * gru_1_out_t0_7 + (0.25674808025360107) * gru_1_out_t0_8 + (0.129135861992836) * gru_1_out_t0_9 + (0.34831470251083374) * gru_1_out_t0_10 + (-0.44525894522666931) * gru_1_out_t0_11 + (-0.074231535196304321) * gru_1_out_t0_12 + (0.01831374503672123) * gru_1_out_t0_13 + (-0.048573870211839676) * gru_1_out_t0_14 + (0.19309590756893158) * gru_1_out_t0_15 + (-0.17389845848083496) * gru_1_out_t0_16 + (-0.063781045377254486) * gru_1_out_t0_17 + (0.0015015116659924388) * gru_1_out_t0_18 + (-0.2131815105676651) * gru_1_out_t0_19 + (-0.21812146902084351) * gru_1_out_t0_20 + (-0.64212697744369507) * gru_1_out_t0_21 + (-0.62772631645202637) * gru_1_out_t0_22 + (-0.22713145613670349) * gru_1_out_t0_23 + (0.21193283796310425) * gru_1_out_t0_24 + (0.46509882807731628) * gru_1_out_t0_25 + (-0.7677997350692749) * gru_1_out_t0_26 + (-0.42033210396766663) * gru_1_out_t0_27 + (0.3126315176486969) * gru_1_out_t0_28 + (-0.4197135865688324) * gru_1_out_t0_29 + (0.93476366996765137) * gru_1_out_t0_30 + (-0.26553207635879517) * gru_1_out_t0_31 + (0.33596527576446533) * gru_1_out_t0_32 + (-0.083317659795284271) * gru_1_out_t0_33 + (0.59368115663528442) * gru_1_out_t0_34 + (-0.81892555952072144) * gru_1_out_t0_35 + (0.78556334972381592) * gru_1_out_t0_36 + (0.28016236424446106) * gru_1_out_t0_37 + (-0.03971487283706665) * gru_1_out_t0_38 + (0.5227656364440918) * gru_1_out_t0_39 + (-0.59910601377487183) * gru_1_out_t0_40 + (0.36231544613838196) * gru_1_out_t0_41 + (-0.41476759314537048) * gru_1_out_t0_42 + (-0.42130067944526672) * gru_1_out_t0_43 + (0.1511048823595047) * gru_1_out_t0_44 + (0.81594663858413696) * gru_1_out_t0_45 + (0.08609260618686676) * gru_1_out_t0_46 + (-1.1672836542129517) * gru_1_out_t0_47 + (0.21514579653739929) * gru_1_out_t0_48 + (0.055982101708650589) * gru_1_out_t0_49 + (-0.38753250241279602) * gru_1_out_t0_50 + (0.47130560874938965) * gru_1_out_t0_51 + (0.5247424840927124) * gru_1_out_t0_52 + (-0.36222803592681885) * gru_1_out_t0_53 + (0.17719320952892303) * gru_1_out_t0_54 + (0.18356692790985107) * gru_1_out_t0_55 + (0.79807877540588379) * gru_1_out_t0_56 + (-0.1005273163318634) * gru_1_out_t0_57 + (0.11582723259925842) * gru_1_out_t0_58 + (-0.13494521379470825) * gru_1_out_t0_59 + (-0.32238897681236267) * gru_1_out_t0_60 + (-0.19158834218978882) * gru_1_out_t0_61 + (0.28233730792999268) * gru_1_out_t0_62 + (0.43124166131019592) * gru_1_out_t0_63 + gate_r * (0.21849149465560913));
    gru_2_fwd_t0_h_24 = (1.0 - gate_z) * gate_n;
    // h=25
    gate_r = sigmoid((-0.13911190629005432) + (-0.74884223937988281) * gru_1_out_t0_0 + (1.4952476024627686) * gru_1_out_t0_1 + (-0.096099540591239929) * gru_1_out_t0_2 + (0.33777570724487305) * gru_1_out_t0_3 + (-0.21848736703395844) * gru_1_out_t0_4 + (1.1303707361221313) * gru_1_out_t0_5 + (1.0223513841629028) * gru_1_out_t0_6 + (-0.39082658290863037) * gru_1_out_t0_7 + (-0.15167652070522308) * gru_1_out_t0_8 + (0.20396402478218079) * gru_1_out_t0_9 + (-1.3515660762786865) * gru_1_out_t0_10 + (-0.01382903940975666) * gru_1_out_t0_11 + (0.049498084932565689) * gru_1_out_t0_12 + (-0.20253771543502808) * gru_1_out_t0_13 + (1.2001274824142456) * gru_1_out_t0_14 + (0.091363720595836639) * gru_1_out_t0_15 + (-0.43682795763015747) * gru_1_out_t0_16 + (0.79960834980010986) * gru_1_out_t0_17 + (0.86959719657897949) * gru_1_out_t0_18 + (-0.16588173806667328) * gru_1_out_t0_19 + (0.035142086446285248) * gru_1_out_t0_20 + (1.2600973844528198) * gru_1_out_t0_21 + (1.5998013019561768) * gru_1_out_t0_22 + (0.51038116216659546) * gru_1_out_t0_23 + (1.8165864944458008) * gru_1_out_t0_24 + (-0.24423703551292419) * gru_1_out_t0_25 + (-0.096976049244403839) * gru_1_out_t0_26 + (0.41760867834091187) * gru_1_out_t0_27 + (0.22566437721252441) * gru_1_out_t0_28 + (0.67941039800643921) * gru_1_out_t0_29 + (-1.1434328556060791) * gru_1_out_t0_30 + (-0.77067285776138306) * gru_1_out_t0_31 + (1.5782463550567627) * gru_1_out_t0_32 + (0.97780460119247437) * gru_1_out_t0_33 + (-0.50434446334838867) * gru_1_out_t0_34 + (0.42615470290184021) * gru_1_out_t0_35 + (-0.35157465934753418) * gru_1_out_t0_36 + (-1.5342257022857666) * gru_1_out_t0_37 + (-0.9812089204788208) * gru_1_out_t0_38 + (-0.76583975553512573) * gru_1_out_t0_39 + (0.62424278259277344) * gru_1_out_t0_40 + (0.064028277993202209) * gru_1_out_t0_41 + (-1.7800111770629883) * gru_1_out_t0_42 + (0.86528366804122925) * gru_1_out_t0_43 + (-1.7529394626617432) * gru_1_out_t0_44 + (0.33419892191886902) * gru_1_out_t0_45 + (-1.0739176273345947) * gru_1_out_t0_46 + (-0.42274141311645508) * gru_1_out_t0_47 + (0.83790034055709839) * gru_1_out_t0_48 + (-1.545401930809021) * gru_1_out_t0_49 + (-1.1446218490600586) * gru_1_out_t0_50 + (3.7184476852416992) * gru_1_out_t0_51 + (-1.0489485263824463) * gru_1_out_t0_52 + (-0.06993025541305542) * gru_1_out_t0_53 + (-0.29259073734283447) * gru_1_out_t0_54 + (-1.2040654420852661) * gru_1_out_t0_55 + (0.019697174429893494) * gru_1_out_t0_56 + (0.23414821922779083) * gru_1_out_t0_57 + (0.054722469300031662) * gru_1_out_t0_58 + (-0.95283716917037964) * gru_1_out_t0_59 + (-0.93420910835266113) * gru_1_out_t0_60 + (0.0018306792480871081) * gru_1_out_t0_61 + (1.202085018157959) * gru_1_out_t0_62 + (0.8555063009262085) * gru_1_out_t0_63);
    gate_z = sigmoid((0.68813371658325195) + (-0.038842715322971344) * gru_1_out_t0_0 + (0.11078698933124542) * gru_1_out_t0_1 + (0.49061894416809082) * gru_1_out_t0_2 + (0.093512430787086487) * gru_1_out_t0_3 + (0.13934674859046936) * gru_1_out_t0_4 + (1.3907451629638672) * gru_1_out_t0_5 + (0.041032511740922928) * gru_1_out_t0_6 + (0.31529819965362549) * gru_1_out_t0_7 + (0.092930600047111511) * gru_1_out_t0_8 + (-0.71662938594818115) * gru_1_out_t0_9 + (-0.67985343933105469) * gru_1_out_t0_10 + (-0.69343370199203491) * gru_1_out_t0_11 + (0.14162690937519073) * gru_1_out_t0_12 + (0.1818174421787262) * gru_1_out_t0_13 + (0.66497665643692017) * gru_1_out_t0_14 + (-0.10337434709072113) * gru_1_out_t0_15 + (0.50752937793731689) * gru_1_out_t0_16 + (0.28734299540519714) * gru_1_out_t0_17 + (0.01458175852894783) * gru_1_out_t0_18 + (-0.21465873718261719) * gru_1_out_t0_19 + (0.66359204053878784) * gru_1_out_t0_20 + (0.56994479894638062) * gru_1_out_t0_21 + (0.50571787357330322) * gru_1_out_t0_22 + (0.33632180094718933) * gru_1_out_t0_23 + (0.53706032037734985) * gru_1_out_t0_24 + (0.15992997586727142) * gru_1_out_t0_25 + (-0.09399230033159256) * gru_1_out_t0_26 + (0.063154846429824829) * gru_1_out_t0_27 + (-0.21219570934772491) * gru_1_out_t0_28 + (0.087515860795974731) * gru_1_out_t0_29 + (-1.0134462118148804) * gru_1_out_t0_30 + (0.53287994861602783) * gru_1_out_t0_31 + (-0.1646883636713028) * gru_1_out_t0_32 + (-0.24773561954498291) * gru_1_out_t0_33 + (0.168839231133461) * gru_1_out_t0_34 + (0.046957653015851974) * gru_1_out_t0_35 + (0.63433152437210083) * gru_1_out_t0_36 + (-0.20580798387527466) * gru_1_out_t0_37 + (0.23009791970252991) * gru_1_out_t0_38 + (0.39112651348114014) * gru_1_out_t0_39 + (0.24010251462459564) * gru_1_out_t0_40 + (0.10770433396100998) * gru_1_out_t0_41 + (-0.35188135504722595) * gru_1_out_t0_42 + (0.09411156177520752) * gru_1_out_t0_43 + (0.52559030055999756) * gru_1_out_t0_44 + (0.13654491305351257) * gru_1_out_t0_45 + (0.55550724267959595) * gru_1_out_t0_46 + (-0.49137145280838013) * gru_1_out_t0_47 + (-0.054394543170928955) * gru_1_out_t0_48 + (-0.50316739082336426) * gru_1_out_t0_49 + (0.27084836363792419) * gru_1_out_t0_50 + (1.4028559923171997) * gru_1_out_t0_51 + (0.063805505633354187) * gru_1_out_t0_52 + (0.51783382892608643) * gru_1_out_t0_53 + (-0.76736998558044434) * gru_1_out_t0_54 + (-0.51454848051071167) * gru_1_out_t0_55 + (-0.091150820255279541) * gru_1_out_t0_56 + (0.39368349313735962) * gru_1_out_t0_57 + (0.72896087169647217) * gru_1_out_t0_58 + (0.28375953435897827) * gru_1_out_t0_59 + (-0.70826739072799683) * gru_1_out_t0_60 + (0.41784539818763733) * gru_1_out_t0_61 + (-0.27206134796142578) * gru_1_out_t0_62 + (0.14112566411495209) * gru_1_out_t0_63);
    gate_n = tanh((-0.074005588889122009) + (-1.2369143962860107) * gru_1_out_t0_0 + (0.68402111530303955) * gru_1_out_t0_1 + (0.66591501235961914) * gru_1_out_t0_2 + (-0.04051496833562851) * gru_1_out_t0_3 + (-0.47070527076721191) * gru_1_out_t0_4 + (3.0898900032043457) * gru_1_out_t0_5 + (1.5335904359817505) * gru_1_out_t0_6 + (0.08094005286693573) * gru_1_out_t0_7 + (0.71569567918777466) * gru_1_out_t0_8 + (0.15385781228542328) * gru_1_out_t0_9 + (-0.8374055027961731) * gru_1_out_t0_10 + (-0.12457315623760223) * gru_1_out_t0_11 + (0.29568672180175781) * gru_1_out_t0_12 + (-0.65149110555648804) * gru_1_out_t0_13 + (-0.23395073413848877) * gru_1_out_t0_14 + (0.60972332954406738) * gru_1_out_t0_15 + (1.6616543531417847) * gru_1_out_t0_16 + (-0.57126426696777344) * gru_1_out_t0_17 + (-2.2264351844787598) * gru_1_out_t0_18 + (0.18242144584655762) * gru_1_out_t0_19 + (-0.25245964527130127) * gru_1_out_t0_20 + (-1.122431755065918) * gru_1_out_t0_21 + (0.94328534603118896) * gru_1_out_t0_22 + (3.9716353416442871) * gru_1_out_t0_23 + (1.5939474105834961) * gru_1_out_t0_24 + (0.037542574107646942) * gru_1_out_t0_25 + (-0.24186427891254425) * gru_1_out_t0_26 + (-1.8668984174728394) * gru_1_out_t0_27 + (2.4404745101928711) * gru_1_out_t0_28 + (0.36105954647064209) * gru_1_out_t0_29 + (-3.4821517467498779) * gru_1_out_t0_30 + (-1.9511008262634277) * gru_1_out_t0_31 + (-0.85294145345687866) * gru_1_out_t0_32 + (-0.69362270832061768) * gru_1_out_t0_33 + (0.477102130651474) * gru_1_out_t0_34 + (-0.57014793157577515) * gru_1_out_t0_35 + (0.49566829204559326) * gru_1_out_t0_36 + (-0.17568893730640411) * gru_1_out_t0_37 + (-0.080022819340229034) * gru_1_out_t0_38 + (0.32815268635749817) * gru_1_out_t0_39 + (-0.050667185336351395) * gru_1_out_t0_40 + (-0.34652537107467651) * gru_1_out_t0_41 + (-0.56599670648574829) * gru_1_out_t0_42 + (0.53619307279586792) * gru_1_out_t0_43 + (2.14048171043396) * gru_1_out_t0_44 + (0.72516930103302002) * gru_1_out_t0_45 + (0.77292543649673462) * gru_1_out_t0_46 + (-2.2475216388702393) * gru_1_out_t0_47 + (0.26747500896453857) * gru_1_out_t0_48 + (-1.1024981737136841) * gru_1_out_t0_49 + (0.44986778497695923) * gru_1_out_t0_50 + (-0.55125731229782104) * gru_1_out_t0_51 + (0.52797782421112061) * gru_1_out_t0_52 + (0.12135373800992966) * gru_1_out_t0_53 + (-0.59775501489639282) * gru_1_out_t0_54 + (0.35554921627044678) * gru_1_out_t0_55 + (1.0247483253479004) * gru_1_out_t0_56 + (-0.38548266887664795) * gru_1_out_t0_57 + (-0.059060920029878616) * gru_1_out_t0_58 + (0.20514534413814545) * gru_1_out_t0_59 + (1.9166020154953003) * gru_1_out_t0_60 + (0.66354537010192871) * gru_1_out_t0_61 + (-1.3004556894302368) * gru_1_out_t0_62 + (0.22160391509532928) * gru_1_out_t0_63 + gate_r * (0.44456362724304199));
    gru_2_fwd_t0_h_25 = (1.0 - gate_z) * gate_n;
    // h=26
    gate_r = sigmoid((0.10689800232648849) + (-0.18316248059272766) * gru_1_out_t0_0 + (1.4888871908187866) * gru_1_out_t0_1 + (0.15313154458999634) * gru_1_out_t0_2 + (-0.73088455200195312) * gru_1_out_t0_3 + (-0.35855385661125183) * gru_1_out_t0_4 + (0.54722040891647339) * gru_1_out_t0_5 + (0.22342461347579956) * gru_1_out_t0_6 + (-0.06343609094619751) * gru_1_out_t0_7 + (-0.032313812524080276) * gru_1_out_t0_8 + (0.18431994318962097) * gru_1_out_t0_9 + (-0.85149061679840088) * gru_1_out_t0_10 + (0.38520386815071106) * gru_1_out_t0_11 + (-0.2541237473487854) * gru_1_out_t0_12 + (1.1792020797729492) * gru_1_out_t0_13 + (1.1283130645751953) * gru_1_out_t0_14 + (0.054941780865192413) * gru_1_out_t0_15 + (0.43381932377815247) * gru_1_out_t0_16 + (-0.55045437812805176) * gru_1_out_t0_17 + (-0.96835780143737793) * gru_1_out_t0_18 + (0.18522128462791443) * gru_1_out_t0_19 + (0.29718068242073059) * gru_1_out_t0_20 + (0.25216600298881531) * gru_1_out_t0_21 + (-0.26735836267471313) * gru_1_out_t0_22 + (3.1086788177490234) * gru_1_out_t0_23 + (-0.19657939672470093) * gru_1_out_t0_24 + (0.54944878816604614) * gru_1_out_t0_25 + (-0.40156117081642151) * gru_1_out_t0_26 + (-0.15184205770492554) * gru_1_out_t0_27 + (1.9075691699981689) * gru_1_out_t0_28 + (0.10091401636600494) * gru_1_out_t0_29 + (-3.1260185241699219) * gru_1_out_t0_30 + (0.32227304577827454) * gru_1_out_t0_31 + (-1.4731384515762329) * gru_1_out_t0_32 + (0.72767829895019531) * gru_1_out_t0_33 + (-0.13296008110046387) * gru_1_out_t0_34 + (1.1502406597137451) * gru_1_out_t0_35 + (0.47861200571060181) * gru_1_out_t0_36 + (1.0191847085952759) * gru_1_out_t0_37 + (0.26508703827857971) * gru_1_out_t0_38 + (0.75664412975311279) * gru_1_out_t0_39 + (0.45910665392875671) * gru_1_out_t0_40 + (-0.11774518340826035) * gru_1_out_t0_41 + (0.4339066743850708) * gru_1_out_t0_42 + (-0.20965863764286041) * gru_1_out_t0_43 + (-0.22902439534664154) * gru_1_out_t0_44 + (-0.45312735438346863) * gru_1_out_t0_45 + (0.17511627078056335) * gru_1_out_t0_46 + (-0.81364274024963379) * gru_1_out_t0_47 + (1.5442333221435547) * gru_1_out_t0_48 + (0.34145262837409973) * gru_1_out_t0_49 + (0.77093714475631714) * gru_1_out_t0_50 + (0.24053916335105896) * gru_1_out_t0_51 + (-0.41484370827674866) * gru_1_out_t0_52 + (0.17817206680774689) * gru_1_out_t0_53 + (-0.47277680039405823) * gru_1_out_t0_54 + (0.080902554094791412) * gru_1_out_t0_55 + (-1.4545679092407227) * gru_1_out_t0_56 + (0.1859317272901535) * gru_1_out_t0_57 + (0.032128423452377319) * gru_1_out_t0_58 + (-1.3250042200088501) * gru_1_out_t0_59 + (-0.77583754062652588) * gru_1_out_t0_60 + (-0.61020517349243164) * gru_1_out_t0_61 + (0.77488654851913452) * gru_1_out_t0_62 + (0.23833677172660828) * gru_1_out_t0_63);
    gate_z = sigmoid((1.4906297922134399) + (-0.10185521095991135) * gru_1_out_t0_0 + (-0.17789915204048157) * gru_1_out_t0_1 + (0.40005728602409363) * gru_1_out_t0_2 + (-0.33060839772224426) * gru_1_out_t0_3 + (-0.1648714691400528) * gru_1_out_t0_4 + (1.4689217805862427) * gru_1_out_t0_5 + (-0.088939473032951355) * gru_1_out_t0_6 + (0.086823001503944397) * gru_1_out_t0_7 + (-0.17372195422649384) * gru_1_out_t0_8 + (0.024666471406817436) * gru_1_out_t0_9 + (-0.07053443044424057) * gru_1_out_t0_10 + (0.014476575888693333) * gru_1_out_t0_11 + (-0.94500696659088135) * gru_1_out_t0_12 + (-0.36262384057044983) * gru_1_out_t0_13 + (0.22860568761825562) * gru_1_out_t0_14 + (0.051371399313211441) * gru_1_out_t0_15 + (0.94250297546386719) * gru_1_out_t0_16 + (0.43795901536941528) * gru_1_out_t0_17 + (0.0035999349784106016) * gru_1_out_t0_18 + (-0.74355554580688477) * gru_1_out_t0_19 + (0.25715804100036621) * gru_1_out_t0_20 + (1.2550472021102905) * gru_1_out_t0_21 + (1.5005980730056763) * gru_1_out_t0_22 + (-0.048415329307317734) * gru_1_out_t0_23 + (-0.3682730495929718) * gru_1_out_t0_24 + (0.19391992688179016) * gru_1_out_t0_25 + (0.63027507066726685) * gru_1_out_t0_26 + (0.038145389407873154) * gru_1_out_t0_27 + (-0.028867334127426147) * gru_1_out_t0_28 + (-0.123035728931427) * gru_1_out_t0_29 + (0.97668689489364624) * gru_1_out_t0_30 + (0.20128707587718964) * gru_1_out_t0_31 + (0.29799702763557434) * gru_1_out_t0_32 + (-0.094211295247077942) * gru_1_out_t0_33 + (-0.057660255581140518) * gru_1_out_t0_34 + (0.16921858489513397) * gru_1_out_t0_35 + (1.1242141723632812) * gru_1_out_t0_36 + (0.27940800786018372) * gru_1_out_t0_37 + (-0.35793983936309814) * gru_1_out_t0_38 + (-0.37903618812561035) * gru_1_out_t0_39 + (0.043937820941209793) * gru_1_out_t0_40 + (-0.18020065128803253) * gru_1_out_t0_41 + (0.14797677099704742) * gru_1_out_t0_42 + (0.29885107278823853) * gru_1_out_t0_43 + (-0.061922866851091385) * gru_1_out_t0_44 + (0.36354097723960876) * gru_1_out_t0_45 + (-0.22548997402191162) * gru_1_out_t0_46 + (-1.0071890354156494) * gru_1_out_t0_47 + (-0.10394540429115295) * gru_1_out_t0_48 + (0.1631205677986145) * gru_1_out_t0_49 + (0.13262827694416046) * gru_1_out_t0_50 + (0.96944731473922729) * gru_1_out_t0_51 + (1.1466548442840576) * gru_1_out_t0_52 + (0.68706876039505005) * gru_1_out_t0_53 + (1.0062174797058105) * gru_1_out_t0_54 + (0.05204014852643013) * gru_1_out_t0_55 + (0.17742727696895599) * gru_1_out_t0_56 + (-0.30688273906707764) * gru_1_out_t0_57 + (0.91437047719955444) * gru_1_out_t0_58 + (-0.45980426669120789) * gru_1_out_t0_59 + (0.53268724679946899) * gru_1_out_t0_60 + (0.18460473418235779) * gru_1_out_t0_61 + (0.77188771963119507) * gru_1_out_t0_62 + (0.70561343431472778) * gru_1_out_t0_63);
    gate_n = tanh((0.054834265261888504) + (-0.46956756711006165) * gru_1_out_t0_0 + (0.14283636212348938) * gru_1_out_t0_1 + (0.71871387958526611) * gru_1_out_t0_2 + (-1.041450023651123) * gru_1_out_t0_3 + (-0.33199092745780945) * gru_1_out_t0_4 + (0.5341455340385437) * gru_1_out_t0_5 + (-1.0786583423614502) * gru_1_out_t0_6 + (0.090845033526420593) * gru_1_out_t0_7 + (-0.049735378473997116) * gru_1_out_t0_8 + (0.21218626201152802) * gru_1_out_t0_9 + (0.054017063230276108) * gru_1_out_t0_10 + (-0.40643242001533508) * gru_1_out_t0_11 + (0.38050305843353271) * gru_1_out_t0_12 + (-1.531998872756958) * gru_1_out_t0_13 + (-0.71277469396591187) * gru_1_out_t0_14 + (-0.12473146617412567) * gru_1_out_t0_15 + (0.48627570271492004) * gru_1_out_t0_16 + (-0.11893695592880249) * gru_1_out_t0_17 + (-0.54584187269210815) * gru_1_out_t0_18 + (-0.88483947515487671) * gru_1_out_t0_19 + (-0.15610051155090332) * gru_1_out_t0_20 + (-0.58347874879837036) * gru_1_out_t0_21 + (-0.51420849561691284) * gru_1_out_t0_22 + (1.72075355052948) * gru_1_out_t0_23 + (-0.47643214464187622) * gru_1_out_t0_24 + (0.30141738057136536) * gru_1_out_t0_25 + (-0.15457440912723541) * gru_1_out_t0_26 + (-0.7765997052192688) * gru_1_out_t0_27 + (1.2824186086654663) * gru_1_out_t0_28 + (0.13060513138771057) * gru_1_out_t0_29 + (-0.42382964491844177) * gru_1_out_t0_30 + (2.1138098239898682) * gru_1_out_t0_31 + (0.02286246232688427) * gru_1_out_t0_32 + (0.25586074590682983) * gru_1_out_t0_33 + (0.29201480746269226) * gru_1_out_t0_34 + (-0.60120928287506104) * gru_1_out_t0_35 + (0.078785531222820282) * gru_1_out_t0_36 + (0.25998204946517944) * gru_1_out_t0_37 + (0.24553139507770538) * gru_1_out_t0_38 + (0.40602850914001465) * gru_1_out_t0_39 + (0.41439637541770935) * gru_1_out_t0_40 + (-0.20253723859786987) * gru_1_out_t0_41 + (-0.46944081783294678) * gru_1_out_t0_42 + (0.10174597054719925) * gru_1_out_t0_43 + (1.1528556346893311) * gru_1_out_t0_44 + (1.3292281627655029) * gru_1_out_t0_45 + (0.43599718809127808) * gru_1_out_t0_46 + (-0.97197705507278442) * gru_1_out_t0_47 + (0.27662080526351929) * gru_1_out_t0_48 + (-0.058269869536161423) * gru_1_out_t0_49 + (-0.13074110448360443) * gru_1_out_t0_50 + (0.58249408006668091) * gru_1_out_t0_51 + (0.66777306795120239) * gru_1_out_t0_52 + (0.14795903861522675) * gru_1_out_t0_53 + (-0.55216234922409058) * gru_1_out_t0_54 + (0.75648421049118042) * gru_1_out_t0_55 + (0.94173383712768555) * gru_1_out_t0_56 + (-0.31568092107772827) * gru_1_out_t0_57 + (0.041591409593820572) * gru_1_out_t0_58 + (0.38527780771255493) * gru_1_out_t0_59 + (-0.11555605381727219) * gru_1_out_t0_60 + (-0.1455942690372467) * gru_1_out_t0_61 + (-2.3821315765380859) * gru_1_out_t0_62 + (0.044680286198854446) * gru_1_out_t0_63 + gate_r * (0.21356229484081268));
    gru_2_fwd_t0_h_26 = (1.0 - gate_z) * gate_n;
    // h=27
    gate_r = sigmoid((0.41580018401145935) + (3.7086246013641357) * gru_1_out_t0_0 + (0.27879434823989868) * gru_1_out_t0_1 + (-0.36931648850440979) * gru_1_out_t0_2 + (0.26378723978996277) * gru_1_out_t0_3 + (-0.8253900408744812) * gru_1_out_t0_4 + (0.43274262547492981) * gru_1_out_t0_5 + (-0.61202269792556763) * gru_1_out_t0_6 + (-0.27769488096237183) * gru_1_out_t0_7 + (-0.044994384050369263) * gru_1_out_t0_8 + (-0.77026087045669556) * gru_1_out_t0_9 + (0.11727739125490189) * gru_1_out_t0_10 + (-0.15276014804840088) * gru_1_out_t0_11 + (0.38785856962203979) * gru_1_out_t0_12 + (2.0633747577667236) * gru_1_out_t0_13 + (-0.52875083684921265) * gru_1_out_t0_14 + (-0.064678587019443512) * gru_1_out_t0_15 + (-0.091352276504039764) * gru_1_out_t0_16 + (0.48003265261650085) * gru_1_out_t0_17 + (2.3973169326782227) * gru_1_out_t0_18 + (0.2015422135591507) * gru_1_out_t0_19 + (-0.51784908771514893) * gru_1_out_t0_20 + (-0.95553076267242432) * gru_1_out_t0_21 + (-0.96238923072814941) * gru_1_out_t0_22 + (-1.6482492685317993) * gru_1_out_t0_23 + (0.95636886358261108) * gru_1_out_t0_24 + (-0.29985335469245911) * gru_1_out_t0_25 + (0.052295487374067307) * gru_1_out_t0_26 + (-1.2501161098480225) * gru_1_out_t0_27 + (0.81457972526550293) * gru_1_out_t0_28 + (-1.0923364162445068) * gru_1_out_t0_29 + (-2.822577953338623) * gru_1_out_t0_30 + (0.50433957576751709) * gru_1_out_t0_31 + (0.19929143786430359) * gru_1_out_t0_32 + (1.3107587099075317) * gru_1_out_t0_33 + (2.2480208873748779) * gru_1_out_t0_34 + (-0.0085353543981909752) * gru_1_out_t0_35 + (-0.1342131495475769) * gru_1_out_t0_36 + (-0.05615336075425148) * gru_1_out_t0_37 + (-0.44415304064750671) * gru_1_out_t0_38 + (-0.73249608278274536) * gru_1_out_t0_39 + (0.88065177202224731) * gru_1_out_t0_40 + (-0.089959278702735901) * gru_1_out_t0_41 + (-0.013593791052699089) * gru_1_out_t0_42 + (-0.62030649185180664) * gru_1_out_t0_43 + (2.1590580940246582) * gru_1_out_t0_44 + (0.62537211179733276) * gru_1_out_t0_45 + (-0.67549538612365723) * gru_1_out_t0_46 + (-0.46986356377601624) * gru_1_out_t0_47 + (-2.7329883575439453) * gru_1_out_t0_48 + (-0.35300147533416748) * gru_1_out_t0_49 + (0.39231079816818237) * gru_1_out_t0_50 + (0.49848547577857971) * gru_1_out_t0_51 + (-1.3591911792755127) * gru_1_out_t0_52 + (0.057544104754924774) * gru_1_out_t0_53 + (0.76176881790161133) * gru_1_out_t0_54 + (-0.25341764092445374) * gru_1_out_t0_55 + (1.1952433586120605) * gru_1_out_t0_56 + (0.13332542777061462) * gru_1_out_t0_57 + (-2.4399712085723877) * gru_1_out_t0_58 + (-0.47432634234428406) * gru_1_out_t0_59 + (-1.255840539932251) * gru_1_out_t0_60 + (0.27080929279327393) * gru_1_out_t0_61 + (-0.69473624229431152) * gru_1_out_t0_62 + (-0.79403865337371826) * gru_1_out_t0_63);
    gate_z = sigmoid((0.32804688811302185) + (0.45961940288543701) * gru_1_out_t0_0 + (0.79854792356491089) * gru_1_out_t0_1 + (-0.051412686705589294) * gru_1_out_t0_2 + (-0.43305358290672302) * gru_1_out_t0_3 + (-0.48481106758117676) * gru_1_out_t0_4 + (-0.91550153493881226) * gru_1_out_t0_5 + (0.61693805456161499) * gru_1_out_t0_6 + (0.40314227342605591) * gru_1_out_t0_7 + (-0.23037973046302795) * gru_1_out_t0_8 + (0.15173393487930298) * gru_1_out_t0_9 + (-0.31163761019706726) * gru_1_out_t0_10 + (-0.37985849380493164) * gru_1_out_t0_11 + (-0.42228677868843079) * gru_1_out_t0_12 + (0.38088586926460266) * gru_1_out_t0_13 + (-0.037102729082107544) * gru_1_out_t0_14 + (0.15762236714363098) * gru_1_out_t0_15 + (0.31431299448013306) * gru_1_out_t0_16 + (-0.45536124706268311) * gru_1_out_t0_17 + (0.94310593605041504) * gru_1_out_t0_18 + (0.70627957582473755) * gru_1_out_t0_19 + (-0.20465125143527985) * gru_1_out_t0_20 + (-0.083394475281238556) * gru_1_out_t0_21 + (-0.16415148973464966) * gru_1_out_t0_22 + (1.0514651536941528) * gru_1_out_t0_23 + (0.76530671119689941) * gru_1_out_t0_24 + (-0.27175509929656982) * gru_1_out_t0_25 + (-0.49267181754112244) * gru_1_out_t0_26 + (0.65047621726989746) * gru_1_out_t0_27 + (-0.56621861457824707) * gru_1_out_t0_28 + (-0.14590355753898621) * gru_1_out_t0_29 + (0.12451981753110886) * gru_1_out_t0_30 + (0.1864459365606308) * gru_1_out_t0_31 + (-0.26697462797164917) * gru_1_out_t0_32 + (-0.14563797414302826) * gru_1_out_t0_33 + (-0.096174284815788269) * gru_1_out_t0_34 + (-0.053099043667316437) * gru_1_out_t0_35 + (0.26278451085090637) * gru_1_out_t0_36 + (-0.47411003708839417) * gru_1_out_t0_37 + (-0.30231022834777832) * gru_1_out_t0_38 + (0.16569596529006958) * gru_1_out_t0_39 + (-0.1551542729139328) * gru_1_out_t0_40 + (-0.013591929338872433) * gru_1_out_t0_41 + (-0.29572036862373352) * gru_1_out_t0_42 + (-0.062138598412275314) * gru_1_out_t0_43 + (-0.37600886821746826) * gru_1_out_t0_44 + (-0.061830911785364151) * gru_1_out_t0_45 + (0.36463576555252075) * gru_1_out_t0_46 + (-0.24188199639320374) * gru_1_out_t0_47 + (-0.16672343015670776) * gru_1_out_t0_48 + (0.21325981616973877) * gru_1_out_t0_49 + (-0.0032028309069573879) * gru_1_out_t0_50 + (0.20494003593921661) * gru_1_out_t0_51 + (-0.0048749828711152077) * gru_1_out_t0_52 + (0.22401495277881622) * gru_1_out_t0_53 + (-0.13976873457431793) * gru_1_out_t0_54 + (-0.22613584995269775) * gru_1_out_t0_55 + (0.4398251473903656) * gru_1_out_t0_56 + (0.32782065868377686) * gru_1_out_t0_57 + (0.08051665872335434) * gru_1_out_t0_58 + (-0.10666608065366745) * gru_1_out_t0_59 + (-0.4341810941696167) * gru_1_out_t0_60 + (0.38550674915313721) * gru_1_out_t0_61 + (-0.02272835373878479) * gru_1_out_t0_62 + (0.32444599270820618) * gru_1_out_t0_63);
    gate_n = tanh((-0.071578800678253174) + (-0.69615578651428223) * gru_1_out_t0_0 + (-0.28391730785369873) * gru_1_out_t0_1 + (0.17077928781509399) * gru_1_out_t0_2 + (-0.83024531602859497) * gru_1_out_t0_3 + (0.68842297792434692) * gru_1_out_t0_4 + (-0.53634905815124512) * gru_1_out_t0_5 + (-0.71416401863098145) * gru_1_out_t0_6 + (0.40654760599136353) * gru_1_out_t0_7 + (-0.23945091664791107) * gru_1_out_t0_8 + (0.85853248834609985) * gru_1_out_t0_9 + (-0.054806482046842575) * gru_1_out_t0_10 + (0.41330164670944214) * gru_1_out_t0_11 + (0.51357185840606689) * gru_1_out_t0_12 + (0.28535473346710205) * gru_1_out_t0_13 + (-6.9654321123380214e-05) * gru_1_out_t0_14 + (0.48430562019348145) * gru_1_out_t0_15 + (0.46909844875335693) * gru_1_out_t0_16 + (-0.67559027671813965) * gru_1_out_t0_17 + (0.41689795255661011) * gru_1_out_t0_18 + (-0.37869557738304138) * gru_1_out_t0_19 + (0.15335416793823242) * gru_1_out_t0_20 + (-0.22824820876121521) * gru_1_out_t0_21 + (-0.97115021944046021) * gru_1_out_t0_22 + (-0.40898597240447998) * gru_1_out_t0_23 + (-1.2844247817993164) * gru_1_out_t0_24 + (0.14099547266960144) * gru_1_out_t0_25 + (0.10164864361286163) * gru_1_out_t0_26 + (-0.99745035171508789) * gru_1_out_t0_27 + (-1.0242366790771484) * gru_1_out_t0_28 + (0.65554261207580566) * gru_1_out_t0_29 + (0.5451200008392334) * gru_1_out_t0_30 + (0.58187252283096313) * gru_1_out_t0_31 + (-0.90134847164154053) * gru_1_out_t0_32 + (-0.50214046239852905) * gru_1_out_t0_33 + (0.48849436640739441) * gru_1_out_t0_34 + (-0.27724814414978027) * gru_1_out_t0_35 + (0.21774117648601532) * gru_1_out_t0_36 + (-0.34722131490707397) * gru_1_out_t0_37 + (0.84531682729721069) * gru_1_out_t0_38 + (0.24543243646621704) * gru_1_out_t0_39 + (0.41307586431503296) * gru_1_out_t0_40 + (-0.27557599544525146) * gru_1_out_t0_41 + (0.12522973120212555) * gru_1_out_t0_42 + (-0.1927386075258255) * gru_1_out_t0_43 + (-0.18155312538146973) * gru_1_out_t0_44 + (0.90065431594848633) * gru_1_out_t0_45 + (0.54620856046676636) * gru_1_out_t0_46 + (-0.19095702469348907) * gru_1_out_t0_47 + (-0.24318204820156097) * gru_1_out_t0_48 + (-0.15006965398788452) * gru_1_out_t0_49 + (0.16425967216491699) * gru_1_out_t0_50 + (0.23669461905956268) * gru_1_out_t0_51 + (-0.18842722475528717) * gru_1_out_t0_52 + (0.0042753973975777626) * gru_1_out_t0_53 + (1.2584464550018311) * gru_1_out_t0_54 + (1.2750664949417114) * gru_1_out_t0_55 + (-0.47451943159103394) * gru_1_out_t0_56 + (-0.36584466695785522) * gru_1_out_t0_57 + (-0.25194633007049561) * gru_1_out_t0_58 + (0.55924469232559204) * gru_1_out_t0_59 + (-1.0836969614028931) * gru_1_out_t0_60 + (0.43094450235366821) * gru_1_out_t0_61 + (1.399687647819519) * gru_1_out_t0_62 + (-0.04467179998755455) * gru_1_out_t0_63 + gate_r * (0.07338821142911911));
    gru_2_fwd_t0_h_27 = (1.0 - gate_z) * gate_n;
    // h=28
    gate_r = sigmoid((1.1170806884765625) + (-1.2967590093612671) * gru_1_out_t0_0 + (0.9028325080871582) * gru_1_out_t0_1 + (-0.42581677436828613) * gru_1_out_t0_2 + (-0.42284071445465088) * gru_1_out_t0_3 + (-2.6211867332458496) * gru_1_out_t0_4 + (-1.4938701391220093) * gru_1_out_t0_5 + (2.2780041694641113) * gru_1_out_t0_6 + (0.46688687801361084) * gru_1_out_t0_7 + (-0.033835079520940781) * gru_1_out_t0_8 + (0.50523722171783447) * gru_1_out_t0_9 + (0.34245246648788452) * gru_1_out_t0_10 + (-0.64736306667327881) * gru_1_out_t0_11 + (0.26818963885307312) * gru_1_out_t0_12 + (-1.0582691431045532) * gru_1_out_t0_13 + (0.24692894518375397) * gru_1_out_t0_14 + (-0.73977994918823242) * gru_1_out_t0_15 + (0.42608469724655151) * gru_1_out_t0_16 + (-0.049303788691759109) * gru_1_out_t0_17 + (-0.91933178901672363) * gru_1_out_t0_18 + (-0.79125255346298218) * gru_1_out_t0_19 + (-0.52567493915557861) * gru_1_out_t0_20 + (-0.65829157829284668) * gru_1_out_t0_21 + (-3.5879130363464355) * gru_1_out_t0_22 + (-1.4670025110244751) * gru_1_out_t0_23 + (-1.5425759553909302) * gru_1_out_t0_24 + (-0.58593446016311646) * gru_1_out_t0_25 + (1.1616331338882446) * gru_1_out_t0_26 + (0.99392443895339966) * gru_1_out_t0_27 + (-1.9191586971282959) * gru_1_out_t0_28 + (0.43660524487495422) * gru_1_out_t0_29 + (1.9824197292327881) * gru_1_out_t0_30 + (0.17158624529838562) * gru_1_out_t0_31 + (-1.856863260269165) * gru_1_out_t0_32 + (0.50728189945220947) * gru_1_out_t0_33 + (0.095842413604259491) * gru_1_out_t0_34 + (0.40860059857368469) * gru_1_out_t0_35 + (0.092369481921195984) * gru_1_out_t0_36 + (-0.44300800561904907) * gru_1_out_t0_37 + (0.60195213556289673) * gru_1_out_t0_38 + (0.24483698606491089) * gru_1_out_t0_39 + (-1.0711474418640137) * gru_1_out_t0_40 + (-0.67678141593933105) * gru_1_out_t0_41 + (-0.61776334047317505) * gru_1_out_t0_42 + (1.853980541229248) * gru_1_out_t0_43 + (-0.393818199634552) * gru_1_out_t0_44 + (-1.5616822242736816) * gru_1_out_t0_45 + (-1.0709168910980225) * gru_1_out_t0_46 + (-0.10334233939647675) * gru_1_out_t0_47 + (-1.9349422454833984) * gru_1_out_t0_48 + (-1.0550938844680786) * gru_1_out_t0_49 + (-0.22409519553184509) * gru_1_out_t0_50 + (0.41025722026824951) * gru_1_out_t0_51 + (0.98111987113952637) * gru_1_out_t0_52 + (-0.15557181835174561) * gru_1_out_t0_53 + (0.73194456100463867) * gru_1_out_t0_54 + (0.090679444372653961) * gru_1_out_t0_55 + (-0.27741137146949768) * gru_1_out_t0_56 + (-1.3093100786209106) * gru_1_out_t0_57 + (0.61330032348632812) * gru_1_out_t0_58 + (0.064260639250278473) * gru_1_out_t0_59 + (-0.17360961437225342) * gru_1_out_t0_60 + (-0.12058087438344955) * gru_1_out_t0_61 + (-0.31108325719833374) * gru_1_out_t0_62 + (-0.77554011344909668) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.37027975916862488) + (0.30526870489120483) * gru_1_out_t0_0 + (-1.2309169769287109) * gru_1_out_t0_1 + (0.50694853067398071) * gru_1_out_t0_2 + (0.058804161846637726) * gru_1_out_t0_3 + (0.090288683772087097) * gru_1_out_t0_4 + (0.86798399686813354) * gru_1_out_t0_5 + (-0.77444589138031006) * gru_1_out_t0_6 + (0.56577384471893311) * gru_1_out_t0_7 + (-0.50492972135543823) * gru_1_out_t0_8 + (-0.12548185884952545) * gru_1_out_t0_9 + (-0.45968997478485107) * gru_1_out_t0_10 + (-0.60753387212753296) * gru_1_out_t0_11 + (-0.44124948978424072) * gru_1_out_t0_12 + (-0.023395610973238945) * gru_1_out_t0_13 + (-0.14289647340774536) * gru_1_out_t0_14 + (-0.10563436150550842) * gru_1_out_t0_15 + (-0.054798383265733719) * gru_1_out_t0_16 + (-0.16547827422618866) * gru_1_out_t0_17 + (-0.1611328125) * gru_1_out_t0_18 + (0.30655726790428162) * gru_1_out_t0_19 + (-0.15290753543376923) * gru_1_out_t0_20 + (-0.021461445838212967) * gru_1_out_t0_21 + (0.007224526721984148) * gru_1_out_t0_22 + (-0.21269242465496063) * gru_1_out_t0_23 + (-2.0056929588317871) * gru_1_out_t0_24 + (-0.064549855887889862) * gru_1_out_t0_25 + (0.18294709920883179) * gru_1_out_t0_26 + (0.34903454780578613) * gru_1_out_t0_27 + (-0.11637317389249802) * gru_1_out_t0_28 + (-0.19664911925792694) * gru_1_out_t0_29 + (0.88234364986419678) * gru_1_out_t0_30 + (0.088892392814159393) * gru_1_out_t0_31 + (0.1583559662103653) * gru_1_out_t0_32 + (0.12506350874900818) * gru_1_out_t0_33 + (-0.037688132375478745) * gru_1_out_t0_34 + (-0.48491010069847107) * gru_1_out_t0_35 + (0.17735202610492706) * gru_1_out_t0_36 + (0.069282136857509613) * gru_1_out_t0_37 + (0.016531364992260933) * gru_1_out_t0_38 + (-0.30957385897636414) * gru_1_out_t0_39 + (0.17990747094154358) * gru_1_out_t0_40 + (-0.027048539370298386) * gru_1_out_t0_41 + (0.077697359025478363) * gru_1_out_t0_42 + (-0.060357104986906052) * gru_1_out_t0_43 + (-0.11884570866823196) * gru_1_out_t0_44 + (0.53653675317764282) * gru_1_out_t0_45 + (0.029773999005556107) * gru_1_out_t0_46 + (-0.10056977719068527) * gru_1_out_t0_47 + (-0.036650072783231735) * gru_1_out_t0_48 + (0.22061353921890259) * gru_1_out_t0_49 + (0.27281120419502258) * gru_1_out_t0_50 + (0.29081490635871887) * gru_1_out_t0_51 + (-0.040592499077320099) * gru_1_out_t0_52 + (-0.086713530123233795) * gru_1_out_t0_53 + (0.052844170480966568) * gru_1_out_t0_54 + (-0.28755432367324829) * gru_1_out_t0_55 + (-0.051014091819524765) * gru_1_out_t0_56 + (0.089517600834369659) * gru_1_out_t0_57 + (0.46082749962806702) * gru_1_out_t0_58 + (0.12313845753669739) * gru_1_out_t0_59 + (-0.091130316257476807) * gru_1_out_t0_60 + (-0.14881472289562225) * gru_1_out_t0_61 + (-0.029487328603863716) * gru_1_out_t0_62 + (-0.03344295546412468) * gru_1_out_t0_63);
    gate_n = tanh((-0.47201827168464661) + (-0.27722576260566711) * gru_1_out_t0_0 + (-0.3958774209022522) * gru_1_out_t0_1 + (0.60805892944335938) * gru_1_out_t0_2 + (-0.83109796047210693) * gru_1_out_t0_3 + (0.30026456713676453) * gru_1_out_t0_4 + (0.14769832789897919) * gru_1_out_t0_5 + (-0.87506771087646484) * gru_1_out_t0_6 + (-0.010086673311889172) * gru_1_out_t0_7 + (-0.4451526403427124) * gru_1_out_t0_8 + (0.41272756457328796) * gru_1_out_t0_9 + (-0.33770540356636047) * gru_1_out_t0_10 + (-0.55525177717208862) * gru_1_out_t0_11 + (0.19176684319972992) * gru_1_out_t0_12 + (-0.29127165675163269) * gru_1_out_t0_13 + (0.11479844897985458) * gru_1_out_t0_14 + (0.15615461766719818) * gru_1_out_t0_15 + (-0.41491696238517761) * gru_1_out_t0_16 + (-0.39673095941543579) * gru_1_out_t0_17 + (0.0040986379608511925) * gru_1_out_t0_18 + (0.096343174576759338) * gru_1_out_t0_19 + (0.25345709919929504) * gru_1_out_t0_20 + (0.011902938596904278) * gru_1_out_t0_21 + (0.3153950572013855) * gru_1_out_t0_22 + (-0.17603808641433716) * gru_1_out_t0_23 + (-2.0158889293670654) * gru_1_out_t0_24 + (-0.62003076076507568) * gru_1_out_t0_25 + (0.082758627831935883) * gru_1_out_t0_26 + (0.40812331438064575) * gru_1_out_t0_27 + (-0.094929218292236328) * gru_1_out_t0_28 + (-0.096843235194683075) * gru_1_out_t0_29 + (0.12479756772518158) * gru_1_out_t0_30 + (0.57444357872009277) * gru_1_out_t0_31 + (0.47875240445137024) * gru_1_out_t0_32 + (0.6576961874961853) * gru_1_out_t0_33 + (0.18932685256004333) * gru_1_out_t0_34 + (0.27019456028938293) * gru_1_out_t0_35 + (-0.19678276777267456) * gru_1_out_t0_36 + (-0.53844332695007324) * gru_1_out_t0_37 + (0.1639750599861145) * gru_1_out_t0_38 + (-0.21807602047920227) * gru_1_out_t0_39 + (1.243410587310791) * gru_1_out_t0_40 + (-0.1725132018327713) * gru_1_out_t0_41 + (-0.17781171202659607) * gru_1_out_t0_42 + (-0.13003820180892944) * gru_1_out_t0_43 + (-0.26735791563987732) * gru_1_out_t0_44 + (0.39312294125556946) * gru_1_out_t0_45 + (-0.24664770066738129) * gru_1_out_t0_46 + (-0.018071478232741356) * gru_1_out_t0_47 + (-0.86573368310928345) * gru_1_out_t0_48 + (-0.071698099374771118) * gru_1_out_t0_49 + (-0.038592908531427383) * gru_1_out_t0_50 + (-0.23152501881122589) * gru_1_out_t0_51 + (-0.092969298362731934) * gru_1_out_t0_52 + (0.16723303496837616) * gru_1_out_t0_53 + (-0.081203065812587738) * gru_1_out_t0_54 + (-0.34754028916358948) * gru_1_out_t0_55 + (0.19831310212612152) * gru_1_out_t0_56 + (0.61445474624633789) * gru_1_out_t0_57 + (0.17247271537780762) * gru_1_out_t0_58 + (0.26096951961517334) * gru_1_out_t0_59 + (-0.43987718224525452) * gru_1_out_t0_60 + (-0.48867300152778625) * gru_1_out_t0_61 + (-0.078533120453357697) * gru_1_out_t0_62 + (-0.29024809598922729) * gru_1_out_t0_63 + gate_r * (-0.25809669494628906));
    gru_2_fwd_t0_h_28 = (1.0 - gate_z) * gate_n;
    // h=29
    gate_r = sigmoid((0.25899970531463623) + (0.62501055002212524) * gru_1_out_t0_0 + (-0.18466962873935699) * gru_1_out_t0_1 + (0.087951801717281342) * gru_1_out_t0_2 + (0.35427123308181763) * gru_1_out_t0_3 + (0.062685921788215637) * gru_1_out_t0_4 + (0.11190027743577957) * gru_1_out_t0_5 + (1.1742591857910156) * gru_1_out_t0_6 + (0.099101617932319641) * gru_1_out_t0_7 + (0.038016144186258316) * gru_1_out_t0_8 + (0.53571343421936035) * gru_1_out_t0_9 + (0.1459326446056366) * gru_1_out_t0_10 + (0.31855908036231995) * gru_1_out_t0_11 + (-0.78712606430053711) * gru_1_out_t0_12 + (0.47583141922950745) * gru_1_out_t0_13 + (1.6928505897521973) * gru_1_out_t0_14 + (-0.98529732227325439) * gru_1_out_t0_15 + (-0.85523009300231934) * gru_1_out_t0_16 + (-0.90064489841461182) * gru_1_out_t0_17 + (-1.1511166095733643) * gru_1_out_t0_18 + (-0.42705526947975159) * gru_1_out_t0_19 + (0.20130437612533569) * gru_1_out_t0_20 + (0.48680150508880615) * gru_1_out_t0_21 + (0.046126190572977066) * gru_1_out_t0_22 + (-0.37126883864402771) * gru_1_out_t0_23 + (0.59660029411315918) * gru_1_out_t0_24 + (-1.3088152408599854) * gru_1_out_t0_25 + (-0.041113562881946564) * gru_1_out_t0_26 + (-0.34042885899543762) * gru_1_out_t0_27 + (-1.0374907255172729) * gru_1_out_t0_28 + (1.2243119478225708) * gru_1_out_t0_29 + (-1.7217565774917603) * gru_1_out_t0_30 + (0.14639505743980408) * gru_1_out_t0_31 + (-1.2016023397445679) * gru_1_out_t0_32 + (0.2770538330078125) * gru_1_out_t0_33 + (-0.2793840765953064) * gru_1_out_t0_34 + (0.34134876728057861) * gru_1_out_t0_35 + (-0.93383699655532837) * gru_1_out_t0_36 + (-1.0521451234817505) * gru_1_out_t0_37 + (1.1809391975402832) * gru_1_out_t0_38 + (0.99676662683486938) * gru_1_out_t0_39 + (-0.84346663951873779) * gru_1_out_t0_40 + (-0.12747412919998169) * gru_1_out_t0_41 + (0.13940627872943878) * gru_1_out_t0_42 + (0.40971139073371887) * gru_1_out_t0_43 + (-0.24267213046550751) * gru_1_out_t0_44 + (-0.67140978574752808) * gru_1_out_t0_45 + (-0.98376327753067017) * gru_1_out_t0_46 + (-0.07416989654302597) * gru_1_out_t0_47 + (-0.88438373804092407) * gru_1_out_t0_48 + (-0.73679536581039429) * gru_1_out_t0_49 + (-1.9675153493881226) * gru_1_out_t0_50 + (-0.32375025749206543) * gru_1_out_t0_51 + (-0.37444654107093811) * gru_1_out_t0_52 + (-0.29671499133110046) * gru_1_out_t0_53 + (0.31692108511924744) * gru_1_out_t0_54 + (-0.27565091848373413) * gru_1_out_t0_55 + (-0.8334883451461792) * gru_1_out_t0_56 + (0.30619272589683533) * gru_1_out_t0_57 + (0.32396557927131653) * gru_1_out_t0_58 + (-0.53973406553268433) * gru_1_out_t0_59 + (-2.532987117767334) * gru_1_out_t0_60 + (-0.32557889819145203) * gru_1_out_t0_61 + (-0.027131404727697372) * gru_1_out_t0_62 + (0.56310725212097168) * gru_1_out_t0_63);
    gate_z = sigmoid((-0.82164716720581055) + (-1.2334725856781006) * gru_1_out_t0_0 + (-2.7538251876831055) * gru_1_out_t0_1 + (0.20357942581176758) * gru_1_out_t0_2 + (-1.560415506362915) * gru_1_out_t0_3 + (2.3551571369171143) * gru_1_out_t0_4 + (-2.8150584697723389) * gru_1_out_t0_5 + (-1.8145488500595093) * gru_1_out_t0_6 + (0.071179859340190887) * gru_1_out_t0_7 + (0.89873981475830078) * gru_1_out_t0_8 + (-0.045009911060333252) * gru_1_out_t0_9 + (0.61683893203735352) * gru_1_out_t0_10 + (-0.049352876842021942) * gru_1_out_t0_11 + (-1.413280725479126) * gru_1_out_t0_12 + (0.83196967840194702) * gru_1_out_t0_13 + (0.22739879786968231) * gru_1_out_t0_14 + (-0.072252452373504639) * gru_1_out_t0_15 + (0.50008141994476318) * gru_1_out_t0_16 + (-1.2275667190551758) * gru_1_out_t0_17 + (-2.4929084777832031) * gru_1_out_t0_18 + (0.7492944598197937) * gru_1_out_t0_19 + (0.34500494599342346) * gru_1_out_t0_20 + (0.44790244102478027) * gru_1_out_t0_21 + (1.2681951522827148) * gru_1_out_t0_22 + (-0.84682971239089966) * gru_1_out_t0_23 + (-1.323762059211731) * gru_1_out_t0_24 + (0.54339367151260376) * gru_1_out_t0_25 + (0.25517365336418152) * gru_1_out_t0_26 + (-1.5069817304611206) * gru_1_out_t0_27 + (0.71935302019119263) * gru_1_out_t0_28 + (0.36218076944351196) * gru_1_out_t0_29 + (-0.79016631841659546) * gru_1_out_t0_30 + (0.43491125106811523) * gru_1_out_t0_31 + (-0.24046154320240021) * gru_1_out_t0_32 + (-0.44228559732437134) * gru_1_out_t0_33 + (0.41466489434242249) * gru_1_out_t0_34 + (1.0060116052627563) * gru_1_out_t0_35 + (-0.21110199391841888) * gru_1_out_t0_36 + (0.69292181730270386) * gru_1_out_t0_37 + (0.89084839820861816) * gru_1_out_t0_38 + (0.57069534063339233) * gru_1_out_t0_39 + (0.58204877376556396) * gru_1_out_t0_40 + (-1.0742350816726685) * gru_1_out_t0_41 + (0.29432353377342224) * gru_1_out_t0_42 + (-0.9001765251159668) * gru_1_out_t0_43 + (-1.2728835344314575) * gru_1_out_t0_44 + (-0.15802179276943207) * gru_1_out_t0_45 + (0.45991960167884827) * gru_1_out_t0_46 + (0.59648662805557251) * gru_1_out_t0_47 + (0.90296095609664917) * gru_1_out_t0_48 + (0.45400252938270569) * gru_1_out_t0_49 + (-1.7886620759963989) * gru_1_out_t0_50 + (-0.61682033538818359) * gru_1_out_t0_51 + (0.039207663387060165) * gru_1_out_t0_52 + (0.17518936097621918) * gru_1_out_t0_53 + (0.25630784034729004) * gru_1_out_t0_54 + (0.26514822244644165) * gru_1_out_t0_55 + (0.31615006923675537) * gru_1_out_t0_56 + (-0.20887178182601929) * gru_1_out_t0_57 + (-1.0626435279846191) * gru_1_out_t0_58 + (1.1821368932723999) * gru_1_out_t0_59 + (1.4549019336700439) * gru_1_out_t0_60 + (0.084335014224052429) * gru_1_out_t0_61 + (1.4574141502380371) * gru_1_out_t0_62 + (-0.81142586469650269) * gru_1_out_t0_63);
