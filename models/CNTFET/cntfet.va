    gate_r = sigmoid((-0.86868244409561157) + (-0.34697121381759644) * gru_0_out_t4_0 + (0.18967863917350769) * gru_0_out_t4_1 + (0.18173842132091522) * gru_0_out_t4_2 + (0.68365049362182617) * gru_0_out_t4_3 + (0.29115530848503113) * gru_0_out_t4_4 + (0.79211574792861938) * gru_0_out_t4_5 + (-0.71262192726135254) * gru_0_out_t4_6 + (-1.224705696105957) * gru_0_out_t4_7 + (0.88752621412277222) * gru_0_out_t4_8 + (-1.7929888963699341) * gru_0_out_t4_9 + (0.82308787107467651) * gru_0_out_t4_10 + (-0.57957661151885986) * gru_0_out_t4_11 + (0.18759529292583466) * gru_0_out_t4_12 + (0.21172942221164703) * gru_0_out_t4_13 + (-0.2630234956741333) * gru_0_out_t4_14 + (1.2525253295898438) * gru_0_out_t4_15 + (0.41601258516311646) * gru_0_out_t4_16 + (0.11622653901576996) * gru_0_out_t4_17 + (0.82903885841369629) * gru_0_out_t4_18 + (2.2396926879882812) * gru_0_out_t4_19 + (-1.4957054853439331) * gru_0_out_t4_20 + (0.59828543663024902) * gru_0_out_t4_21 + (-0.20681065320968628) * gru_0_out_t4_22 + (-0.35710138082504272) * gru_0_out_t4_23 + (1.486964225769043) * gru_0_out_t4_24 + (-0.11370556056499481) * gru_0_out_t4_25 + (-1.1863374710083008) * gru_0_out_t4_26 + (0.69345349073410034) * gru_0_out_t4_27 + (-0.024042068049311638) * gru_0_out_t4_28 + (0.53577756881713867) * gru_0_out_t4_29 + (-0.1436774879693985) * gru_0_out_t4_30 + (-4.117408275604248) * gru_0_out_t4_31 + (-1.1653522253036499) * gru_0_out_t4_32 + (0.46456235647201538) * gru_0_out_t4_33 + (-0.20534321665763855) * gru_0_out_t4_34 + (0.074372768402099609) * gru_0_out_t4_35 + (-0.16653381288051605) * gru_0_out_t4_36 + (0.15804155170917511) * gru_0_out_t4_37 + (0.012111191637814045) * gru_0_out_t4_38 + (0.079909995198249817) * gru_0_out_t4_39 + (0.73227953910827637) * gru_0_out_t4_40 + (-0.10929638147354126) * gru_0_out_t4_41 + (2.1610260009765625) * gru_0_out_t4_42 + (-0.10465149581432343) * gru_0_out_t4_43 + (-0.70635092258453369) * gru_0_out_t4_44 + (-0.27271726727485657) * gru_0_out_t4_45 + (-0.29159641265869141) * gru_0_out_t4_46 + (0.26668599247932434) * gru_0_out_t4_47 + (-0.18232174217700958) * gru_0_out_t4_48 + (0.11549025774002075) * gru_0_out_t4_49 + (-0.23823173344135284) * gru_0_out_t4_50 + (0.98151767253875732) * gru_0_out_t4_51 + (-0.25662073493003845) * gru_0_out_t4_52 + (0.0031926701776683331) * gru_0_out_t4_53 + (-0.33342918753623962) * gru_0_out_t4_54 + (-0.43766987323760986) * gru_0_out_t4_55 + (0.34654012322425842) * gru_0_out_t4_56 + (0.33429506421089172) * gru_0_out_t4_57 + (0.11083298176527023) * gru_0_out_t4_58 + (0.54052650928497314) * gru_0_out_t4_59 + (0.99470537900924683) * gru_0_out_t4_60 + (0.20675328373908997) * gru_0_out_t4_61 + (1.3286465406417847) * gru_0_out_t4_62 + (0.16312959790229797) * gru_0_out_t4_63 + (0.83877450227737427) * gru_1_fwd_t3_h_0 + (-0.771950364112854) * gru_1_fwd_t3_h_1 + (1.4217849969863892) * gru_1_fwd_t3_h_2 + (-0.49594786763191223) * gru_1_fwd_t3_h_3 + (1.170246958732605) * gru_1_fwd_t3_h_4 + (-2.159583568572998) * gru_1_fwd_t3_h_5 + (1.6332790851593018) * gru_1_fwd_t3_h_6 + (-1.0809395313262939) * gru_1_fwd_t3_h_7 + (-0.0072112772613763809) * gru_1_fwd_t3_h_8 + (0.54272443056106567) * gru_1_fwd_t3_h_9 + (0.42202857136726379) * gru_1_fwd_t3_h_10 + (0.049420721828937531) * gru_1_fwd_t3_h_11 + (-0.69319993257522583) * gru_1_fwd_t3_h_12 + (0.4198453426361084) * gru_1_fwd_t3_h_13 + (-0.61358803510665894) * gru_1_fwd_t3_h_14 + (1.5061087608337402) * gru_1_fwd_t3_h_15 + (-0.62690746784210205) * gru_1_fwd_t3_h_16 + (0.28428378701210022) * gru_1_fwd_t3_h_17 + (-0.62983691692352295) * gru_1_fwd_t3_h_18 + (0.26186287403106689) * gru_1_fwd_t3_h_19 + (0.52221685647964478) * gru_1_fwd_t3_h_20 + (0.22187063097953796) * gru_1_fwd_t3_h_21 + (1.7208113670349121) * gru_1_fwd_t3_h_22 + (-0.67760801315307617) * gru_1_fwd_t3_h_23 + (2.9978196620941162) * gru_1_fwd_t3_h_24 + (0.96962970495223999) * gru_1_fwd_t3_h_25 + (-2.7868270874023438) * gru_1_fwd_t3_h_26 + (-0.30905994772911072) * gru_1_fwd_t3_h_27 + (0.91641461849212646) * gru_1_fwd_t3_h_28 + (-0.043612692505121231) * gru_1_fwd_t3_h_29 + (0.65428990125656128) * gru_1_fwd_t3_h_30 + (0.63820570707321167) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((0.36791986227035522) + (0.54722118377685547) * gru_0_out_t4_0 + (-0.20282416045665741) * gru_0_out_t4_1 + (1.3032547235488892) * gru_0_out_t4_2 + (0.68645751476287842) * gru_0_out_t4_3 + (0.036828503012657166) * gru_0_out_t4_4 + (0.54895520210266113) * gru_0_out_t4_5 + (-0.35686805844306946) * gru_0_out_t4_6 + (-0.78790438175201416) * gru_0_out_t4_7 + (0.22940470278263092) * gru_0_out_t4_8 + (1.0058671236038208) * gru_0_out_t4_9 + (-0.98197102546691895) * gru_0_out_t4_10 + (0.57148200273513794) * gru_0_out_t4_11 + (0.12222187966108322) * gru_0_out_t4_12 + (0.079848773777484894) * gru_0_out_t4_13 + (-0.11904613673686981) * gru_0_out_t4_14 + (0.68889135122299194) * gru_0_out_t4_15 + (0.38767001032829285) * gru_0_out_t4_16 + (0.52891045808792114) * gru_0_out_t4_17 + (0.31318038702011108) * gru_0_out_t4_18 + (1.8489186763763428) * gru_0_out_t4_19 + (0.036988582462072372) * gru_0_out_t4_20 + (-0.27463957667350769) * gru_0_out_t4_21 + (0.4887758195400238) * gru_0_out_t4_22 + (0.20195753872394562) * gru_0_out_t4_23 + (-1.5405286550521851) * gru_0_out_t4_24 + (-0.61348235607147217) * gru_0_out_t4_25 + (0.21648210287094116) * gru_0_out_t4_26 + (0.4908352792263031) * gru_0_out_t4_27 + (-1.0435421466827393) * gru_0_out_t4_28 + (-0.76586192846298218) * gru_0_out_t4_29 + (-0.095818772912025452) * gru_0_out_t4_30 + (1.5397857427597046) * gru_0_out_t4_31 + (-0.76097416877746582) * gru_0_out_t4_32 + (0.39889726042747498) * gru_0_out_t4_33 + (0.19591477513313293) * gru_0_out_t4_34 + (0.36992868781089783) * gru_0_out_t4_35 + (-0.26538810133934021) * gru_0_out_t4_36 + (0.24588780105113983) * gru_0_out_t4_37 + (-0.062437083572149277) * gru_0_out_t4_38 + (0.00010240373376291245) * gru_0_out_t4_39 + (-0.16742977499961853) * gru_0_out_t4_40 + (0.64715152978897095) * gru_0_out_t4_41 + (-0.65151786804199219) * gru_0_out_t4_42 + (0.21121004223823547) * gru_0_out_t4_43 + (0.55353879928588867) * gru_0_out_t4_44 + (-0.48270019888877869) * gru_0_out_t4_45 + (-0.82655638456344604) * gru_0_out_t4_46 + (0.69995546340942383) * gru_0_out_t4_47 + (1.0435880422592163) * gru_0_out_t4_48 + (-0.43678474426269531) * gru_0_out_t4_49 + (0.028196880593895912) * gru_0_out_t4_50 + (0.095496542751789093) * gru_0_out_t4_51 + (0.14613273739814758) * gru_0_out_t4_52 + (-0.14087760448455811) * gru_0_out_t4_53 + (-0.48146101832389832) * gru_0_out_t4_54 + (-1.370659351348877) * gru_0_out_t4_55 + (0.17489950358867645) * gru_0_out_t4_56 + (-0.33385688066482544) * gru_0_out_t4_57 + (0.006064197514206171) * gru_0_out_t4_58 + (0.3133578896522522) * gru_0_out_t4_59 + (0.13343943655490875) * gru_0_out_t4_60 + (-0.3690241277217865) * gru_0_out_t4_61 + (0.62344437837600708) * gru_0_out_t4_62 + (-0.38674631714820862) * gru_0_out_t4_63 + (0.72473621368408203) * gru_1_fwd_t3_h_0 + (0.8832588791847229) * gru_1_fwd_t3_h_1 + (0.26938042044639587) * gru_1_fwd_t3_h_2 + (0.32108432054519653) * gru_1_fwd_t3_h_3 + (-0.8765723705291748) * gru_1_fwd_t3_h_4 + (0.070506654679775238) * gru_1_fwd_t3_h_5 + (-0.32015314698219299) * gru_1_fwd_t3_h_6 + (-0.5157092809677124) * gru_1_fwd_t3_h_7 + (-0.27657988667488098) * gru_1_fwd_t3_h_8 + (-0.067152820527553558) * gru_1_fwd_t3_h_9 + (0.23878930509090424) * gru_1_fwd_t3_h_10 + (-0.18771460652351379) * gru_1_fwd_t3_h_11 + (0.19229017198085785) * gru_1_fwd_t3_h_12 + (-0.52206635475158691) * gru_1_fwd_t3_h_13 + (0.15198825299739838) * gru_1_fwd_t3_h_14 + (0.030645305290818214) * gru_1_fwd_t3_h_15 + (-1.519591212272644) * gru_1_fwd_t3_h_16 + (0.54415434598922729) * gru_1_fwd_t3_h_17 + (0.46411436796188354) * gru_1_fwd_t3_h_18 + (0.34408113360404968) * gru_1_fwd_t3_h_19 + (-0.16188061237335205) * gru_1_fwd_t3_h_20 + (-0.0087371654808521271) * gru_1_fwd_t3_h_21 + (0.42599338293075562) * gru_1_fwd_t3_h_22 + (-0.20831857621669769) * gru_1_fwd_t3_h_23 + (-0.18172724545001984) * gru_1_fwd_t3_h_24 + (0.17437276244163513) * gru_1_fwd_t3_h_25 + (0.32464265823364258) * gru_1_fwd_t3_h_26 + (0.088059805333614349) * gru_1_fwd_t3_h_27 + (-0.80814319849014282) * gru_1_fwd_t3_h_28 + (0.71563374996185303) * gru_1_fwd_t3_h_29 + (-0.50392669439315796) * gru_1_fwd_t3_h_30 + (0.18853190541267395) * gru_1_fwd_t3_h_31);
    gate_n = tanh((-0.07844165712594986) + (-0.036570079624652863) * gru_0_out_t4_0 + (0.48610407114028931) * gru_0_out_t4_1 + (-0.58075845241546631) * gru_0_out_t4_2 + (-0.12996004521846771) * gru_0_out_t4_3 + (0.2230934351682663) * gru_0_out_t4_4 + (0.043407179415225983) * gru_0_out_t4_5 + (0.065098725259304047) * gru_0_out_t4_6 + (0.92734795808792114) * gru_0_out_t4_7 + (0.42566502094268799) * gru_0_out_t4_8 + (-0.51432418823242188) * gru_0_out_t4_9 + (0.21132287383079529) * gru_0_out_t4_10 + (-0.28490471839904785) * gru_0_out_t4_11 + (-0.036234185099601746) * gru_0_out_t4_12 + (-0.30409038066864014) * gru_0_out_t4_13 + (-0.1007307767868042) * gru_0_out_t4_14 + (-0.18038341403007507) * gru_0_out_t4_15 + (0.22914175689220428) * gru_0_out_t4_16 + (0.41348874568939209) * gru_0_out_t4_17 + (0.015937523916363716) * gru_0_out_t4_18 + (-0.16166788339614868) * gru_0_out_t4_19 + (0.58892691135406494) * gru_0_out_t4_20 + (0.42221489548683167) * gru_0_out_t4_21 + (-0.13876116275787354) * gru_0_out_t4_22 + (-0.64583295583724976) * gru_0_out_t4_23 + (0.2513728141784668) * gru_0_out_t4_24 + (0.25199893116950989) * gru_0_out_t4_25 + (0.014393478631973267) * gru_0_out_t4_26 + (0.061971057206392288) * gru_0_out_t4_27 + (-1.153501033782959) * gru_0_out_t4_28 + (0.42657655477523804) * gru_0_out_t4_29 + (0.059064321219921112) * gru_0_out_t4_30 + (-0.49195411801338196) * gru_0_out_t4_31 + (-0.25557294487953186) * gru_0_out_t4_32 + (0.2742047905921936) * gru_0_out_t4_33 + (-0.15901051461696625) * gru_0_out_t4_34 + (0.29477685689926147) * gru_0_out_t4_35 + (0.32356637716293335) * gru_0_out_t4_36 + (0.013849759474396706) * gru_0_out_t4_37 + (-0.0019976345356553793) * gru_0_out_t4_38 + (-0.053016521036624908) * gru_0_out_t4_39 + (1.0968267917633057) * gru_0_out_t4_40 + (-0.28061798214912415) * gru_0_out_t4_41 + (0.21947365999221802) * gru_0_out_t4_42 + (0.38111340999603271) * gru_0_out_t4_43 + (0.23368459939956665) * gru_0_out_t4_44 + (-0.070505551993846893) * gru_0_out_t4_45 + (-0.035770807415246964) * gru_0_out_t4_46 + (0.2307613343000412) * gru_0_out_t4_47 + (0.65299493074417114) * gru_0_out_t4_48 + (-0.74505102634429932) * gru_0_out_t4_49 + (0.026003705337643623) * gru_0_out_t4_50 + (0.32518941164016724) * gru_0_out_t4_51 + (-0.090063147246837616) * gru_0_out_t4_52 + (-0.42559459805488586) * gru_0_out_t4_53 + (0.099475525319576263) * gru_0_out_t4_54 + (-0.021766331046819687) * gru_0_out_t4_55 + (0.31232210993766785) * gru_0_out_t4_56 + (-0.5396198034286499) * gru_0_out_t4_57 + (-0.010189720429480076) * gru_0_out_t4_58 + (0.076861090958118439) * gru_0_out_t4_59 + (0.37099450826644897) * gru_0_out_t4_60 + (-0.090944960713386536) * gru_0_out_t4_61 + (-0.48432555794715881) * gru_0_out_t4_62 + (0.0091879749670624733) * gru_0_out_t4_63 + gate_r * ((-0.39314836263656616) + (0.56713080406188965) * gru_1_fwd_t3_h_0 + (0.26159682869911194) * gru_1_fwd_t3_h_1 + (-0.47833740711212158) * gru_1_fwd_t3_h_2 + (0.024767056107521057) * gru_1_fwd_t3_h_3 + (0.37780255079269409) * gru_1_fwd_t3_h_4 + (0.92447024583816528) * gru_1_fwd_t3_h_5 + (-2.0719106197357178) * gru_1_fwd_t3_h_6 + (0.36527034640312195) * gru_1_fwd_t3_h_7 + (-0.19121021032333374) * gru_1_fwd_t3_h_8 + (0.4266296923160553) * gru_1_fwd_t3_h_9 + (-0.17136375606060028) * gru_1_fwd_t3_h_10 + (3.1968443393707275) * gru_1_fwd_t3_h_11 + (-0.12383893132209778) * gru_1_fwd_t3_h_12 + (1.3796007633209229) * gru_1_fwd_t3_h_13 + (-0.41960406303405762) * gru_1_fwd_t3_h_14 + (0.14112035930156708) * gru_1_fwd_t3_h_15 + (-0.11448495090007782) * gru_1_fwd_t3_h_16 + (0.060797564685344696) * gru_1_fwd_t3_h_17 + (-0.10671617835760117) * gru_1_fwd_t3_h_18 + (0.21011252701282501) * gru_1_fwd_t3_h_19 + (-0.039656456559896469) * gru_1_fwd_t3_h_20 + (-1.5431952476501465) * gru_1_fwd_t3_h_21 + (-2.4670202732086182) * gru_1_fwd_t3_h_22 + (0.66046720743179321) * gru_1_fwd_t3_h_23 + (-1.2438833713531494) * gru_1_fwd_t3_h_24 + (0.2125687450170517) * gru_1_fwd_t3_h_25 + (-0.0041750534437596798) * gru_1_fwd_t3_h_26 + (-0.63700950145721436) * gru_1_fwd_t3_h_27 + (0.39468500018119812) * gru_1_fwd_t3_h_28 + (0.17591069638729095) * gru_1_fwd_t3_h_29 + (-0.7968711256980896) * gru_1_fwd_t3_h_30 + (-0.65359002351760864) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_12 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_12;
    // h=13
    gate_r = sigmoid((0.43509262800216675) + (0.38591518998146057) * gru_0_out_t4_0 + (-0.32747700810432434) * gru_0_out_t4_1 + (-0.31397691369056702) * gru_0_out_t4_2 + (-1.0062137842178345) * gru_0_out_t4_3 + (0.090118043124675751) * gru_0_out_t4_4 + (-0.9443819522857666) * gru_0_out_t4_5 + (0.72979682683944702) * gru_0_out_t4_6 + (0.25065755844116211) * gru_0_out_t4_7 + (-0.29402622580528259) * gru_0_out_t4_8 + (1.057439923286438) * gru_0_out_t4_9 + (0.42256805300712585) * gru_0_out_t4_10 + (0.12718275189399719) * gru_0_out_t4_11 + (-0.08947327733039856) * gru_0_out_t4_12 + (0.1933409571647644) * gru_0_out_t4_13 + (0.2830672562122345) * gru_0_out_t4_14 + (-0.50181752443313599) * gru_0_out_t4_15 + (-0.1109703928232193) * gru_0_out_t4_16 + (-0.34983474016189575) * gru_0_out_t4_17 + (-0.3887898325920105) * gru_0_out_t4_18 + (5.887631893157959) * gru_0_out_t4_19 + (2.0297629833221436) * gru_0_out_t4_20 + (-1.0529803037643433) * gru_0_out_t4_21 + (0.65658813714981079) * gru_0_out_t4_22 + (0.35956710577011108) * gru_0_out_t4_23 + (-0.18145817518234253) * gru_0_out_t4_24 + (0.16407138109207153) * gru_0_out_t4_25 + (-1.5412025451660156) * gru_0_out_t4_26 + (-0.41400974988937378) * gru_0_out_t4_27 + (-0.62290757894515991) * gru_0_out_t4_28 + (0.57952666282653809) * gru_0_out_t4_29 + (0.30749931931495667) * gru_0_out_t4_30 + (0.062277834862470627) * gru_0_out_t4_31 + (-0.027396680787205696) * gru_0_out_t4_32 + (-0.15558430552482605) * gru_0_out_t4_33 + (0.13866870105266571) * gru_0_out_t4_34 + (0.049737658351659775) * gru_0_out_t4_35 + (-0.15231405198574066) * gru_0_out_t4_36 + (0.2091619074344635) * gru_0_out_t4_37 + (-0.32669484615325928) * gru_0_out_t4_38 + (1.0885552167892456) * gru_0_out_t4_39 + (0.5635523796081543) * gru_0_out_t4_40 + (-0.054122116416692734) * gru_0_out_t4_41 + (0.8637700080871582) * gru_0_out_t4_42 + (-0.07494623214006424) * gru_0_out_t4_43 + (-0.3040747344493866) * gru_0_out_t4_44 + (-0.1117178350687027) * gru_0_out_t4_45 + (-0.76064079999923706) * gru_0_out_t4_46 + (0.68738353252410889) * gru_0_out_t4_47 + (0.69195759296417236) * gru_0_out_t4_48 + (-0.82645273208618164) * gru_0_out_t4_49 + (-1.748950719833374) * gru_0_out_t4_50 + (0.13695614039897919) * gru_0_out_t4_51 + (-0.27650779485702515) * gru_0_out_t4_52 + (0.2359863817691803) * gru_0_out_t4_53 + (-1.103547215461731) * gru_0_out_t4_54 + (-0.047154862433671951) * gru_0_out_t4_55 + (1.6823813915252686) * gru_0_out_t4_56 + (-0.59031301736831665) * gru_0_out_t4_57 + (0.5997200608253479) * gru_0_out_t4_58 + (0.51232630014419556) * gru_0_out_t4_59 + (0.55954128503799438) * gru_0_out_t4_60 + (-0.76222634315490723) * gru_0_out_t4_61 + (0.72130531072616577) * gru_0_out_t4_62 + (-0.23224765062332153) * gru_0_out_t4_63 + (-0.58504164218902588) * gru_1_fwd_t3_h_0 + (-0.25709608197212219) * gru_1_fwd_t3_h_1 + (-0.24257880449295044) * gru_1_fwd_t3_h_2 + (-0.18858402967453003) * gru_1_fwd_t3_h_3 + (0.79846185445785522) * gru_1_fwd_t3_h_4 + (2.1325123310089111) * gru_1_fwd_t3_h_5 + (0.33260747790336609) * gru_1_fwd_t3_h_6 + (-0.85465133190155029) * gru_1_fwd_t3_h_7 + (-0.42772006988525391) * gru_1_fwd_t3_h_8 + (0.35138016939163208) * gru_1_fwd_t3_h_9 + (-0.30612242221832275) * gru_1_fwd_t3_h_10 + (-0.44762870669364929) * gru_1_fwd_t3_h_11 + (-0.66137909889221191) * gru_1_fwd_t3_h_12 + (-0.35698062181472778) * gru_1_fwd_t3_h_13 + (-0.96980029344558716) * gru_1_fwd_t3_h_14 + (1.6976799964904785) * gru_1_fwd_t3_h_15 + (-0.16869796812534332) * gru_1_fwd_t3_h_16 + (-2.2967054843902588) * gru_1_fwd_t3_h_17 + (0.39973399043083191) * gru_1_fwd_t3_h_18 + (-0.80288374423980713) * gru_1_fwd_t3_h_19 + (0.88682937622070312) * gru_1_fwd_t3_h_20 + (1.9015952348709106) * gru_1_fwd_t3_h_21 + (-1.5845749378204346) * gru_1_fwd_t3_h_22 + (-1.2260398864746094) * gru_1_fwd_t3_h_23 + (1.2047275304794312) * gru_1_fwd_t3_h_24 + (1.8833355903625488) * gru_1_fwd_t3_h_25 + (0.65857887268066406) * gru_1_fwd_t3_h_26 + (-0.011704790405929089) * gru_1_fwd_t3_h_27 + (0.019964538514614105) * gru_1_fwd_t3_h_28 + (-1.5064451694488525) * gru_1_fwd_t3_h_29 + (0.54687958955764771) * gru_1_fwd_t3_h_30 + (-0.81841552257537842) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((0.51432788372039795) + (0.11289842426776886) * gru_0_out_t4_0 + (-0.26762405037879944) * gru_0_out_t4_1 + (0.78463321924209595) * gru_0_out_t4_2 + (-0.43576321005821228) * gru_0_out_t4_3 + (-0.49026969075202942) * gru_0_out_t4_4 + (0.1936413049697876) * gru_0_out_t4_5 + (-0.73305946588516235) * gru_0_out_t4_6 + (-0.3723469078540802) * gru_0_out_t4_7 + (0.36472713947296143) * gru_0_out_t4_8 + (0.43684163689613342) * gru_0_out_t4_9 + (-0.64519679546356201) * gru_0_out_t4_10 + (-0.48837083578109741) * gru_0_out_t4_11 + (0.062260068953037262) * gru_0_out_t4_12 + (-0.052425567060709) * gru_0_out_t4_13 + (0.071124263107776642) * gru_0_out_t4_14 + (0.45537930727005005) * gru_0_out_t4_15 + (0.037050239741802216) * gru_0_out_t4_16 + (0.10675768554210663) * gru_0_out_t4_17 + (-0.1298975795507431) * gru_0_out_t4_18 + (2.3403890132904053) * gru_0_out_t4_19 + (0.29279321432113647) * gru_0_out_t4_20 + (-0.41195172071456909) * gru_0_out_t4_21 + (-0.83271527290344238) * gru_0_out_t4_22 + (-0.37574741244316101) * gru_0_out_t4_23 + (-0.50411224365234375) * gru_0_out_t4_24 + (-0.54167342185974121) * gru_0_out_t4_25 + (-0.26256781816482544) * gru_0_out_t4_26 + (0.44973737001419067) * gru_0_out_t4_27 + (0.84666728973388672) * gru_0_out_t4_28 + (-0.2062159925699234) * gru_0_out_t4_29 + (0.29007872939109802) * gru_0_out_t4_30 + (-0.76124697923660278) * gru_0_out_t4_31 + (1.0611113309860229) * gru_0_out_t4_32 + (-0.11152104288339615) * gru_0_out_t4_33 + (-0.16499555110931396) * gru_0_out_t4_34 + (-0.16733741760253906) * gru_0_out_t4_35 + (-0.21883960068225861) * gru_0_out_t4_36 + (-0.4049379825592041) * gru_0_out_t4_37 + (-0.041414901614189148) * gru_0_out_t4_38 + (-0.45436537265777588) * gru_0_out_t4_39 + (0.30430430173873901) * gru_0_out_t4_40 + (0.49648571014404297) * gru_0_out_t4_41 + (-0.15206412971019745) * gru_0_out_t4_42 + (-0.65548646450042725) * gru_0_out_t4_43 + (0.19895894825458527) * gru_0_out_t4_44 + (-0.11196598410606384) * gru_0_out_t4_45 + (-0.66343063116073608) * gru_0_out_t4_46 + (-0.92472994327545166) * gru_0_out_t4_47 + (-0.6357429027557373) * gru_0_out_t4_48 + (0.30115112662315369) * gru_0_out_t4_49 + (1.2445659637451172) * gru_0_out_t4_50 + (0.096673719584941864) * gru_0_out_t4_51 + (0.43040570616722107) * gru_0_out_t4_52 + (-0.42013263702392578) * gru_0_out_t4_53 + (-0.51939862966537476) * gru_0_out_t4_54 + (0.45673197507858276) * gru_0_out_t4_55 + (-0.46647343039512634) * gru_0_out_t4_56 + (0.61639666557312012) * gru_0_out_t4_57 + (-0.38771575689315796) * gru_0_out_t4_58 + (0.092840604484081268) * gru_0_out_t4_59 + (-0.53582239151000977) * gru_0_out_t4_60 + (0.63283836841583252) * gru_0_out_t4_61 + (-2.5337040424346924) * gru_0_out_t4_62 + (-0.82687747478485107) * gru_0_out_t4_63 + (0.66889053583145142) * gru_1_fwd_t3_h_0 + (0.54824918508529663) * gru_1_fwd_t3_h_1 + (0.2713046669960022) * gru_1_fwd_t3_h_2 + (0.18272869288921356) * gru_1_fwd_t3_h_3 + (-0.46410062909126282) * gru_1_fwd_t3_h_4 + (-0.62431943416595459) * gru_1_fwd_t3_h_5 + (-0.12731318175792694) * gru_1_fwd_t3_h_6 + (-0.33913567662239075) * gru_1_fwd_t3_h_7 + (0.30635908246040344) * gru_1_fwd_t3_h_8 + (-0.71809786558151245) * gru_1_fwd_t3_h_9 + (0.25712475180625916) * gru_1_fwd_t3_h_10 + (-0.60687774419784546) * gru_1_fwd_t3_h_11 + (0.042603511363267899) * gru_1_fwd_t3_h_12 + (-0.6943817138671875) * gru_1_fwd_t3_h_13 + (-0.43504568934440613) * gru_1_fwd_t3_h_14 + (0.44583281874656677) * gru_1_fwd_t3_h_15 + (0.29137018322944641) * gru_1_fwd_t3_h_16 + (0.20578879117965698) * gru_1_fwd_t3_h_17 + (0.36437469720840454) * gru_1_fwd_t3_h_18 + (-0.24922876060009003) * gru_1_fwd_t3_h_19 + (-0.082598380744457245) * gru_1_fwd_t3_h_20 + (0.26127517223358154) * gru_1_fwd_t3_h_21 + (0.37084925174713135) * gru_1_fwd_t3_h_22 + (-0.49937564134597778) * gru_1_fwd_t3_h_23 + (-1.3182768821716309) * gru_1_fwd_t3_h_24 + (0.15996529161930084) * gru_1_fwd_t3_h_25 + (0.029081488028168678) * gru_1_fwd_t3_h_26 + (-0.94583910703659058) * gru_1_fwd_t3_h_27 + (-0.79961216449737549) * gru_1_fwd_t3_h_28 + (0.50110197067260742) * gru_1_fwd_t3_h_29 + (0.57482069730758667) * gru_1_fwd_t3_h_30 + (-0.29071363806724548) * gru_1_fwd_t3_h_31);
    gate_n = tanh((0.039114959537982941) + (0.0023950028698891401) * gru_0_out_t4_0 + (0.21926088631153107) * gru_0_out_t4_1 + (0.67397981882095337) * gru_0_out_t4_2 + (0.11899778991937637) * gru_0_out_t4_3 + (-0.28685611486434937) * gru_0_out_t4_4 + (-0.66319453716278076) * gru_0_out_t4_5 + (-1.6514712572097778) * gru_0_out_t4_6 + (-1.5019286870956421) * gru_0_out_t4_7 + (-0.086422309279441833) * gru_0_out_t4_8 + (0.81714338064193726) * gru_0_out_t4_9 + (0.54448026418685913) * gru_0_out_t4_10 + (-0.34092822670936584) * gru_0_out_t4_11 + (-0.087344907224178314) * gru_0_out_t4_12 + (0.094212085008621216) * gru_0_out_t4_13 + (-0.2189936488866806) * gru_0_out_t4_14 + (-0.31758204102516174) * gru_0_out_t4_15 + (-0.16069424152374268) * gru_0_out_t4_16 + (-0.44163632392883301) * gru_0_out_t4_17 + (-0.062354303896427155) * gru_0_out_t4_18 + (2.4423258304595947) * gru_0_out_t4_19 + (0.66531425714492798) * gru_0_out_t4_20 + (-0.21771624684333801) * gru_0_out_t4_21 + (0.34395381808280945) * gru_0_out_t4_22 + (-0.25098699331283569) * gru_0_out_t4_23 + (-0.93102395534515381) * gru_0_out_t4_24 + (-0.29571405053138733) * gru_0_out_t4_25 + (-0.064366079866886139) * gru_0_out_t4_26 + (0.06669645756483078) * gru_0_out_t4_27 + (0.81671911478042603) * gru_0_out_t4_28 + (-0.055667806416749954) * gru_0_out_t4_29 + (0.046038810163736343) * gru_0_out_t4_30 + (1.0249530076980591) * gru_0_out_t4_31 + (-0.067164219915866852) * gru_0_out_t4_32 + (0.076418474316596985) * gru_0_out_t4_33 + (-0.025692170485854149) * gru_0_out_t4_34 + (0.34281322360038757) * gru_0_out_t4_35 + (0.087087810039520264) * gru_0_out_t4_36 + (0.175267294049263) * gru_0_out_t4_37 + (-0.041517697274684906) * gru_0_out_t4_38 + (0.42566853761672974) * gru_0_out_t4_39 + (2.4249124526977539) * gru_0_out_t4_40 + (-0.19823606312274933) * gru_0_out_t4_41 + (0.040898218750953674) * gru_0_out_t4_42 + (0.23090088367462158) * gru_0_out_t4_43 + (0.14099183678627014) * gru_0_out_t4_44 + (0.021987520158290863) * gru_0_out_t4_45 + (-0.031861085444688797) * gru_0_out_t4_46 + (0.43984568119049072) * gru_0_out_t4_47 + (0.05984913557767868) * gru_0_out_t4_48 + (-0.47422137856483459) * gru_0_out_t4_49 + (-1.3122358322143555) * gru_0_out_t4_50 + (-0.1107628270983696) * gru_0_out_t4_51 + (0.00087232672376558185) * gru_0_out_t4_52 + (-0.17246446013450623) * gru_0_out_t4_53 + (-0.38974106311798096) * gru_0_out_t4_54 + (-0.81881099939346313) * gru_0_out_t4_55 + (0.5410192608833313) * gru_0_out_t4_56 + (-0.041958414018154144) * gru_0_out_t4_57 + (-0.075381927192211151) * gru_0_out_t4_58 + (-0.5384671688079834) * gru_0_out_t4_59 + (1.2136861085891724) * gru_0_out_t4_60 + (0.16526138782501221) * gru_0_out_t4_61 + (0.37392604351043701) * gru_0_out_t4_62 + (0.41102740168571472) * gru_0_out_t4_63 + gate_r * ((0.43865671753883362) + (0.62537086009979248) * gru_1_fwd_t3_h_0 + (-0.74091112613677979) * gru_1_fwd_t3_h_1 + (0.23210690915584564) * gru_1_fwd_t3_h_2 + (0.19552870094776154) * gru_1_fwd_t3_h_3 + (0.38348975777626038) * gru_1_fwd_t3_h_4 + (-0.79432386159896851) * gru_1_fwd_t3_h_5 + (0.73081570863723755) * gru_1_fwd_t3_h_6 + (0.50658726692199707) * gru_1_fwd_t3_h_7 + (-0.14737163484096527) * gru_1_fwd_t3_h_8 + (-0.42823049426078796) * gru_1_fwd_t3_h_9 + (-0.25390326976776123) * gru_1_fwd_t3_h_10 + (-1.0577816963195801) * gru_1_fwd_t3_h_11 + (0.001883208635263145) * gru_1_fwd_t3_h_12 + (-0.90593063831329346) * gru_1_fwd_t3_h_13 + (0.39244240522384644) * gru_1_fwd_t3_h_14 + (1.1968843936920166) * gru_1_fwd_t3_h_15 + (-0.26617276668548584) * gru_1_fwd_t3_h_16 + (-0.64043134450912476) * gru_1_fwd_t3_h_17 + (0.38692235946655273) * gru_1_fwd_t3_h_18 + (-0.35272136330604553) * gru_1_fwd_t3_h_19 + (-0.22276060283184052) * gru_1_fwd_t3_h_20 + (-0.78180080652236938) * gru_1_fwd_t3_h_21 + (-0.13515168428421021) * gru_1_fwd_t3_h_22 + (-1.3200618028640747) * gru_1_fwd_t3_h_23 + (0.11425834149122238) * gru_1_fwd_t3_h_24 + (-0.69640642404556274) * gru_1_fwd_t3_h_25 + (1.2620557546615601) * gru_1_fwd_t3_h_26 + (0.88249218463897705) * gru_1_fwd_t3_h_27 + (-1.3738139867782593) * gru_1_fwd_t3_h_28 + (-0.15458497405052185) * gru_1_fwd_t3_h_29 + (-1.6893235445022583) * gru_1_fwd_t3_h_30 + (1.1944317817687988) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_13 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_13;
    // h=14
    gate_r = sigmoid((-0.7322998046875) + (-0.55080431699752808) * gru_0_out_t4_0 + (0.17692682147026062) * gru_0_out_t4_1 + (-0.29682469367980957) * gru_0_out_t4_2 + (-0.19187059998512268) * gru_0_out_t4_3 + (0.1955077201128006) * gru_0_out_t4_4 + (0.19937810301780701) * gru_0_out_t4_5 + (-0.4303373396396637) * gru_0_out_t4_6 + (-1.5627362728118896) * gru_0_out_t4_7 + (-0.17026637494564056) * gru_0_out_t4_8 + (0.14900580048561096) * gru_0_out_t4_9 + (-0.46745225787162781) * gru_0_out_t4_10 + (-0.37139192223548889) * gru_0_out_t4_11 + (0.076101973652839661) * gru_0_out_t4_12 + (0.61001485586166382) * gru_0_out_t4_13 + (0.13555888831615448) * gru_0_out_t4_14 + (-0.14079084992408752) * gru_0_out_t4_15 + (0.28336349129676819) * gru_0_out_t4_16 + (0.19230291247367859) * gru_0_out_t4_17 + (0.49239477515220642) * gru_0_out_t4_18 + (1.8485497236251831) * gru_0_out_t4_19 + (-0.80951118469238281) * gru_0_out_t4_20 + (0.44873875379562378) * gru_0_out_t4_21 + (-0.00090501981321722269) * gru_0_out_t4_22 + (0.036082267761230469) * gru_0_out_t4_23 + (-0.28521168231964111) * gru_0_out_t4_24 + (-0.36188378930091858) * gru_0_out_t4_25 + (0.086555056273937225) * gru_0_out_t4_26 + (-0.34277728199958801) * gru_0_out_t4_27 + (0.29941961169242859) * gru_0_out_t4_28 + (-0.28493231534957886) * gru_0_out_t4_29 + (-0.66237431764602661) * gru_0_out_t4_30 + (1.010175347328186) * gru_0_out_t4_31 + (0.032905504107475281) * gru_0_out_t4_32 + (0.55509346723556519) * gru_0_out_t4_33 + (0.29262539744377136) * gru_0_out_t4_34 + (0.5885699987411499) * gru_0_out_t4_35 + (0.6056256890296936) * gru_0_out_t4_36 + (-0.35247701406478882) * gru_0_out_t4_37 + (-0.14046141505241394) * gru_0_out_t4_38 + (1.2940018177032471) * gru_0_out_t4_39 + (0.6850656270980835) * gru_0_out_t4_40 + (0.88575375080108643) * gru_0_out_t4_41 + (-0.10188610106706619) * gru_0_out_t4_42 + (0.16904768347740173) * gru_0_out_t4_43 + (0.85066777467727661) * gru_0_out_t4_44 + (0.88443714380264282) * gru_0_out_t4_45 + (-0.71691060066223145) * gru_0_out_t4_46 + (-0.30236634612083435) * gru_0_out_t4_47 + (-0.86307603120803833) * gru_0_out_t4_48 + (0.84335094690322876) * gru_0_out_t4_49 + (0.31988513469696045) * gru_0_out_t4_50 + (0.23529228568077087) * gru_0_out_t4_51 + (-0.93715131282806396) * gru_0_out_t4_52 + (0.003754141042008996) * gru_0_out_t4_53 + (0.13462789356708527) * gru_0_out_t4_54 + (-0.65104693174362183) * gru_0_out_t4_55 + (-1.3752061128616333) * gru_0_out_t4_56 + (0.51433652639389038) * gru_0_out_t4_57 + (-0.27617257833480835) * gru_0_out_t4_58 + (-2.7495675086975098) * gru_0_out_t4_59 + (0.13888546824455261) * gru_0_out_t4_60 + (-0.27406489849090576) * gru_0_out_t4_61 + (-0.41494840383529663) * gru_0_out_t4_62 + (1.3362240791320801) * gru_0_out_t4_63 + (-0.041732165962457657) * gru_1_fwd_t3_h_0 + (-0.016576563939452171) * gru_1_fwd_t3_h_1 + (-0.245015949010849) * gru_1_fwd_t3_h_2 + (0.23846179246902466) * gru_1_fwd_t3_h_3 + (-0.32932841777801514) * gru_1_fwd_t3_h_4 + (-0.21227425336837769) * gru_1_fwd_t3_h_5 + (0.47178182005882263) * gru_1_fwd_t3_h_6 + (-0.0023707954678684473) * gru_1_fwd_t3_h_7 + (0.41096729040145874) * gru_1_fwd_t3_h_8 + (0.20910212397575378) * gru_1_fwd_t3_h_9 + (-0.33496865630149841) * gru_1_fwd_t3_h_10 + (-0.028084451332688332) * gru_1_fwd_t3_h_11 + (0.34780052304267883) * gru_1_fwd_t3_h_12 + (-0.17077605426311493) * gru_1_fwd_t3_h_13 + (-0.2009197324514389) * gru_1_fwd_t3_h_14 + (0.053950972855091095) * gru_1_fwd_t3_h_15 + (0.052494004368782043) * gru_1_fwd_t3_h_16 + (0.43999680876731873) * gru_1_fwd_t3_h_17 + (0.82535898685455322) * gru_1_fwd_t3_h_18 + (-0.6448860764503479) * gru_1_fwd_t3_h_19 + (0.0205240398645401) * gru_1_fwd_t3_h_20 + (0.15798042714595795) * gru_1_fwd_t3_h_21 + (0.059097722172737122) * gru_1_fwd_t3_h_22 + (-1.1104462146759033) * gru_1_fwd_t3_h_23 + (0.24538725614547729) * gru_1_fwd_t3_h_24 + (-0.28571489453315735) * gru_1_fwd_t3_h_25 + (0.42187216877937317) * gru_1_fwd_t3_h_26 + (0.80645447969436646) * gru_1_fwd_t3_h_27 + (-0.33080679178237915) * gru_1_fwd_t3_h_28 + (0.62054038047790527) * gru_1_fwd_t3_h_29 + (-0.21589159965515137) * gru_1_fwd_t3_h_30 + (-0.21121154725551605) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((0.0071336678229272366) + (0.061321601271629333) * gru_0_out_t4_0 + (-0.40985801815986633) * gru_0_out_t4_1 + (0.18714253604412079) * gru_0_out_t4_2 + (-0.17197036743164062) * gru_0_out_t4_3 + (-0.29947495460510254) * gru_0_out_t4_4 + (0.14685589075088501) * gru_0_out_t4_5 + (0.27177944779396057) * gru_0_out_t4_6 + (0.16077294945716858) * gru_0_out_t4_7 + (0.024070888757705688) * gru_0_out_t4_8 + (-1.5642459392547607) * gru_0_out_t4_9 + (-0.38952153921127319) * gru_0_out_t4_10 + (-0.37884166836738586) * gru_0_out_t4_11 + (0.45900392532348633) * gru_0_out_t4_12 + (0.16189673542976379) * gru_0_out_t4_13 + (0.10609824955463409) * gru_0_out_t4_14 + (0.13015526533126831) * gru_0_out_t4_15 + (-0.29942485690116882) * gru_0_out_t4_16 + (0.11639967560768127) * gru_0_out_t4_17 + (-0.32770180702209473) * gru_0_out_t4_18 + (0.50745826959609985) * gru_0_out_t4_19 + (-0.087120719254016876) * gru_0_out_t4_20 + (-0.11347895115613937) * gru_0_out_t4_21 + (0.43825647234916687) * gru_0_out_t4_22 + (0.016274094581604004) * gru_0_out_t4_23 + (-0.27412733435630798) * gru_0_out_t4_24 + (0.096948191523551941) * gru_0_out_t4_25 + (0.29073867201805115) * gru_0_out_t4_26 + (0.31920126080513) * gru_0_out_t4_27 + (-1.3736724853515625) * gru_0_out_t4_28 + (-0.94266194105148315) * gru_0_out_t4_29 + (-0.067986682057380676) * gru_0_out_t4_30 + (0.29914399981498718) * gru_0_out_t4_31 + (-0.33566519618034363) * gru_0_out_t4_32 + (-0.31247183680534363) * gru_0_out_t4_33 + (0.21962806582450867) * gru_0_out_t4_34 + (0.19625480473041534) * gru_0_out_t4_35 + (0.53571218252182007) * gru_0_out_t4_36 + (-0.50366801023483276) * gru_0_out_t4_37 + (0.021223613992333412) * gru_0_out_t4_38 + (0.81688666343688965) * gru_0_out_t4_39 + (0.45373529195785522) * gru_0_out_t4_40 + (0.096980728209018707) * gru_0_out_t4_41 + (0.2138754278421402) * gru_0_out_t4_42 + (1.0157727003097534) * gru_0_out_t4_43 + (0.23796339333057404) * gru_0_out_t4_44 + (0.02629191055893898) * gru_0_out_t4_45 + (0.024832934141159058) * gru_0_out_t4_46 + (-0.044953234493732452) * gru_0_out_t4_47 + (-0.50564908981323242) * gru_0_out_t4_48 + (0.43396738171577454) * gru_0_out_t4_49 + (0.0042607169598340988) * gru_0_out_t4_50 + (0.37425318360328674) * gru_0_out_t4_51 + (-0.067060679197311401) * gru_0_out_t4_52 + (-0.060896962881088257) * gru_0_out_t4_53 + (-0.052947431802749634) * gru_0_out_t4_54 + (0.11198531836271286) * gru_0_out_t4_55 + (0.11253343522548676) * gru_0_out_t4_56 + (0.15130850672721863) * gru_0_out_t4_57 + (-0.29437318444252014) * gru_0_out_t4_58 + (0.24619533121585846) * gru_0_out_t4_59 + (0.13050547242164612) * gru_0_out_t4_60 + (0.013341153040528297) * gru_0_out_t4_61 + (-0.059861715883016586) * gru_0_out_t4_62 + (-0.11001855880022049) * gru_0_out_t4_63 + (-0.067381739616394043) * gru_1_fwd_t3_h_0 + (-0.18727526068687439) * gru_1_fwd_t3_h_1 + (-0.27475965023040771) * gru_1_fwd_t3_h_2 + (-0.2333810031414032) * gru_1_fwd_t3_h_3 + (-0.53831315040588379) * gru_1_fwd_t3_h_4 + (-0.10168656706809998) * gru_1_fwd_t3_h_5 + (0.28506731986999512) * gru_1_fwd_t3_h_6 + (-0.15104110538959503) * gru_1_fwd_t3_h_7 + (-0.39193767309188843) * gru_1_fwd_t3_h_8 + (-0.02357780747115612) * gru_1_fwd_t3_h_9 + (0.12735253572463989) * gru_1_fwd_t3_h_10 + (0.68009883165359497) * gru_1_fwd_t3_h_11 + (0.12446372210979462) * gru_1_fwd_t3_h_12 + (0.12010499835014343) * gru_1_fwd_t3_h_13 + (0.19572994112968445) * gru_1_fwd_t3_h_14 + (-0.21900112926959991) * gru_1_fwd_t3_h_15 + (-0.16851170361042023) * gru_1_fwd_t3_h_16 + (0.20427238941192627) * gru_1_fwd_t3_h_17 + (-0.14343179762363434) * gru_1_fwd_t3_h_18 + (-0.13019101321697235) * gru_1_fwd_t3_h_19 + (-0.23662476241588593) * gru_1_fwd_t3_h_20 + (0.013105894438922405) * gru_1_fwd_t3_h_21 + (-0.015328638255596161) * gru_1_fwd_t3_h_22 + (0.18555033206939697) * gru_1_fwd_t3_h_23 + (0.16685807704925537) * gru_1_fwd_t3_h_24 + (0.28616365790367126) * gru_1_fwd_t3_h_25 + (-0.60642784833908081) * gru_1_fwd_t3_h_26 + (-0.18876057863235474) * gru_1_fwd_t3_h_27 + (0.93627655506134033) * gru_1_fwd_t3_h_28 + (-0.090905338525772095) * gru_1_fwd_t3_h_29 + (0.14891539514064789) * gru_1_fwd_t3_h_30 + (-0.027689650654792786) * gru_1_fwd_t3_h_31);
    gate_n = tanh((0.096124112606048584) + (-0.38427659869194031) * gru_0_out_t4_0 + (0.070049688220024109) * gru_0_out_t4_1 + (-0.055394962430000305) * gru_0_out_t4_2 + (-0.23749922215938568) * gru_0_out_t4_3 + (-0.032686695456504822) * gru_0_out_t4_4 + (-0.0015806993469595909) * gru_0_out_t4_5 + (0.57977229356765747) * gru_0_out_t4_6 + (-0.20226961374282837) * gru_0_out_t4_7 + (-0.46314910054206848) * gru_0_out_t4_8 + (0.46615245938301086) * gru_0_out_t4_9 + (-0.15350691974163055) * gru_0_out_t4_10 + (-0.0019299390260130167) * gru_0_out_t4_11 + (-0.15327197313308716) * gru_0_out_t4_12 + (0.023031879216432571) * gru_0_out_t4_13 + (0.073992908000946045) * gru_0_out_t4_14 + (0.17573116719722748) * gru_0_out_t4_15 + (-0.32039368152618408) * gru_0_out_t4_16 + (-0.19048731029033661) * gru_0_out_t4_17 + (-0.091667309403419495) * gru_0_out_t4_18 + (-0.62564849853515625) * gru_0_out_t4_19 + (0.062167968600988388) * gru_0_out_t4_20 + (-0.27274632453918457) * gru_0_out_t4_21 + (0.11623002588748932) * gru_0_out_t4_22 + (0.15481224656105042) * gru_0_out_t4_23 + (-0.03005792573094368) * gru_0_out_t4_24 + (-0.049482453614473343) * gru_0_out_t4_25 + (0.020882545039057732) * gru_0_out_t4_26 + (0.016499297693371773) * gru_0_out_t4_27 + (0.055536545813083649) * gru_0_out_t4_28 + (0.45674505829811096) * gru_0_out_t4_29 + (-0.19262437522411346) * gru_0_out_t4_30 + (0.062675170600414276) * gru_0_out_t4_31 + (-0.19511221349239349) * gru_0_out_t4_32 + (0.090337380766868591) * gru_0_out_t4_33 + (-0.22088406980037689) * gru_0_out_t4_34 + (0.15848396718502045) * gru_0_out_t4_35 + (0.050301223993301392) * gru_0_out_t4_36 + (0.2811870276927948) * gru_0_out_t4_37 + (0.17899945378303528) * gru_0_out_t4_38 + (-0.4378095269203186) * gru_0_out_t4_39 + (-0.76556414365768433) * gru_0_out_t4_40 + (-0.091834485530853271) * gru_0_out_t4_41 + (-0.11335230618715286) * gru_0_out_t4_42 + (0.23445148766040802) * gru_0_out_t4_43 + (0.35661101341247559) * gru_0_out_t4_44 + (0.62727963924407959) * gru_0_out_t4_45 + (0.038305513560771942) * gru_0_out_t4_46 + (0.32794162631034851) * gru_0_out_t4_47 + (0.45793217420578003) * gru_0_out_t4_48 + (-0.22803770005702972) * gru_0_out_t4_49 + (0.071381725370883942) * gru_0_out_t4_50 + (-0.045355048030614853) * gru_0_out_t4_51 + (0.10306844860315323) * gru_0_out_t4_52 + (0.076342448592185974) * gru_0_out_t4_53 + (-0.10961225628852844) * gru_0_out_t4_54 + (-0.59295517206192017) * gru_0_out_t4_55 + (0.029434345662593842) * gru_0_out_t4_56 + (-0.18059845268726349) * gru_0_out_t4_57 + (0.23845726251602173) * gru_0_out_t4_58 + (-0.028557509183883667) * gru_0_out_t4_59 + (0.093887537717819214) * gru_0_out_t4_60 + (0.27662676572799683) * gru_0_out_t4_61 + (0.88219749927520752) * gru_0_out_t4_62 + (0.19515010714530945) * gru_0_out_t4_63 + gate_r * ((0.034245166927576065) + (-0.77074599266052246) * gru_1_fwd_t3_h_0 + (0.099380888044834137) * gru_1_fwd_t3_h_1 + (-0.054463043808937073) * gru_1_fwd_t3_h_2 + (-0.12775819003582001) * gru_1_fwd_t3_h_3 + (0.5962710976600647) * gru_1_fwd_t3_h_4 + (0.0080833267420530319) * gru_1_fwd_t3_h_5 + (-0.030090240761637688) * gru_1_fwd_t3_h_6 + (-0.16068761050701141) * gru_1_fwd_t3_h_7 + (0.22550457715988159) * gru_1_fwd_t3_h_8 + (-0.16060830652713776) * gru_1_fwd_t3_h_9 + (0.47746774554252625) * gru_1_fwd_t3_h_10 + (0.28645774722099304) * gru_1_fwd_t3_h_11 + (0.090604014694690704) * gru_1_fwd_t3_h_12 + (-0.33011943101882935) * gru_1_fwd_t3_h_13 + (0.1352289617061615) * gru_1_fwd_t3_h_14 + (-0.1631234735250473) * gru_1_fwd_t3_h_15 + (-0.15875649452209473) * gru_1_fwd_t3_h_16 + (0.047294583171606064) * gru_1_fwd_t3_h_17 + (0.37092176079750061) * gru_1_fwd_t3_h_18 + (0.17070020735263824) * gru_1_fwd_t3_h_19 + (0.17905627191066742) * gru_1_fwd_t3_h_20 + (0.042319614440202713) * gru_1_fwd_t3_h_21 + (-0.1152726411819458) * gru_1_fwd_t3_h_22 + (1.1376104354858398) * gru_1_fwd_t3_h_23 + (0.20985528826713562) * gru_1_fwd_t3_h_24 + (0.95099472999572754) * gru_1_fwd_t3_h_25 + (-0.63805234432220459) * gru_1_fwd_t3_h_26 + (0.011583583429455757) * gru_1_fwd_t3_h_27 + (1.1962337493896484) * gru_1_fwd_t3_h_28 + (0.11202040314674377) * gru_1_fwd_t3_h_29 + (0.15463393926620483) * gru_1_fwd_t3_h_30 + (-0.13114038109779358) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_14 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_14;
    // h=15
    gate_r = sigmoid((-0.14252696931362152) + (-0.1273108571767807) * gru_0_out_t4_0 + (0.13209371268749237) * gru_0_out_t4_1 + (-0.27649807929992676) * gru_0_out_t4_2 + (-0.0099655613303184509) * gru_0_out_t4_3 + (0.10868848860263824) * gru_0_out_t4_4 + (0.5941234827041626) * gru_0_out_t4_5 + (0.032085347920656204) * gru_0_out_t4_6 + (-0.8950156569480896) * gru_0_out_t4_7 + (1.2804546356201172) * gru_0_out_t4_8 + (1.0697314739227295) * gru_0_out_t4_9 + (0.14049191772937775) * gru_0_out_t4_10 + (-0.024638650938868523) * gru_0_out_t4_11 + (-0.14962819218635559) * gru_0_out_t4_12 + (-0.041989404708147049) * gru_0_out_t4_13 + (-0.30899831652641296) * gru_0_out_t4_14 + (-0.16325952112674713) * gru_0_out_t4_15 + (0.35378620028495789) * gru_0_out_t4_16 + (-0.17614762485027313) * gru_0_out_t4_17 + (0.5205073356628418) * gru_0_out_t4_18 + (2.3674690723419189) * gru_0_out_t4_19 + (0.41909164190292358) * gru_0_out_t4_20 + (1.0414119958877563) * gru_0_out_t4_21 + (0.42300298810005188) * gru_0_out_t4_22 + (-1.6564027070999146) * gru_0_out_t4_23 + (-1.239443302154541) * gru_0_out_t4_24 + (-1.1604893207550049) * gru_0_out_t4_25 + (0.49952754378318787) * gru_0_out_t4_26 + (0.6091504693031311) * gru_0_out_t4_27 + (-2.1779499053955078) * gru_0_out_t4_28 + (-0.74442142248153687) * gru_0_out_t4_29 + (-0.16004063189029694) * gru_0_out_t4_30 + (-1.8758703470230103) * gru_0_out_t4_31 + (-0.18648026883602142) * gru_0_out_t4_32 + (0.31585228443145752) * gru_0_out_t4_33 + (0.15462078154087067) * gru_0_out_t4_34 + (0.098539508879184723) * gru_0_out_t4_35 + (0.04049186035990715) * gru_0_out_t4_36 + (0.28540173172950745) * gru_0_out_t4_37 + (-0.39856112003326416) * gru_0_out_t4_38 + (0.47101417183876038) * gru_0_out_t4_39 + (-1.414319634437561) * gru_0_out_t4_40 + (0.16349148750305176) * gru_0_out_t4_41 + (0.26332685351371765) * gru_0_out_t4_42 + (-0.038379114121198654) * gru_0_out_t4_43 + (-0.24572345614433289) * gru_0_out_t4_44 + (-0.23756125569343567) * gru_0_out_t4_45 + (0.62001961469650269) * gru_0_out_t4_46 + (-0.5900687575340271) * gru_0_out_t4_47 + (0.094671629369258881) * gru_0_out_t4_48 + (-0.057108063250780106) * gru_0_out_t4_49 + (-0.073551937937736511) * gru_0_out_t4_50 + (0.55618304014205933) * gru_0_out_t4_51 + (-0.062850795686244965) * gru_0_out_t4_52 + (0.10332390666007996) * gru_0_out_t4_53 + (1.3049144744873047) * gru_0_out_t4_54 + (-0.19350026547908783) * gru_0_out_t4_55 + (-0.021466055884957314) * gru_0_out_t4_56 + (0.028373481705784798) * gru_0_out_t4_57 + (0.26017984747886658) * gru_0_out_t4_58 + (1.1394516229629517) * gru_0_out_t4_59 + (0.72652536630630493) * gru_0_out_t4_60 + (0.2654549777507782) * gru_0_out_t4_61 + (-0.25978207588195801) * gru_0_out_t4_62 + (1.061166524887085) * gru_0_out_t4_63 + (0.9225272536277771) * gru_1_fwd_t3_h_0 + (0.54736500978469849) * gru_1_fwd_t3_h_1 + (-0.99681371450424194) * gru_1_fwd_t3_h_2 + (-0.4158480167388916) * gru_1_fwd_t3_h_3 + (-0.34156540036201477) * gru_1_fwd_t3_h_4 + (-1.0619323253631592) * gru_1_fwd_t3_h_5 + (1.6103748083114624) * gru_1_fwd_t3_h_6 + (-0.032484941184520721) * gru_1_fwd_t3_h_7 + (-1.8735204935073853) * gru_1_fwd_t3_h_8 + (-0.24988490343093872) * gru_1_fwd_t3_h_9 + (-0.33532038331031799) * gru_1_fwd_t3_h_10 + (1.1532289981842041) * gru_1_fwd_t3_h_11 + (-0.26214775443077087) * gru_1_fwd_t3_h_12 + (-0.67231756448745728) * gru_1_fwd_t3_h_13 + (-0.040990851819515228) * gru_1_fwd_t3_h_14 + (-0.8349500298500061) * gru_1_fwd_t3_h_15 + (-0.22177739441394806) * gru_1_fwd_t3_h_16 + (0.47193285822868347) * gru_1_fwd_t3_h_17 + (-0.33817058801651001) * gru_1_fwd_t3_h_18 + (0.29424202442169189) * gru_1_fwd_t3_h_19 + (-0.21899332106113434) * gru_1_fwd_t3_h_20 + (-1.5138702392578125) * gru_1_fwd_t3_h_21 + (-1.4406968355178833) * gru_1_fwd_t3_h_22 + (-0.10625933855772018) * gru_1_fwd_t3_h_23 + (0.22119729220867157) * gru_1_fwd_t3_h_24 + (-0.70695710182189941) * gru_1_fwd_t3_h_25 + (-2.1485846042633057) * gru_1_fwd_t3_h_26 + (-0.14369969069957733) * gru_1_fwd_t3_h_27 + (-0.48045995831489563) * gru_1_fwd_t3_h_28 + (-0.20452511310577393) * gru_1_fwd_t3_h_29 + (-0.61336880922317505) * gru_1_fwd_t3_h_30 + (0.159974604845047) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((-0.20010054111480713) + (0.20837114751338959) * gru_0_out_t4_0 + (0.01103175338357687) * gru_0_out_t4_1 + (1.4599847793579102) * gru_0_out_t4_2 + (-0.82316410541534424) * gru_0_out_t4_3 + (0.20982158184051514) * gru_0_out_t4_4 + (-1.5093766450881958) * gru_0_out_t4_5 + (-1.0777796506881714) * gru_0_out_t4_6 + (-0.43025398254394531) * gru_0_out_t4_7 + (0.73049712181091309) * gru_0_out_t4_8 + (2.2380328178405762) * gru_0_out_t4_9 + (-1.3304436206817627) * gru_0_out_t4_10 + (0.30146953463554382) * gru_0_out_t4_11 + (-0.014563877135515213) * gru_0_out_t4_12 + (0.24543450772762299) * gru_0_out_t4_13 + (-0.37925195693969727) * gru_0_out_t4_14 + (0.56397521495819092) * gru_0_out_t4_15 + (1.2668452262878418) * gru_0_out_t4_16 + (0.19709737598896027) * gru_0_out_t4_17 + (0.36501863598823547) * gru_0_out_t4_18 + (0.32603225111961365) * gru_0_out_t4_19 + (1.1689451932907104) * gru_0_out_t4_20 + (0.83956372737884521) * gru_0_out_t4_21 + (0.37466534972190857) * gru_0_out_t4_22 + (0.42630356550216675) * gru_0_out_t4_23 + (-0.79960572719573975) * gru_0_out_t4_24 + (0.19976326823234558) * gru_0_out_t4_25 + (-0.079449132084846497) * gru_0_out_t4_26 + (-0.032034266740083694) * gru_0_out_t4_27 + (-1.041562557220459) * gru_0_out_t4_28 + (0.33244732022285461) * gru_0_out_t4_29 + (0.19705168902873993) * gru_0_out_t4_30 + (0.2167586088180542) * gru_0_out_t4_31 + (-1.1369268894195557) * gru_0_out_t4_32 + (0.6370273232460022) * gru_0_out_t4_33 + (-0.48087617754936218) * gru_0_out_t4_34 + (-0.13734914362430573) * gru_0_out_t4_35 + (-0.056470133364200592) * gru_0_out_t4_36 + (0.074742585420608521) * gru_0_out_t4_37 + (0.099214352667331696) * gru_0_out_t4_38 + (-0.86935544013977051) * gru_0_out_t4_39 + (-1.042494535446167) * gru_0_out_t4_40 + (0.042564816772937775) * gru_0_out_t4_41 + (0.17438636720180511) * gru_0_out_t4_42 + (-0.2369200587272644) * gru_0_out_t4_43 + (0.0059458939358592033) * gru_0_out_t4_44 + (0.10548446327447891) * gru_0_out_t4_45 + (0.28301936388015747) * gru_0_out_t4_46 + (0.23119893670082092) * gru_0_out_t4_47 + (-0.12024985253810883) * gru_0_out_t4_48 + (0.30621486902236938) * gru_0_out_t4_49 + (-0.0053261634893715382) * gru_0_out_t4_50 + (0.055038966238498688) * gru_0_out_t4_51 + (-0.043306399136781693) * gru_0_out_t4_52 + (-0.2367749810218811) * gru_0_out_t4_53 + (0.060773830860853195) * gru_0_out_t4_54 + (-0.13898658752441406) * gru_0_out_t4_55 + (-0.22388049960136414) * gru_0_out_t4_56 + (-0.056070476770401001) * gru_0_out_t4_57 + (0.31873193383216858) * gru_0_out_t4_58 + (0.042977135628461838) * gru_0_out_t4_59 + (-0.33431950211524963) * gru_0_out_t4_60 + (-0.38221061229705811) * gru_0_out_t4_61 + (0.51840907335281372) * gru_0_out_t4_62 + (0.66650509834289551) * gru_0_out_t4_63 + (0.89041239023208618) * gru_1_fwd_t3_h_0 + (0.48555842041969299) * gru_1_fwd_t3_h_1 + (-0.1131487563252449) * gru_1_fwd_t3_h_2 + (0.19706635177135468) * gru_1_fwd_t3_h_3 + (-0.25381040573120117) * gru_1_fwd_t3_h_4 + (-0.80056107044219971) * gru_1_fwd_t3_h_5 + (0.08113793283700943) * gru_1_fwd_t3_h_6 + (-0.47052842378616333) * gru_1_fwd_t3_h_7 + (0.37915930151939392) * gru_1_fwd_t3_h_8 + (-0.19041734933853149) * gru_1_fwd_t3_h_9 + (1.6031692028045654) * gru_1_fwd_t3_h_10 + (1.0791275501251221) * gru_1_fwd_t3_h_11 + (0.15339197218418121) * gru_1_fwd_t3_h_12 + (-0.19778591394424438) * gru_1_fwd_t3_h_13 + (0.086621254682540894) * gru_1_fwd_t3_h_14 + (0.4531891942024231) * gru_1_fwd_t3_h_15 + (0.41358399391174316) * gru_1_fwd_t3_h_16 + (-0.19029928743839264) * gru_1_fwd_t3_h_17 + (0.37494802474975586) * gru_1_fwd_t3_h_18 + (0.063745178282260895) * gru_1_fwd_t3_h_19 + (0.14925503730773926) * gru_1_fwd_t3_h_20 + (-0.41758465766906738) * gru_1_fwd_t3_h_21 + (0.46809226274490356) * gru_1_fwd_t3_h_22 + (0.11447564512491226) * gru_1_fwd_t3_h_23 + (0.2613576352596283) * gru_1_fwd_t3_h_24 + (1.2266989946365356) * gru_1_fwd_t3_h_25 + (-0.4682915210723877) * gru_1_fwd_t3_h_26 + (0.13888901472091675) * gru_1_fwd_t3_h_27 + (-0.08909279853105545) * gru_1_fwd_t3_h_28 + (0.22793951630592346) * gru_1_fwd_t3_h_29 + (-0.029005277901887894) * gru_1_fwd_t3_h_30 + (0.077649384737014771) * gru_1_fwd_t3_h_31);
    gate_n = tanh((-0.27310928702354431) + (0.13068944215774536) * gru_0_out_t4_0 + (0.44534191489219666) * gru_0_out_t4_1 + (-0.52533513307571411) * gru_0_out_t4_2 + (0.037337087094783783) * gru_0_out_t4_3 + (0.44608861207962036) * gru_0_out_t4_4 + (0.083989568054676056) * gru_0_out_t4_5 + (-0.61942631006240845) * gru_0_out_t4_6 + (0.11928364634513855) * gru_0_out_t4_7 + (1.0010055303573608) * gru_0_out_t4_8 + (0.86570531129837036) * gru_0_out_t4_9 + (-0.67394012212753296) * gru_0_out_t4_10 + (-0.031762424856424332) * gru_0_out_t4_11 + (-0.18867084383964539) * gru_0_out_t4_12 + (-0.43164819478988647) * gru_0_out_t4_13 + (0.084357358515262604) * gru_0_out_t4_14 + (-0.091652952134609222) * gru_0_out_t4_15 + (0.73219025135040283) * gru_0_out_t4_16 + (0.25531294941902161) * gru_0_out_t4_17 + (0.12771874666213989) * gru_0_out_t4_18 + (-0.39284190535545349) * gru_0_out_t4_19 + (-0.070826590061187744) * gru_0_out_t4_20 + (0.78559744358062744) * gru_0_out_t4_21 + (-0.47350525856018066) * gru_0_out_t4_22 + (-1.1793445348739624) * gru_0_out_t4_23 + (-0.19741111993789673) * gru_0_out_t4_24 + (0.33291855454444885) * gru_0_out_t4_25 + (-0.11186069995164871) * gru_0_out_t4_26 + (0.031002603471279144) * gru_0_out_t4_27 + (0.96631467342376709) * gru_0_out_t4_28 + (-0.38327184319496155) * gru_0_out_t4_29 + (-0.37440729141235352) * gru_0_out_t4_30 + (-0.48583304882049561) * gru_0_out_t4_31 + (-0.045444726943969727) * gru_0_out_t4_32 + (0.17876286804676056) * gru_0_out_t4_33 + (-0.55092191696166992) * gru_0_out_t4_34 + (-0.016904372721910477) * gru_0_out_t4_35 + (0.19009539484977722) * gru_0_out_t4_36 + (0.34925100207328796) * gru_0_out_t4_37 + (-0.14794503152370453) * gru_0_out_t4_38 + (-0.57555007934570312) * gru_0_out_t4_39 + (1.3538603782653809) * gru_0_out_t4_40 + (-0.24438515305519104) * gru_0_out_t4_41 + (0.32886520028114319) * gru_0_out_t4_42 + (0.016996392980217934) * gru_0_out_t4_43 + (-0.93078523874282837) * gru_0_out_t4_44 + (-0.50831836462020874) * gru_0_out_t4_45 + (-0.16950492560863495) * gru_0_out_t4_46 + (-0.089502573013305664) * gru_0_out_t4_47 + (-0.27272287011146545) * gru_0_out_t4_48 + (0.027521057054400444) * gru_0_out_t4_49 + (-0.0030496451072394848) * gru_0_out_t4_50 + (0.0091908760368824005) * gru_0_out_t4_51 + (-0.14111720025539398) * gru_0_out_t4_52 + (-0.61911410093307495) * gru_0_out_t4_53 + (0.74847781658172607) * gru_0_out_t4_54 + (0.015259590931236744) * gru_0_out_t4_55 + (0.24447356164455414) * gru_0_out_t4_56 + (-0.075419157743453979) * gru_0_out_t4_57 + (0.16044260561466217) * gru_0_out_t4_58 + (-0.010633731260895729) * gru_0_out_t4_59 + (1.2168402671813965) * gru_0_out_t4_60 + (0.72344702482223511) * gru_0_out_t4_61 + (-0.48917239904403687) * gru_0_out_t4_62 + (-0.23016200959682465) * gru_0_out_t4_63 + gate_r * ((-0.39011108875274658) + (0.54748284816741943) * gru_1_fwd_t3_h_0 + (0.028262393549084663) * gru_1_fwd_t3_h_1 + (0.99697232246398926) * gru_1_fwd_t3_h_2 + (0.33071178197860718) * gru_1_fwd_t3_h_3 + (-0.20900626480579376) * gru_1_fwd_t3_h_4 + (-0.024302165955305099) * gru_1_fwd_t3_h_5 + (-0.26677075028419495) * gru_1_fwd_t3_h_6 + (0.060709256678819656) * gru_1_fwd_t3_h_7 + (-0.0065368674695491791) * gru_1_fwd_t3_h_8 + (-0.21267244219779968) * gru_1_fwd_t3_h_9 + (0.11591779440641403) * gru_1_fwd_t3_h_10 + (-0.83535641431808472) * gru_1_fwd_t3_h_11 + (0.033392433077096939) * gru_1_fwd_t3_h_12 + (0.056867994368076324) * gru_1_fwd_t3_h_13 + (-0.3345550000667572) * gru_1_fwd_t3_h_14 + (-0.44265261292457581) * gru_1_fwd_t3_h_15 + (-0.012428202666342258) * gru_1_fwd_t3_h_16 + (-0.18101565539836884) * gru_1_fwd_t3_h_17 + (-0.025231409817934036) * gru_1_fwd_t3_h_18 + (-0.31299403309822083) * gru_1_fwd_t3_h_19 + (0.51982003450393677) * gru_1_fwd_t3_h_20 + (-0.31096053123474121) * gru_1_fwd_t3_h_21 + (-0.0092970440164208412) * gru_1_fwd_t3_h_22 + (0.50608259439468384) * gru_1_fwd_t3_h_23 + (1.1007579565048218) * gru_1_fwd_t3_h_24 + (0.301230788230896) * gru_1_fwd_t3_h_25 + (-0.22389601171016693) * gru_1_fwd_t3_h_26 + (-0.82675635814666748) * gru_1_fwd_t3_h_27 + (-0.053431857377290726) * gru_1_fwd_t3_h_28 + (0.21673603355884552) * gru_1_fwd_t3_h_29 + (0.48022615909576416) * gru_1_fwd_t3_h_30 + (0.2123757004737854) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_15 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_15;
    // h=16
    gate_r = sigmoid((-0.29410448670387268) + (-0.64615559577941895) * gru_0_out_t4_0 + (1.4186617136001587) * gru_0_out_t4_1 + (-1.0398908853530884) * gru_0_out_t4_2 + (-0.68223631381988525) * gru_0_out_t4_3 + (0.053732812404632568) * gru_0_out_t4_4 + (-0.50579380989074707) * gru_0_out_t4_5 + (-0.11160075664520264) * gru_0_out_t4_6 + (-0.68993586301803589) * gru_0_out_t4_7 + (0.2862686812877655) * gru_0_out_t4_8 + (-0.29196858406066895) * gru_0_out_t4_9 + (1.2952944040298462) * gru_0_out_t4_10 + (0.1911855936050415) * gru_0_out_t4_11 + (0.084379449486732483) * gru_0_out_t4_12 + (0.39103186130523682) * gru_0_out_t4_13 + (-0.2205733060836792) * gru_0_out_t4_14 + (-0.78194600343704224) * gru_0_out_t4_15 + (0.25682789087295532) * gru_0_out_t4_16 + (0.34257283806800842) * gru_0_out_t4_17 + (-0.25675708055496216) * gru_0_out_t4_18 + (0.69322538375854492) * gru_0_out_t4_19 + (-0.58638018369674683) * gru_0_out_t4_20 + (0.035921018570661545) * gru_0_out_t4_21 + (-1.3290404081344604) * gru_0_out_t4_22 + (-0.15674965083599091) * gru_0_out_t4_23 + (1.5568701028823853) * gru_0_out_t4_24 + (0.1607079952955246) * gru_0_out_t4_25 + (-0.20773473381996155) * gru_0_out_t4_26 + (-0.77457445859909058) * gru_0_out_t4_27 + (0.53829407691955566) * gru_0_out_t4_28 + (0.075575165450572968) * gru_0_out_t4_29 + (0.2209957093000412) * gru_0_out_t4_30 + (2.1318554878234863) * gru_0_out_t4_31 + (3.6907036304473877) * gru_0_out_t4_32 + (1.0573219060897827) * gru_0_out_t4_33 + (0.38706481456756592) * gru_0_out_t4_34 + (-1.8441382646560669) * gru_0_out_t4_35 + (-0.31447711586952209) * gru_0_out_t4_36 + (0.11242479085922241) * gru_0_out_t4_37 + (-0.44741994142532349) * gru_0_out_t4_38 + (-0.90080368518829346) * gru_0_out_t4_39 + (-3.827888011932373) * gru_0_out_t4_40 + (0.48193979263305664) * gru_0_out_t4_41 + (0.96341961622238159) * gru_0_out_t4_42 + (-1.7891477346420288) * gru_0_out_t4_43 + (-0.71881502866744995) * gru_0_out_t4_44 + (-0.63431823253631592) * gru_0_out_t4_45 + (0.57844573259353638) * gru_0_out_t4_46 + (-2.4977519512176514) * gru_0_out_t4_47 + (-0.38457313179969788) * gru_0_out_t4_48 + (0.5209355354309082) * gru_0_out_t4_49 + (0.0060571278445422649) * gru_0_out_t4_50 + (-0.12831979990005493) * gru_0_out_t4_51 + (0.31226179003715515) * gru_0_out_t4_52 + (0.44886913895606995) * gru_0_out_t4_53 + (0.045342497527599335) * gru_0_out_t4_54 + (0.27190998196601868) * gru_0_out_t4_55 + (0.30759355425834656) * gru_0_out_t4_56 + (0.52536672353744507) * gru_0_out_t4_57 + (-0.2799641489982605) * gru_0_out_t4_58 + (4.4690742492675781) * gru_0_out_t4_59 + (0.15575703978538513) * gru_0_out_t4_60 + (0.0026140378322452307) * gru_0_out_t4_61 + (-0.099210225045681) * gru_0_out_t4_62 + (2.3683121204376221) * gru_0_out_t4_63 + (-2.7111828327178955) * gru_1_fwd_t3_h_0 + (1.2488409280776978) * gru_1_fwd_t3_h_1 + (-0.80689710378646851) * gru_1_fwd_t3_h_2 + (-0.9205324649810791) * gru_1_fwd_t3_h_3 + (-0.12060008198022842) * gru_1_fwd_t3_h_4 + (-0.0023304985370486975) * gru_1_fwd_t3_h_5 + (0.96697801351547241) * gru_1_fwd_t3_h_6 + (1.0441755056381226) * gru_1_fwd_t3_h_7 + (0.53406774997711182) * gru_1_fwd_t3_h_8 + (0.82018065452575684) * gru_1_fwd_t3_h_9 + (0.38070765137672424) * gru_1_fwd_t3_h_10 + (-0.6820443868637085) * gru_1_fwd_t3_h_11 + (1.3043214082717896) * gru_1_fwd_t3_h_12 + (-0.37380287051200867) * gru_1_fwd_t3_h_13 + (1.0409265756607056) * gru_1_fwd_t3_h_14 + (-0.74934357404708862) * gru_1_fwd_t3_h_15 + (0.65143537521362305) * gru_1_fwd_t3_h_16 + (-0.72782385349273682) * gru_1_fwd_t3_h_17 + (1.1853723526000977) * gru_1_fwd_t3_h_18 + (-0.45256069302558899) * gru_1_fwd_t3_h_19 + (-0.40377748012542725) * gru_1_fwd_t3_h_20 + (3.1520791053771973) * gru_1_fwd_t3_h_21 + (0.72287839651107788) * gru_1_fwd_t3_h_22 + (2.4087786674499512) * gru_1_fwd_t3_h_23 + (-0.016056898981332779) * gru_1_fwd_t3_h_24 + (0.58438271284103394) * gru_1_fwd_t3_h_25 + (-2.1881868839263916) * gru_1_fwd_t3_h_26 + (-0.23527480661869049) * gru_1_fwd_t3_h_27 + (1.4907263517379761) * gru_1_fwd_t3_h_28 + (-0.81724625825881958) * gru_1_fwd_t3_h_29 + (1.1501772403717041) * gru_1_fwd_t3_h_30 + (-1.3607919216156006) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((-0.97060859203338623) + (-0.037337504327297211) * gru_0_out_t4_0 + (0.27543348073959351) * gru_0_out_t4_1 + (-0.06484648585319519) * gru_0_out_t4_2 + (0.092112518846988678) * gru_0_out_t4_3 + (-0.53779476881027222) * gru_0_out_t4_4 + (0.1989690363407135) * gru_0_out_t4_5 + (0.81809419393539429) * gru_0_out_t4_6 + (-1.4531619548797607) * gru_0_out_t4_7 + (0.28458157181739807) * gru_0_out_t4_8 + (-0.62000107765197754) * gru_0_out_t4_9 + (0.35276502370834351) * gru_0_out_t4_10 + (0.043119531124830246) * gru_0_out_t4_11 + (-0.10890460014343262) * gru_0_out_t4_12 + (0.095366917550563812) * gru_0_out_t4_13 + (-0.12012272328138351) * gru_0_out_t4_14 + (0.33950242400169373) * gru_0_out_t4_15 + (1.0166375637054443) * gru_0_out_t4_16 + (0.22579401731491089) * gru_0_out_t4_17 + (0.42682340741157532) * gru_0_out_t4_18 + (1.5678606033325195) * gru_0_out_t4_19 + (-0.4683399498462677) * gru_0_out_t4_20 + (1.3571635484695435) * gru_0_out_t4_21 + (0.65204781293869019) * gru_0_out_t4_22 + (-0.5366026759147644) * gru_0_out_t4_23 + (-0.4994320273399353) * gru_0_out_t4_24 + (-0.3614422082901001) * gru_0_out_t4_25 + (-0.24203141033649445) * gru_0_out_t4_26 + (0.33753257989883423) * gru_0_out_t4_27 + (2.1065077781677246) * gru_0_out_t4_28 + (-0.8456043004989624) * gru_0_out_t4_29 + (-0.89641201496124268) * gru_0_out_t4_30 + (0.14637118577957153) * gru_0_out_t4_31 + (-3.1288564205169678) * gru_0_out_t4_32 + (-0.38054487109184265) * gru_0_out_t4_33 + (-0.24205127358436584) * gru_0_out_t4_34 + (-0.07553911954164505) * gru_0_out_t4_35 + (0.10474294424057007) * gru_0_out_t4_36 + (0.13916096091270447) * gru_0_out_t4_37 + (0.034799873828887939) * gru_0_out_t4_38 + (-0.43294656276702881) * gru_0_out_t4_39 + (0.091682225465774536) * gru_0_out_t4_40 + (0.64046889543533325) * gru_0_out_t4_41 + (-0.31308954954147339) * gru_0_out_t4_42 + (-0.31525006890296936) * gru_0_out_t4_43 + (-0.074149109423160553) * gru_0_out_t4_44 + (-0.32027631998062134) * gru_0_out_t4_45 + (-0.21475879848003387) * gru_0_out_t4_46 + (1.3514038324356079) * gru_0_out_t4_47 + (-0.3134523332118988) * gru_0_out_t4_48 + (0.14589816331863403) * gru_0_out_t4_49 + (-0.80087816715240479) * gru_0_out_t4_50 + (0.0068223909474909306) * gru_0_out_t4_51 + (0.38784906268119812) * gru_0_out_t4_52 + (-0.77051353454589844) * gru_0_out_t4_53 + (0.06820080429315567) * gru_0_out_t4_54 + (-0.30778107047080994) * gru_0_out_t4_55 + (1.1999181509017944) * gru_0_out_t4_56 + (0.60534501075744629) * gru_0_out_t4_57 + (-0.32900020480155945) * gru_0_out_t4_58 + (0.2913983166217804) * gru_0_out_t4_59 + (0.20297254621982574) * gru_0_out_t4_60 + (-0.22547332942485809) * gru_0_out_t4_61 + (-0.54179054498672485) * gru_0_out_t4_62 + (1.5167461633682251) * gru_0_out_t4_63 + (0.44947418570518494) * gru_1_fwd_t3_h_0 + (-0.53886228799819946) * gru_1_fwd_t3_h_1 + (-0.53234708309173584) * gru_1_fwd_t3_h_2 + (0.89293324947357178) * gru_1_fwd_t3_h_3 + (-0.00094895320944488049) * gru_1_fwd_t3_h_4 + (0.47871148586273193) * gru_1_fwd_t3_h_5 + (0.26120111346244812) * gru_1_fwd_t3_h_6 + (-0.61157423257827759) * gru_1_fwd_t3_h_7 + (-0.74095445871353149) * gru_1_fwd_t3_h_8 + (0.17440888285636902) * gru_1_fwd_t3_h_9 + (0.86495769023895264) * gru_1_fwd_t3_h_10 + (-0.016308361664414406) * gru_1_fwd_t3_h_11 + (-0.27331531047821045) * gru_1_fwd_t3_h_12 + (0.15217790007591248) * gru_1_fwd_t3_h_13 + (1.1521637439727783) * gru_1_fwd_t3_h_14 + (-0.2883039116859436) * gru_1_fwd_t3_h_15 + (-0.62530416250228882) * gru_1_fwd_t3_h_16 + (0.54128408432006836) * gru_1_fwd_t3_h_17 + (-1.4101169109344482) * gru_1_fwd_t3_h_18 + (-0.02296452596783638) * gru_1_fwd_t3_h_19 + (-0.046477440744638443) * gru_1_fwd_t3_h_20 + (-0.10003414005041122) * gru_1_fwd_t3_h_21 + (0.42140623927116394) * gru_1_fwd_t3_h_22 + (-2.5295350551605225) * gru_1_fwd_t3_h_23 + (-0.057407446205615997) * gru_1_fwd_t3_h_24 + (-0.37359309196472168) * gru_1_fwd_t3_h_25 + (-0.17729708552360535) * gru_1_fwd_t3_h_26 + (0.99514114856719971) * gru_1_fwd_t3_h_27 + (-0.93953120708465576) * gru_1_fwd_t3_h_28 + (-0.060108032077550888) * gru_1_fwd_t3_h_29 + (0.78097081184387207) * gru_1_fwd_t3_h_30 + (0.46018317341804504) * gru_1_fwd_t3_h_31);
    gate_n = tanh((-0.5933833122253418) + (0.019754273816943169) * gru_0_out_t4_0 + (2.6644489765167236) * gru_0_out_t4_1 + (0.043807491660118103) * gru_0_out_t4_2 + (-0.13925927877426147) * gru_0_out_t4_3 + (-0.1834932267665863) * gru_0_out_t4_4 + (-0.86176717281341553) * gru_0_out_t4_5 + (0.4760972261428833) * gru_0_out_t4_6 + (1.115276575088501) * gru_0_out_t4_7 + (-0.22560754418373108) * gru_0_out_t4_8 + (0.37708494067192078) * gru_0_out_t4_9 + (-0.13993830978870392) * gru_0_out_t4_10 + (-0.3410625159740448) * gru_0_out_t4_11 + (-0.2422889918088913) * gru_0_out_t4_12 + (-1.1451092958450317) * gru_0_out_t4_13 + (-0.10507015138864517) * gru_0_out_t4_14 + (-0.96366012096405029) * gru_0_out_t4_15 + (0.36831417679786682) * gru_0_out_t4_16 + (0.078452207148075104) * gru_0_out_t4_17 + (0.39467808604240417) * gru_0_out_t4_18 + (1.1776833534240723) * gru_0_out_t4_19 + (0.32065474987030029) * gru_0_out_t4_20 + (1.6158574819564819) * gru_0_out_t4_21 + (-0.54503059387207031) * gru_0_out_t4_22 + (-0.45511823892593384) * gru_0_out_t4_23 + (-0.77460801601409912) * gru_0_out_t4_24 + (0.36026141047477722) * gru_0_out_t4_25 + (-0.09381372481584549) * gru_0_out_t4_26 + (-1.3670574426651001) * gru_0_out_t4_27 + (0.45654091238975525) * gru_0_out_t4_28 + (0.66345483064651489) * gru_0_out_t4_29 + (0.38188013434410095) * gru_0_out_t4_30 + (-1.4395555257797241) * gru_0_out_t4_31 + (0.31092935800552368) * gru_0_out_t4_32 + (0.56428623199462891) * gru_0_out_t4_33 + (-0.38335809111595154) * gru_0_out_t4_34 + (-3.1057138442993164) * gru_0_out_t4_35 + (-0.026680737733840942) * gru_0_out_t4_36 + (1.1241950988769531) * gru_0_out_t4_37 + (0.044988054782152176) * gru_0_out_t4_38 + (0.78339022397994995) * gru_0_out_t4_39 + (0.57983523607254028) * gru_0_out_t4_40 + (-0.55712032318115234) * gru_0_out_t4_41 + (0.51464420557022095) * gru_0_out_t4_42 + (-0.014154508709907532) * gru_0_out_t4_43 + (-0.51596003770828247) * gru_0_out_t4_44 + (-0.57639098167419434) * gru_0_out_t4_45 + (0.42564752697944641) * gru_0_out_t4_46 + (-0.90847045183181763) * gru_0_out_t4_47 + (-0.61161273717880249) * gru_0_out_t4_48 + (-0.28582248091697693) * gru_0_out_t4_49 + (0.10884002596139908) * gru_0_out_t4_50 + (-0.53468751907348633) * gru_0_out_t4_51 + (0.19121696054935455) * gru_0_out_t4_52 + (-0.10358615219593048) * gru_0_out_t4_53 + (0.02262437529861927) * gru_0_out_t4_54 + (0.19122141599655151) * gru_0_out_t4_55 + (0.68889975547790527) * gru_0_out_t4_56 + (0.33800831437110901) * gru_0_out_t4_57 + (0.025625260546803474) * gru_0_out_t4_58 + (0.82837897539138794) * gru_0_out_t4_59 + (-0.081156149506568909) * gru_0_out_t4_60 + (-0.010824074037373066) * gru_0_out_t4_61 + (-0.54488962888717651) * gru_0_out_t4_62 + (-1.9135136604309082) * gru_0_out_t4_63 + gate_r * ((1.3445340394973755) + (-0.72670108079910278) * gru_1_fwd_t3_h_0 + (-0.98379713296890259) * gru_1_fwd_t3_h_1 + (1.1309353113174438) * gru_1_fwd_t3_h_2 + (-0.23982429504394531) * gru_1_fwd_t3_h_3 + (1.1368358135223389) * gru_1_fwd_t3_h_4 + (0.44870331883430481) * gru_1_fwd_t3_h_5 + (0.45607438683509827) * gru_1_fwd_t3_h_6 + (-0.66903722286224365) * gru_1_fwd_t3_h_7 + (-1.0165234804153442) * gru_1_fwd_t3_h_8 + (0.61388140916824341) * gru_1_fwd_t3_h_9 + (1.1479865312576294) * gru_1_fwd_t3_h_10 + (1.3086510896682739) * gru_1_fwd_t3_h_11 + (-0.52618718147277832) * gru_1_fwd_t3_h_12 + (-0.33545377850532532) * gru_1_fwd_t3_h_13 + (0.52494603395462036) * gru_1_fwd_t3_h_14 + (0.27716478705406189) * gru_1_fwd_t3_h_15 + (-1.024301290512085) * gru_1_fwd_t3_h_16 + (-0.15380613505840302) * gru_1_fwd_t3_h_17 + (0.85772573947906494) * gru_1_fwd_t3_h_18 + (1.6784783601760864) * gru_1_fwd_t3_h_19 + (-0.073591180145740509) * gru_1_fwd_t3_h_20 + (-0.16970914602279663) * gru_1_fwd_t3_h_21 + (0.65429937839508057) * gru_1_fwd_t3_h_22 + (-0.27311456203460693) * gru_1_fwd_t3_h_23 + (2.2529256343841553) * gru_1_fwd_t3_h_24 + (-1.5689877271652222) * gru_1_fwd_t3_h_25 + (1.9697020053863525) * gru_1_fwd_t3_h_26 + (1.1341851949691772) * gru_1_fwd_t3_h_27 + (-0.1124720573425293) * gru_1_fwd_t3_h_28 + (-0.23632447421550751) * gru_1_fwd_t3_h_29 + (-0.4775625467300415) * gru_1_fwd_t3_h_30 + (0.34884184598922729) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_16 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_16;
    // h=17
    gate_r = sigmoid((-0.41148003935813904) + (0.47238573431968689) * gru_0_out_t4_0 + (0.66103261709213257) * gru_0_out_t4_1 + (-0.98806369304656982) * gru_0_out_t4_2 + (-0.42350888252258301) * gru_0_out_t4_3 + (0.4640190601348877) * gru_0_out_t4_4 + (-0.74383640289306641) * gru_0_out_t4_5 + (-2.1639344692230225) * gru_0_out_t4_6 + (-1.2958414554595947) * gru_0_out_t4_7 + (-0.19463802874088287) * gru_0_out_t4_8 + (1.4465732574462891) * gru_0_out_t4_9 + (1.0512278079986572) * gru_0_out_t4_10 + (-0.35838231444358826) * gru_0_out_t4_11 + (-0.36811384558677673) * gru_0_out_t4_12 + (1.3973922729492188) * gru_0_out_t4_13 + (-0.67438089847564697) * gru_0_out_t4_14 + (-1.2710835933685303) * gru_0_out_t4_15 + (0.12473719567060471) * gru_0_out_t4_16 + (0.13504362106323242) * gru_0_out_t4_17 + (0.33399808406829834) * gru_0_out_t4_18 + (2.9357411861419678) * gru_0_out_t4_19 + (-2.29567551612854) * gru_0_out_t4_20 + (0.15434952080249786) * gru_0_out_t4_21 + (-1.7308231592178345) * gru_0_out_t4_22 + (-0.10938715934753418) * gru_0_out_t4_23 + (0.12009493261575699) * gru_0_out_t4_24 + (0.21539868414402008) * gru_0_out_t4_25 + (0.44444450736045837) * gru_0_out_t4_26 + (-0.20681340992450714) * gru_0_out_t4_27 + (-0.24683965742588043) * gru_0_out_t4_28 + (-0.25147664546966553) * gru_0_out_t4_29 + (-0.54391962289810181) * gru_0_out_t4_30 + (3.9395337104797363) * gru_0_out_t4_31 + (0.60500240325927734) * gru_0_out_t4_32 + (-0.58866328001022339) * gru_0_out_t4_33 + (0.25301980972290039) * gru_0_out_t4_34 + (-0.66588348150253296) * gru_0_out_t4_35 + (-1.9679735898971558) * gru_0_out_t4_36 + (-0.32015416026115417) * gru_0_out_t4_37 + (0.40246737003326416) * gru_0_out_t4_38 + (0.46883094310760498) * gru_0_out_t4_39 + (1.367402195930481) * gru_0_out_t4_40 + (-1.295067310333252) * gru_0_out_t4_41 + (-0.20777805149555206) * gru_0_out_t4_42 + (-0.43703430891036987) * gru_0_out_t4_43 + (-0.35505858063697815) * gru_0_out_t4_44 + (-0.14413580298423767) * gru_0_out_t4_45 + (1.395282506942749) * gru_0_out_t4_46 + (0.064788401126861572) * gru_0_out_t4_47 + (0.26926514506340027) * gru_0_out_t4_48 + (-0.63569307327270508) * gru_0_out_t4_49 + (-0.67407858371734619) * gru_0_out_t4_50 + (-1.3780974149703979) * gru_0_out_t4_51 + (-0.011366341263055801) * gru_0_out_t4_52 + (-0.15577498078346252) * gru_0_out_t4_53 + (-0.46138247847557068) * gru_0_out_t4_54 + (-0.12100930511951447) * gru_0_out_t4_55 + (1.4568145275115967) * gru_0_out_t4_56 + (-0.71388602256774902) * gru_0_out_t4_57 + (0.51148396730422974) * gru_0_out_t4_58 + (0.026473948732018471) * gru_0_out_t4_59 + (-0.13368572294712067) * gru_0_out_t4_60 + (0.3639971911907196) * gru_0_out_t4_61 + (-3.9786458015441895) * gru_0_out_t4_62 + (0.69883072376251221) * gru_0_out_t4_63 + (0.27167186141014099) * gru_1_fwd_t3_h_0 + (0.020365992560982704) * gru_1_fwd_t3_h_1 + (1.2854567766189575) * gru_1_fwd_t3_h_2 + (0.20891593396663666) * gru_1_fwd_t3_h_3 + (-0.26299148797988892) * gru_1_fwd_t3_h_4 + (-1.8146891593933105) * gru_1_fwd_t3_h_5 + (-0.027107665315270424) * gru_1_fwd_t3_h_6 + (0.82493817806243896) * gru_1_fwd_t3_h_7 + (0.046666420996189117) * gru_1_fwd_t3_h_8 + (0.50535362958908081) * gru_1_fwd_t3_h_9 + (-0.055275328457355499) * gru_1_fwd_t3_h_10 + (1.7068792581558228) * gru_1_fwd_t3_h_11 + (-0.33011564612388611) * gru_1_fwd_t3_h_12 + (0.68490976095199585) * gru_1_fwd_t3_h_13 + (0.36785873770713806) * gru_1_fwd_t3_h_14 + (-0.68023234605789185) * gru_1_fwd_t3_h_15 + (0.43559971451759338) * gru_1_fwd_t3_h_16 + (-0.54693436622619629) * gru_1_fwd_t3_h_17 + (0.10778649151325226) * gru_1_fwd_t3_h_18 + (-0.45565295219421387) * gru_1_fwd_t3_h_19 + (0.97338038682937622) * gru_1_fwd_t3_h_20 + (-1.3887478113174438) * gru_1_fwd_t3_h_21 + (1.1298952102661133) * gru_1_fwd_t3_h_22 + (-0.50673162937164307) * gru_1_fwd_t3_h_23 + (-3.2248141765594482) * gru_1_fwd_t3_h_24 + (-0.81580626964569092) * gru_1_fwd_t3_h_25 + (-0.43484845757484436) * gru_1_fwd_t3_h_26 + (0.72725510597229004) * gru_1_fwd_t3_h_27 + (-1.294333815574646) * gru_1_fwd_t3_h_28 + (1.024578332901001) * gru_1_fwd_t3_h_29 + (-1.2793688774108887) * gru_1_fwd_t3_h_30 + (1.3361537456512451) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((0.764637291431427) + (-0.38635200262069702) * gru_0_out_t4_0 + (-0.40014761686325073) * gru_0_out_t4_1 + (2.4240093231201172) * gru_0_out_t4_2 + (-0.56269538402557373) * gru_0_out_t4_3 + (-0.17769171297550201) * gru_0_out_t4_4 + (0.46267414093017578) * gru_0_out_t4_5 + (0.16072991490364075) * gru_0_out_t4_6 + (-1.5523312091827393) * gru_0_out_t4_7 + (0.28363028168678284) * gru_0_out_t4_8 + (-0.14460667967796326) * gru_0_out_t4_9 + (-1.4602681398391724) * gru_0_out_t4_10 + (0.57768934965133667) * gru_0_out_t4_11 + (-0.70759761333465576) * gru_0_out_t4_12 + (-0.11177968233823776) * gru_0_out_t4_13 + (0.11393314599990845) * gru_0_out_t4_14 + (0.64546823501586914) * gru_0_out_t4_15 + (0.15875080227851868) * gru_0_out_t4_16 + (0.28666570782661438) * gru_0_out_t4_17 + (-0.12255144864320755) * gru_0_out_t4_18 + (-0.25357347726821899) * gru_0_out_t4_19 + (1.1201801300048828) * gru_0_out_t4_20 + (-0.081488229334354401) * gru_0_out_t4_21 + (-0.5998038649559021) * gru_0_out_t4_22 + (-0.46479368209838867) * gru_0_out_t4_23 + (-0.75020867586135864) * gru_0_out_t4_24 + (-0.69816911220550537) * gru_0_out_t4_25 + (-0.0023969360627233982) * gru_0_out_t4_26 + (0.24285534024238586) * gru_0_out_t4_27 + (-1.316237211227417) * gru_0_out_t4_28 + (-0.1372210830450058) * gru_0_out_t4_29 + (0.50853478908538818) * gru_0_out_t4_30 + (0.0051748482510447502) * gru_0_out_t4_31 + (0.00076241814531385899) * gru_0_out_t4_32 + (-0.1740880012512207) * gru_0_out_t4_33 + (0.0094936061650514603) * gru_0_out_t4_34 + (-0.71370965242385864) * gru_0_out_t4_35 + (-0.55613267421722412) * gru_0_out_t4_36 + (-0.30314946174621582) * gru_0_out_t4_37 + (0.14988988637924194) * gru_0_out_t4_38 + (-0.11570865660905838) * gru_0_out_t4_39 + (-0.37169775366783142) * gru_0_out_t4_40 + (0.63421612977981567) * gru_0_out_t4_41 + (-0.63877660036087036) * gru_0_out_t4_42 + (-0.51200926303863525) * gru_0_out_t4_43 + (0.30854851007461548) * gru_0_out_t4_44 + (-0.7897651195526123) * gru_0_out_t4_45 + (0.34715563058853149) * gru_0_out_t4_46 + (0.041685491800308228) * gru_0_out_t4_47 + (0.46840125322341919) * gru_0_out_t4_48 + (-0.23999869823455811) * gru_0_out_t4_49 + (-0.20149403810501099) * gru_0_out_t4_50 + (-0.60607033967971802) * gru_0_out_t4_51 + (0.53305822610855103) * gru_0_out_t4_52 + (0.25261446833610535) * gru_0_out_t4_53 + (-0.12006900459527969) * gru_0_out_t4_54 + (-0.075961902737617493) * gru_0_out_t4_55 + (0.076765738427639008) * gru_0_out_t4_56 + (-0.12261445820331573) * gru_0_out_t4_57 + (0.10041086375713348) * gru_0_out_t4_58 + (-0.53630739450454712) * gru_0_out_t4_59 + (-0.29484662413597107) * gru_0_out_t4_60 + (-0.30708962678909302) * gru_0_out_t4_61 + (-0.49881666898727417) * gru_0_out_t4_62 + (0.36483666300773621) * gru_0_out_t4_63 + (0.15004463493824005) * gru_1_fwd_t3_h_0 + (-0.088696181774139404) * gru_1_fwd_t3_h_1 + (-0.54319077730178833) * gru_1_fwd_t3_h_2 + (0.18371888995170593) * gru_1_fwd_t3_h_3 + (0.47454535961151123) * gru_1_fwd_t3_h_4 + (0.087245240807533264) * gru_1_fwd_t3_h_5 + (0.25205522775650024) * gru_1_fwd_t3_h_6 + (0.16222724318504333) * gru_1_fwd_t3_h_7 + (0.15323103964328766) * gru_1_fwd_t3_h_8 + (0.038162022829055786) * gru_1_fwd_t3_h_9 + (1.0611019134521484) * gru_1_fwd_t3_h_10 + (0.22682023048400879) * gru_1_fwd_t3_h_11 + (0.020265521481633186) * gru_1_fwd_t3_h_12 + (-0.02462959848344326) * gru_1_fwd_t3_h_13 + (0.27212360501289368) * gru_1_fwd_t3_h_14 + (0.17232020199298859) * gru_1_fwd_t3_h_15 + (-0.50968289375305176) * gru_1_fwd_t3_h_16 + (0.21244867146015167) * gru_1_fwd_t3_h_17 + (-0.14514261484146118) * gru_1_fwd_t3_h_18 + (-0.30012339353561401) * gru_1_fwd_t3_h_19 + (-0.21556679904460907) * gru_1_fwd_t3_h_20 + (-0.14933310449123383) * gru_1_fwd_t3_h_21 + (0.35361453890800476) * gru_1_fwd_t3_h_22 + (-0.51695835590362549) * gru_1_fwd_t3_h_23 + (0.25989583134651184) * gru_1_fwd_t3_h_24 + (0.25310659408569336) * gru_1_fwd_t3_h_25 + (0.84243804216384888) * gru_1_fwd_t3_h_26 + (-0.50366717576980591) * gru_1_fwd_t3_h_27 + (1.426155686378479) * gru_1_fwd_t3_h_28 + (0.28992122411727905) * gru_1_fwd_t3_h_29 + (-0.83955562114715576) * gru_1_fwd_t3_h_30 + (-0.065013259649276733) * gru_1_fwd_t3_h_31);
    gate_n = tanh((-0.02798701636493206) + (0.054011281579732895) * gru_0_out_t4_0 + (-0.49930581450462341) * gru_0_out_t4_1 + (0.52970230579376221) * gru_0_out_t4_2 + (0.4737151563167572) * gru_0_out_t4_3 + (0.15142902731895447) * gru_0_out_t4_4 + (-0.15612494945526123) * gru_0_out_t4_5 + (1.0054217576980591) * gru_0_out_t4_6 + (0.79292172193527222) * gru_0_out_t4_7 + (-0.071434557437896729) * gru_0_out_t4_8 + (-0.14579230546951294) * gru_0_out_t4_9 + (-0.74811768531799316) * gru_0_out_t4_10 + (0.58895868062973022) * gru_0_out_t4_11 + (0.39210242033004761) * gru_0_out_t4_12 + (0.38702660799026489) * gru_0_out_t4_13 + (0.0045525007881224155) * gru_0_out_t4_14 + (0.5961449146270752) * gru_0_out_t4_15 + (0.0004642338608391583) * gru_0_out_t4_16 + (0.43989062309265137) * gru_0_out_t4_17 + (-0.22468841075897217) * gru_0_out_t4_18 + (1.4088281393051147) * gru_0_out_t4_19 + (0.34005051851272583) * gru_0_out_t4_20 + (-0.16137288510799408) * gru_0_out_t4_21 + (-0.020395329222083092) * gru_0_out_t4_22 + (-0.35417789220809937) * gru_0_out_t4_23 + (-0.68552416563034058) * gru_0_out_t4_24 + (-0.038087423890829086) * gru_0_out_t4_25 + (-0.043236155062913895) * gru_0_out_t4_26 + (0.33996090292930603) * gru_0_out_t4_27 + (-1.4470556974411011) * gru_0_out_t4_28 + (0.79092955589294434) * gru_0_out_t4_29 + (-0.22945457696914673) * gru_0_out_t4_30 + (0.76781779527664185) * gru_0_out_t4_31 + (-0.2208503931760788) * gru_0_out_t4_32 + (0.46004757285118103) * gru_0_out_t4_33 + (-0.11591313034296036) * gru_0_out_t4_34 + (0.17627586424350739) * gru_0_out_t4_35 + (0.36979728937149048) * gru_0_out_t4_36 + (-0.070795111358165741) * gru_0_out_t4_37 + (0.14010477066040039) * gru_0_out_t4_38 + (0.011498434469103813) * gru_0_out_t4_39 + (-3.7190825939178467) * gru_0_out_t4_40 + (0.89090675115585327) * gru_0_out_t4_41 + (0.18355785310268402) * gru_0_out_t4_42 + (0.50188428163528442) * gru_0_out_t4_43 + (0.24833840131759644) * gru_0_out_t4_44 + (0.081104077398777008) * gru_0_out_t4_45 + (0.1338428258895874) * gru_0_out_t4_46 + (0.33014419674873352) * gru_0_out_t4_47 + (-0.52534216642379761) * gru_0_out_t4_48 + (-0.10141061991453171) * gru_0_out_t4_49 + (0.36117023229598999) * gru_0_out_t4_50 + (-0.24445481598377228) * gru_0_out_t4_51 + (-0.15164883434772491) * gru_0_out_t4_52 + (-0.43070724606513977) * gru_0_out_t4_53 + (0.0077728233300149441) * gru_0_out_t4_54 + (0.65161103010177612) * gru_0_out_t4_55 + (-0.30940639972686768) * gru_0_out_t4_56 + (0.12393079698085785) * gru_0_out_t4_57 + (-0.53707945346832275) * gru_0_out_t4_58 + (-0.41703009605407715) * gru_0_out_t4_59 + (0.51151394844055176) * gru_0_out_t4_60 + (0.22281837463378906) * gru_0_out_t4_61 + (-2.4077327251434326) * gru_0_out_t4_62 + (1.3233685493469238) * gru_0_out_t4_63 + gate_r * ((-0.14635650813579559) + (-0.62920159101486206) * gru_1_fwd_t3_h_0 + (-0.19425962865352631) * gru_1_fwd_t3_h_1 + (-0.063780099153518677) * gru_1_fwd_t3_h_2 + (-0.81707984209060669) * gru_1_fwd_t3_h_3 + (-0.24857026338577271) * gru_1_fwd_t3_h_4 + (-0.040016941726207733) * gru_1_fwd_t3_h_5 + (-0.20857198536396027) * gru_1_fwd_t3_h_6 + (-0.0039613568224012852) * gru_1_fwd_t3_h_7 + (0.16065487265586853) * gru_1_fwd_t3_h_8 + (0.023922540247440338) * gru_1_fwd_t3_h_9 + (-0.015233422629535198) * gru_1_fwd_t3_h_10 + (1.500346302986145) * gru_1_fwd_t3_h_11 + (0.19053171575069427) * gru_1_fwd_t3_h_12 + (0.44485482573509216) * gru_1_fwd_t3_h_13 + (-0.91621613502502441) * gru_1_fwd_t3_h_14 + (0.20424409210681915) * gru_1_fwd_t3_h_15 + (0.25733184814453125) * gru_1_fwd_t3_h_16 + (-0.60079222917556763) * gru_1_fwd_t3_h_17 + (-0.059542819857597351) * gru_1_fwd_t3_h_18 + (0.33392578363418579) * gru_1_fwd_t3_h_19 + (0.13135933876037598) * gru_1_fwd_t3_h_20 + (0.11628855764865875) * gru_1_fwd_t3_h_21 + (-0.26727744936943054) * gru_1_fwd_t3_h_22 + (-0.80372905731201172) * gru_1_fwd_t3_h_23 + (-0.37681031227111816) * gru_1_fwd_t3_h_24 + (1.3074864149093628) * gru_1_fwd_t3_h_25 + (-0.36248338222503662) * gru_1_fwd_t3_h_26 + (0.018732354044914246) * gru_1_fwd_t3_h_27 + (-0.68293124437332153) * gru_1_fwd_t3_h_28 + (-0.40635597705841064) * gru_1_fwd_t3_h_29 + (0.31109011173248291) * gru_1_fwd_t3_h_30 + (-0.052935916930437088) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_17 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_17;
    // h=18
    gate_r = sigmoid((-0.26545426249504089) + (-0.89171987771987915) * gru_0_out_t4_0 + (-0.14711882174015045) * gru_0_out_t4_1 + (1.431216835975647) * gru_0_out_t4_2 + (-0.88631480932235718) * gru_0_out_t4_3 + (-0.042791515588760376) * gru_0_out_t4_4 + (-1.4263224601745605) * gru_0_out_t4_5 + (-1.4125267267227173) * gru_0_out_t4_6 + (-1.9287781715393066) * gru_0_out_t4_7 + (1.7384178638458252) * gru_0_out_t4_8 + (-0.13778068125247955) * gru_0_out_t4_9 + (-1.1224737167358398) * gru_0_out_t4_10 + (-0.34192538261413574) * gru_0_out_t4_11 + (-0.096887052059173584) * gru_0_out_t4_12 + (0.063838750123977661) * gru_0_out_t4_13 + (-0.19947640597820282) * gru_0_out_t4_14 + (0.14792335033416748) * gru_0_out_t4_15 + (0.39715102314949036) * gru_0_out_t4_16 + (-0.23609015345573425) * gru_0_out_t4_17 + (0.58513426780700684) * gru_0_out_t4_18 + (0.8923068642616272) * gru_0_out_t4_19 + (0.058364853262901306) * gru_0_out_t4_20 + (0.63839554786682129) * gru_0_out_t4_21 + (-1.0828745365142822) * gru_0_out_t4_22 + (-0.80349272489547729) * gru_0_out_t4_23 + (0.75735634565353394) * gru_0_out_t4_24 + (-0.061466515064239502) * gru_0_out_t4_25 + (-2.5244216918945312) * gru_0_out_t4_26 + (0.70825529098510742) * gru_0_out_t4_27 + (1.0499652624130249) * gru_0_out_t4_28 + (1.0552661418914795) * gru_0_out_t4_29 + (-0.036444954574108124) * gru_0_out_t4_30 + (3.1354067325592041) * gru_0_out_t4_31 + (-1.3201682567596436) * gru_0_out_t4_32 + (-0.26050189137458801) * gru_0_out_t4_33 + (0.67592751979827881) * gru_0_out_t4_34 + (0.14620457589626312) * gru_0_out_t4_35 + (0.43809321522712708) * gru_0_out_t4_36 + (-0.54078733921051025) * gru_0_out_t4_37 + (0.41957035660743713) * gru_0_out_t4_38 + (0.10027614235877991) * gru_0_out_t4_39 + (2.3291826248168945) * gru_0_out_t4_40 + (0.45135307312011719) * gru_0_out_t4_41 + (1.8394701480865479) * gru_0_out_t4_42 + (-0.28979086875915527) * gru_0_out_t4_43 + (0.21835435926914215) * gru_0_out_t4_44 + (0.28140890598297119) * gru_0_out_t4_45 + (0.10227799415588379) * gru_0_out_t4_46 + (0.73193418979644775) * gru_0_out_t4_47 + (0.01708601787686348) * gru_0_out_t4_48 + (0.038629971444606781) * gru_0_out_t4_49 + (-0.95869201421737671) * gru_0_out_t4_50 + (-0.65919262170791626) * gru_0_out_t4_51 + (0.35723164677619934) * gru_0_out_t4_52 + (-0.44966605305671692) * gru_0_out_t4_53 + (-0.85331368446350098) * gru_0_out_t4_54 + (-0.36975163221359253) * gru_0_out_t4_55 + (0.36524006724357605) * gru_0_out_t4_56 + (-0.010250807739794254) * gru_0_out_t4_57 + (0.057101037353277206) * gru_0_out_t4_58 + (0.9014132022857666) * gru_0_out_t4_59 + (-0.60690206289291382) * gru_0_out_t4_60 + (0.27420318126678467) * gru_0_out_t4_61 + (0.18549928069114685) * gru_0_out_t4_62 + (0.90848731994628906) * gru_0_out_t4_63 + (-0.18887799978256226) * gru_1_fwd_t3_h_0 + (-0.42572006583213806) * gru_1_fwd_t3_h_1 + (-0.69529896974563599) * gru_1_fwd_t3_h_2 + (0.095908477902412415) * gru_1_fwd_t3_h_3 + (0.021165447309613228) * gru_1_fwd_t3_h_4 + (-1.0041283369064331) * gru_1_fwd_t3_h_5 + (0.71536058187484741) * gru_1_fwd_t3_h_6 + (0.074085608124732971) * gru_1_fwd_t3_h_7 + (0.96617662906646729) * gru_1_fwd_t3_h_8 + (0.78232145309448242) * gru_1_fwd_t3_h_9 + (1.5504696369171143) * gru_1_fwd_t3_h_10 + (-1.0828292369842529) * gru_1_fwd_t3_h_11 + (-0.68159329891204834) * gru_1_fwd_t3_h_12 + (0.13404151797294617) * gru_1_fwd_t3_h_13 + (-0.71757984161376953) * gru_1_fwd_t3_h_14 + (-0.44785067439079285) * gru_1_fwd_t3_h_15 + (-0.31369751691818237) * gru_1_fwd_t3_h_16 + (0.53218942880630493) * gru_1_fwd_t3_h_17 + (-1.9608831405639648) * gru_1_fwd_t3_h_18 + (0.61070907115936279) * gru_1_fwd_t3_h_19 + (0.25004425644874573) * gru_1_fwd_t3_h_20 + (0.69705545902252197) * gru_1_fwd_t3_h_21 + (0.6467355489730835) * gru_1_fwd_t3_h_22 + (-0.042218197137117386) * gru_1_fwd_t3_h_23 + (1.0223734378814697) * gru_1_fwd_t3_h_24 + (0.61429888010025024) * gru_1_fwd_t3_h_25 + (-0.090147726237773895) * gru_1_fwd_t3_h_26 + (-2.522733211517334) * gru_1_fwd_t3_h_27 + (0.27274134755134583) * gru_1_fwd_t3_h_28 + (0.028112282976508141) * gru_1_fwd_t3_h_29 + (0.6845894455909729) * gru_1_fwd_t3_h_30 + (0.14956018328666687) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((0.83454203605651855) + (0.51016038656234741) * gru_0_out_t4_0 + (-0.27175581455230713) * gru_0_out_t4_1 + (0.77933347225189209) * gru_0_out_t4_2 + (-0.42917385697364807) * gru_0_out_t4_3 + (0.18129141628742218) * gru_0_out_t4_4 + (-0.36838170886039734) * gru_0_out_t4_5 + (0.57990634441375732) * gru_0_out_t4_6 + (-0.43917471170425415) * gru_0_out_t4_7 + (-0.12411060929298401) * gru_0_out_t4_8 + (0.16235774755477905) * gru_0_out_t4_9 + (-0.71797364950180054) * gru_0_out_t4_10 + (0.0042833816260099411) * gru_0_out_t4_11 + (0.079833947122097015) * gru_0_out_t4_12 + (0.33018037676811218) * gru_0_out_t4_13 + (-0.071026250720024109) * gru_0_out_t4_14 + (-0.1903974860906601) * gru_0_out_t4_15 + (-0.13693419098854065) * gru_0_out_t4_16 + (-0.17653438448905945) * gru_0_out_t4_17 + (0.32118728756904602) * gru_0_out_t4_18 + (-1.0494686365127563) * gru_0_out_t4_19 + (-0.046684227883815765) * gru_0_out_t4_20 + (-0.55580669641494751) * gru_0_out_t4_21 + (-0.14526934921741486) * gru_0_out_t4_22 + (-1.0786162614822388) * gru_0_out_t4_23 + (-2.0760235786437988) * gru_0_out_t4_24 + (-0.93071061372756958) * gru_0_out_t4_25 + (0.49828585982322693) * gru_0_out_t4_26 + (0.433491051197052) * gru_0_out_t4_27 + (-0.090623512864112854) * gru_0_out_t4_28 + (0.49229338765144348) * gru_0_out_t4_29 + (0.47725147008895874) * gru_0_out_t4_30 + (0.49352428317070007) * gru_0_out_t4_31 + (0.040151972323656082) * gru_0_out_t4_32 + (0.23458336293697357) * gru_0_out_t4_33 + (0.19429241120815277) * gru_0_out_t4_34 + (-0.26751574873924255) * gru_0_out_t4_35 + (0.0032494545448571444) * gru_0_out_t4_36 + (0.13468840718269348) * gru_0_out_t4_37 + (-0.070425719022750854) * gru_0_out_t4_38 + (0.27335885167121887) * gru_0_out_t4_39 + (0.76278603076934814) * gru_0_out_t4_40 + (0.24780069291591644) * gru_0_out_t4_41 + (-0.0017698145238682628) * gru_0_out_t4_42 + (0.04777120053768158) * gru_0_out_t4_43 + (-0.009277738630771637) * gru_0_out_t4_44 + (0.049351323395967484) * gru_0_out_t4_45 + (-0.66593879461288452) * gru_0_out_t4_46 + (0.33963516354560852) * gru_0_out_t4_47 + (-0.018058765679597855) * gru_0_out_t4_48 + (-0.16917666792869568) * gru_0_out_t4_49 + (0.18458093702793121) * gru_0_out_t4_50 + (-0.12737555801868439) * gru_0_out_t4_51 + (-0.27084803581237793) * gru_0_out_t4_52 + (-0.033225730061531067) * gru_0_out_t4_53 + (0.46488600969314575) * gru_0_out_t4_54 + (-0.16997583210468292) * gru_0_out_t4_55 + (0.025382399559020996) * gru_0_out_t4_56 + (0.38311311602592468) * gru_0_out_t4_57 + (-0.071106262505054474) * gru_0_out_t4_58 + (-0.57767140865325928) * gru_0_out_t4_59 + (-0.45581880211830139) * gru_0_out_t4_60 + (-0.0044395062141120434) * gru_0_out_t4_61 + (0.097954213619232178) * gru_0_out_t4_62 + (0.060721501708030701) * gru_0_out_t4_63 + (-0.16429093480110168) * gru_1_fwd_t3_h_0 + (0.04869457334280014) * gru_1_fwd_t3_h_1 + (-1.3686339855194092) * gru_1_fwd_t3_h_2 + (-0.51798552274703979) * gru_1_fwd_t3_h_3 + (-0.3038155734539032) * gru_1_fwd_t3_h_4 + (-0.50408881902694702) * gru_1_fwd_t3_h_5 + (0.27853500843048096) * gru_1_fwd_t3_h_6 + (0.33243313431739807) * gru_1_fwd_t3_h_7 + (-0.27005711197853088) * gru_1_fwd_t3_h_8 + (0.14805698394775391) * gru_1_fwd_t3_h_9 + (-0.25179946422576904) * gru_1_fwd_t3_h_10 + (1.0273177623748779) * gru_1_fwd_t3_h_11 + (-0.087860934436321259) * gru_1_fwd_t3_h_12 + (0.17302536964416504) * gru_1_fwd_t3_h_13 + (-0.023543160408735275) * gru_1_fwd_t3_h_14 + (-0.23144684731960297) * gru_1_fwd_t3_h_15 + (-0.24091064929962158) * gru_1_fwd_t3_h_16 + (-0.15786971151828766) * gru_1_fwd_t3_h_17 + (0.46415454149246216) * gru_1_fwd_t3_h_18 + (-0.89962035417556763) * gru_1_fwd_t3_h_19 + (-0.24532763659954071) * gru_1_fwd_t3_h_20 + (-0.59257495403289795) * gru_1_fwd_t3_h_21 + (-0.68678665161132812) * gru_1_fwd_t3_h_22 + (0.35628962516784668) * gru_1_fwd_t3_h_23 + (-0.84459871053695679) * gru_1_fwd_t3_h_24 + (0.86810904741287231) * gru_1_fwd_t3_h_25 + (0.95815861225128174) * gru_1_fwd_t3_h_26 + (-0.49412748217582703) * gru_1_fwd_t3_h_27 + (0.16758327186107635) * gru_1_fwd_t3_h_28 + (-0.028868747875094414) * gru_1_fwd_t3_h_29 + (-0.37758567929267883) * gru_1_fwd_t3_h_30 + (0.55202829837799072) * gru_1_fwd_t3_h_31);
    gate_n = tanh((0.16364885866641998) + (0.61796313524246216) * gru_0_out_t4_0 + (0.025010205805301666) * gru_0_out_t4_1 + (0.34159523248672485) * gru_0_out_t4_2 + (0.68374764919281006) * gru_0_out_t4_3 + (-0.4403546154499054) * gru_0_out_t4_4 + (0.43695679306983948) * gru_0_out_t4_5 + (0.44106006622314453) * gru_0_out_t4_6 + (-1.1462807655334473) * gru_0_out_t4_7 + (-0.28287014365196228) * gru_0_out_t4_8 + (0.55738288164138794) * gru_0_out_t4_9 + (-0.11419957876205444) * gru_0_out_t4_10 + (0.84815222024917603) * gru_0_out_t4_11 + (-0.078989654779434204) * gru_0_out_t4_12 + (-0.15754285454750061) * gru_0_out_t4_13 + (0.27858734130859375) * gru_0_out_t4_14 + (0.20828400552272797) * gru_0_out_t4_15 + (-0.16347454488277435) * gru_0_out_t4_16 + (-0.2830054759979248) * gru_0_out_t4_17 + (0.09949599951505661) * gru_0_out_t4_18 + (-1.159549355506897) * gru_0_out_t4_19 + (1.2729897499084473) * gru_0_out_t4_20 + (-0.13110257685184479) * gru_0_out_t4_21 + (0.91520094871520996) * gru_0_out_t4_22 + (0.020907407626509666) * gru_0_out_t4_23 + (-0.047117535024881363) * gru_0_out_t4_24 + (-0.15060260891914368) * gru_0_out_t4_25 + (-0.10456959158182144) * gru_0_out_t4_26 + (-0.28710472583770752) * gru_0_out_t4_27 + (-0.25540688633918762) * gru_0_out_t4_28 + (0.60114777088165283) * gru_0_out_t4_29 + (0.074120767414569855) * gru_0_out_t4_30 + (-0.20555378496646881) * gru_0_out_t4_31 + (-0.20009979605674744) * gru_0_out_t4_32 + (-0.24899579584598541) * gru_0_out_t4_33 + (-0.30741056799888611) * gru_0_out_t4_34 + (-0.12792231142520905) * gru_0_out_t4_35 + (0.33521625399589539) * gru_0_out_t4_36 + (-0.072519086301326752) * gru_0_out_t4_37 + (0.0027174041606485844) * gru_0_out_t4_38 + (-0.71989482641220093) * gru_0_out_t4_39 + (0.12663498520851135) * gru_0_out_t4_40 + (-0.036858335137367249) * gru_0_out_t4_41 + (0.17811959981918335) * gru_0_out_t4_42 + (0.49165740609169006) * gru_0_out_t4_43 + (0.057818770408630371) * gru_0_out_t4_44 + (0.89773648977279663) * gru_0_out_t4_45 + (0.044372152537107468) * gru_0_out_t4_46 + (0.40009540319442749) * gru_0_out_t4_47 + (0.063416115939617157) * gru_0_out_t4_48 + (0.1070193275809288) * gru_0_out_t4_49 + (-0.026652341708540916) * gru_0_out_t4_50 + (-0.018241498619318008) * gru_0_out_t4_51 + (-0.0152331767603755) * gru_0_out_t4_52 + (-0.018808262422680855) * gru_0_out_t4_53 + (-0.25292229652404785) * gru_0_out_t4_54 + (-0.68571138381958008) * gru_0_out_t4_55 + (-0.28387358784675598) * gru_0_out_t4_56 + (0.22108162939548492) * gru_0_out_t4_57 + (-0.73379063606262207) * gru_0_out_t4_58 + (-0.28541776537895203) * gru_0_out_t4_59 + (-0.026600237935781479) * gru_0_out_t4_60 + (-0.00013979031064081937) * gru_0_out_t4_61 + (0.028137663379311562) * gru_0_out_t4_62 + (0.0066284984350204468) * gru_0_out_t4_63 + gate_r * ((0.27120113372802734) + (0.070794366300106049) * gru_1_fwd_t3_h_0 + (1.0478872060775757) * gru_1_fwd_t3_h_1 + (-0.47745966911315918) * gru_1_fwd_t3_h_2 + (0.66106492280960083) * gru_1_fwd_t3_h_3 + (-0.14472532272338867) * gru_1_fwd_t3_h_4 + (0.024646848440170288) * gru_1_fwd_t3_h_5 + (-0.24244067072868347) * gru_1_fwd_t3_h_6 + (0.078029826283454895) * gru_1_fwd_t3_h_7 + (-0.0080286366865038872) * gru_1_fwd_t3_h_8 + (0.056525465101003647) * gru_1_fwd_t3_h_9 + (0.58835631608963013) * gru_1_fwd_t3_h_10 + (0.67307901382446289) * gru_1_fwd_t3_h_11 + (-0.22049570083618164) * gru_1_fwd_t3_h_12 + (-0.18597342073917389) * gru_1_fwd_t3_h_13 + (1.3354793787002563) * gru_1_fwd_t3_h_14 + (-1.2646929025650024) * gru_1_fwd_t3_h_15 + (0.42369037866592407) * gru_1_fwd_t3_h_16 + (-1.376018762588501) * gru_1_fwd_t3_h_17 + (-1.9172918796539307) * gru_1_fwd_t3_h_18 + (-0.55637693405151367) * gru_1_fwd_t3_h_19 + (-0.20025244355201721) * gru_1_fwd_t3_h_20 + (-0.16976642608642578) * gru_1_fwd_t3_h_21 + (-0.66273403167724609) * gru_1_fwd_t3_h_22 + (-0.45675665140151978) * gru_1_fwd_t3_h_23 + (0.47187647223472595) * gru_1_fwd_t3_h_24 + (-0.45811745524406433) * gru_1_fwd_t3_h_25 + (-0.0037213345058262348) * gru_1_fwd_t3_h_26 + (-1.3292819261550903) * gru_1_fwd_t3_h_27 + (0.24851641058921814) * gru_1_fwd_t3_h_28 + (-0.25921231508255005) * gru_1_fwd_t3_h_29 + (-0.63332349061965942) * gru_1_fwd_t3_h_30 + (-0.22161048650741577) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_18 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_18;
    // h=19
    gate_r = sigmoid((-1.8526585102081299) + (-0.018787266686558723) * gru_0_out_t4_0 + (0.23146736621856689) * gru_0_out_t4_1 + (-1.3263881206512451) * gru_0_out_t4_2 + (-0.93332594633102417) * gru_0_out_t4_3 + (-0.099179133772850037) * gru_0_out_t4_4 + (2.6688146591186523) * gru_0_out_t4_5 + (1.1423527002334595) * gru_0_out_t4_6 + (0.82077902555465698) * gru_0_out_t4_7 + (0.99237561225891113) * gru_0_out_t4_8 + (-2.3567652702331543) * gru_0_out_t4_9 + (1.0362616777420044) * gru_0_out_t4_10 + (0.14775820076465607) * gru_0_out_t4_11 + (-0.32346418499946594) * gru_0_out_t4_12 + (-0.42393282055854797) * gru_0_out_t4_13 + (-0.29720118641853333) * gru_0_out_t4_14 + (-0.010968072339892387) * gru_0_out_t4_15 + (0.68952995538711548) * gru_0_out_t4_16 + (0.036487329751253128) * gru_0_out_t4_17 + (0.67047065496444702) * gru_0_out_t4_18 + (0.55376148223876953) * gru_0_out_t4_19 + (-1.491391658782959) * gru_0_out_t4_20 + (1.5732290744781494) * gru_0_out_t4_21 + (-0.57767993211746216) * gru_0_out_t4_22 + (0.70601081848144531) * gru_0_out_t4_23 + (0.92456322908401489) * gru_0_out_t4_24 + (0.2056073397397995) * gru_0_out_t4_25 + (0.42933300137519836) * gru_0_out_t4_26 + (-1.352304220199585) * gru_0_out_t4_27 + (2.0330796241760254) * gru_0_out_t4_28 + (-1.1516090631484985) * gru_0_out_t4_29 + (-1.2903603315353394) * gru_0_out_t4_30 + (0.89606773853302002) * gru_0_out_t4_31 + (-0.68357664346694946) * gru_0_out_t4_32 + (0.44748300313949585) * gru_0_out_t4_33 + (-0.037482645362615585) * gru_0_out_t4_34 + (-0.048763606697320938) * gru_0_out_t4_35 + (0.26135817170143127) * gru_0_out_t4_36 + (0.04730534553527832) * gru_0_out_t4_37 + (-0.055356808006763458) * gru_0_out_t4_38 + (-1.7237874269485474) * gru_0_out_t4_39 + (-0.1564251184463501) * gru_0_out_t4_40 + (0.035093363374471664) * gru_0_out_t4_41 + (1.3016924858093262) * gru_0_out_t4_42 + (-0.22320689260959625) * gru_0_out_t4_43 + (-0.62106424570083618) * gru_0_out_t4_44 + (-0.35933798551559448) * gru_0_out_t4_45 + (-0.03669608011841774) * gru_0_out_t4_46 + (-0.51293939352035522) * gru_0_out_t4_47 + (-1.0065891742706299) * gru_0_out_t4_48 + (1.050722599029541) * gru_0_out_t4_49 + (0.72977334260940552) * gru_0_out_t4_50 + (0.36016988754272461) * gru_0_out_t4_51 + (-0.26452374458312988) * gru_0_out_t4_52 + (0.076091870665550232) * gru_0_out_t4_53 + (-0.76141071319580078) * gru_0_out_t4_54 + (0.24391366541385651) * gru_0_out_t4_55 + (-0.302878737449646) * gru_0_out_t4_56 + (0.48982685804367065) * gru_0_out_t4_57 + (0.10044987499713898) * gru_0_out_t4_58 + (-0.38008925318717957) * gru_0_out_t4_59 + (-0.22934843599796295) * gru_0_out_t4_60 + (1.318184494972229) * gru_0_out_t4_61 + (-0.31201252341270447) * gru_0_out_t4_62 + (2.4664731025695801) * gru_0_out_t4_63 + (-1.7960832118988037) * gru_1_fwd_t3_h_0 + (-1.3290693759918213) * gru_1_fwd_t3_h_1 + (1.2395086288452148) * gru_1_fwd_t3_h_2 + (0.46057593822479248) * gru_1_fwd_t3_h_3 + (0.35587039589881897) * gru_1_fwd_t3_h_4 + (-0.84295576810836792) * gru_1_fwd_t3_h_5 + (-2.7236652374267578) * gru_1_fwd_t3_h_6 + (0.20572578907012939) * gru_1_fwd_t3_h_7 + (-0.65384280681610107) * gru_1_fwd_t3_h_8 + (-1.0448691844940186) * gru_1_fwd_t3_h_9 + (-0.66544336080551147) * gru_1_fwd_t3_h_10 + (-0.77474838495254517) * gru_1_fwd_t3_h_11 + (0.10013418644666672) * gru_1_fwd_t3_h_12 + (-1.9896997213363647) * gru_1_fwd_t3_h_13 + (-0.73830169439315796) * gru_1_fwd_t3_h_14 + (0.71709489822387695) * gru_1_fwd_t3_h_15 + (-0.3250262439250946) * gru_1_fwd_t3_h_16 + (1.1683673858642578) * gru_1_fwd_t3_h_17 + (0.033319290727376938) * gru_1_fwd_t3_h_18 + (1.6575809717178345) * gru_1_fwd_t3_h_19 + (0.49718090891838074) * gru_1_fwd_t3_h_20 + (2.0018410682678223) * gru_1_fwd_t3_h_21 + (1.0074919462203979) * gru_1_fwd_t3_h_22 + (-1.5418457984924316) * gru_1_fwd_t3_h_23 + (-1.7297191619873047) * gru_1_fwd_t3_h_24 + (0.52108758687973022) * gru_1_fwd_t3_h_25 + (-1.4556560516357422) * gru_1_fwd_t3_h_26 + (-0.33912909030914307) * gru_1_fwd_t3_h_27 + (0.21716852486133575) * gru_1_fwd_t3_h_28 + (1.9063683748245239) * gru_1_fwd_t3_h_29 + (-1.0588998794555664) * gru_1_fwd_t3_h_30 + (0.10528906434774399) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((0.32984411716461182) + (0.094709202647209167) * gru_0_out_t4_0 + (-0.032557319849729538) * gru_0_out_t4_1 + (1.0526591539382935) * gru_0_out_t4_2 + (-1.2972768545150757) * gru_0_out_t4_3 + (-0.084496304392814636) * gru_0_out_t4_4 + (-0.10593945533037186) * gru_0_out_t4_5 + (-0.54010206460952759) * gru_0_out_t4_6 + (-0.48525682091712952) * gru_0_out_t4_7 + (0.05189124122262001) * gru_0_out_t4_8 + (-1.2043406963348389) * gru_0_out_t4_9 + (-1.1216480731964111) * gru_0_out_t4_10 + (0.18922458589076996) * gru_0_out_t4_11 + (0.012619988061487675) * gru_0_out_t4_12 + (-0.26433300971984863) * gru_0_out_t4_13 + (0.077577561140060425) * gru_0_out_t4_14 + (-0.30777376890182495) * gru_0_out_t4_15 + (-0.049444656819105148) * gru_0_out_t4_16 + (-0.39421379566192627) * gru_0_out_t4_17 + (-0.32197174429893494) * gru_0_out_t4_18 + (1.0167546272277832) * gru_0_out_t4_19 + (0.50850355625152588) * gru_0_out_t4_20 + (-0.69116318225860596) * gru_0_out_t4_21 + (-0.22989080846309662) * gru_0_out_t4_22 + (0.36351385712623596) * gru_0_out_t4_23 + (-1.1813477277755737) * gru_0_out_t4_24 + (-0.15447598695755005) * gru_0_out_t4_25 + (-0.067565940320491791) * gru_0_out_t4_26 + (0.37153381109237671) * gru_0_out_t4_27 + (-2.3141818046569824) * gru_0_out_t4_28 + (-0.12378764897584915) * gru_0_out_t4_29 + (0.053320471197366714) * gru_0_out_t4_30 + (1.1902854442596436) * gru_0_out_t4_31 + (-0.043593160808086395) * gru_0_out_t4_32 + (-0.19327174127101898) * gru_0_out_t4_33 + (0.13580389320850372) * gru_0_out_t4_34 + (-0.088078342378139496) * gru_0_out_t4_35 + (0.27228271961212158) * gru_0_out_t4_36 + (-0.035504404455423355) * gru_0_out_t4_37 + (0.016506990417838097) * gru_0_out_t4_38 + (0.37897348403930664) * gru_0_out_t4_39 + (0.25948157906532288) * gru_0_out_t4_40 + (0.23168079555034637) * gru_0_out_t4_41 + (-0.37157970666885376) * gru_0_out_t4_42 + (-0.21516183018684387) * gru_0_out_t4_43 + (-0.053073219954967499) * gru_0_out_t4_44 + (-0.52064222097396851) * gru_0_out_t4_45 + (-0.76919084787368774) * gru_0_out_t4_46 + (0.19261758029460907) * gru_0_out_t4_47 + (-0.85872143507003784) * gru_0_out_t4_48 + (0.57999873161315918) * gru_0_out_t4_49 + (0.27053290605545044) * gru_0_out_t4_50 + (-0.048831790685653687) * gru_0_out_t4_51 + (-0.057747021317481995) * gru_0_out_t4_52 + (-0.092676699161529541) * gru_0_out_t4_53 + (-0.21469363570213318) * gru_0_out_t4_54 + (1.003268837928772) * gru_0_out_t4_55 + (0.22990973293781281) * gru_0_out_t4_56 + (0.99787247180938721) * gru_0_out_t4_57 + (0.32891052961349487) * gru_0_out_t4_58 + (0.31211388111114502) * gru_0_out_t4_59 + (-0.23376005887985229) * gru_0_out_t4_60 + (-0.25790059566497803) * gru_0_out_t4_61 + (-0.54692894220352173) * gru_0_out_t4_62 + (-0.96172767877578735) * gru_0_out_t4_63 + (0.38281741738319397) * gru_1_fwd_t3_h_0 + (0.061281707137823105) * gru_1_fwd_t3_h_1 + (-0.45641502737998962) * gru_1_fwd_t3_h_2 + (-0.090298406779766083) * gru_1_fwd_t3_h_3 + (-0.10794778168201447) * gru_1_fwd_t3_h_4 + (0.0045257131569087505) * gru_1_fwd_t3_h_5 + (0.36475813388824463) * gru_1_fwd_t3_h_6 + (-0.11822421103715897) * gru_1_fwd_t3_h_7 + (-0.4352608323097229) * gru_1_fwd_t3_h_8 + (-0.14166782796382904) * gru_1_fwd_t3_h_9 + (0.16978144645690918) * gru_1_fwd_t3_h_10 + (0.5385480523109436) * gru_1_fwd_t3_h_11 + (-0.27226027846336365) * gru_1_fwd_t3_h_12 + (-0.31668370962142944) * gru_1_fwd_t3_h_13 + (0.51006656885147095) * gru_1_fwd_t3_h_14 + (0.59143269062042236) * gru_1_fwd_t3_h_15 + (-0.34663087129592896) * gru_1_fwd_t3_h_16 + (-0.086491107940673828) * gru_1_fwd_t3_h_17 + (0.3908085823059082) * gru_1_fwd_t3_h_18 + (-0.38046851754188538) * gru_1_fwd_t3_h_19 + (0.23882642388343811) * gru_1_fwd_t3_h_20 + (-0.38521862030029297) * gru_1_fwd_t3_h_21 + (-0.43094572424888611) * gru_1_fwd_t3_h_22 + (0.20174229145050049) * gru_1_fwd_t3_h_23 + (-0.28828555345535278) * gru_1_fwd_t3_h_24 + (0.53871047496795654) * gru_1_fwd_t3_h_25 + (-0.20021799206733704) * gru_1_fwd_t3_h_26 + (0.36606237292289734) * gru_1_fwd_t3_h_27 + (-0.21764965355396271) * gru_1_fwd_t3_h_28 + (0.37323948740959167) * gru_1_fwd_t3_h_29 + (-0.080184996128082275) * gru_1_fwd_t3_h_30 + (-0.24070160090923309) * gru_1_fwd_t3_h_31);
    gate_n = tanh((-0.29251444339752197) + (0.026830151677131653) * gru_0_out_t4_0 + (-0.12948521971702576) * gru_0_out_t4_1 + (0.27467355132102966) * gru_0_out_t4_2 + (-0.059903938323259354) * gru_0_out_t4_3 + (0.052837342023849487) * gru_0_out_t4_4 + (0.17700819671154022) * gru_0_out_t4_5 + (1.1752376556396484) * gru_0_out_t4_6 + (-0.41206124424934387) * gru_0_out_t4_7 + (0.33663409948348999) * gru_0_out_t4_8 + (-0.87714946269989014) * gru_0_out_t4_9 + (0.19340027868747711) * gru_0_out_t4_10 + (0.27655187249183655) * gru_0_out_t4_11 + (0.24503844976425171) * gru_0_out_t4_12 + (0.031700789928436279) * gru_0_out_t4_13 + (-0.31356456875801086) * gru_0_out_t4_14 + (0.051690898835659027) * gru_0_out_t4_15 + (0.39647403359413147) * gru_0_out_t4_16 + (0.14088538289070129) * gru_0_out_t4_17 + (-0.26146954298019409) * gru_0_out_t4_18 + (0.0080361152067780495) * gru_0_out_t4_19 + (0.47543990612030029) * gru_0_out_t4_20 + (0.28557687997817993) * gru_0_out_t4_21 + (0.28839012980461121) * gru_0_out_t4_22 + (-0.11987888067960739) * gru_0_out_t4_23 + (0.11407956480979919) * gru_0_out_t4_24 + (0.8898235559463501) * gru_0_out_t4_25 + (0.46476039290428162) * gru_0_out_t4_26 + (-0.21232528984546661) * gru_0_out_t4_27 + (0.23082010447978973) * gru_0_out_t4_28 + (0.41002580523490906) * gru_0_out_t4_29 + (-0.51700443029403687) * gru_0_out_t4_30 + (-0.43231847882270813) * gru_0_out_t4_31 + (-0.82508409023284912) * gru_0_out_t4_32 + (-0.21479296684265137) * gru_0_out_t4_33 + (-0.73385167121887207) * gru_0_out_t4_34 + (-0.40458407998085022) * gru_0_out_t4_35 + (-0.067305400967597961) * gru_0_out_t4_36 + (-0.12753619253635406) * gru_0_out_t4_37 + (-0.0055721476674079895) * gru_0_out_t4_38 + (0.10639890283346176) * gru_0_out_t4_39 + (-0.54028606414794922) * gru_0_out_t4_40 + (-0.20570182800292969) * gru_0_out_t4_41 + (-0.27402195334434509) * gru_0_out_t4_42 + (0.14525134861469269) * gru_0_out_t4_43 + (-0.34303975105285645) * gru_0_out_t4_44 + (-0.38593956828117371) * gru_0_out_t4_45 + (0.20048145949840546) * gru_0_out_t4_46 + (0.29963567852973938) * gru_0_out_t4_47 + (-0.029207715764641762) * gru_0_out_t4_48 + (-0.40316545963287354) * gru_0_out_t4_49 + (-0.34238719940185547) * gru_0_out_t4_50 + (0.16187761723995209) * gru_0_out_t4_51 + (-0.10254108905792236) * gru_0_out_t4_52 + (-0.52675521373748779) * gru_0_out_t4_53 + (-0.13777926564216614) * gru_0_out_t4_54 + (0.5058211088180542) * gru_0_out_t4_55 + (-0.003554090391844511) * gru_0_out_t4_56 + (-0.050308138132095337) * gru_0_out_t4_57 + (0.64174258708953857) * gru_0_out_t4_58 + (-0.508342444896698) * gru_0_out_t4_59 + (0.65733540058135986) * gru_0_out_t4_60 + (0.36407449841499329) * gru_0_out_t4_61 + (-0.27135136723518372) * gru_0_out_t4_62 + (0.15568053722381592) * gru_0_out_t4_63 + gate_r * ((-0.32279935479164124) + (1.1437923908233643) * gru_1_fwd_t3_h_0 + (0.32568028569221497) * gru_1_fwd_t3_h_1 + (-0.56981301307678223) * gru_1_fwd_t3_h_2 + (-0.75587260723114014) * gru_1_fwd_t3_h_3 + (-0.39798828959465027) * gru_1_fwd_t3_h_4 + (0.62853491306304932) * gru_1_fwd_t3_h_5 + (1.3885971307754517) * gru_1_fwd_t3_h_6 + (0.68579638004302979) * gru_1_fwd_t3_h_7 + (0.15096454322338104) * gru_1_fwd_t3_h_8 + (0.53237402439117432) * gru_1_fwd_t3_h_9 + (0.92598134279251099) * gru_1_fwd_t3_h_10 + (1.2241053581237793) * gru_1_fwd_t3_h_11 + (-0.27677345275878906) * gru_1_fwd_t3_h_12 + (2.1847970485687256) * gru_1_fwd_t3_h_13 + (0.52348619699478149) * gru_1_fwd_t3_h_14 + (-0.41622611880302429) * gru_1_fwd_t3_h_15 + (-0.50309902429580688) * gru_1_fwd_t3_h_16 + (-0.55013746023178101) * gru_1_fwd_t3_h_17 + (0.91259688138961792) * gru_1_fwd_t3_h_18 + (-0.75689911842346191) * gru_1_fwd_t3_h_19 + (-0.081816300749778748) * gru_1_fwd_t3_h_20 + (-2.2009150981903076) * gru_1_fwd_t3_h_21 + (-0.24990512430667877) * gru_1_fwd_t3_h_22 + (0.7308843731880188) * gru_1_fwd_t3_h_23 + (-0.36886399984359741) * gru_1_fwd_t3_h_24 + (0.49137243628501892) * gru_1_fwd_t3_h_25 + (-0.44015917181968689) * gru_1_fwd_t3_h_26 + (-0.64191555976867676) * gru_1_fwd_t3_h_27 + (0.11956638842821121) * gru_1_fwd_t3_h_28 + (-0.91458630561828613) * gru_1_fwd_t3_h_29 + (-1.010636568069458) * gru_1_fwd_t3_h_30 + (-1.5189944505691528) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_19 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_19;
    // h=20
    gate_r = sigmoid((-1.2817106246948242) + (-0.48983830213546753) * gru_0_out_t4_0 + (0.26076200604438782) * gru_0_out_t4_1 + (-2.0339467525482178) * gru_0_out_t4_2 + (-0.7943655252456665) * gru_0_out_t4_3 + (0.065380431711673737) * gru_0_out_t4_4 + (-1.9250783920288086) * gru_0_out_t4_5 + (0.61275762319564819) * gru_0_out_t4_6 + (4.4645047187805176) * gru_0_out_t4_7 + (-0.41770091652870178) * gru_0_out_t4_8 + (-2.4737174510955811) * gru_0_out_t4_9 + (1.9250880479812622) * gru_0_out_t4_10 + (0.56847888231277466) * gru_0_out_t4_11 + (-0.64444941282272339) * gru_0_out_t4_12 + (0.1959405392408371) * gru_0_out_t4_13 + (-0.57659471035003662) * gru_0_out_t4_14 + (-0.20287524163722992) * gru_0_out_t4_15 + (0.29061686992645264) * gru_0_out_t4_16 + (-0.78408008813858032) * gru_0_out_t4_17 + (-0.36424306035041809) * gru_0_out_t4_18 + (-1.9746310710906982) * gru_0_out_t4_19 + (-2.3035664558410645) * gru_0_out_t4_20 + (0.38996464014053345) * gru_0_out_t4_21 + (-0.71755260229110718) * gru_0_out_t4_22 + (1.176018238067627) * gru_0_out_t4_23 + (0.8680378794670105) * gru_0_out_t4_24 + (0.69510316848754883) * gru_0_out_t4_25 + (-0.45407024025917053) * gru_0_out_t4_26 + (0.92619991302490234) * gru_0_out_t4_27 + (1.436305046081543) * gru_0_out_t4_28 + (0.11339384317398071) * gru_0_out_t4_29 + (-0.60003936290740967) * gru_0_out_t4_30 + (1.480060338973999) * gru_0_out_t4_31 + (-1.0097053050994873) * gru_0_out_t4_32 + (-1.0582259893417358) * gru_0_out_t4_33 + (-1.6620794534683228) * gru_0_out_t4_34 + (0.00091572350356727839) * gru_0_out_t4_35 + (-0.5328947901725769) * gru_0_out_t4_36 + (-0.39754354953765869) * gru_0_out_t4_37 + (-1.0054599046707153) * gru_0_out_t4_38 + (-0.34544891119003296) * gru_0_out_t4_39 + (-1.2044377326965332) * gru_0_out_t4_40 + (0.2425118088722229) * gru_0_out_t4_41 + (-0.72249853610992432) * gru_0_out_t4_42 + (1.0901083946228027) * gru_0_out_t4_43 + (-0.11071000248193741) * gru_0_out_t4_44 + (-0.0079990271478891373) * gru_0_out_t4_45 + (-0.57627654075622559) * gru_0_out_t4_46 + (0.34137451648712158) * gru_0_out_t4_47 + (-0.65458297729492188) * gru_0_out_t4_48 + (0.85728693008422852) * gru_0_out_t4_49 + (-0.36919191479682922) * gru_0_out_t4_50 + (0.48018693923950195) * gru_0_out_t4_51 + (0.10771072655916214) * gru_0_out_t4_52 + (0.57193011045455933) * gru_0_out_t4_53 + (0.32601609826087952) * gru_0_out_t4_54 + (0.39585083723068237) * gru_0_out_t4_55 + (-0.07703901082277298) * gru_0_out_t4_56 + (0.36514389514923096) * gru_0_out_t4_57 + (-0.40096607804298401) * gru_0_out_t4_58 + (-0.29119917750358582) * gru_0_out_t4_59 + (0.15617626905441284) * gru_0_out_t4_60 + (-1.5166794061660767) * gru_0_out_t4_61 + (1.7377892732620239) * gru_0_out_t4_62 + (1.7023379802703857) * gru_0_out_t4_63 + (-0.33521488308906555) * gru_1_fwd_t3_h_0 + (-0.32187202572822571) * gru_1_fwd_t3_h_1 + (-0.57641243934631348) * gru_1_fwd_t3_h_2 + (0.16520436108112335) * gru_1_fwd_t3_h_3 + (0.42208504676818848) * gru_1_fwd_t3_h_4 + (-0.59827929735183716) * gru_1_fwd_t3_h_5 + (0.50468939542770386) * gru_1_fwd_t3_h_6 + (0.65825116634368896) * gru_1_fwd_t3_h_7 + (-0.27057138085365295) * gru_1_fwd_t3_h_8 + (0.78022670745849609) * gru_1_fwd_t3_h_9 + (1.1752244234085083) * gru_1_fwd_t3_h_10 + (1.4211736917495728) * gru_1_fwd_t3_h_11 + (-1.9868612289428711) * gru_1_fwd_t3_h_12 + (-1.7980130910873413) * gru_1_fwd_t3_h_13 + (-0.55381166934967041) * gru_1_fwd_t3_h_14 + (-1.0283242464065552) * gru_1_fwd_t3_h_15 + (0.22629804909229279) * gru_1_fwd_t3_h_16 + (-0.64106714725494385) * gru_1_fwd_t3_h_17 + (-0.82097464799880981) * gru_1_fwd_t3_h_18 + (-0.26980084180831909) * gru_1_fwd_t3_h_19 + (0.16065406799316406) * gru_1_fwd_t3_h_20 + (-0.01949925534427166) * gru_1_fwd_t3_h_21 + (0.57618439197540283) * gru_1_fwd_t3_h_22 + (-1.9955564737319946) * gru_1_fwd_t3_h_23 + (1.6437255144119263) * gru_1_fwd_t3_h_24 + (-0.58922475576400757) * gru_1_fwd_t3_h_25 + (0.45950746536254883) * gru_1_fwd_t3_h_26 + (0.43752372264862061) * gru_1_fwd_t3_h_27 + (-0.22521600127220154) * gru_1_fwd_t3_h_28 + (-0.53467386960983276) * gru_1_fwd_t3_h_29 + (-1.2152405977249146) * gru_1_fwd_t3_h_30 + (-0.88326185941696167) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((-0.17312385141849518) + (0.14970517158508301) * gru_0_out_t4_0 + (-0.38636276125907898) * gru_0_out_t4_1 + (0.56152725219726562) * gru_0_out_t4_2 + (-0.22224454581737518) * gru_0_out_t4_3 + (-0.24877025187015533) * gru_0_out_t4_4 + (0.0087913032621145248) * gru_0_out_t4_5 + (-1.0320265293121338) * gru_0_out_t4_6 + (0.35578665137290955) * gru_0_out_t4_7 + (0.50566589832305908) * gru_0_out_t4_8 + (0.40748491883277893) * gru_0_out_t4_9 + (-0.26413393020629883) * gru_0_out_t4_10 + (0.77450782060623169) * gru_0_out_t4_11 + (-0.015219733119010925) * gru_0_out_t4_12 + (0.32364383339881897) * gru_0_out_t4_13 + (-0.17424628138542175) * gru_0_out_t4_14 + (0.23067599534988403) * gru_0_out_t4_15 + (-0.23119036853313446) * gru_0_out_t4_16 + (0.076736398041248322) * gru_0_out_t4_17 + (-0.41830915212631226) * gru_0_out_t4_18 + (-0.053435388952493668) * gru_0_out_t4_19 + (-0.38996493816375732) * gru_0_out_t4_20 + (-0.66914260387420654) * gru_0_out_t4_21 + (0.30278286337852478) * gru_0_out_t4_22 + (-0.4447612464427948) * gru_0_out_t4_23 + (-1.1095203161239624) * gru_0_out_t4_24 + (0.42436224222183228) * gru_0_out_t4_25 + (0.034619506448507309) * gru_0_out_t4_26 + (0.19181223213672638) * gru_0_out_t4_27 + (-0.74360889196395874) * gru_0_out_t4_28 + (-0.28956553339958191) * gru_0_out_t4_29 + (-0.41535887122154236) * gru_0_out_t4_30 + (-1.1370761394500732) * gru_0_out_t4_31 + (0.61764043569564819) * gru_0_out_t4_32 + (0.67983359098434448) * gru_0_out_t4_33 + (0.19368462264537811) * gru_0_out_t4_34 + (-0.41565233469009399) * gru_0_out_t4_35 + (-0.093325160443782806) * gru_0_out_t4_36 + (0.38772040605545044) * gru_0_out_t4_37 + (-0.25220435857772827) * gru_0_out_t4_38 + (-0.20623686909675598) * gru_0_out_t4_39 + (-1.2610181570053101) * gru_0_out_t4_40 + (-0.65647000074386597) * gru_0_out_t4_41 + (0.040898140519857407) * gru_0_out_t4_42 + (-0.046225473284721375) * gru_0_out_t4_43 + (-0.44436731934547424) * gru_0_out_t4_44 + (0.56600433588027954) * gru_0_out_t4_45 + (-0.36236506700515747) * gru_0_out_t4_46 + (0.38397184014320374) * gru_0_out_t4_47 + (-0.26508453488349915) * gru_0_out_t4_48 + (-0.0040701050311326981) * gru_0_out_t4_49 + (0.25089821219444275) * gru_0_out_t4_50 + (0.70271188020706177) * gru_0_out_t4_51 + (-0.2321012020111084) * gru_0_out_t4_52 + (-0.019074326381087303) * gru_0_out_t4_53 + (-0.17519956827163696) * gru_0_out_t4_54 + (0.44246190786361694) * gru_0_out_t4_55 + (-0.42229366302490234) * gru_0_out_t4_56 + (-0.016487764194607735) * gru_0_out_t4_57 + (-0.5290372371673584) * gru_0_out_t4_58 + (-0.36430618166923523) * gru_0_out_t4_59 + (0.52517753839492798) * gru_0_out_t4_60 + (0.55844056606292725) * gru_0_out_t4_61 + (1.1980520486831665) * gru_0_out_t4_62 + (0.66427648067474365) * gru_0_out_t4_63 + (0.10294567793607712) * gru_1_fwd_t3_h_0 + (-0.27567645907402039) * gru_1_fwd_t3_h_1 + (0.24168230593204498) * gru_1_fwd_t3_h_2 + (-0.38725849986076355) * gru_1_fwd_t3_h_3 + (-0.064500465989112854) * gru_1_fwd_t3_h_4 + (-0.00063728727400302887) * gru_1_fwd_t3_h_5 + (1.3210464715957642) * gru_1_fwd_t3_h_6 + (-0.61923027038574219) * gru_1_fwd_t3_h_7 + (0.13474206626415253) * gru_1_fwd_t3_h_8 + (0.083223365247249603) * gru_1_fwd_t3_h_9 + (0.1716928631067276) * gru_1_fwd_t3_h_10 + (0.60996562242507935) * gru_1_fwd_t3_h_11 + (0.38387036323547363) * gru_1_fwd_t3_h_12 + (-0.31448632478713989) * gru_1_fwd_t3_h_13 + (0.075321055948734283) * gru_1_fwd_t3_h_14 + (0.090761251747608185) * gru_1_fwd_t3_h_15 + (-0.70088052749633789) * gru_1_fwd_t3_h_16 + (0.029526742175221443) * gru_1_fwd_t3_h_17 + (0.31767386198043823) * gru_1_fwd_t3_h_18 + (-0.22582297027111053) * gru_1_fwd_t3_h_19 + (0.029199108481407166) * gru_1_fwd_t3_h_20 + (-0.021042803302407265) * gru_1_fwd_t3_h_21 + (-0.30595192313194275) * gru_1_fwd_t3_h_22 + (0.3468906581401825) * gru_1_fwd_t3_h_23 + (0.25035470724105835) * gru_1_fwd_t3_h_24 + (0.48981243371963501) * gru_1_fwd_t3_h_25 + (-0.4514734148979187) * gru_1_fwd_t3_h_26 + (-0.84741389751434326) * gru_1_fwd_t3_h_27 + (-0.22727245092391968) * gru_1_fwd_t3_h_28 + (0.21625961363315582) * gru_1_fwd_t3_h_29 + (-0.20036995410919189) * gru_1_fwd_t3_h_30 + (0.12982822954654694) * gru_1_fwd_t3_h_31);
    gate_n = tanh((0.14517863094806671) + (-0.3137567937374115) * gru_0_out_t4_0 + (-0.13946141302585602) * gru_0_out_t4_1 + (-0.47565659880638123) * gru_0_out_t4_2 + (-0.34183803200721741) * gru_0_out_t4_3 + (0.21821098029613495) * gru_0_out_t4_4 + (-0.015212906524538994) * gru_0_out_t4_5 + (0.3494468629360199) * gru_0_out_t4_6 + (1.1272504329681396) * gru_0_out_t4_7 + (-0.35477888584136963) * gru_0_out_t4_8 + (-0.49726229906082153) * gru_0_out_t4_9 + (0.44370880722999573) * gru_0_out_t4_10 + (-0.19282530248165131) * gru_0_out_t4_11 + (0.17688289284706116) * gru_0_out_t4_12 + (-0.01379067450761795) * gru_0_out_t4_13 + (0.025039201602339745) * gru_0_out_t4_14 + (-0.14378471672534943) * gru_0_out_t4_15 + (-0.26954445242881775) * gru_0_out_t4_16 + (-0.21467207372188568) * gru_0_out_t4_17 + (-0.026149852201342583) * gru_0_out_t4_18 + (0.31923958659172058) * gru_0_out_t4_19 + (-0.37810808420181274) * gru_0_out_t4_20 + (-0.52649116516113281) * gru_0_out_t4_21 + (-0.43426588177680969) * gru_0_out_t4_22 + (0.17634622752666473) * gru_0_out_t4_23 + (0.55884265899658203) * gru_0_out_t4_24 + (0.33705848455429077) * gru_0_out_t4_25 + (0.012912916019558907) * gru_0_out_t4_26 + (0.20079140365123749) * gru_0_out_t4_27 + (-0.081835731863975525) * gru_0_out_t4_28 + (-0.41591396927833557) * gru_0_out_t4_29 + (0.54674732685089111) * gru_0_out_t4_30 + (-0.83932298421859741) * gru_0_out_t4_31 + (0.83749878406524658) * gru_0_out_t4_32 + (-0.11164047569036484) * gru_0_out_t4_33 + (0.13896012306213379) * gru_0_out_t4_34 + (-0.32776570320129395) * gru_0_out_t4_35 + (0.031428039073944092) * gru_0_out_t4_36 + (0.17911738157272339) * gru_0_out_t4_37 + (0.20719631016254425) * gru_0_out_t4_38 + (-0.2341323047876358) * gru_0_out_t4_39 + (-1.0062003135681152) * gru_0_out_t4_40 + (0.20318098366260529) * gru_0_out_t4_41 + (-0.072444707155227661) * gru_0_out_t4_42 + (0.074775561690330505) * gru_0_out_t4_43 + (0.23928366601467133) * gru_0_out_t4_44 + (-0.29708567261695862) * gru_0_out_t4_45 + (-0.098189614713191986) * gru_0_out_t4_46 + (-0.90723490715026855) * gru_0_out_t4_47 + (-0.69157421588897705) * gru_0_out_t4_48 + (0.56777030229568481) * gru_0_out_t4_49 + (0.42417523264884949) * gru_0_out_t4_50 + (-0.1543581634759903) * gru_0_out_t4_51 + (-0.14930815994739532) * gru_0_out_t4_52 + (0.13046346604824066) * gru_0_out_t4_53 + (0.044927783310413361) * gru_0_out_t4_54 + (-0.083579011261463165) * gru_0_out_t4_55 + (-0.025028487667441368) * gru_0_out_t4_56 + (0.37587285041809082) * gru_0_out_t4_57 + (0.37373507022857666) * gru_0_out_t4_58 + (0.12707950174808502) * gru_0_out_t4_59 + (-0.53156471252441406) * gru_0_out_t4_60 + (-0.059414796531200409) * gru_0_out_t4_61 + (0.19793474674224854) * gru_0_out_t4_62 + (-0.11455708742141724) * gru_0_out_t4_63 + gate_r * ((-0.18165589869022369) + (0.25941604375839233) * gru_1_fwd_t3_h_0 + (0.09543851763010025) * gru_1_fwd_t3_h_1 + (-0.32985812425613403) * gru_1_fwd_t3_h_2 + (-1.0468642711639404) * gru_1_fwd_t3_h_3 + (0.30117380619049072) * gru_1_fwd_t3_h_4 + (0.42603185772895813) * gru_1_fwd_t3_h_5 + (0.47205516695976257) * gru_1_fwd_t3_h_6 + (-1.3281594514846802) * gru_1_fwd_t3_h_7 + (0.43004047870635986) * gru_1_fwd_t3_h_8 + (-0.59216713905334473) * gru_1_fwd_t3_h_9 + (0.032118130475282669) * gru_1_fwd_t3_h_10 + (-0.26255717873573303) * gru_1_fwd_t3_h_11 + (0.28919783234596252) * gru_1_fwd_t3_h_12 + (0.58789092302322388) * gru_1_fwd_t3_h_13 + (-0.42499157786369324) * gru_1_fwd_t3_h_14 + (0.43090471625328064) * gru_1_fwd_t3_h_15 + (-0.23091495037078857) * gru_1_fwd_t3_h_16 + (-0.33794435858726501) * gru_1_fwd_t3_h_17 + (-1.2708356380462646) * gru_1_fwd_t3_h_18 + (0.27788400650024414) * gru_1_fwd_t3_h_19 + (-1.1976678371429443) * gru_1_fwd_t3_h_20 + (0.52629983425140381) * gru_1_fwd_t3_h_21 + (1.8896212577819824) * gru_1_fwd_t3_h_22 + (1.2512897253036499) * gru_1_fwd_t3_h_23 + (-0.42488965392112732) * gru_1_fwd_t3_h_24 + (0.16756696999073029) * gru_1_fwd_t3_h_25 + (-0.8294597864151001) * gru_1_fwd_t3_h_26 + (-1.5811538696289062) * gru_1_fwd_t3_h_27 + (0.85369092226028442) * gru_1_fwd_t3_h_28 + (-0.39516863226890564) * gru_1_fwd_t3_h_29 + (0.38887488842010498) * gru_1_fwd_t3_h_30 + (-0.39943104982376099) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_20 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_20;
    // h=21
    gate_r = sigmoid((-0.97572582960128784) + (-0.095662973821163177) * gru_0_out_t4_0 + (0.36371147632598877) * gru_0_out_t4_1 + (-0.3994843065738678) * gru_0_out_t4_2 + (0.24410293996334076) * gru_0_out_t4_3 + (-0.25856077671051025) * gru_0_out_t4_4 + (-0.85858243703842163) * gru_0_out_t4_5 + (0.47278743982315063) * gru_0_out_t4_6 + (-0.81376951932907104) * gru_0_out_t4_7 + (1.4860039949417114) * gru_0_out_t4_8 + (-0.86087960004806519) * gru_0_out_t4_9 + (1.1848442554473877) * gru_0_out_t4_10 + (-0.21700465679168701) * gru_0_out_t4_11 + (-0.34250277280807495) * gru_0_out_t4_12 + (-0.17672990262508392) * gru_0_out_t4_13 + (0.32325455546379089) * gru_0_out_t4_14 + (0.12373548746109009) * gru_0_out_t4_15 + (0.65120428800582886) * gru_0_out_t4_16 + (-0.02976401150226593) * gru_0_out_t4_17 + (0.69171345233917236) * gru_0_out_t4_18 + (1.3637052774429321) * gru_0_out_t4_19 + (-0.20415022969245911) * gru_0_out_t4_20 + (1.2128101587295532) * gru_0_out_t4_21 + (-0.34202760457992554) * gru_0_out_t4_22 + (1.3982101678848267) * gru_0_out_t4_23 + (2.2721931934356689) * gru_0_out_t4_24 + (0.18512848019599915) * gru_0_out_t4_25 + (0.56006723642349243) * gru_0_out_t4_26 + (-1.5779100656509399) * gru_0_out_t4_27 + (4.0672054290771484) * gru_0_out_t4_28 + (-0.3156503438949585) * gru_0_out_t4_29 + (-0.85022866725921631) * gru_0_out_t4_30 + (0.93937748670578003) * gru_0_out_t4_31 + (0.60415029525756836) * gru_0_out_t4_32 + (-0.15187413990497589) * gru_0_out_t4_33 + (1.1231993436813354) * gru_0_out_t4_34 + (-0.38286492228507996) * gru_0_out_t4_35 + (0.1260366290807724) * gru_0_out_t4_36 + (-0.2329193651676178) * gru_0_out_t4_37 + (-0.062392231076955795) * gru_0_out_t4_38 + (-3.9326751232147217) * gru_0_out_t4_39 + (0.35190856456756592) * gru_0_out_t4_40 + (0.040233485400676727) * gru_0_out_t4_41 + (-1.2722417116165161) * gru_0_out_t4_42 + (-0.35438230633735657) * gru_0_out_t4_43 + (0.0074670491740107536) * gru_0_out_t4_44 + (-0.52326440811157227) * gru_0_out_t4_45 + (-1.2080467939376831) * gru_0_out_t4_46 + (0.0097133731469511986) * gru_0_out_t4_47 + (0.59461390972137451) * gru_0_out_t4_48 + (-1.0890825986862183) * gru_0_out_t4_49 + (1.3913891315460205) * gru_0_out_t4_50 + (-0.36905133724212646) * gru_0_out_t4_51 + (0.098983816802501678) * gru_0_out_t4_52 + (0.21289213001728058) * gru_0_out_t4_53 + (1.2363343238830566) * gru_0_out_t4_54 + (1.503623366355896) * gru_0_out_t4_55 + (-1.8754136562347412) * gru_0_out_t4_56 + (-0.74406617879867554) * gru_0_out_t4_57 + (-0.087981894612312317) * gru_0_out_t4_58 + (-1.7327289581298828) * gru_0_out_t4_59 + (-0.017352107912302017) * gru_0_out_t4_60 + (-0.79450058937072754) * gru_0_out_t4_61 + (-0.089709028601646423) * gru_0_out_t4_62 + (-0.45183461904525757) * gru_0_out_t4_63 + (0.94540101289749146) * gru_1_fwd_t3_h_0 + (1.4062687158584595) * gru_1_fwd_t3_h_1 + (0.2991408109664917) * gru_1_fwd_t3_h_2 + (0.14129117131233215) * gru_1_fwd_t3_h_3 + (-1.3963797092437744) * gru_1_fwd_t3_h_4 + (-0.18941077589988708) * gru_1_fwd_t3_h_5 + (-0.58182764053344727) * gru_1_fwd_t3_h_6 + (0.15551835298538208) * gru_1_fwd_t3_h_7 + (0.03945733979344368) * gru_1_fwd_t3_h_8 + (0.58527541160583496) * gru_1_fwd_t3_h_9 + (0.45746269822120667) * gru_1_fwd_t3_h_10 + (-1.1680364608764648) * gru_1_fwd_t3_h_11 + (-0.27155080437660217) * gru_1_fwd_t3_h_12 + (-0.79760289192199707) * gru_1_fwd_t3_h_13 + (-0.4256344735622406) * gru_1_fwd_t3_h_14 + (-1.8206816911697388) * gru_1_fwd_t3_h_15 + (0.20938366651535034) * gru_1_fwd_t3_h_16 + (0.10282550752162933) * gru_1_fwd_t3_h_17 + (-0.62015575170516968) * gru_1_fwd_t3_h_18 + (0.91579151153564453) * gru_1_fwd_t3_h_19 + (-0.13205398619174957) * gru_1_fwd_t3_h_20 + (-2.8778417110443115) * gru_1_fwd_t3_h_21 + (1.0177972316741943) * gru_1_fwd_t3_h_22 + (-0.90135782957077026) * gru_1_fwd_t3_h_23 + (0.90904390811920166) * gru_1_fwd_t3_h_24 + (0.56791514158248901) * gru_1_fwd_t3_h_25 + (0.37335243821144104) * gru_1_fwd_t3_h_26 + (-1.4614157676696777) * gru_1_fwd_t3_h_27 + (-0.21565286815166473) * gru_1_fwd_t3_h_28 + (-0.26224705576896667) * gru_1_fwd_t3_h_29 + (-1.3020766973495483) * gru_1_fwd_t3_h_30 + (-0.57850831747055054) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((0.38889366388320923) + (0.25210043787956238) * gru_0_out_t4_0 + (-0.061205539852380753) * gru_0_out_t4_1 + (0.31897264719009399) * gru_0_out_t4_2 + (-0.27405631542205811) * gru_0_out_t4_3 + (-0.20512163639068604) * gru_0_out_t4_4 + (-0.24994079768657684) * gru_0_out_t4_5 + (0.23984207212924957) * gru_0_out_t4_6 + (0.5860639214515686) * gru_0_out_t4_7 + (-0.0267220139503479) * gru_0_out_t4_8 + (-0.071945317089557648) * gru_0_out_t4_9 + (-0.3343711793422699) * gru_0_out_t4_10 + (0.081579349935054779) * gru_0_out_t4_11 + (-0.3215559720993042) * gru_0_out_t4_12 + (0.40715038776397705) * gru_0_out_t4_13 + (0.57827103137969971) * gru_0_out_t4_14 + (-0.2624344527721405) * gru_0_out_t4_15 + (0.10224200040102005) * gru_0_out_t4_16 + (-0.087222129106521606) * gru_0_out_t4_17 + (-0.03484799712896347) * gru_0_out_t4_18 + (-0.58153557777404785) * gru_0_out_t4_19 + (0.13023479282855988) * gru_0_out_t4_20 + (0.22022579610347748) * gru_0_out_t4_21 + (-0.015459101647138596) * gru_0_out_t4_22 + (0.23503805696964264) * gru_0_out_t4_23 + (-0.46167305111885071) * gru_0_out_t4_24 + (-0.37427979707717896) * gru_0_out_t4_25 + (-0.093848459422588348) * gru_0_out_t4_26 + (1.5073754787445068) * gru_0_out_t4_27 + (2.5815598964691162) * gru_0_out_t4_28 + (-0.46528550982475281) * gru_0_out_t4_29 + (0.55191642045974731) * gru_0_out_t4_30 + (-0.60217362642288208) * gru_0_out_t4_31 + (0.31667441129684448) * gru_0_out_t4_32 + (0.17841628193855286) * gru_0_out_t4_33 + (-0.35002243518829346) * gru_0_out_t4_34 + (-0.053544670343399048) * gru_0_out_t4_35 + (-0.048704363405704498) * gru_0_out_t4_36 + (-0.10971169173717499) * gru_0_out_t4_37 + (-0.51504451036453247) * gru_0_out_t4_38 + (0.21998918056488037) * gru_0_out_t4_39 + (-2.3165395259857178) * gru_0_out_t4_40 + (0.55651754140853882) * gru_0_out_t4_41 + (-0.11226580291986465) * gru_0_out_t4_42 + (0.045597050338983536) * gru_0_out_t4_43 + (-0.057641245424747467) * gru_0_out_t4_44 + (-0.11208820343017578) * gru_0_out_t4_45 + (0.078309565782546997) * gru_0_out_t4_46 + (0.31334125995635986) * gru_0_out_t4_47 + (0.939400315284729) * gru_0_out_t4_48 + (-1.0069636106491089) * gru_0_out_t4_49 + (-0.12932273745536804) * gru_0_out_t4_50 + (0.017252612859010696) * gru_0_out_t4_51 + (0.26695558428764343) * gru_0_out_t4_52 + (0.37706893682479858) * gru_0_out_t4_53 + (-0.054132770746946335) * gru_0_out_t4_54 + (1.1879684925079346) * gru_0_out_t4_55 + (-0.50723469257354736) * gru_0_out_t4_56 + (0.044946156442165375) * gru_0_out_t4_57 + (-0.36188656091690063) * gru_0_out_t4_58 + (-0.096934519708156586) * gru_0_out_t4_59 + (0.26043671369552612) * gru_0_out_t4_60 + (-0.54119807481765747) * gru_0_out_t4_61 + (-0.49144372344017029) * gru_0_out_t4_62 + (0.11413858085870743) * gru_0_out_t4_63 + (0.001500828773714602) * gru_1_fwd_t3_h_0 + (-0.61324876546859741) * gru_1_fwd_t3_h_1 + (-0.57265204191207886) * gru_1_fwd_t3_h_2 + (-0.47856146097183228) * gru_1_fwd_t3_h_3 + (0.33077239990234375) * gru_1_fwd_t3_h_4 + (0.33221468329429626) * gru_1_fwd_t3_h_5 + (0.72083097696304321) * gru_1_fwd_t3_h_6 + (-0.4478583037853241) * gru_1_fwd_t3_h_7 + (-0.37333717942237854) * gru_1_fwd_t3_h_8 + (-0.020392835140228271) * gru_1_fwd_t3_h_9 + (-0.35804826021194458) * gru_1_fwd_t3_h_10 + (0.070721171796321869) * gru_1_fwd_t3_h_11 + (0.16184750199317932) * gru_1_fwd_t3_h_12 + (-0.05844588577747345) * gru_1_fwd_t3_h_13 + (-0.39776349067687988) * gru_1_fwd_t3_h_14 + (0.033588282763957977) * gru_1_fwd_t3_h_15 + (-0.43139004707336426) * gru_1_fwd_t3_h_16 + (-0.010245521552860737) * gru_1_fwd_t3_h_17 + (0.5273972749710083) * gru_1_fwd_t3_h_18 + (0.19962255656719208) * gru_1_fwd_t3_h_19 + (-0.33443549275398254) * gru_1_fwd_t3_h_20 + (-1.2251861095428467) * gru_1_fwd_t3_h_21 + (-0.76087421178817749) * gru_1_fwd_t3_h_22 + (-1.5698533058166504) * gru_1_fwd_t3_h_23 + (-0.4871990978717804) * gru_1_fwd_t3_h_24 + (-0.23817773163318634) * gru_1_fwd_t3_h_25 + (-0.39214852452278137) * gru_1_fwd_t3_h_26 + (-0.073740839958190918) * gru_1_fwd_t3_h_27 + (-0.84004074335098267) * gru_1_fwd_t3_h_28 + (-0.53973430395126343) * gru_1_fwd_t3_h_29 + (-0.58572214841842651) * gru_1_fwd_t3_h_30 + (0.40000990033149719) * gru_1_fwd_t3_h_31);
    gate_n = tanh((-0.045062098652124405) + (-0.30754965543746948) * gru_0_out_t4_0 + (-0.12149661779403687) * gru_0_out_t4_1 + (0.19865764677524567) * gru_0_out_t4_2 + (0.32590010762214661) * gru_0_out_t4_3 + (0.79506593942642212) * gru_0_out_t4_4 + (0.41803479194641113) * gru_0_out_t4_5 + (-0.65782171487808228) * gru_0_out_t4_6 + (0.36040440201759338) * gru_0_out_t4_7 + (-0.3558921217918396) * gru_0_out_t4_8 + (2.2671072483062744) * gru_0_out_t4_9 + (-0.16764411330223083) * gru_0_out_t4_10 + (-0.38314792513847351) * gru_0_out_t4_11 + (0.32389107346534729) * gru_0_out_t4_12 + (-0.065801337361335754) * gru_0_out_t4_13 + (0.20528718829154968) * gru_0_out_t4_14 + (-0.042872603982686996) * gru_0_out_t4_15 + (-0.28424081206321716) * gru_0_out_t4_16 + (0.083119519054889679) * gru_0_out_t4_17 + (0.068105518817901611) * gru_0_out_t4_18 + (-0.53487563133239746) * gru_0_out_t4_19 + (0.20002442598342896) * gru_0_out_t4_20 + (0.3039085865020752) * gru_0_out_t4_21 + (0.28855222463607788) * gru_0_out_t4_22 + (-0.350516676902771) * gru_0_out_t4_23 + (-0.84799104928970337) * gru_0_out_t4_24 + (0.37663167715072632) * gru_0_out_t4_25 + (0.086711093783378601) * gru_0_out_t4_26 + (0.31585264205932617) * gru_0_out_t4_27 + (0.40005302429199219) * gru_0_out_t4_28 + (-0.14315222203731537) * gru_0_out_t4_29 + (1.0299261808395386) * gru_0_out_t4_30 + (1.2327816486358643) * gru_0_out_t4_31 + (0.044263832271099091) * gru_0_out_t4_32 + (0.10651897639036179) * gru_0_out_t4_33 + (-0.49660834670066833) * gru_0_out_t4_34 + (-0.28042599558830261) * gru_0_out_t4_35 + (-0.0015521731693297625) * gru_0_out_t4_36 + (-0.57655757665634155) * gru_0_out_t4_37 + (0.038994506001472473) * gru_0_out_t4_38 + (0.55303603410720825) * gru_0_out_t4_39 + (-0.68304049968719482) * gru_0_out_t4_40 + (-0.0031028364319354296) * gru_0_out_t4_41 + (1.1204543113708496) * gru_0_out_t4_42 + (0.35415223240852356) * gru_0_out_t4_43 + (-0.11834608018398285) * gru_0_out_t4_44 + (0.15548183023929596) * gru_0_out_t4_45 + (1.4937592744827271) * gru_0_out_t4_46 + (0.11292536556720734) * gru_0_out_t4_47 + (-0.24004001915454865) * gru_0_out_t4_48 + (0.00033956512925215065) * gru_0_out_t4_49 + (0.049456294625997543) * gru_0_out_t4_50 + (-0.34014573693275452) * gru_0_out_t4_51 + (-0.42333364486694336) * gru_0_out_t4_52 + (-0.27375081181526184) * gru_0_out_t4_53 + (0.33247467875480652) * gru_0_out_t4_54 + (-0.6417158842086792) * gru_0_out_t4_55 + (0.26806887984275818) * gru_0_out_t4_56 + (0.22909116744995117) * gru_0_out_t4_57 + (0.15555201470851898) * gru_0_out_t4_58 + (0.46147942543029785) * gru_0_out_t4_59 + (-0.10734757035970688) * gru_0_out_t4_60 + (0.28036239743232727) * gru_0_out_t4_61 + (-0.9336693286895752) * gru_0_out_t4_62 + (-0.69945693016052246) * gru_0_out_t4_63 + gate_r * ((-0.1166287362575531) + (0.17004188895225525) * gru_1_fwd_t3_h_0 + (-0.59564369916915894) * gru_1_fwd_t3_h_1 + (0.38626798987388611) * gru_1_fwd_t3_h_2 + (0.93474912643432617) * gru_1_fwd_t3_h_3 + (-0.69351708889007568) * gru_1_fwd_t3_h_4 + (0.278034508228302) * gru_1_fwd_t3_h_5 + (0.025181323289871216) * gru_1_fwd_t3_h_6 + (0.045095451176166534) * gru_1_fwd_t3_h_7 + (0.37426236271858215) * gru_1_fwd_t3_h_8 + (-0.33249852061271667) * gru_1_fwd_t3_h_9 + (-1.027288556098938) * gru_1_fwd_t3_h_10 + (0.43408668041229248) * gru_1_fwd_t3_h_11 + (0.52003622055053711) * gru_1_fwd_t3_h_12 + (0.21184597909450531) * gru_1_fwd_t3_h_13 + (0.40146660804748535) * gru_1_fwd_t3_h_14 + (-0.32578077912330627) * gru_1_fwd_t3_h_15 + (0.25039857625961304) * gru_1_fwd_t3_h_16 + (0.2578827440738678) * gru_1_fwd_t3_h_17 + (0.69051986932754517) * gru_1_fwd_t3_h_18 + (0.14950898289680481) * gru_1_fwd_t3_h_19 + (0.052200499922037125) * gru_1_fwd_t3_h_20 + (-3.2490236759185791) * gru_1_fwd_t3_h_21 + (-1.2018259763717651) * gru_1_fwd_t3_h_22 + (1.1734403371810913) * gru_1_fwd_t3_h_23 + (1.0182715654373169) * gru_1_fwd_t3_h_24 + (-0.029313376173377037) * gru_1_fwd_t3_h_25 + (-0.62022459506988525) * gru_1_fwd_t3_h_26 + (-1.4238991737365723) * gru_1_fwd_t3_h_27 + (0.2260095626115799) * gru_1_fwd_t3_h_28 + (-0.26308217644691467) * gru_1_fwd_t3_h_29 + (0.64933031797409058) * gru_1_fwd_t3_h_30 + (0.26363199949264526) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_21 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_21;
    // h=22
    gate_r = sigmoid((-0.36216527223587036) + (-0.74367058277130127) * gru_0_out_t4_0 + (-0.58084571361541748) * gru_0_out_t4_1 + (-0.6232532262802124) * gru_0_out_t4_2 + (-1.1707674264907837) * gru_0_out_t4_3 + (-0.63045680522918701) * gru_0_out_t4_4 + (0.41954532265663147) * gru_0_out_t4_5 + (0.38541865348815918) * gru_0_out_t4_6 + (0.77768945693969727) * gru_0_out_t4_7 + (1.2543720006942749) * gru_0_out_t4_8 + (-0.11024962365627289) * gru_0_out_t4_9 + (0.23102028667926788) * gru_0_out_t4_10 + (-0.61773043870925903) * gru_0_out_t4_11 + (0.36243525147438049) * gru_0_out_t4_12 + (0.10716316103935242) * gru_0_out_t4_13 + (0.1254047304391861) * gru_0_out_t4_14 + (-0.31630715727806091) * gru_0_out_t4_15 + (0.049033720046281815) * gru_0_out_t4_16 + (-0.18428747355937958) * gru_0_out_t4_17 + (-0.47675997018814087) * gru_0_out_t4_18 + (0.94643503427505493) * gru_0_out_t4_19 + (-0.27927249670028687) * gru_0_out_t4_20 + (0.052847821265459061) * gru_0_out_t4_21 + (0.085995577275753021) * gru_0_out_t4_22 + (-1.212965726852417) * gru_0_out_t4_23 + (-0.10241477936506271) * gru_0_out_t4_24 + (0.85734277963638306) * gru_0_out_t4_25 + (0.050860211253166199) * gru_0_out_t4_26 + (-1.4734209775924683) * gru_0_out_t4_27 + (0.76380032300949097) * gru_0_out_t4_28 + (-0.28551328182220459) * gru_0_out_t4_29 + (-0.097737841308116913) * gru_0_out_t4_30 + (1.7435916662216187) * gru_0_out_t4_31 + (-1.6127448081970215) * gru_0_out_t4_32 + (-0.1934209018945694) * gru_0_out_t4_33 + (-0.29889637231826782) * gru_0_out_t4_34 + (0.13532045483589172) * gru_0_out_t4_35 + (0.08543434739112854) * gru_0_out_t4_36 + (-0.2295016348361969) * gru_0_out_t4_37 + (0.054275631904602051) * gru_0_out_t4_38 + (-1.1048449277877808) * gru_0_out_t4_39 + (3.9845700263977051) * gru_0_out_t4_40 + (0.02328520268201828) * gru_0_out_t4_41 + (0.2412593811750412) * gru_0_out_t4_42 + (0.37626537680625916) * gru_0_out_t4_43 + (0.39688685536384583) * gru_0_out_t4_44 + (0.17796045541763306) * gru_0_out_t4_45 + (-0.56956946849822998) * gru_0_out_t4_46 + (0.54836058616638184) * gru_0_out_t4_47 + (0.1468479186296463) * gru_0_out_t4_48 + (-0.21168020367622375) * gru_0_out_t4_49 + (0.86784827709197998) * gru_0_out_t4_50 + (-0.25251609086990356) * gru_0_out_t4_51 + (0.065298765897750854) * gru_0_out_t4_52 + (-0.22561034560203552) * gru_0_out_t4_53 + (-0.036766119301319122) * gru_0_out_t4_54 + (1.9545638561248779) * gru_0_out_t4_55 + (0.17516636848449707) * gru_0_out_t4_56 + (0.082415349781513214) * gru_0_out_t4_57 + (0.08480362594127655) * gru_0_out_t4_58 + (-0.067344009876251221) * gru_0_out_t4_59 + (-0.33597517013549805) * gru_0_out_t4_60 + (0.12900063395500183) * gru_0_out_t4_61 + (-2.0098869800567627) * gru_0_out_t4_62 + (-0.46273058652877808) * gru_0_out_t4_63 + (-0.22307366132736206) * gru_1_fwd_t3_h_0 + (-0.38731664419174194) * gru_1_fwd_t3_h_1 + (0.34636914730072021) * gru_1_fwd_t3_h_2 + (-0.9253736138343811) * gru_1_fwd_t3_h_3 + (-0.37741521000862122) * gru_1_fwd_t3_h_4 + (0.4415690004825592) * gru_1_fwd_t3_h_5 + (-1.0355105400085449) * gru_1_fwd_t3_h_6 + (-0.36815246939659119) * gru_1_fwd_t3_h_7 + (0.36872577667236328) * gru_1_fwd_t3_h_8 + (1.0609010457992554) * gru_1_fwd_t3_h_9 + (0.092126265168190002) * gru_1_fwd_t3_h_10 + (-0.58784961700439453) * gru_1_fwd_t3_h_11 + (-0.12356256693601608) * gru_1_fwd_t3_h_12 + (-1.9940776824951172) * gru_1_fwd_t3_h_13 + (-0.77973639965057373) * gru_1_fwd_t3_h_14 + (0.24378851056098938) * gru_1_fwd_t3_h_15 + (0.80571448802947998) * gru_1_fwd_t3_h_16 + (-1.5486207008361816) * gru_1_fwd_t3_h_17 + (-0.9952729344367981) * gru_1_fwd_t3_h_18 + (0.43098270893096924) * gru_1_fwd_t3_h_19 + (0.034936763346195221) * gru_1_fwd_t3_h_20 + (-1.999408483505249) * gru_1_fwd_t3_h_21 + (2.0075929164886475) * gru_1_fwd_t3_h_22 + (0.61375582218170166) * gru_1_fwd_t3_h_23 + (-0.10233233869075775) * gru_1_fwd_t3_h_24 + (0.86497467756271362) * gru_1_fwd_t3_h_25 + (-0.81204378604888916) * gru_1_fwd_t3_h_26 + (-1.1856577396392822) * gru_1_fwd_t3_h_27 + (0.83700573444366455) * gru_1_fwd_t3_h_28 + (0.28791341185569763) * gru_1_fwd_t3_h_29 + (0.098517134785652161) * gru_1_fwd_t3_h_30 + (0.51134318113327026) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((0.69649475812911987) + (-0.096710130572319031) * gru_0_out_t4_0 + (-0.38425016403198242) * gru_0_out_t4_1 + (1.0357855558395386) * gru_0_out_t4_2 + (0.53613054752349854) * gru_0_out_t4_3 + (-0.35610267519950867) * gru_0_out_t4_4 + (-0.42359805107116699) * gru_0_out_t4_5 + (0.055762294679880142) * gru_0_out_t4_6 + (0.12940327823162079) * gru_0_out_t4_7 + (-0.63902425765991211) * gru_0_out_t4_8 + (0.90616178512573242) * gru_0_out_t4_9 + (-0.31552636623382568) * gru_0_out_t4_10 + (0.073895767331123352) * gru_0_out_t4_11 + (-0.3393285870552063) * gru_0_out_t4_12 + (0.17125611007213593) * gru_0_out_t4_13 + (0.20609880983829498) * gru_0_out_t4_14 + (0.0023923639673739672) * gru_0_out_t4_15 + (-0.44156631827354431) * gru_0_out_t4_16 + (-0.76151663064956665) * gru_0_out_t4_17 + (0.32226154208183289) * gru_0_out_t4_18 + (0.029781077057123184) * gru_0_out_t4_19 + (0.35592487454414368) * gru_0_out_t4_20 + (-0.94051629304885864) * gru_0_out_t4_21 + (-0.0044304132461547852) * gru_0_out_t4_22 + (0.7417559027671814) * gru_0_out_t4_23 + (-0.13795426487922668) * gru_0_out_t4_24 + (-0.10423746705055237) * gru_0_out_t4_25 + (-0.55129021406173706) * gru_0_out_t4_26 + (0.70528841018676758) * gru_0_out_t4_27 + (0.43005052208900452) * gru_0_out_t4_28 + (-0.18941231071949005) * gru_0_out_t4_29 + (-0.43907079100608826) * gru_0_out_t4_30 + (0.51787149906158447) * gru_0_out_t4_31 + (0.67564558982849121) * gru_0_out_t4_32 + (0.3502642810344696) * gru_0_out_t4_33 + (0.19018258154392242) * gru_0_out_t4_34 + (0.017173301428556442) * gru_0_out_t4_35 + (-0.22175869345664978) * gru_0_out_t4_36 + (0.54629999399185181) * gru_0_out_t4_37 + (-0.43758967518806458) * gru_0_out_t4_38 + (0.99299043416976929) * gru_0_out_t4_39 + (0.82782375812530518) * gru_0_out_t4_40 + (0.2593027651309967) * gru_0_out_t4_41 + (-0.50448614358901978) * gru_0_out_t4_42 + (0.0039015770889818668) * gru_0_out_t4_43 + (0.31250867247581482) * gru_0_out_t4_44 + (-0.4797222912311554) * gru_0_out_t4_45 + (0.4963030219078064) * gru_0_out_t4_46 + (-0.43982282280921936) * gru_0_out_t4_47 + (0.013091869652271271) * gru_0_out_t4_48 + (0.27531039714813232) * gru_0_out_t4_49 + (0.013123373501002789) * gru_0_out_t4_50 + (0.41175121068954468) * gru_0_out_t4_51 + (-0.54692244529724121) * gru_0_out_t4_52 + (-0.23871973156929016) * gru_0_out_t4_53 + (0.055909749120473862) * gru_0_out_t4_54 + (1.3040136098861694) * gru_0_out_t4_55 + (-0.32727795839309692) * gru_0_out_t4_56 + (0.087840825319290161) * gru_0_out_t4_57 + (-0.43928411602973938) * gru_0_out_t4_58 + (-0.32226157188415527) * gru_0_out_t4_59 + (-0.064606055617332458) * gru_0_out_t4_60 + (0.14720143377780914) * gru_0_out_t4_61 + (0.046903591603040695) * gru_0_out_t4_62 + (0.39568430185317993) * gru_0_out_t4_63 + (-0.049899641424417496) * gru_1_fwd_t3_h_0 + (-0.072983458638191223) * gru_1_fwd_t3_h_1 + (0.1921866238117218) * gru_1_fwd_t3_h_2 + (-0.34291890263557434) * gru_1_fwd_t3_h_3 + (0.20353040099143982) * gru_1_fwd_t3_h_4 + (-0.5564882755279541) * gru_1_fwd_t3_h_5 + (-0.27699118852615356) * gru_1_fwd_t3_h_6 + (0.35071194171905518) * gru_1_fwd_t3_h_7 + (0.57345998287200928) * gru_1_fwd_t3_h_8 + (-0.38401314616203308) * gru_1_fwd_t3_h_9 + (-0.52446681261062622) * gru_1_fwd_t3_h_10 + (-0.32773593068122864) * gru_1_fwd_t3_h_11 + (-0.46593365073204041) * gru_1_fwd_t3_h_12 + (-0.041239842772483826) * gru_1_fwd_t3_h_13 + (-0.40622571110725403) * gru_1_fwd_t3_h_14 + (-0.40598160028457642) * gru_1_fwd_t3_h_15 + (0.25963205099105835) * gru_1_fwd_t3_h_16 + (0.34022533893585205) * gru_1_fwd_t3_h_17 + (0.15966564416885376) * gru_1_fwd_t3_h_18 + (-0.73818528652191162) * gru_1_fwd_t3_h_19 + (-0.10658656805753708) * gru_1_fwd_t3_h_20 + (-1.0331251621246338) * gru_1_fwd_t3_h_21 + (-0.41626673936843872) * gru_1_fwd_t3_h_22 + (0.37667614221572876) * gru_1_fwd_t3_h_23 + (-0.63568532466888428) * gru_1_fwd_t3_h_24 + (-0.17843867838382721) * gru_1_fwd_t3_h_25 + (0.2292180210351944) * gru_1_fwd_t3_h_26 + (0.68002796173095703) * gru_1_fwd_t3_h_27 + (0.24892494082450867) * gru_1_fwd_t3_h_28 + (0.0056247152388095856) * gru_1_fwd_t3_h_29 + (0.073280535638332367) * gru_1_fwd_t3_h_30 + (-0.16032294929027557) * gru_1_fwd_t3_h_31);
    gate_n = tanh((-0.00076227332465350628) + (-0.22902296483516693) * gru_0_out_t4_0 + (-0.27836352586746216) * gru_0_out_t4_1 + (0.55331069231033325) * gru_0_out_t4_2 + (-0.27809971570968628) * gru_0_out_t4_3 + (-0.10055508464574814) * gru_0_out_t4_4 + (-0.29612839221954346) * gru_0_out_t4_5 + (-1.3244835138320923) * gru_0_out_t4_6 + (-0.35527399182319641) * gru_0_out_t4_7 + (-1.011773943901062) * gru_0_out_t4_8 + (-0.8966529369354248) * gru_0_out_t4_9 + (-0.71478605270385742) * gru_0_out_t4_10 + (0.075667828321456909) * gru_0_out_t4_11 + (-0.42687380313873291) * gru_0_out_t4_12 + (0.329856276512146) * gru_0_out_t4_13 + (0.18555057048797607) * gru_0_out_t4_14 + (0.24662607908248901) * gru_0_out_t4_15 + (-0.54740059375762939) * gru_0_out_t4_16 + (-0.56040525436401367) * gru_0_out_t4_17 + (0.45544415712356567) * gru_0_out_t4_18 + (0.18060263991355896) * gru_0_out_t4_19 + (0.16692431271076202) * gru_0_out_t4_20 + (-0.20792624354362488) * gru_0_out_t4_21 + (-0.62150639295578003) * gru_0_out_t4_22 + (0.71988999843597412) * gru_0_out_t4_23 + (1.4547996520996094) * gru_0_out_t4_24 + (-0.86005204916000366) * gru_0_out_t4_25 + (0.052233044058084488) * gru_0_out_t4_26 + (0.25267946720123291) * gru_0_out_t4_27 + (-0.21297857165336609) * gru_0_out_t4_28 + (-0.020412670448422432) * gru_0_out_t4_29 + (-0.20165015757083893) * gru_0_out_t4_30 + (-0.35401824116706848) * gru_0_out_t4_31 + (0.48200708627700806) * gru_0_out_t4_32 + (-0.52854591608047485) * gru_0_out_t4_33 + (0.11353141069412231) * gru_0_out_t4_34 + (0.08713250607252121) * gru_0_out_t4_35 + (0.013717825524508953) * gru_0_out_t4_36 + (-0.27733644843101501) * gru_0_out_t4_37 + (0.44160148501396179) * gru_0_out_t4_38 + (-0.98695707321166992) * gru_0_out_t4_39 + (-0.046613708138465881) * gru_0_out_t4_40 + (0.092703647911548615) * gru_0_out_t4_41 + (-0.10834440588951111) * gru_0_out_t4_42 + (-0.136924147605896) * gru_0_out_t4_43 + (-0.69988292455673218) * gru_0_out_t4_44 + (0.078827075660228729) * gru_0_out_t4_45 + (-0.66135859489440918) * gru_0_out_t4_46 + (-0.39453041553497314) * gru_0_out_t4_47 + (0.52347451448440552) * gru_0_out_t4_48 + (-0.43252164125442505) * gru_0_out_t4_49 + (0.4888511598110199) * gru_0_out_t4_50 + (0.15185999870300293) * gru_0_out_t4_51 + (0.39450916647911072) * gru_0_out_t4_52 + (0.64434957504272461) * gru_0_out_t4_53 + (1.4324482679367065) * gru_0_out_t4_54 + (-1.4638803005218506) * gru_0_out_t4_55 + (-0.24163506925106049) * gru_0_out_t4_56 + (0.20733650028705597) * gru_0_out_t4_57 + (0.051474880427122116) * gru_0_out_t4_58 + (-0.01142557617276907) * gru_0_out_t4_59 + (0.91145944595336914) * gru_0_out_t4_60 + (0.5920223593711853) * gru_0_out_t4_61 + (1.0308057069778442) * gru_0_out_t4_62 + (-0.0062385816127061844) * gru_0_out_t4_63 + gate_r * ((-0.35027316212654114) + (-1.4193401336669922) * gru_1_fwd_t3_h_0 + (-0.46640273928642273) * gru_1_fwd_t3_h_1 + (0.078222706913948059) * gru_1_fwd_t3_h_2 + (-0.46454206109046936) * gru_1_fwd_t3_h_3 + (0.5499495267868042) * gru_1_fwd_t3_h_4 + (0.64025551080703735) * gru_1_fwd_t3_h_5 + (-1.1813725233078003) * gru_1_fwd_t3_h_6 + (-0.2666352391242981) * gru_1_fwd_t3_h_7 + (-0.22054161131381989) * gru_1_fwd_t3_h_8 + (0.7341960072517395) * gru_1_fwd_t3_h_9 + (-0.12650138139724731) * gru_1_fwd_t3_h_10 + (0.54635626077651978) * gru_1_fwd_t3_h_11 + (0.10001052916049957) * gru_1_fwd_t3_h_12 + (0.027572464197874069) * gru_1_fwd_t3_h_13 + (-1.1973471641540527) * gru_1_fwd_t3_h_14 + (-0.12909846007823944) * gru_1_fwd_t3_h_15 + (-0.012160650454461575) * gru_1_fwd_t3_h_16 + (0.60037904977798462) * gru_1_fwd_t3_h_17 + (-0.63369292020797729) * gru_1_fwd_t3_h_18 + (-0.80045747756958008) * gru_1_fwd_t3_h_19 + (0.2914033830165863) * gru_1_fwd_t3_h_20 + (0.16861151158809662) * gru_1_fwd_t3_h_21 + (-0.92693275213241577) * gru_1_fwd_t3_h_22 + (0.31253629922866821) * gru_1_fwd_t3_h_23 + (0.66055810451507568) * gru_1_fwd_t3_h_24 + (-0.10935722291469574) * gru_1_fwd_t3_h_25 + (-0.89687573909759521) * gru_1_fwd_t3_h_26 + (0.24638865888118744) * gru_1_fwd_t3_h_27 + (1.5749073028564453) * gru_1_fwd_t3_h_28 + (-0.57198172807693481) * gru_1_fwd_t3_h_29 + (-0.66686713695526123) * gru_1_fwd_t3_h_30 + (0.62695193290710449) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_22 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_22;
    // h=23
    gate_r = sigmoid((-0.37737375497817993) + (-0.79503357410430908) * gru_0_out_t4_0 + (0.068538494408130646) * gru_0_out_t4_1 + (0.20416095852851868) * gru_0_out_t4_2 + (-0.26548156142234802) * gru_0_out_t4_3 + (-0.70045971870422363) * gru_0_out_t4_4 + (0.77639025449752808) * gru_0_out_t4_5 + (0.13428539037704468) * gru_0_out_t4_6 + (0.2342989593744278) * gru_0_out_t4_7 + (-0.17787046730518341) * gru_0_out_t4_8 + (-0.47323006391525269) * gru_0_out_t4_9 + (-1.2252817153930664) * gru_0_out_t4_10 + (0.14471831917762756) * gru_0_out_t4_11 + (-0.19823853671550751) * gru_0_out_t4_12 + (-0.77416467666625977) * gru_0_out_t4_13 + (0.21379135549068451) * gru_0_out_t4_14 + (0.96714437007904053) * gru_0_out_t4_15 + (0.26352331042289734) * gru_0_out_t4_16 + (-0.22273299098014832) * gru_0_out_t4_17 + (-0.28035879135131836) * gru_0_out_t4_18 + (1.2696213722229004) * gru_0_out_t4_19 + (-0.0061995214782655239) * gru_0_out_t4_20 + (0.75150167942047119) * gru_0_out_t4_21 + (-0.034218180924654007) * gru_0_out_t4_22 + (0.52240067720413208) * gru_0_out_t4_23 + (-0.91591286659240723) * gru_0_out_t4_24 + (-1.176419734954834) * gru_0_out_t4_25 + (0.85171782970428467) * gru_0_out_t4_26 + (1.2482680082321167) * gru_0_out_t4_27 + (-0.11940784007310867) * gru_0_out_t4_28 + (-0.39296808838844299) * gru_0_out_t4_29 + (-0.18432345986366272) * gru_0_out_t4_30 + (0.76933199167251587) * gru_0_out_t4_31 + (-0.083392210304737091) * gru_0_out_t4_32 + (3.0442266464233398) * gru_0_out_t4_33 + (0.082386456429958344) * gru_0_out_t4_34 + (0.057291429489850998) * gru_0_out_t4_35 + (0.34498786926269531) * gru_0_out_t4_36 + (0.18979761004447937) * gru_0_out_t4_37 + (-2.6722040176391602) * gru_0_out_t4_38 + (0.89488029479980469) * gru_0_out_t4_39 + (-0.26715415716171265) * gru_0_out_t4_40 + (0.49999827146530151) * gru_0_out_t4_41 + (-0.57614648342132568) * gru_0_out_t4_42 + (0.28703239560127258) * gru_0_out_t4_43 + (0.060748394578695297) * gru_0_out_t4_44 + (-0.44752448797225952) * gru_0_out_t4_45 + (1.926239013671875) * gru_0_out_t4_46 + (-0.45975783467292786) * gru_0_out_t4_47 + (-0.48401820659637451) * gru_0_out_t4_48 + (0.97299635410308838) * gru_0_out_t4_49 + (-0.20765344798564911) * gru_0_out_t4_50 + (0.038622204214334488) * gru_0_out_t4_51 + (-3.3229861259460449) * gru_0_out_t4_52 + (0.41831788420677185) * gru_0_out_t4_53 + (0.21645171940326691) * gru_0_out_t4_54 + (-1.606818675994873) * gru_0_out_t4_55 + (-0.43441274762153625) * gru_0_out_t4_56 + (0.40787917375564575) * gru_0_out_t4_57 + (-0.37236413359642029) * gru_0_out_t4_58 + (-0.87850737571716309) * gru_0_out_t4_59 + (-0.54532349109649658) * gru_0_out_t4_60 + (-0.47573274374008179) * gru_0_out_t4_61 + (-0.069479554891586304) * gru_0_out_t4_62 + (1.3320877552032471) * gru_0_out_t4_63 + (-0.22558419406414032) * gru_1_fwd_t3_h_0 + (0.69185453653335571) * gru_1_fwd_t3_h_1 + (0.079887442290782928) * gru_1_fwd_t3_h_2 + (0.056931454688310623) * gru_1_fwd_t3_h_3 + (1.0718625783920288) * gru_1_fwd_t3_h_4 + (-0.20790429413318634) * gru_1_fwd_t3_h_5 + (0.21381668746471405) * gru_1_fwd_t3_h_6 + (0.19933830201625824) * gru_1_fwd_t3_h_7 + (-0.99202573299407959) * gru_1_fwd_t3_h_8 + (0.4927636981010437) * gru_1_fwd_t3_h_9 + (0.26296001672744751) * gru_1_fwd_t3_h_10 + (0.00016545277321711183) * gru_1_fwd_t3_h_11 + (-0.10316966474056244) * gru_1_fwd_t3_h_12 + (-0.1180804967880249) * gru_1_fwd_t3_h_13 + (1.4954652786254883) * gru_1_fwd_t3_h_14 + (0.31283754110336304) * gru_1_fwd_t3_h_15 + (0.85124635696411133) * gru_1_fwd_t3_h_16 + (0.043368775397539139) * gru_1_fwd_t3_h_17 + (1.4958066940307617) * gru_1_fwd_t3_h_18 + (-0.16446287930011749) * gru_1_fwd_t3_h_19 + (-0.05331028625369072) * gru_1_fwd_t3_h_20 + (0.29236409068107605) * gru_1_fwd_t3_h_21 + (0.80650436878204346) * gru_1_fwd_t3_h_22 + (0.38654071092605591) * gru_1_fwd_t3_h_23 + (1.4080207347869873) * gru_1_fwd_t3_h_24 + (0.15401634573936462) * gru_1_fwd_t3_h_25 + (-1.9987717866897583) * gru_1_fwd_t3_h_26 + (0.73389369249343872) * gru_1_fwd_t3_h_27 + (-0.10106315463781357) * gru_1_fwd_t3_h_28 + (1.9111822843551636) * gru_1_fwd_t3_h_29 + (-0.52861112356185913) * gru_1_fwd_t3_h_30 + (-0.91695904731750488) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((0.45544227957725525) + (-0.39899855852127075) * gru_0_out_t4_0 + (-0.48115536570549011) * gru_0_out_t4_1 + (0.90719711780548096) * gru_0_out_t4_2 + (0.27937033772468567) * gru_0_out_t4_3 + (0.14508701860904694) * gru_0_out_t4_4 + (0.26283589005470276) * gru_0_out_t4_5 + (-0.60269701480865479) * gru_0_out_t4_6 + (0.037988651543855667) * gru_0_out_t4_7 + (0.39225947856903076) * gru_0_out_t4_8 + (-0.28212738037109375) * gru_0_out_t4_9 + (0.35572734475135803) * gru_0_out_t4_10 + (-0.14603516459465027) * gru_0_out_t4_11 + (0.10748191922903061) * gru_0_out_t4_12 + (0.10269225388765335) * gru_0_out_t4_13 + (-0.36092615127563477) * gru_0_out_t4_14 + (-0.098021067678928375) * gru_0_out_t4_15 + (0.14099012315273285) * gru_0_out_t4_16 + (-0.17394551634788513) * gru_0_out_t4_17 + (-0.20500774681568146) * gru_0_out_t4_18 + (-0.31262242794036865) * gru_0_out_t4_19 + (0.33173412084579468) * gru_0_out_t4_20 + (-0.86121088266372681) * gru_0_out_t4_21 + (0.12776444852352142) * gru_0_out_t4_22 + (-0.49597838521003723) * gru_0_out_t4_23 + (-2.045438289642334) * gru_0_out_t4_24 + (-1.3676438331604004) * gru_0_out_t4_25 + (0.1861143559217453) * gru_0_out_t4_26 + (0.63738226890563965) * gru_0_out_t4_27 + (-0.68421661853790283) * gru_0_out_t4_28 + (-0.13278044760227203) * gru_0_out_t4_29 + (1.1435256004333496) * gru_0_out_t4_30 + (0.27671867609024048) * gru_0_out_t4_31 + (0.33940234780311584) * gru_0_out_t4_32 + (0.31611856818199158) * gru_0_out_t4_33 + (0.62803435325622559) * gru_0_out_t4_34 + (-0.41935685276985168) * gru_0_out_t4_35 + (0.11273257434368134) * gru_0_out_t4_36 + (-0.19025450944900513) * gru_0_out_t4_37 + (0.29654133319854736) * gru_0_out_t4_38 + (0.68210971355438232) * gru_0_out_t4_39 + (0.10617898404598236) * gru_0_out_t4_40 + (-0.23240180313587189) * gru_0_out_t4_41 + (0.17919887602329254) * gru_0_out_t4_42 + (-0.12985126674175262) * gru_0_out_t4_43 + (0.24262621998786926) * gru_0_out_t4_44 + (0.011309117078781128) * gru_0_out_t4_45 + (-0.39774432778358459) * gru_0_out_t4_46 + (-0.74535369873046875) * gru_0_out_t4_47 + (-0.065180718898773193) * gru_0_out_t4_48 + (-0.36947664618492126) * gru_0_out_t4_49 + (0.66724401712417603) * gru_0_out_t4_50 + (0.18067219853401184) * gru_0_out_t4_51 + (-0.44212111830711365) * gru_0_out_t4_52 + (0.044253259897232056) * gru_0_out_t4_53 + (-0.031454134732484818) * gru_0_out_t4_54 + (-0.12599039077758789) * gru_0_out_t4_55 + (0.36419066786766052) * gru_0_out_t4_56 + (-0.022863099351525307) * gru_0_out_t4_57 + (-0.48885723948478699) * gru_0_out_t4_58 + (-0.12259184569120407) * gru_0_out_t4_59 + (0.93494224548339844) * gru_0_out_t4_60 + (0.21224284172058105) * gru_0_out_t4_61 + (-0.1794813871383667) * gru_0_out_t4_62 + (-1.4116814136505127) * gru_0_out_t4_63 + (0.33855846524238586) * gru_1_fwd_t3_h_0 + (0.33340916037559509) * gru_1_fwd_t3_h_1 + (0.25691697001457214) * gru_1_fwd_t3_h_2 + (-0.088857978582382202) * gru_1_fwd_t3_h_3 + (-0.50371259450912476) * gru_1_fwd_t3_h_4 + (0.27996665239334106) * gru_1_fwd_t3_h_5 + (0.021345930173993111) * gru_1_fwd_t3_h_6 + (0.21396076679229736) * gru_1_fwd_t3_h_7 + (0.26442518830299377) * gru_1_fwd_t3_h_8 + (-0.45566862821578979) * gru_1_fwd_t3_h_9 + (-0.32641083002090454) * gru_1_fwd_t3_h_10 + (-0.35645607113838196) * gru_1_fwd_t3_h_11 + (0.1318848580121994) * gru_1_fwd_t3_h_12 + (-0.032120939344167709) * gru_1_fwd_t3_h_13 + (0.27831482887268066) * gru_1_fwd_t3_h_14 + (0.25805753469467163) * gru_1_fwd_t3_h_15 + (-0.043106522411108017) * gru_1_fwd_t3_h_16 + (-0.33511468768119812) * gru_1_fwd_t3_h_17 + (0.0158672034740448) * gru_1_fwd_t3_h_18 + (0.12873886525630951) * gru_1_fwd_t3_h_19 + (0.2443963885307312) * gru_1_fwd_t3_h_20 + (-0.27350205183029175) * gru_1_fwd_t3_h_21 + (-0.035453695803880692) * gru_1_fwd_t3_h_22 + (1.0342872142791748) * gru_1_fwd_t3_h_23 + (0.53374177217483521) * gru_1_fwd_t3_h_24 + (0.15318283438682556) * gru_1_fwd_t3_h_25 + (-0.15730394423007965) * gru_1_fwd_t3_h_26 + (0.095434121787548065) * gru_1_fwd_t3_h_27 + (-0.68715572357177734) * gru_1_fwd_t3_h_28 + (-0.083020403981208801) * gru_1_fwd_t3_h_29 + (-0.015377921983599663) * gru_1_fwd_t3_h_30 + (0.5191536545753479) * gru_1_fwd_t3_h_31);
    gate_n = tanh((-0.12708337604999542) + (-0.3775753378868103) * gru_0_out_t4_0 + (0.071000121533870697) * gru_0_out_t4_1 + (-0.17115998268127441) * gru_0_out_t4_2 + (-0.027634432539343834) * gru_0_out_t4_3 + (1.9491946697235107) * gru_0_out_t4_4 + (0.33124926686286926) * gru_0_out_t4_5 + (0.10106968134641647) * gru_0_out_t4_6 + (0.47922497987747192) * gru_0_out_t4_7 + (0.24611705541610718) * gru_0_out_t4_8 + (0.70045185089111328) * gru_0_out_t4_9 + (-0.75680041313171387) * gru_0_out_t4_10 + (0.41613885760307312) * gru_0_out_t4_11 + (-0.23472994565963745) * gru_0_out_t4_12 + (0.23338544368743896) * gru_0_out_t4_13 + (-0.13358327746391296) * gru_0_out_t4_14 + (0.33610391616821289) * gru_0_out_t4_15 + (-0.38329371809959412) * gru_0_out_t4_16 + (0.076051756739616394) * gru_0_out_t4_17 + (-0.1995847076177597) * gru_0_out_t4_18 + (-0.84019213914871216) * gru_0_out_t4_19 + (0.45215386152267456) * gru_0_out_t4_20 + (-0.19130167365074158) * gru_0_out_t4_21 + (0.22812074422836304) * gru_0_out_t4_22 + (0.20229272544384003) * gru_0_out_t4_23 + (-1.1922892332077026) * gru_0_out_t4_24 + (0.50652492046356201) * gru_0_out_t4_25 + (0.30163002014160156) * gru_0_out_t4_26 + (0.060001920908689499) * gru_0_out_t4_27 + (1.2401506900787354) * gru_0_out_t4_28 + (-0.15144385397434235) * gru_0_out_t4_29 + (-0.41856268048286438) * gru_0_out_t4_30 + (0.85530644655227661) * gru_0_out_t4_31 + (0.054100662469863892) * gru_0_out_t4_32 + (0.61326122283935547) * gru_0_out_t4_33 + (0.02422199584543705) * gru_0_out_t4_34 + (-0.26219069957733154) * gru_0_out_t4_35 + (-0.20073725283145905) * gru_0_out_t4_36 + (-0.045202244073152542) * gru_0_out_t4_37 + (0.077366091310977936) * gru_0_out_t4_38 + (0.12203789502382278) * gru_0_out_t4_39 + (-0.080158956348896027) * gru_0_out_t4_40 + (0.36362916231155396) * gru_0_out_t4_41 + (1.3904612064361572) * gru_0_out_t4_42 + (-0.49838230013847351) * gru_0_out_t4_43 + (-0.13585658371448517) * gru_0_out_t4_44 + (-0.31171712279319763) * gru_0_out_t4_45 + (0.1360081285238266) * gru_0_out_t4_46 + (-0.046464815735816956) * gru_0_out_t4_47 + (-0.35809218883514404) * gru_0_out_t4_48 + (0.10360386967658997) * gru_0_out_t4_49 + (0.18613453209400177) * gru_0_out_t4_50 + (0.84443825483322144) * gru_0_out_t4_51 + (-0.087376691401004791) * gru_0_out_t4_52 + (-0.1009569987654686) * gru_0_out_t4_53 + (0.40546774864196777) * gru_0_out_t4_54 + (0.31482881307601929) * gru_0_out_t4_55 + (0.47466245293617249) * gru_0_out_t4_56 + (0.99652975797653198) * gru_0_out_t4_57 + (2.2593605518341064) * gru_0_out_t4_58 + (0.45841583609580994) * gru_0_out_t4_59 + (-0.75548893213272095) * gru_0_out_t4_60 + (-0.034613218158483505) * gru_0_out_t4_61 + (-0.38672104477882385) * gru_0_out_t4_62 + (0.31936001777648926) * gru_0_out_t4_63 + gate_r * ((-0.18739134073257446) + (-0.9760444164276123) * gru_1_fwd_t3_h_0 + (0.06566377729177475) * gru_1_fwd_t3_h_1 + (-0.69682967662811279) * gru_1_fwd_t3_h_2 + (0.67474645376205444) * gru_1_fwd_t3_h_3 + (-0.12590846419334412) * gru_1_fwd_t3_h_4 + (2.7951047420501709) * gru_1_fwd_t3_h_5 + (-2.4594869613647461) * gru_1_fwd_t3_h_6 + (0.18574291467666626) * gru_1_fwd_t3_h_7 + (0.67748141288757324) * gru_1_fwd_t3_h_8 + (0.88543069362640381) * gru_1_fwd_t3_h_9 + (-0.28565296530723572) * gru_1_fwd_t3_h_10 + (0.37619304656982422) * gru_1_fwd_t3_h_11 + (1.3425275087356567) * gru_1_fwd_t3_h_12 + (0.19111302495002747) * gru_1_fwd_t3_h_13 + (0.8162960410118103) * gru_1_fwd_t3_h_14 + (1.1571131944656372) * gru_1_fwd_t3_h_15 + (0.73377668857574463) * gru_1_fwd_t3_h_16 + (-0.38701635599136353) * gru_1_fwd_t3_h_17 + (-0.68871545791625977) * gru_1_fwd_t3_h_18 + (0.86174392700195312) * gru_1_fwd_t3_h_19 + (-0.268048495054245) * gru_1_fwd_t3_h_20 + (0.80881321430206299) * gru_1_fwd_t3_h_21 + (-0.36324295401573181) * gru_1_fwd_t3_h_22 + (-1.3227510452270508) * gru_1_fwd_t3_h_23 + (1.5481479167938232) * gru_1_fwd_t3_h_24 + (1.3994145393371582) * gru_1_fwd_t3_h_25 + (1.2413047552108765) * gru_1_fwd_t3_h_26 + (-0.13214625418186188) * gru_1_fwd_t3_h_27 + (1.0640256404876709) * gru_1_fwd_t3_h_28 + (-0.093985691666603088) * gru_1_fwd_t3_h_29 + (0.66725242137908936) * gru_1_fwd_t3_h_30 + (-1.7524372339248657) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_23 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_23;
    // h=24
    gate_r = sigmoid((-0.42758944630622864) + (0.12086772173643112) * gru_0_out_t4_0 + (0.62144660949707031) * gru_0_out_t4_1 + (-0.48935985565185547) * gru_0_out_t4_2 + (0.82100313901901245) * gru_0_out_t4_3 + (0.58317899703979492) * gru_0_out_t4_4 + (-0.037164997309446335) * gru_0_out_t4_5 + (0.83828717470169067) * gru_0_out_t4_6 + (3.6263875961303711) * gru_0_out_t4_7 + (-0.11508907377719879) * gru_0_out_t4_8 + (0.69054818153381348) * gru_0_out_t4_9 + (1.4990606307983398) * gru_0_out_t4_10 + (-0.38191047310829163) * gru_0_out_t4_11 + (-0.15011025965213776) * gru_0_out_t4_12 + (0.16466595232486725) * gru_0_out_t4_13 + (-1.1594454050064087) * gru_0_out_t4_14 + (-0.34800395369529724) * gru_0_out_t4_15 + (-0.20061704516410828) * gru_0_out_t4_16 + (0.65713697671890259) * gru_0_out_t4_17 + (0.16145654022693634) * gru_0_out_t4_18 + (-0.86239135265350342) * gru_0_out_t4_19 + (-0.95374882221221924) * gru_0_out_t4_20 + (-0.205863356590271) * gru_0_out_t4_21 + (0.11541922390460968) * gru_0_out_t4_22 + (-0.21241161227226257) * gru_0_out_t4_23 + (1.3760771751403809) * gru_0_out_t4_24 + (1.1482911109924316) * gru_0_out_t4_25 + (0.7347751259803772) * gru_0_out_t4_26 + (-0.70580005645751953) * gru_0_out_t4_27 + (-3.0640332698822021) * gru_0_out_t4_28 + (1.1274573802947998) * gru_0_out_t4_29 + (-0.19769212603569031) * gru_0_out_t4_30 + (-0.18449895083904266) * gru_0_out_t4_31 + (1.2661093473434448) * gru_0_out_t4_32 + (-0.95003730058670044) * gru_0_out_t4_33 + (-0.06093200296163559) * gru_0_out_t4_34 + (0.097939915955066681) * gru_0_out_t4_35 + (-0.079813390970230103) * gru_0_out_t4_36 + (-0.13495349884033203) * gru_0_out_t4_37 + (0.050990164279937744) * gru_0_out_t4_38 + (-0.88927257061004639) * gru_0_out_t4_39 + (0.65421175956726074) * gru_0_out_t4_40 + (-0.018331075087189674) * gru_0_out_t4_41 + (-3.0811080932617188) * gru_0_out_t4_42 + (0.051750306040048599) * gru_0_out_t4_43 + (-0.39471191167831421) * gru_0_out_t4_44 + (0.10638084262609482) * gru_0_out_t4_45 + (1.1174187660217285) * gru_0_out_t4_46 + (-0.31018084287643433) * gru_0_out_t4_47 + (0.13067001104354858) * gru_0_out_t4_48 + (0.36544689536094666) * gru_0_out_t4_49 + (0.70908272266387939) * gru_0_out_t4_50 + (-0.016749322414398193) * gru_0_out_t4_51 + (-0.31273907423019409) * gru_0_out_t4_52 + (-1.5906529426574707) * gru_0_out_t4_53 + (2.4757986068725586) * gru_0_out_t4_54 + (1.9600518941879272) * gru_0_out_t4_55 + (-1.0278855562210083) * gru_0_out_t4_56 + (-0.12055318802595139) * gru_0_out_t4_57 + (-0.076821371912956238) * gru_0_out_t4_58 + (1.0920866727828979) * gru_0_out_t4_59 + (0.069194577634334564) * gru_0_out_t4_60 + (0.040167413651943207) * gru_0_out_t4_61 + (0.3773486316204071) * gru_0_out_t4_62 + (-1.1114168167114258) * gru_0_out_t4_63 + (-0.24208344519138336) * gru_1_fwd_t3_h_0 + (-0.24073134362697601) * gru_1_fwd_t3_h_1 + (-0.1428060382604599) * gru_1_fwd_t3_h_2 + (0.0089311953634023666) * gru_1_fwd_t3_h_3 + (-0.23874388635158539) * gru_1_fwd_t3_h_4 + (-0.054213043302297592) * gru_1_fwd_t3_h_5 + (1.7490541934967041) * gru_1_fwd_t3_h_6 + (-0.73903536796569824) * gru_1_fwd_t3_h_7 + (0.48096740245819092) * gru_1_fwd_t3_h_8 + (-1.2369050979614258) * gru_1_fwd_t3_h_9 + (-0.5758967399597168) * gru_1_fwd_t3_h_10 + (0.70241433382034302) * gru_1_fwd_t3_h_11 + (-0.18149466812610626) * gru_1_fwd_t3_h_12 + (2.2021093368530273) * gru_1_fwd_t3_h_13 + (-0.47695502638816833) * gru_1_fwd_t3_h_14 + (0.93204718828201294) * gru_1_fwd_t3_h_15 + (0.59389299154281616) * gru_1_fwd_t3_h_16 + (0.38335880637168884) * gru_1_fwd_t3_h_17 + (1.0328997373580933) * gru_1_fwd_t3_h_18 + (-1.9945676326751709) * gru_1_fwd_t3_h_19 + (-0.52833348512649536) * gru_1_fwd_t3_h_20 + (1.1750813722610474) * gru_1_fwd_t3_h_21 + (-0.81881839036941528) * gru_1_fwd_t3_h_22 + (-2.2842061519622803) * gru_1_fwd_t3_h_23 + (0.012994259595870972) * gru_1_fwd_t3_h_24 + (-0.10590313374996185) * gru_1_fwd_t3_h_25 + (1.2527496814727783) * gru_1_fwd_t3_h_26 + (-0.7362746000289917) * gru_1_fwd_t3_h_27 + (-0.93378257751464844) * gru_1_fwd_t3_h_28 + (-0.86448389291763306) * gru_1_fwd_t3_h_29 + (0.98721224069595337) * gru_1_fwd_t3_h_30 + (-0.38127896189689636) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((1.1156911849975586) + (0.2067362517118454) * gru_0_out_t4_0 + (0.45901015400886536) * gru_0_out_t4_1 + (0.16873574256896973) * gru_0_out_t4_2 + (0.040558263659477234) * gru_0_out_t4_3 + (0.36925461888313293) * gru_0_out_t4_4 + (-0.75656312704086304) * gru_0_out_t4_5 + (-0.49349683523178101) * gru_0_out_t4_6 + (-1.7207624912261963) * gru_0_out_t4_7 + (0.040076028555631638) * gru_0_out_t4_8 + (1.6206469535827637) * gru_0_out_t4_9 + (0.099422045052051544) * gru_0_out_t4_10 + (0.28604069352149963) * gru_0_out_t4_11 + (0.13634529709815979) * gru_0_out_t4_12 + (-0.29863083362579346) * gru_0_out_t4_13 + (0.22858324646949768) * gru_0_out_t4_14 + (0.032321449369192123) * gru_0_out_t4_15 + (-0.2906852662563324) * gru_0_out_t4_16 + (-1.0008165836334229) * gru_0_out_t4_17 + (0.16583551466464996) * gru_0_out_t4_18 + (0.15338918566703796) * gru_0_out_t4_19 + (2.3819572925567627) * gru_0_out_t4_20 + (-0.16571304202079773) * gru_0_out_t4_21 + (-0.8238835334777832) * gru_0_out_t4_22 + (0.22420667111873627) * gru_0_out_t4_23 + (-1.5137735605239868) * gru_0_out_t4_24 + (-0.46699687838554382) * gru_0_out_t4_25 + (-4.1895208358764648) * gru_0_out_t4_26 + (-0.3666473925113678) * gru_0_out_t4_27 + (-0.12122910469770432) * gru_0_out_t4_28 + (0.71206539869308472) * gru_0_out_t4_29 + (0.86293983459472656) * gru_0_out_t4_30 + (0.56048786640167236) * gru_0_out_t4_31 + (1.6777205467224121) * gru_0_out_t4_32 + (0.1641516387462616) * gru_0_out_t4_33 + (-0.065599530935287476) * gru_0_out_t4_34 + (0.27819746732711792) * gru_0_out_t4_35 + (-0.12058231979608536) * gru_0_out_t4_36 + (0.10296791046857834) * gru_0_out_t4_37 + (-0.28723397850990295) * gru_0_out_t4_38 + (1.5552459955215454) * gru_0_out_t4_39 + (-2.9317526817321777) * gru_0_out_t4_40 + (-0.049384173005819321) * gru_0_out_t4_41 + (1.6772211790084839) * gru_0_out_t4_42 + (0.040334638208150864) * gru_0_out_t4_43 + (-0.15124237537384033) * gru_0_out_t4_44 + (0.017531076446175575) * gru_0_out_t4_45 + (0.63452231884002686) * gru_0_out_t4_46 + (-0.98695510625839233) * gru_0_out_t4_47 + (0.12054946273565292) * gru_0_out_t4_48 + (-0.17302136123180389) * gru_0_out_t4_49 + (-0.24665583670139313) * gru_0_out_t4_50 + (-0.11118730157613754) * gru_0_out_t4_51 + (0.018669627606868744) * gru_0_out_t4_52 + (0.33077138662338257) * gru_0_out_t4_53 + (-1.2292557954788208) * gru_0_out_t4_54 + (-0.030067063868045807) * gru_0_out_t4_55 + (-1.0358577966690063) * gru_0_out_t4_56 + (-0.23500505089759827) * gru_0_out_t4_57 + (0.62989252805709839) * gru_0_out_t4_58 + (0.2566676139831543) * gru_0_out_t4_59 + (0.19906796514987946) * gru_0_out_t4_60 + (0.24773694574832916) * gru_0_out_t4_61 + (-0.12312977015972137) * gru_0_out_t4_62 + (-0.43776637315750122) * gru_0_out_t4_63 + (0.48242917656898499) * gru_1_fwd_t3_h_0 + (-0.97838449478149414) * gru_1_fwd_t3_h_1 + (0.2489217072725296) * gru_1_fwd_t3_h_2 + (0.068997018039226532) * gru_1_fwd_t3_h_3 + (-0.16308574378490448) * gru_1_fwd_t3_h_4 + (1.4264696836471558) * gru_1_fwd_t3_h_5 + (-0.8929142951965332) * gru_1_fwd_t3_h_6 + (-0.28379344940185547) * gru_1_fwd_t3_h_7 + (-0.073374234139919281) * gru_1_fwd_t3_h_8 + (0.013847000896930695) * gru_1_fwd_t3_h_9 + (0.058372940868139267) * gru_1_fwd_t3_h_10 + (0.25810223817825317) * gru_1_fwd_t3_h_11 + (0.12700542807579041) * gru_1_fwd_t3_h_12 + (0.3059687614440918) * gru_1_fwd_t3_h_13 + (-0.37692174315452576) * gru_1_fwd_t3_h_14 + (0.63697117567062378) * gru_1_fwd_t3_h_15 + (-0.18778844177722931) * gru_1_fwd_t3_h_16 + (-0.81331616640090942) * gru_1_fwd_t3_h_17 + (0.45402747392654419) * gru_1_fwd_t3_h_18 + (-0.88660067319869995) * gru_1_fwd_t3_h_19 + (-0.052612617611885071) * gru_1_fwd_t3_h_20 + (0.14876019954681396) * gru_1_fwd_t3_h_21 + (-0.53237664699554443) * gru_1_fwd_t3_h_22 + (-1.1151003837585449) * gru_1_fwd_t3_h_23 + (-0.82767593860626221) * gru_1_fwd_t3_h_24 + (0.32392951846122742) * gru_1_fwd_t3_h_25 + (0.12181582301855087) * gru_1_fwd_t3_h_26 + (0.19431865215301514) * gru_1_fwd_t3_h_27 + (0.27386400103569031) * gru_1_fwd_t3_h_28 + (-0.17857563495635986) * gru_1_fwd_t3_h_29 + (1.4011279344558716) * gru_1_fwd_t3_h_30 + (0.28979033231735229) * gru_1_fwd_t3_h_31);
    gate_n = tanh((0.099766649305820465) + (0.79422277212142944) * gru_0_out_t4_0 + (-0.13146984577178955) * gru_0_out_t4_1 + (0.68063259124755859) * gru_0_out_t4_2 + (-1.4121799468994141) * gru_0_out_t4_3 + (-0.20353361964225769) * gru_0_out_t4_4 + (-1.9995404481887817) * gru_0_out_t4_5 + (0.99538254737854004) * gru_0_out_t4_6 + (-2.3008580207824707) * gru_0_out_t4_7 + (-0.27305147051811218) * gru_0_out_t4_8 + (0.53454345464706421) * gru_0_out_t4_9 + (-0.20906434953212738) * gru_0_out_t4_10 + (0.17557224631309509) * gru_0_out_t4_11 + (-0.0078884139657020569) * gru_0_out_t4_12 + (0.70538461208343506) * gru_0_out_t4_13 + (0.20952446758747101) * gru_0_out_t4_14 + (0.041410204023122787) * gru_0_out_t4_15 + (0.13891369104385376) * gru_0_out_t4_16 + (-0.73623198270797729) * gru_0_out_t4_17 + (-0.19460342824459076) * gru_0_out_t4_18 + (0.98889803886413574) * gru_0_out_t4_19 + (-1.9283545017242432) * gru_0_out_t4_20 + (-0.35630026459693909) * gru_0_out_t4_21 + (1.2524850368499756) * gru_0_out_t4_22 + (1.029994010925293) * gru_0_out_t4_23 + (-0.0016773607349023223) * gru_0_out_t4_24 + (0.1536717414855957) * gru_0_out_t4_25 + (-3.1089491844177246) * gru_0_out_t4_26 + (-0.093742832541465759) * gru_0_out_t4_27 + (1.5900143384933472) * gru_0_out_t4_28 + (-0.4670257568359375) * gru_0_out_t4_29 + (0.19406507909297943) * gru_0_out_t4_30 + (0.4946863055229187) * gru_0_out_t4_31 + (-0.068529583513736725) * gru_0_out_t4_32 + (-0.052060294896364212) * gru_0_out_t4_33 + (0.05117681622505188) * gru_0_out_t4_34 + (-0.020836209878325462) * gru_0_out_t4_35 + (0.0073959198780357838) * gru_0_out_t4_36 + (0.08229856938123703) * gru_0_out_t4_37 + (-0.35446077585220337) * gru_0_out_t4_38 + (-1.4802600145339966) * gru_0_out_t4_39 + (-0.086178183555603027) * gru_0_out_t4_40 + (0.044513918459415436) * gru_0_out_t4_41 + (-0.62879770994186401) * gru_0_out_t4_42 + (-0.059979565441608429) * gru_0_out_t4_43 + (-0.29184356331825256) * gru_0_out_t4_44 + (-0.010597847402095795) * gru_0_out_t4_45 + (-1.3601990938186646) * gru_0_out_t4_46 + (0.19431939721107483) * gru_0_out_t4_47 + (0.32661902904510498) * gru_0_out_t4_48 + (-0.1624201238155365) * gru_0_out_t4_49 + (-0.14355216920375824) * gru_0_out_t4_50 + (-0.69916337728500366) * gru_0_out_t4_51 + (0.22632761299610138) * gru_0_out_t4_52 + (0.030855134129524231) * gru_0_out_t4_53 + (-1.4554181098937988) * gru_0_out_t4_54 + (-0.23731909692287445) * gru_0_out_t4_55 + (-0.6211739182472229) * gru_0_out_t4_56 + (0.35931473970413208) * gru_0_out_t4_57 + (-0.13164091110229492) * gru_0_out_t4_58 + (1.1322357654571533) * gru_0_out_t4_59 + (0.24162067472934723) * gru_0_out_t4_60 + (0.027392243966460228) * gru_0_out_t4_61 + (0.27378550171852112) * gru_0_out_t4_62 + (0.28950351476669312) * gru_0_out_t4_63 + gate_r * ((0.67133527994155884) + (-0.54307109117507935) * gru_1_fwd_t3_h_0 + (-0.030634650960564613) * gru_1_fwd_t3_h_1 + (1.1986756324768066) * gru_1_fwd_t3_h_2 + (0.055342502892017365) * gru_1_fwd_t3_h_3 + (-0.15252111852169037) * gru_1_fwd_t3_h_4 + (-0.11533195525407791) * gru_1_fwd_t3_h_5 + (-0.47048330307006836) * gru_1_fwd_t3_h_6 + (-0.89376562833786011) * gru_1_fwd_t3_h_7 + (-0.19907191395759583) * gru_1_fwd_t3_h_8 + (-0.43490391969680786) * gru_1_fwd_t3_h_9 + (-0.74443268775939941) * gru_1_fwd_t3_h_10 + (-0.94426196813583374) * gru_1_fwd_t3_h_11 + (-0.27109059691429138) * gru_1_fwd_t3_h_12 + (0.2263442724943161) * gru_1_fwd_t3_h_13 + (-1.3278659582138062) * gru_1_fwd_t3_h_14 + (0.98372995853424072) * gru_1_fwd_t3_h_15 + (-0.20286515355110168) * gru_1_fwd_t3_h_16 + (-0.48449328541755676) * gru_1_fwd_t3_h_17 + (-0.39689072966575623) * gru_1_fwd_t3_h_18 + (1.1849886178970337) * gru_1_fwd_t3_h_19 + (-0.1632220447063446) * gru_1_fwd_t3_h_20 + (1.9962568283081055) * gru_1_fwd_t3_h_21 + (0.30892255902290344) * gru_1_fwd_t3_h_22 + (0.21853812038898468) * gru_1_fwd_t3_h_23 + (0.34960725903511047) * gru_1_fwd_t3_h_24 + (-0.52084469795227051) * gru_1_fwd_t3_h_25 + (0.021700959652662277) * gru_1_fwd_t3_h_26 + (1.0712031126022339) * gru_1_fwd_t3_h_27 + (-0.28299990296363831) * gru_1_fwd_t3_h_28 + (-0.68790632486343384) * gru_1_fwd_t3_h_29 + (1.8765798807144165) * gru_1_fwd_t3_h_30 + (0.62687420845031738) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_24 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_24;
    // h=25
    gate_r = sigmoid((0.14784069359302521) + (0.64793628454208374) * gru_0_out_t4_0 + (-0.34771654009819031) * gru_0_out_t4_1 + (-0.1077476367354393) * gru_0_out_t4_2 + (-1.3351753950119019) * gru_0_out_t4_3 + (0.54230111837387085) * gru_0_out_t4_4 + (-0.37961503863334656) * gru_0_out_t4_5 + (-1.4525712728500366) * gru_0_out_t4_6 + (-1.0458427667617798) * gru_0_out_t4_7 + (0.33517831563949585) * gru_0_out_t4_8 + (0.45465004444122314) * gru_0_out_t4_9 + (0.48269376158714294) * gru_0_out_t4_10 + (-0.84214550256729126) * gru_0_out_t4_11 + (-0.14486022293567657) * gru_0_out_t4_12 + (-0.55970525741577148) * gru_0_out_t4_13 + (0.34367987513542175) * gru_0_out_t4_14 + (-0.65948504209518433) * gru_0_out_t4_15 + (0.22284576296806335) * gru_0_out_t4_16 + (0.34964841604232788) * gru_0_out_t4_17 + (-0.2622896134853363) * gru_0_out_t4_18 + (1.9099991321563721) * gru_0_out_t4_19 + (0.80364990234375) * gru_0_out_t4_20 + (0.5130038857460022) * gru_0_out_t4_21 + (-0.54142594337463379) * gru_0_out_t4_22 + (-0.29513469338417053) * gru_0_out_t4_23 + (0.15972298383712769) * gru_0_out_t4_24 + (0.14560438692569733) * gru_0_out_t4_25 + (-0.15405340492725372) * gru_0_out_t4_26 + (0.047758512198925018) * gru_0_out_t4_27 + (1.252642035484314) * gru_0_out_t4_28 + (-0.39247065782546997) * gru_0_out_t4_29 + (-0.22103966772556305) * gru_0_out_t4_30 + (-0.40724647045135498) * gru_0_out_t4_31 + (-0.30491158366203308) * gru_0_out_t4_32 + (1.3470684289932251) * gru_0_out_t4_33 + (-2.0241944789886475) * gru_0_out_t4_34 + (0.13163977861404419) * gru_0_out_t4_35 + (-0.83819496631622314) * gru_0_out_t4_36 + (0.34586027264595032) * gru_0_out_t4_37 + (-1.1876521110534668) * gru_0_out_t4_38 + (0.99915981292724609) * gru_0_out_t4_39 + (-0.046838141977787018) * gru_0_out_t4_40 + (0.48856762051582336) * gru_0_out_t4_41 + (-2.0180153846740723) * gru_0_out_t4_42 + (-0.58891177177429199) * gru_0_out_t4_43 + (-0.23416215181350708) * gru_0_out_t4_44 + (-0.13047674298286438) * gru_0_out_t4_45 + (1.1867121458053589) * gru_0_out_t4_46 + (0.34221929311752319) * gru_0_out_t4_47 + (-0.52082628011703491) * gru_0_out_t4_48 + (0.34655129909515381) * gru_0_out_t4_49 + (-0.05729476734995842) * gru_0_out_t4_50 + (-1.3149265050888062) * gru_0_out_t4_51 + (-3.2103996276855469) * gru_0_out_t4_52 + (0.40847468376159668) * gru_0_out_t4_53 + (-0.37452656030654907) * gru_0_out_t4_54 + (-0.097612030804157257) * gru_0_out_t4_55 + (-0.5286109447479248) * gru_0_out_t4_56 + (0.24556656181812286) * gru_0_out_t4_57 + (-0.25311177968978882) * gru_0_out_t4_58 + (-0.42517393827438354) * gru_0_out_t4_59 + (-0.68144220113754272) * gru_0_out_t4_60 + (0.074595451354980469) * gru_0_out_t4_61 + (-0.54633671045303345) * gru_0_out_t4_62 + (2.4225177764892578) * gru_0_out_t4_63 + (0.15641732513904572) * gru_1_fwd_t3_h_0 + (0.74148523807525635) * gru_1_fwd_t3_h_1 + (-0.48388603329658508) * gru_1_fwd_t3_h_2 + (0.13604530692100525) * gru_1_fwd_t3_h_3 + (-0.1152515709400177) * gru_1_fwd_t3_h_4 + (-0.10808464139699936) * gru_1_fwd_t3_h_5 + (1.2408928871154785) * gru_1_fwd_t3_h_6 + (-0.19285210967063904) * gru_1_fwd_t3_h_7 + (0.31102627515792847) * gru_1_fwd_t3_h_8 + (0.45243814587593079) * gru_1_fwd_t3_h_9 + (-0.17910075187683105) * gru_1_fwd_t3_h_10 + (0.19186586141586304) * gru_1_fwd_t3_h_11 + (-0.0399915911257267) * gru_1_fwd_t3_h_12 + (-1.7821557521820068) * gru_1_fwd_t3_h_13 + (0.46693545579910278) * gru_1_fwd_t3_h_14 + (-0.014894533902406693) * gru_1_fwd_t3_h_15 + (0.008108614943921566) * gru_1_fwd_t3_h_16 + (-0.0026562465354800224) * gru_1_fwd_t3_h_17 + (-0.10477922111749649) * gru_1_fwd_t3_h_18 + (-0.12384292483329773) * gru_1_fwd_t3_h_19 + (-0.10854751616716385) * gru_1_fwd_t3_h_20 + (-1.11553955078125) * gru_1_fwd_t3_h_21 + (-0.58235716819763184) * gru_1_fwd_t3_h_22 + (-0.62650507688522339) * gru_1_fwd_t3_h_23 + (-1.1862962245941162) * gru_1_fwd_t3_h_24 + (0.26390752196311951) * gru_1_fwd_t3_h_25 + (0.91641604900360107) * gru_1_fwd_t3_h_26 + (-0.07503923773765564) * gru_1_fwd_t3_h_27 + (-0.13762123882770538) * gru_1_fwd_t3_h_28 + (-0.015423152595758438) * gru_1_fwd_t3_h_29 + (-0.91263562440872192) * gru_1_fwd_t3_h_30 + (-1.0171694755554199) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((-0.038963977247476578) + (0.26227423548698425) * gru_0_out_t4_0 + (-0.044254723936319351) * gru_0_out_t4_1 + (0.14953374862670898) * gru_0_out_t4_2 + (-0.085310317575931549) * gru_0_out_t4_3 + (-0.12765650451183319) * gru_0_out_t4_4 + (0.0038044764660298824) * gru_0_out_t4_5 + (-0.89216727018356323) * gru_0_out_t4_6 + (-1.4744287729263306) * gru_0_out_t4_7 + (0.06135641410946846) * gru_0_out_t4_8 + (0.076689273118972778) * gru_0_out_t4_9 + (-0.21587233245372772) * gru_0_out_t4_10 + (0.1863962709903717) * gru_0_out_t4_11 + (0.14475254714488983) * gru_0_out_t4_12 + (-0.34739425778388977) * gru_0_out_t4_13 + (0.020500931888818741) * gru_0_out_t4_14 + (0.062400579452514648) * gru_0_out_t4_15 + (-0.016422979533672333) * gru_0_out_t4_16 + (0.15034559369087219) * gru_0_out_t4_17 + (-0.021572383120656013) * gru_0_out_t4_18 + (1.6864110231399536) * gru_0_out_t4_19 + (0.3316500186920166) * gru_0_out_t4_20 + (0.21687550842761993) * gru_0_out_t4_21 + (-0.12529541552066803) * gru_0_out_t4_22 + (0.13238830864429474) * gru_0_out_t4_23 + (-0.4468996524810791) * gru_0_out_t4_24 + (-0.24838323891162872) * gru_0_out_t4_25 + (-0.083773508667945862) * gru_0_out_t4_26 + (0.035819485783576965) * gru_0_out_t4_27 + (-0.46202012896537781) * gru_0_out_t4_28 + (-1.127859354019165) * gru_0_out_t4_29 + (0.080040901899337769) * gru_0_out_t4_30 + (0.632362961769104) * gru_0_out_t4_31 + (-0.13813994824886322) * gru_0_out_t4_32 + (0.073160521686077118) * gru_0_out_t4_33 + (0.1619332879781723) * gru_0_out_t4_34 + (-0.010452740825712681) * gru_0_out_t4_35 + (0.19558590650558472) * gru_0_out_t4_36 + (0.088207222521305084) * gru_0_out_t4_37 + (-1.0314953327178955) * gru_0_out_t4_38 + (-0.069221466779708862) * gru_0_out_t4_39 + (-0.14552101492881775) * gru_0_out_t4_40 + (-0.17307686805725098) * gru_0_out_t4_41 + (0.042232789099216461) * gru_0_out_t4_42 + (0.11225001513957977) * gru_0_out_t4_43 + (0.15610048174858093) * gru_0_out_t4_44 + (-0.014081462286412716) * gru_0_out_t4_45 + (0.2135934978723526) * gru_0_out_t4_46 + (-0.053089141845703125) * gru_0_out_t4_47 + (0.11143424361944199) * gru_0_out_t4_48 + (-0.29267230629920959) * gru_0_out_t4_49 + (0.26094776391983032) * gru_0_out_t4_50 + (-0.25470837950706482) * gru_0_out_t4_51 + (-0.91952008008956909) * gru_0_out_t4_52 + (0.20079958438873291) * gru_0_out_t4_53 + (-0.11304932832717896) * gru_0_out_t4_54 + (-0.61127817630767822) * gru_0_out_t4_55 + (-0.056505654007196426) * gru_0_out_t4_56 + (0.16422541439533234) * gru_0_out_t4_57 + (0.22805671393871307) * gru_0_out_t4_58 + (-0.18545420467853546) * gru_0_out_t4_59 + (-0.14823460578918457) * gru_0_out_t4_60 + (-0.33449450135231018) * gru_0_out_t4_61 + (0.53247404098510742) * gru_0_out_t4_62 + (-0.50986897945404053) * gru_0_out_t4_63 + (0.69462263584136963) * gru_1_fwd_t3_h_0 + (-0.1002110168337822) * gru_1_fwd_t3_h_1 + (0.35464364290237427) * gru_1_fwd_t3_h_2 + (-0.40514007210731506) * gru_1_fwd_t3_h_3 + (-0.025220884010195732) * gru_1_fwd_t3_h_4 + (-0.72757589817047119) * gru_1_fwd_t3_h_5 + (0.021767821162939072) * gru_1_fwd_t3_h_6 + (0.20600779354572296) * gru_1_fwd_t3_h_7 + (-0.52136105298995972) * gru_1_fwd_t3_h_8 + (-0.083963841199874878) * gru_1_fwd_t3_h_9 + (0.4351021945476532) * gru_1_fwd_t3_h_10 + (0.25151899456977844) * gru_1_fwd_t3_h_11 + (0.051527820527553558) * gru_1_fwd_t3_h_12 + (-0.14021706581115723) * gru_1_fwd_t3_h_13 + (0.10451799631118774) * gru_1_fwd_t3_h_14 + (-0.12368157505989075) * gru_1_fwd_t3_h_15 + (-0.48293519020080566) * gru_1_fwd_t3_h_16 + (0.23997761309146881) * gru_1_fwd_t3_h_17 + (0.31865918636322021) * gru_1_fwd_t3_h_18 + (0.058318644762039185) * gru_1_fwd_t3_h_19 + (-0.097787119448184967) * gru_1_fwd_t3_h_20 + (0.10991073399782181) * gru_1_fwd_t3_h_21 + (-0.2901337742805481) * gru_1_fwd_t3_h_22 + (0.047333300113677979) * gru_1_fwd_t3_h_23 + (0.32429832220077515) * gru_1_fwd_t3_h_24 + (0.13376836478710175) * gru_1_fwd_t3_h_25 + (-1.2719895839691162) * gru_1_fwd_t3_h_26 + (-0.22373615205287933) * gru_1_fwd_t3_h_27 + (0.26340678334236145) * gru_1_fwd_t3_h_28 + (0.030275162309408188) * gru_1_fwd_t3_h_29 + (-0.10419816523790359) * gru_1_fwd_t3_h_30 + (0.55240947008132935) * gru_1_fwd_t3_h_31);
    gate_n = tanh((0.24099402129650116) + (-0.081720493733882904) * gru_0_out_t4_0 + (-0.22350789606571198) * gru_0_out_t4_1 + (0.22498087584972382) * gru_0_out_t4_2 + (-1.0923663377761841) * gru_0_out_t4_3 + (0.0526115782558918) * gru_0_out_t4_4 + (-0.37810736894607544) * gru_0_out_t4_5 + (0.96148020029067993) * gru_0_out_t4_6 + (0.59036350250244141) * gru_0_out_t4_7 + (-0.24858054518699646) * gru_0_out_t4_8 + (-0.13005098700523376) * gru_0_out_t4_9 + (0.10471072793006897) * gru_0_out_t4_10 + (0.12695799767971039) * gru_0_out_t4_11 + (0.43793290853500366) * gru_0_out_t4_12 + (0.18344719707965851) * gru_0_out_t4_13 + (0.2254004031419754) * gru_0_out_t4_14 + (-0.41001760959625244) * gru_0_out_t4_15 + (-0.84588253498077393) * gru_0_out_t4_16 + (-0.19655579328536987) * gru_0_out_t4_17 + (0.018302859738469124) * gru_0_out_t4_18 + (0.054398465901613235) * gru_0_out_t4_19 + (-0.12775120139122009) * gru_0_out_t4_20 + (-1.0025448799133301) * gru_0_out_t4_21 + (0.1243298202753067) * gru_0_out_t4_22 + (0.38433283567428589) * gru_0_out_t4_23 + (-0.34269148111343384) * gru_0_out_t4_24 + (0.47426825761795044) * gru_0_out_t4_25 + (-0.12940236926078796) * gru_0_out_t4_26 + (-0.15284371376037598) * gru_0_out_t4_27 + (0.5323798656463623) * gru_0_out_t4_28 + (0.70586252212524414) * gru_0_out_t4_29 + (0.34467661380767822) * gru_0_out_t4_30 + (0.46733993291854858) * gru_0_out_t4_31 + (0.45396775007247925) * gru_0_out_t4_32 + (-0.88176864385604858) * gru_0_out_t4_33 + (-0.31487029790878296) * gru_0_out_t4_34 + (0.78852522373199463) * gru_0_out_t4_35 + (0.12848441302776337) * gru_0_out_t4_36 + (-0.16874648630619049) * gru_0_out_t4_37 + (0.11007984727621078) * gru_0_out_t4_38 + (-0.11136472225189209) * gru_0_out_t4_39 + (-0.20182853937149048) * gru_0_out_t4_40 + (-0.090640440583229065) * gru_0_out_t4_41 + (-0.21501393616199493) * gru_0_out_t4_42 + (0.22762294113636017) * gru_0_out_t4_43 + (0.06663484126329422) * gru_0_out_t4_44 + (-0.12869471311569214) * gru_0_out_t4_45 + (0.59350168704986572) * gru_0_out_t4_46 + (0.3770759105682373) * gru_0_out_t4_47 + (0.68285977840423584) * gru_0_out_t4_48 + (-0.3896510899066925) * gru_0_out_t4_49 + (-0.0016163914697244763) * gru_0_out_t4_50 + (-0.029232924804091454) * gru_0_out_t4_51 + (0.25509113073348999) * gru_0_out_t4_52 + (0.17764553427696228) * gru_0_out_t4_53 + (-0.01939515583217144) * gru_0_out_t4_54 + (-0.2801215648651123) * gru_0_out_t4_55 + (-0.12825670838356018) * gru_0_out_t4_56 + (-0.83580923080444336) * gru_0_out_t4_57 + (0.73483800888061523) * gru_0_out_t4_58 + (0.46928948163986206) * gru_0_out_t4_59 + (0.30807730555534363) * gru_0_out_t4_60 + (-0.22999167442321777) * gru_0_out_t4_61 + (0.42728477716445923) * gru_0_out_t4_62 + (-0.54261273145675659) * gru_0_out_t4_63 + gate_r * ((0.40620821714401245) + (-0.53987020254135132) * gru_1_fwd_t3_h_0 + (0.027536109089851379) * gru_1_fwd_t3_h_1 + (-0.30609163641929626) * gru_1_fwd_t3_h_2 + (-0.07976260781288147) * gru_1_fwd_t3_h_3 + (-0.17717054486274719) * gru_1_fwd_t3_h_4 + (0.047017008066177368) * gru_1_fwd_t3_h_5 + (-0.11404813826084137) * gru_1_fwd_t3_h_6 + (0.0010864792857319117) * gru_1_fwd_t3_h_7 + (0.26438748836517334) * gru_1_fwd_t3_h_8 + (-0.25429537892341614) * gru_1_fwd_t3_h_9 + (-0.1414773017168045) * gru_1_fwd_t3_h_10 + (0.011593489907681942) * gru_1_fwd_t3_h_11 + (0.099501855671405792) * gru_1_fwd_t3_h_12 + (0.044257987290620804) * gru_1_fwd_t3_h_13 + (0.59119158983230591) * gru_1_fwd_t3_h_14 + (-0.67416554689407349) * gru_1_fwd_t3_h_15 + (0.18975499272346497) * gru_1_fwd_t3_h_16 + (0.369637131690979) * gru_1_fwd_t3_h_17 + (0.056145794689655304) * gru_1_fwd_t3_h_18 + (0.45151400566101074) * gru_1_fwd_t3_h_19 + (0.1689552515745163) * gru_1_fwd_t3_h_20 + (0.42627620697021484) * gru_1_fwd_t3_h_21 + (-0.11651196330785751) * gru_1_fwd_t3_h_22 + (0.22095082700252533) * gru_1_fwd_t3_h_23 + (1.9643646478652954) * gru_1_fwd_t3_h_24 + (-0.060385908931493759) * gru_1_fwd_t3_h_25 + (0.24690881371498108) * gru_1_fwd_t3_h_26 + (0.060700837522745132) * gru_1_fwd_t3_h_27 + (0.79758715629577637) * gru_1_fwd_t3_h_28 + (0.10627193003892899) * gru_1_fwd_t3_h_29 + (0.49125882983207703) * gru_1_fwd_t3_h_30 + (-0.6533658504486084) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_25 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_25;
    // h=26
    gate_r = sigmoid((-0.076467685401439667) + (0.2769375741481781) * gru_0_out_t4_0 + (0.070832394063472748) * gru_0_out_t4_1 + (0.077094525098800659) * gru_0_out_t4_2 + (-0.19162987172603607) * gru_0_out_t4_3 + (-0.19423547387123108) * gru_0_out_t4_4 + (0.026720158755779266) * gru_0_out_t4_5 + (-0.24736309051513672) * gru_0_out_t4_6 + (-2.7226133346557617) * gru_0_out_t4_7 + (-0.32351279258728027) * gru_0_out_t4_8 + (-0.48526784777641296) * gru_0_out_t4_9 + (-0.59297895431518555) * gru_0_out_t4_10 + (0.49966245889663696) * gru_0_out_t4_11 + (0.1938680112361908) * gru_0_out_t4_12 + (0.71319013833999634) * gru_0_out_t4_13 + (0.44350463151931763) * gru_0_out_t4_14 + (0.23444966971874237) * gru_0_out_t4_15 + (-0.31931421160697937) * gru_0_out_t4_16 + (-0.19063882529735565) * gru_0_out_t4_17 + (-0.69299006462097168) * gru_0_out_t4_18 + (3.5240192413330078) * gru_0_out_t4_19 + (-1.1968563795089722) * gru_0_out_t4_20 + (0.045003660023212433) * gru_0_out_t4_21 + (-0.099213354289531708) * gru_0_out_t4_22 + (-0.31207022070884705) * gru_0_out_t4_23 + (-0.11669807136058807) * gru_0_out_t4_24 + (-0.69829446077346802) * gru_0_out_t4_25 + (1.6557317972183228) * gru_0_out_t4_26 + (-0.27660062909126282) * gru_0_out_t4_27 + (-0.028498351573944092) * gru_0_out_t4_28 + (0.37796938419342041) * gru_0_out_t4_29 + (0.28396308422088623) * gru_0_out_t4_30 + (0.81037449836730957) * gru_0_out_t4_31 + (0.0056192944757640362) * gru_0_out_t4_32 + (1.0521278381347656) * gru_0_out_t4_33 + (-0.33769500255584717) * gru_0_out_t4_34 + (0.055799674242734909) * gru_0_out_t4_35 + (0.29136011004447937) * gru_0_out_t4_36 + (-0.43240243196487427) * gru_0_out_t4_37 + (0.21832938492298126) * gru_0_out_t4_38 + (-1.5849900245666504) * gru_0_out_t4_39 + (0.33850547671318054) * gru_0_out_t4_40 + (0.070698849856853485) * gru_0_out_t4_41 + (-0.84558069705963135) * gru_0_out_t4_42 + (0.50241130590438843) * gru_0_out_t4_43 + (-0.036095958203077316) * gru_0_out_t4_44 + (-0.15989252924919128) * gru_0_out_t4_45 + (1.5869982242584229) * gru_0_out_t4_46 + (-0.6398465633392334) * gru_0_out_t4_47 + (-0.083037480711936951) * gru_0_out_t4_48 + (0.62104636430740356) * gru_0_out_t4_49 + (0.85020703077316284) * gru_0_out_t4_50 + (-2.1015548706054688) * gru_0_out_t4_51 + (-0.80198603868484497) * gru_0_out_t4_52 + (0.43366053700447083) * gru_0_out_t4_53 + (0.32981520891189575) * gru_0_out_t4_54 + (-0.35246410965919495) * gru_0_out_t4_55 + (-1.1228047609329224) * gru_0_out_t4_56 + (0.43610963225364685) * gru_0_out_t4_57 + (0.064198508858680725) * gru_0_out_t4_58 + (-0.61314660310745239) * gru_0_out_t4_59 + (-0.50830715894699097) * gru_0_out_t4_60 + (-0.37233486771583557) * gru_0_out_t4_61 + (-0.10278254747390747) * gru_0_out_t4_62 + (2.2968344688415527) * gru_0_out_t4_63 + (0.1279274970293045) * gru_1_fwd_t3_h_0 + (-0.36156019568443298) * gru_1_fwd_t3_h_1 + (-0.57325929403305054) * gru_1_fwd_t3_h_2 + (0.57127010822296143) * gru_1_fwd_t3_h_3 + (-0.36992895603179932) * gru_1_fwd_t3_h_4 + (-0.99652540683746338) * gru_1_fwd_t3_h_5 + (0.97806090116500854) * gru_1_fwd_t3_h_6 + (0.11585577577352524) * gru_1_fwd_t3_h_7 + (-0.45205506682395935) * gru_1_fwd_t3_h_8 + (-0.092385701835155487) * gru_1_fwd_t3_h_9 + (-0.052569180727005005) * gru_1_fwd_t3_h_10 + (-0.0064573776908218861) * gru_1_fwd_t3_h_11 + (0.14360027015209198) * gru_1_fwd_t3_h_12 + (-1.5671166181564331) * gru_1_fwd_t3_h_13 + (-0.0099725499749183655) * gru_1_fwd_t3_h_14 + (-0.047282777726650238) * gru_1_fwd_t3_h_15 + (-0.40574735403060913) * gru_1_fwd_t3_h_16 + (0.15778286755084991) * gru_1_fwd_t3_h_17 + (0.30046087503433228) * gru_1_fwd_t3_h_18 + (-0.71401423215866089) * gru_1_fwd_t3_h_19 + (-0.092171594500541687) * gru_1_fwd_t3_h_20 + (-0.33916765451431274) * gru_1_fwd_t3_h_21 + (-0.14947962760925293) * gru_1_fwd_t3_h_22 + (-0.071506120264530182) * gru_1_fwd_t3_h_23 + (-1.7893922328948975) * gru_1_fwd_t3_h_24 + (1.0787578821182251) * gru_1_fwd_t3_h_25 + (0.54126131534576416) * gru_1_fwd_t3_h_26 + (0.026489097625017166) * gru_1_fwd_t3_h_27 + (0.44872143864631653) * gru_1_fwd_t3_h_28 + (-0.069654397666454315) * gru_1_fwd_t3_h_29 + (-1.3622226715087891) * gru_1_fwd_t3_h_30 + (-0.11501754820346832) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((0.098901771008968353) + (0.26790449023246765) * gru_0_out_t4_0 + (0.66023933887481689) * gru_0_out_t4_1 + (-0.49097895622253418) * gru_0_out_t4_2 + (0.83575057983398438) * gru_0_out_t4_3 + (0.25618106126785278) * gru_0_out_t4_4 + (-0.34730884432792664) * gru_0_out_t4_5 + (0.076646372675895691) * gru_0_out_t4_6 + (-1.8044203519821167) * gru_0_out_t4_7 + (0.48304712772369385) * gru_0_out_t4_8 + (1.0323642492294312) * gru_0_out_t4_9 + (0.27785715460777283) * gru_0_out_t4_10 + (0.25535884499549866) * gru_0_out_t4_11 + (-0.47621080279350281) * gru_0_out_t4_12 + (-0.71382826566696167) * gru_0_out_t4_13 + (-0.033862117677927017) * gru_0_out_t4_14 + (-0.31509429216384888) * gru_0_out_t4_15 + (-0.12258738279342651) * gru_0_out_t4_16 + (-0.065539933741092682) * gru_0_out_t4_17 + (0.38164776563644409) * gru_0_out_t4_18 + (0.89014643430709839) * gru_0_out_t4_19 + (-0.40559121966362) * gru_0_out_t4_20 + (-0.12672297656536102) * gru_0_out_t4_21 + (-1.4290814399719238) * gru_0_out_t4_22 + (-0.81405472755432129) * gru_0_out_t4_23 + (1.0293149948120117) * gru_0_out_t4_24 + (0.44364061951637268) * gru_0_out_t4_25 + (-0.20541177690029144) * gru_0_out_t4_26 + (0.26095238327980042) * gru_0_out_t4_27 + (2.0532352924346924) * gru_0_out_t4_28 + (0.93070262670516968) * gru_0_out_t4_29 + (0.63277274370193481) * gru_0_out_t4_30 + (1.2211294174194336) * gru_0_out_t4_31 + (1.8795474767684937) * gru_0_out_t4_32 + (0.33055835962295532) * gru_0_out_t4_33 + (0.1517450362443924) * gru_0_out_t4_34 + (-0.31990328431129456) * gru_0_out_t4_35 + (0.096573047339916229) * gru_0_out_t4_36 + (0.17963609099388123) * gru_0_out_t4_37 + (0.01677272655069828) * gru_0_out_t4_38 + (-0.35066628456115723) * gru_0_out_t4_39 + (0.15757070481777191) * gru_0_out_t4_40 + (-1.1609734296798706) * gru_0_out_t4_41 + (-0.71084761619567871) * gru_0_out_t4_42 + (-0.46621230244636536) * gru_0_out_t4_43 + (-0.12567982077598572) * gru_0_out_t4_44 + (-0.33459195494651794) * gru_0_out_t4_45 + (0.34160834550857544) * gru_0_out_t4_46 + (-0.38255295157432556) * gru_0_out_t4_47 + (0.32127940654754639) * gru_0_out_t4_48 + (-0.50376880168914795) * gru_0_out_t4_49 + (0.48926115036010742) * gru_0_out_t4_50 + (-0.4084513783454895) * gru_0_out_t4_51 + (0.34690967202186584) * gru_0_out_t4_52 + (0.035803288221359253) * gru_0_out_t4_53 + (-0.35029610991477966) * gru_0_out_t4_54 + (0.31896334886550903) * gru_0_out_t4_55 + (0.31267881393432617) * gru_0_out_t4_56 + (-0.001831499976105988) * gru_0_out_t4_57 + (0.30812576413154602) * gru_0_out_t4_58 + (0.61868494749069214) * gru_0_out_t4_59 + (0.24542374908924103) * gru_0_out_t4_60 + (-0.24312825500965118) * gru_0_out_t4_61 + (-0.15853442251682281) * gru_0_out_t4_62 + (-0.4452798068523407) * gru_0_out_t4_63 + (-0.97681337594985962) * gru_1_fwd_t3_h_0 + (0.08331763744354248) * gru_1_fwd_t3_h_1 + (-0.27465251088142395) * gru_1_fwd_t3_h_2 + (0.069623149931430817) * gru_1_fwd_t3_h_3 + (0.20878979563713074) * gru_1_fwd_t3_h_4 + (0.0073037166148424149) * gru_1_fwd_t3_h_5 + (0.28755375742912292) * gru_1_fwd_t3_h_6 + (-0.77620100975036621) * gru_1_fwd_t3_h_7 + (0.46741592884063721) * gru_1_fwd_t3_h_8 + (0.11321624368429184) * gru_1_fwd_t3_h_9 + (-0.25531557202339172) * gru_1_fwd_t3_h_10 + (-0.95224869251251221) * gru_1_fwd_t3_h_11 + (1.214138388633728) * gru_1_fwd_t3_h_12 + (-0.06232534721493721) * gru_1_fwd_t3_h_13 + (-0.42823770642280579) * gru_1_fwd_t3_h_14 + (-0.62786555290222168) * gru_1_fwd_t3_h_15 + (0.29051324725151062) * gru_1_fwd_t3_h_16 + (0.5285419225692749) * gru_1_fwd_t3_h_17 + (0.48163169622421265) * gru_1_fwd_t3_h_18 + (0.36232021450996399) * gru_1_fwd_t3_h_19 + (-0.80483353137969971) * gru_1_fwd_t3_h_20 + (2.0563983917236328) * gru_1_fwd_t3_h_21 + (0.26855066418647766) * gru_1_fwd_t3_h_22 + (1.0019446611404419) * gru_1_fwd_t3_h_23 + (0.46915468573570251) * gru_1_fwd_t3_h_24 + (-0.58661240339279175) * gru_1_fwd_t3_h_25 + (-0.18930664658546448) * gru_1_fwd_t3_h_26 + (-0.34527099132537842) * gru_1_fwd_t3_h_27 + (0.65793842077255249) * gru_1_fwd_t3_h_28 + (-0.23503805696964264) * gru_1_fwd_t3_h_29 + (0.46234336495399475) * gru_1_fwd_t3_h_30 + (-0.49330401420593262) * gru_1_fwd_t3_h_31);
    gate_n = tanh((0.035159725695848465) + (-0.08853517472743988) * gru_0_out_t4_0 + (0.28788402676582336) * gru_0_out_t4_1 + (-0.54823362827301025) * gru_0_out_t4_2 + (-0.0042568342760205269) * gru_0_out_t4_3 + (0.19225247204303741) * gru_0_out_t4_4 + (0.11134367436170578) * gru_0_out_t4_5 + (0.21037399768829346) * gru_0_out_t4_6 + (-0.15053296089172363) * gru_0_out_t4_7 + (-0.40025916695594788) * gru_0_out_t4_8 + (-0.025375574827194214) * gru_0_out_t4_9 + (-0.12294541299343109) * gru_0_out_t4_10 + (-0.12273577600717545) * gru_0_out_t4_11 + (0.04265211895108223) * gru_0_out_t4_12 + (-0.26186558604240417) * gru_0_out_t4_13 + (0.17058643698692322) * gru_0_out_t4_14 + (-0.027253648266196251) * gru_0_out_t4_15 + (0.59505236148834229) * gru_0_out_t4_16 + (-0.1141689345240593) * gru_0_out_t4_17 + (-0.15626473724842072) * gru_0_out_t4_18 + (-0.17445825040340424) * gru_0_out_t4_19 + (0.10242993384599686) * gru_0_out_t4_20 + (0.052345592528581619) * gru_0_out_t4_21 + (0.081754356622695923) * gru_0_out_t4_22 + (0.34917214512825012) * gru_0_out_t4_23 + (-0.050582218915224075) * gru_0_out_t4_24 + (-0.25408637523651123) * gru_0_out_t4_25 + (0.069133155047893524) * gru_0_out_t4_26 + (-0.12887786328792572) * gru_0_out_t4_27 + (-1.4698892831802368) * gru_0_out_t4_28 + (-0.77784442901611328) * gru_0_out_t4_29 + (0.29932042956352234) * gru_0_out_t4_30 + (0.25389385223388672) * gru_0_out_t4_31 + (-0.011390303261578083) * gru_0_out_t4_32 + (0.0060517392121255398) * gru_0_out_t4_33 + (0.093926019966602325) * gru_0_out_t4_34 + (0.4721972644329071) * gru_0_out_t4_35 + (-0.11033742874860764) * gru_0_out_t4_36 + (-0.23404668271541595) * gru_0_out_t4_37 + (-0.1707637757062912) * gru_0_out_t4_38 + (-1.0134559869766235) * gru_0_out_t4_39 + (-0.029952997341752052) * gru_0_out_t4_40 + (0.040784019976854324) * gru_0_out_t4_41 + (-0.25285729765892029) * gru_0_out_t4_42 + (-0.13345231115818024) * gru_0_out_t4_43 + (-0.028507119044661522) * gru_0_out_t4_44 + (0.4731193482875824) * gru_0_out_t4_45 + (-0.21453763544559479) * gru_0_out_t4_46 + (0.30017560720443726) * gru_0_out_t4_47 + (0.96943986415863037) * gru_0_out_t4_48 + (-0.11195682734251022) * gru_0_out_t4_49 + (-0.55412352085113525) * gru_0_out_t4_50 + (-0.21212081611156464) * gru_0_out_t4_51 + (0.19174441695213318) * gru_0_out_t4_52 + (-0.18461023271083832) * gru_0_out_t4_53 + (0.058927111327648163) * gru_0_out_t4_54 + (0.15701396763324738) * gru_0_out_t4_55 + (-0.12456706166267395) * gru_0_out_t4_56 + (-0.14607350528240204) * gru_0_out_t4_57 + (0.32731017470359802) * gru_0_out_t4_58 + (0.42114987969398499) * gru_0_out_t4_59 + (0.014675414189696312) * gru_0_out_t4_60 + (-0.052481375634670258) * gru_0_out_t4_61 + (-0.12645533680915833) * gru_0_out_t4_62 + (1.7810565233230591) * gru_0_out_t4_63 + gate_r * ((-0.2310643196105957) + (-0.10161932557821274) * gru_1_fwd_t3_h_0 + (-0.027378702536225319) * gru_1_fwd_t3_h_1 + (-0.026164045557379723) * gru_1_fwd_t3_h_2 + (-0.25556400418281555) * gru_1_fwd_t3_h_3 + (-0.19964107871055603) * gru_1_fwd_t3_h_4 + (0.21500395238399506) * gru_1_fwd_t3_h_5 + (0.31625452637672424) * gru_1_fwd_t3_h_6 + (-0.24881403148174286) * gru_1_fwd_t3_h_7 + (0.29941552877426147) * gru_1_fwd_t3_h_8 + (-0.094522550702095032) * gru_1_fwd_t3_h_9 + (0.19519755244255066) * gru_1_fwd_t3_h_10 + (0.11414958536624908) * gru_1_fwd_t3_h_11 + (-0.16130149364471436) * gru_1_fwd_t3_h_12 + (-0.3815155029296875) * gru_1_fwd_t3_h_13 + (0.35557779669761658) * gru_1_fwd_t3_h_14 + (-0.11919749528169632) * gru_1_fwd_t3_h_15 + (-0.0083007412031292915) * gru_1_fwd_t3_h_16 + (0.073021858930587769) * gru_1_fwd_t3_h_17 + (-0.0067197885364294052) * gru_1_fwd_t3_h_18 + (0.24978102743625641) * gru_1_fwd_t3_h_19 + (-0.13269484043121338) * gru_1_fwd_t3_h_20 + (0.071465209126472473) * gru_1_fwd_t3_h_21 + (-0.15624240040779114) * gru_1_fwd_t3_h_22 + (-1.1506456136703491) * gru_1_fwd_t3_h_23 + (0.24524341523647308) * gru_1_fwd_t3_h_24 + (-0.1749148964881897) * gru_1_fwd_t3_h_25 + (-0.24097849428653717) * gru_1_fwd_t3_h_26 + (-0.25703004002571106) * gru_1_fwd_t3_h_27 + (-0.14647114276885986) * gru_1_fwd_t3_h_28 + (0.16564995050430298) * gru_1_fwd_t3_h_29 + (0.17593143880367279) * gru_1_fwd_t3_h_30 + (0.26184177398681641) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_26 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_26;
    // h=27
    gate_r = sigmoid((-0.46266156435012817) + (-0.17690213024616241) * gru_0_out_t4_0 + (0.39805281162261963) * gru_0_out_t4_1 + (0.48003080487251282) * gru_0_out_t4_2 + (0.78808289766311646) * gru_0_out_t4_3 + (0.17656855285167694) * gru_0_out_t4_4 + (0.37412503361701965) * gru_0_out_t4_5 + (-1.5806025266647339) * gru_0_out_t4_6 + (-0.90156131982803345) * gru_0_out_t4_7 + (0.052514322102069855) * gru_0_out_t4_8 + (-0.14406579732894897) * gru_0_out_t4_9 + (-0.092430122196674347) * gru_0_out_t4_10 + (1.3271166086196899) * gru_0_out_t4_11 + (-0.19042648375034332) * gru_0_out_t4_12 + (-0.4084133505821228) * gru_0_out_t4_13 + (-0.19637815654277802) * gru_0_out_t4_14 + (0.60568296909332275) * gru_0_out_t4_15 + (0.025304369628429413) * gru_0_out_t4_16 + (0.16182741522789001) * gru_0_out_t4_17 + (-0.01197005994617939) * gru_0_out_t4_18 + (-0.86063051223754883) * gru_0_out_t4_19 + (0.035169310867786407) * gru_0_out_t4_20 + (0.40657484531402588) * gru_0_out_t4_21 + (0.81035816669464111) * gru_0_out_t4_22 + (0.15718436241149902) * gru_0_out_t4_23 + (-3.3010518550872803) * gru_0_out_t4_24 + (0.086790688335895538) * gru_0_out_t4_25 + (1.0286291837692261) * gru_0_out_t4_26 + (0.17655761539936066) * gru_0_out_t4_27 + (-1.5627838373184204) * gru_0_out_t4_28 + (0.099544249475002289) * gru_0_out_t4_29 + (-0.2321852445602417) * gru_0_out_t4_30 + (2.1300156116485596) * gru_0_out_t4_31 + (-0.041468128561973572) * gru_0_out_t4_32 + (1.6231603622436523) * gru_0_out_t4_33 + (1.196184515953064) * gru_0_out_t4_34 + (-0.17761018872261047) * gru_0_out_t4_35 + (-1.3216122388839722) * gru_0_out_t4_36 + (0.95802593231201172) * gru_0_out_t4_37 + (-0.16500398516654968) * gru_0_out_t4_38 + (-1.7530776262283325) * gru_0_out_t4_39 + (0.094662830233573914) * gru_0_out_t4_40 + (-0.035025123506784439) * gru_0_out_t4_41 + (0.31252974271774292) * gru_0_out_t4_42 + (1.7129338979721069) * gru_0_out_t4_43 + (0.48306536674499512) * gru_0_out_t4_44 + (-0.039640277624130249) * gru_0_out_t4_45 + (2.3545219898223877) * gru_0_out_t4_46 + (0.080370105803012848) * gru_0_out_t4_47 + (-0.65957075357437134) * gru_0_out_t4_48 + (0.32162865996360779) * gru_0_out_t4_49 + (0.2682584822177887) * gru_0_out_t4_50 + (-0.176847904920578) * gru_0_out_t4_51 + (-2.2430248260498047) * gru_0_out_t4_52 + (0.79624253511428833) * gru_0_out_t4_53 + (0.31350612640380859) * gru_0_out_t4_54 + (-0.4660300612449646) * gru_0_out_t4_55 + (-0.92167216539382935) * gru_0_out_t4_56 + (0.41907140612602234) * gru_0_out_t4_57 + (0.44410884380340576) * gru_0_out_t4_58 + (0.69895142316818237) * gru_0_out_t4_59 + (-0.18372361361980438) * gru_0_out_t4_60 + (0.042234990745782852) * gru_0_out_t4_61 + (-1.2581833600997925) * gru_0_out_t4_62 + (0.30793109536170959) * gru_0_out_t4_63 + (0.69012761116027832) * gru_1_fwd_t3_h_0 + (1.9290456771850586) * gru_1_fwd_t3_h_1 + (-0.58328062295913696) * gru_1_fwd_t3_h_2 + (0.48346406221389771) * gru_1_fwd_t3_h_3 + (-0.78185242414474487) * gru_1_fwd_t3_h_4 + (0.85304969549179077) * gru_1_fwd_t3_h_5 + (0.27101030945777893) * gru_1_fwd_t3_h_6 + (-0.81157982349395752) * gru_1_fwd_t3_h_7 + (-1.2876484394073486) * gru_1_fwd_t3_h_8 + (0.22055685520172119) * gru_1_fwd_t3_h_9 + (0.19453853368759155) * gru_1_fwd_t3_h_10 + (0.69804090261459351) * gru_1_fwd_t3_h_11 + (0.43181443214416504) * gru_1_fwd_t3_h_12 + (0.40058153867721558) * gru_1_fwd_t3_h_13 + (0.44322815537452698) * gru_1_fwd_t3_h_14 + (0.62534636259078979) * gru_1_fwd_t3_h_15 + (0.041804123669862747) * gru_1_fwd_t3_h_16 + (0.46044901013374329) * gru_1_fwd_t3_h_17 + (0.32727187871932983) * gru_1_fwd_t3_h_18 + (-0.20609748363494873) * gru_1_fwd_t3_h_19 + (-0.36359140276908875) * gru_1_fwd_t3_h_20 + (0.75188511610031128) * gru_1_fwd_t3_h_21 + (1.0623284578323364) * gru_1_fwd_t3_h_22 + (0.95388895273208618) * gru_1_fwd_t3_h_23 + (0.77921456098556519) * gru_1_fwd_t3_h_24 + (0.32610294222831726) * gru_1_fwd_t3_h_25 + (1.0090687274932861) * gru_1_fwd_t3_h_26 + (-1.240517258644104) * gru_1_fwd_t3_h_27 + (0.8376879096031189) * gru_1_fwd_t3_h_28 + (0.7643926739692688) * gru_1_fwd_t3_h_29 + (-1.9757161140441895) * gru_1_fwd_t3_h_30 + (0.91344583034515381) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((1.3229556083679199) + (-0.19408118724822998) * gru_0_out_t4_0 + (-0.23358795046806335) * gru_0_out_t4_1 + (0.98805457353591919) * gru_0_out_t4_2 + (-0.64171534776687622) * gru_0_out_t4_3 + (0.34609121084213257) * gru_0_out_t4_4 + (0.019168959930539131) * gru_0_out_t4_5 + (-0.24356620013713837) * gru_0_out_t4_6 + (-1.2493016719818115) * gru_0_out_t4_7 + (-0.29067152738571167) * gru_0_out_t4_8 + (-0.52916741371154785) * gru_0_out_t4_9 + (-0.87251752614974976) * gru_0_out_t4_10 + (-0.35165524482727051) * gru_0_out_t4_11 + (-0.096616163849830627) * gru_0_out_t4_12 + (-0.40826353430747986) * gru_0_out_t4_13 + (0.21357770264148712) * gru_0_out_t4_14 + (0.17562766373157501) * gru_0_out_t4_15 + (0.2310110479593277) * gru_0_out_t4_16 + (0.15968644618988037) * gru_0_out_t4_17 + (-0.30910789966583252) * gru_0_out_t4_18 + (-1.1662306785583496) * gru_0_out_t4_19 + (1.4947967529296875) * gru_0_out_t4_20 + (0.1501757949590683) * gru_0_out_t4_21 + (-0.36502715945243835) * gru_0_out_t4_22 + (0.17250221967697144) * gru_0_out_t4_23 + (0.13504825532436371) * gru_0_out_t4_24 + (-0.59695678949356079) * gru_0_out_t4_25 + (-0.069472193717956543) * gru_0_out_t4_26 + (0.33949404954910278) * gru_0_out_t4_27 + (-1.2997053861618042) * gru_0_out_t4_28 + (-0.11241608858108521) * gru_0_out_t4_29 + (0.39656755328178406) * gru_0_out_t4_30 + (-0.27382257580757141) * gru_0_out_t4_31 + (-0.0060353772714734077) * gru_0_out_t4_32 + (0.30710777640342712) * gru_0_out_t4_33 + (0.17229078710079193) * gru_0_out_t4_34 + (0.71598315238952637) * gru_0_out_t4_35 + (0.054784055799245834) * gru_0_out_t4_36 + (0.31369408965110779) * gru_0_out_t4_37 + (-0.40285336971282959) * gru_0_out_t4_38 + (0.225486159324646) * gru_0_out_t4_39 + (0.0068082367070019245) * gru_0_out_t4_40 + (-0.038092441856861115) * gru_0_out_t4_41 + (-0.17348015308380127) * gru_0_out_t4_42 + (-0.029206864535808563) * gru_0_out_t4_43 + (0.18822723627090454) * gru_0_out_t4_44 + (0.24751554429531097) * gru_0_out_t4_45 + (0.16960126161575317) * gru_0_out_t4_46 + (-0.53373128175735474) * gru_0_out_t4_47 + (0.011361001990735531) * gru_0_out_t4_48 + (-0.19353409111499786) * gru_0_out_t4_49 + (0.51860243082046509) * gru_0_out_t4_50 + (0.026689315214753151) * gru_0_out_t4_51 + (0.67123115062713623) * gru_0_out_t4_52 + (0.61337155103683472) * gru_0_out_t4_53 + (-0.043040905147790909) * gru_0_out_t4_54 + (-0.97380971908569336) * gru_0_out_t4_55 + (0.017116930335760117) * gru_0_out_t4_56 + (-0.38505706191062927) * gru_0_out_t4_57 + (1.0475902557373047) * gru_0_out_t4_58 + (0.07731589674949646) * gru_0_out_t4_59 + (0.0769672691822052) * gru_0_out_t4_60 + (-0.12370793521404266) * gru_0_out_t4_61 + (0.22392010688781738) * gru_0_out_t4_62 + (-0.4176185131072998) * gru_0_out_t4_63 + (0.05029924213886261) * gru_1_fwd_t3_h_0 + (-0.042512658983469009) * gru_1_fwd_t3_h_1 + (-0.13258562982082367) * gru_1_fwd_t3_h_2 + (0.048657514154911041) * gru_1_fwd_t3_h_3 + (-0.48304593563079834) * gru_1_fwd_t3_h_4 + (0.4075295627117157) * gru_1_fwd_t3_h_5 + (-0.81183981895446777) * gru_1_fwd_t3_h_6 + (-0.12810757756233215) * gru_1_fwd_t3_h_7 + (-0.0090620918199419975) * gru_1_fwd_t3_h_8 + (0.14675474166870117) * gru_1_fwd_t3_h_9 + (0.2826198935508728) * gru_1_fwd_t3_h_10 + (0.47382363677024841) * gru_1_fwd_t3_h_11 + (0.18025462329387665) * gru_1_fwd_t3_h_12 + (-0.21279884874820709) * gru_1_fwd_t3_h_13 + (0.068469859659671783) * gru_1_fwd_t3_h_14 + (-0.48510155081748962) * gru_1_fwd_t3_h_15 + (-0.74551665782928467) * gru_1_fwd_t3_h_16 + (0.41722646355628967) * gru_1_fwd_t3_h_17 + (0.58349162340164185) * gru_1_fwd_t3_h_18 + (-0.33853861689567566) * gru_1_fwd_t3_h_19 + (-0.24335719645023346) * gru_1_fwd_t3_h_20 + (-0.18778686225414276) * gru_1_fwd_t3_h_21 + (0.074099011719226837) * gru_1_fwd_t3_h_22 + (0.15932762622833252) * gru_1_fwd_t3_h_23 + (0.056651704013347626) * gru_1_fwd_t3_h_24 + (0.25060722231864929) * gru_1_fwd_t3_h_25 + (-0.20705272257328033) * gru_1_fwd_t3_h_26 + (-0.31949368119239807) * gru_1_fwd_t3_h_27 + (0.8193366527557373) * gru_1_fwd_t3_h_28 + (0.41072604060173035) * gru_1_fwd_t3_h_29 + (-0.10766115784645081) * gru_1_fwd_t3_h_30 + (-0.076130211353302002) * gru_1_fwd_t3_h_31);
    gate_n = tanh((-0.10986202955245972) + (-0.15132446587085724) * gru_0_out_t4_0 + (-0.047645311802625656) * gru_0_out_t4_1 + (0.022800343111157417) * gru_0_out_t4_2 + (0.72179222106933594) * gru_0_out_t4_3 + (0.018053233623504639) * gru_0_out_t4_4 + (-0.0079949526116251945) * gru_0_out_t4_5 + (-0.44103798270225525) * gru_0_out_t4_6 + (-0.81276571750640869) * gru_0_out_t4_7 + (-0.24211443960666656) * gru_0_out_t4_8 + (0.059833303093910217) * gru_0_out_t4_9 + (-0.3750927746295929) * gru_0_out_t4_10 + (-0.042615491896867752) * gru_0_out_t4_11 + (0.28127750754356384) * gru_0_out_t4_12 + (0.0056372336111962795) * gru_0_out_t4_13 + (-0.086078844964504242) * gru_0_out_t4_14 + (-0.04189179465174675) * gru_0_out_t4_15 + (0.084578096866607666) * gru_0_out_t4_16 + (0.028473369777202606) * gru_0_out_t4_17 + (-0.063915744423866272) * gru_0_out_t4_18 + (-1.7903996706008911) * gru_0_out_t4_19 + (-0.11881640553474426) * gru_0_out_t4_20 + (-0.2240329384803772) * gru_0_out_t4_21 + (0.078823000192642212) * gru_0_out_t4_22 + (0.093560591340065002) * gru_0_out_t4_23 + (-0.24129828810691833) * gru_0_out_t4_24 + (0.033049155026674271) * gru_0_out_t4_25 + (0.01011956762522459) * gru_0_out_t4_26 + (0.13075383007526398) * gru_0_out_t4_27 + (-0.30526226758956909) * gru_0_out_t4_28 + (-0.42008984088897705) * gru_0_out_t4_29 + (-0.55150467157363892) * gru_0_out_t4_30 + (0.12012997269630432) * gru_0_out_t4_31 + (-0.14246127009391785) * gru_0_out_t4_32 + (0.39198222756385803) * gru_0_out_t4_33 + (0.46505078673362732) * gru_0_out_t4_34 + (0.12762421369552612) * gru_0_out_t4_35 + (-0.17087139189243317) * gru_0_out_t4_36 + (-0.067461922764778137) * gru_0_out_t4_37 + (-0.21715927124023438) * gru_0_out_t4_38 + (0.37669804692268372) * gru_0_out_t4_39 + (-0.0057161059230566025) * gru_0_out_t4_40 + (0.054626982659101486) * gru_0_out_t4_41 + (-0.13482645153999329) * gru_0_out_t4_42 + (0.34352749586105347) * gru_0_out_t4_43 + (0.14716720581054688) * gru_0_out_t4_44 + (-0.14493536949157715) * gru_0_out_t4_45 + (-0.47443497180938721) * gru_0_out_t4_46 + (-0.2263568639755249) * gru_0_out_t4_47 + (-0.49783539772033691) * gru_0_out_t4_48 + (0.40575695037841797) * gru_0_out_t4_49 + (-0.07882419228553772) * gru_0_out_t4_50 + (-0.037815365940332413) * gru_0_out_t4_51 + (-0.23600991070270538) * gru_0_out_t4_52 + (0.11244021356105804) * gru_0_out_t4_53 + (0.050635199993848801) * gru_0_out_t4_54 + (-0.57346516847610474) * gru_0_out_t4_55 + (-0.17085875570774078) * gru_0_out_t4_56 + (0.49295917153358459) * gru_0_out_t4_57 + (-0.38841795921325684) * gru_0_out_t4_58 + (-0.4260963499546051) * gru_0_out_t4_59 + (-0.25148192048072815) * gru_0_out_t4_60 + (-0.062053903937339783) * gru_0_out_t4_61 + (-0.17309589684009552) * gru_0_out_t4_62 + (-1.2660020589828491) * gru_0_out_t4_63 + gate_r * ((0.20784817636013031) + (-0.11957739293575287) * gru_1_fwd_t3_h_0 + (0.41642230749130249) * gru_1_fwd_t3_h_1 + (0.10992847383022308) * gru_1_fwd_t3_h_2 + (0.114470474421978) * gru_1_fwd_t3_h_3 + (0.00046876363921910524) * gru_1_fwd_t3_h_4 + (-0.63266223669052124) * gru_1_fwd_t3_h_5 + (-1.7140777111053467) * gru_1_fwd_t3_h_6 + (0.1877790242433548) * gru_1_fwd_t3_h_7 + (-0.72462975978851318) * gru_1_fwd_t3_h_8 + (-0.18423940241336823) * gru_1_fwd_t3_h_9 + (0.59281313419342041) * gru_1_fwd_t3_h_10 + (0.0074567529372870922) * gru_1_fwd_t3_h_11 + (0.090893454849720001) * gru_1_fwd_t3_h_12 + (0.064232304692268372) * gru_1_fwd_t3_h_13 + (0.082251675426959991) * gru_1_fwd_t3_h_14 + (-0.22943024337291718) * gru_1_fwd_t3_h_15 + (0.25550812482833862) * gru_1_fwd_t3_h_16 + (0.21975533664226532) * gru_1_fwd_t3_h_17 + (-0.54472231864929199) * gru_1_fwd_t3_h_18 + (0.1911674439907074) * gru_1_fwd_t3_h_19 + (-0.16192390024662018) * gru_1_fwd_t3_h_20 + (0.059335801750421524) * gru_1_fwd_t3_h_21 + (0.66550922393798828) * gru_1_fwd_t3_h_22 + (-0.48722758889198303) * gru_1_fwd_t3_h_23 + (0.10165116190910339) * gru_1_fwd_t3_h_24 + (-0.57978683710098267) * gru_1_fwd_t3_h_25 + (0.84031236171722412) * gru_1_fwd_t3_h_26 + (-0.46686133742332458) * gru_1_fwd_t3_h_27 + (0.52492588758468628) * gru_1_fwd_t3_h_28 + (-0.011396618559956551) * gru_1_fwd_t3_h_29 + (-0.089386850595474243) * gru_1_fwd_t3_h_30 + (0.58417230844497681) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_27 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_27;
    // h=28
    gate_r = sigmoid((-0.11330907791852951) + (0.23868207633495331) * gru_0_out_t4_0 + (-0.26589274406433105) * gru_0_out_t4_1 + (0.22211344540119171) * gru_0_out_t4_2 + (-0.22721266746520996) * gru_0_out_t4_3 + (0.51347047090530396) * gru_0_out_t4_4 + (0.094098299741744995) * gru_0_out_t4_5 + (-0.26612523198127747) * gru_0_out_t4_6 + (2.07944655418396) * gru_0_out_t4_7 + (-0.11185628920793533) * gru_0_out_t4_8 + (-0.70029062032699585) * gru_0_out_t4_9 + (0.26492491364479065) * gru_0_out_t4_10 + (-0.96662825345993042) * gru_0_out_t4_11 + (-0.021238695830106735) * gru_0_out_t4_12 + (0.029995609074831009) * gru_0_out_t4_13 + (-0.20772404968738556) * gru_0_out_t4_14 + (0.14736655354499817) * gru_0_out_t4_15 + (0.17589056491851807) * gru_0_out_t4_16 + (-0.094975575804710388) * gru_0_out_t4_17 + (-0.10728712379932404) * gru_0_out_t4_18 + (0.6890215277671814) * gru_0_out_t4_19 + (1.6729998588562012) * gru_0_out_t4_20 + (0.042248018085956573) * gru_0_out_t4_21 + (-0.009382772259414196) * gru_0_out_t4_22 + (-1.2302887439727783) * gru_0_out_t4_23 + (0.73327797651290894) * gru_0_out_t4_24 + (0.3207356333732605) * gru_0_out_t4_25 + (2.1189708709716797) * gru_0_out_t4_26 + (0.24689359962940216) * gru_0_out_t4_27 + (-2.3345799446105957) * gru_0_out_t4_28 + (-1.0443856716156006) * gru_0_out_t4_29 + (-0.084836609661579132) * gru_0_out_t4_30 + (-1.2881007194519043) * gru_0_out_t4_31 + (0.0077554001472890377) * gru_0_out_t4_32 + (-0.15084411203861237) * gru_0_out_t4_33 + (-0.50253176689147949) * gru_0_out_t4_34 + (0.13887390494346619) * gru_0_out_t4_35 + (-0.18549858033657074) * gru_0_out_t4_36 + (0.042670011520385742) * gru_0_out_t4_37 + (0.31364706158638) * gru_0_out_t4_38 + (0.54703521728515625) * gru_0_out_t4_39 + (0.92722576856613159) * gru_0_out_t4_40 + (0.33524727821350098) * gru_0_out_t4_41 + (1.5436555147171021) * gru_0_out_t4_42 + (-0.2408667653799057) * gru_0_out_t4_43 + (-0.129362553358078) * gru_0_out_t4_44 + (-0.30828237533569336) * gru_0_out_t4_45 + (0.71437788009643555) * gru_0_out_t4_46 + (-0.3641757071018219) * gru_0_out_t4_47 + (0.20061153173446655) * gru_0_out_t4_48 + (-0.39720180630683899) * gru_0_out_t4_49 + (-0.41693547368049622) * gru_0_out_t4_50 + (-0.39698934555053711) * gru_0_out_t4_51 + (-0.34782266616821289) * gru_0_out_t4_52 + (-0.397462397813797) * gru_0_out_t4_53 + (-0.33320078253746033) * gru_0_out_t4_54 + (-0.61713320016860962) * gru_0_out_t4_55 + (0.25206875801086426) * gru_0_out_t4_56 + (0.2800675630569458) * gru_0_out_t4_57 + (0.63394159078598022) * gru_0_out_t4_58 + (0.86329883337020874) * gru_0_out_t4_59 + (-0.5461503267288208) * gru_0_out_t4_60 + (-0.77278047800064087) * gru_0_out_t4_61 + (-1.6426070928573608) * gru_0_out_t4_62 + (-1.1830781698226929) * gru_0_out_t4_63 + (-0.19762478768825531) * gru_1_fwd_t3_h_0 + (0.39954051375389099) * gru_1_fwd_t3_h_1 + (0.064608506858348846) * gru_1_fwd_t3_h_2 + (-0.52282851934432983) * gru_1_fwd_t3_h_3 + (-0.64223223924636841) * gru_1_fwd_t3_h_4 + (0.1589525043964386) * gru_1_fwd_t3_h_5 + (-1.1951804161071777) * gru_1_fwd_t3_h_6 + (0.73369759321212769) * gru_1_fwd_t3_h_7 + (0.23770622909069061) * gru_1_fwd_t3_h_8 + (0.66960102319717407) * gru_1_fwd_t3_h_9 + (0.51748830080032349) * gru_1_fwd_t3_h_10 + (-0.17856761813163757) * gru_1_fwd_t3_h_11 + (0.017382381483912468) * gru_1_fwd_t3_h_12 + (0.59949177503585815) * gru_1_fwd_t3_h_13 + (-0.7694929838180542) * gru_1_fwd_t3_h_14 + (-0.84058630466461182) * gru_1_fwd_t3_h_15 + (-0.25160661339759827) * gru_1_fwd_t3_h_16 + (-0.026627423241734505) * gru_1_fwd_t3_h_17 + (-0.89583492279052734) * gru_1_fwd_t3_h_18 + (-0.39361593127250671) * gru_1_fwd_t3_h_19 + (0.16620483994483948) * gru_1_fwd_t3_h_20 + (-0.038880672305822372) * gru_1_fwd_t3_h_21 + (-0.41281166672706604) * gru_1_fwd_t3_h_22 + (-0.57736748456954956) * gru_1_fwd_t3_h_23 + (-1.1113115549087524) * gru_1_fwd_t3_h_24 + (1.2116637229919434) * gru_1_fwd_t3_h_25 + (0.86436039209365845) * gru_1_fwd_t3_h_26 + (-2.1153652667999268) * gru_1_fwd_t3_h_27 + (0.40905645489692688) * gru_1_fwd_t3_h_28 + (0.45748615264892578) * gru_1_fwd_t3_h_29 + (-0.59583783149719238) * gru_1_fwd_t3_h_30 + (-0.44737356901168823) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((1.0137003660202026) + (0.096069946885108948) * gru_0_out_t4_0 + (0.60274285078048706) * gru_0_out_t4_1 + (1.8841409683227539) * gru_0_out_t4_2 + (-0.36468514800071716) * gru_0_out_t4_3 + (-0.11091623455286026) * gru_0_out_t4_4 + (0.17133083939552307) * gru_0_out_t4_5 + (-0.74669456481933594) * gru_0_out_t4_6 + (-1.0042018890380859) * gru_0_out_t4_7 + (0.46870109438896179) * gru_0_out_t4_8 + (0.86777263879776001) * gru_0_out_t4_9 + (-2.325650691986084) * gru_0_out_t4_10 + (-0.13318872451782227) * gru_0_out_t4_11 + (0.1803363561630249) * gru_0_out_t4_12 + (-0.01500435546040535) * gru_0_out_t4_13 + (0.22377978265285492) * gru_0_out_t4_14 + (-0.48864454030990601) * gru_0_out_t4_15 + (0.0064848419278860092) * gru_0_out_t4_16 + (0.26269811391830444) * gru_0_out_t4_17 + (0.088999420404434204) * gru_0_out_t4_18 + (-1.1525503396987915) * gru_0_out_t4_19 + (0.15682427585124969) * gru_0_out_t4_20 + (-0.17340855300426483) * gru_0_out_t4_21 + (-0.3393481969833374) * gru_0_out_t4_22 + (-0.10375408828258514) * gru_0_out_t4_23 + (-2.332902193069458) * gru_0_out_t4_24 + (-0.90679287910461426) * gru_0_out_t4_25 + (-0.050443381071090698) * gru_0_out_t4_26 + (0.94321978092193604) * gru_0_out_t4_27 + (-0.053961370140314102) * gru_0_out_t4_28 + (0.72054827213287354) * gru_0_out_t4_29 + (1.5476299524307251) * gru_0_out_t4_30 + (1.6552830934524536) * gru_0_out_t4_31 + (0.36996898055076599) * gru_0_out_t4_32 + (-0.56176078319549561) * gru_0_out_t4_33 + (-0.24438998103141785) * gru_0_out_t4_34 + (-0.66791278123855591) * gru_0_out_t4_35 + (-0.13870760798454285) * gru_0_out_t4_36 + (-0.04323713481426239) * gru_0_out_t4_37 + (0.50320303440093994) * gru_0_out_t4_38 + (0.23860694468021393) * gru_0_out_t4_39 + (0.083128005266189575) * gru_0_out_t4_40 + (-0.20730403065681458) * gru_0_out_t4_41 + (0.064789183437824249) * gru_0_out_t4_42 + (-0.33715721964836121) * gru_0_out_t4_43 + (0.029271423816680908) * gru_0_out_t4_44 + (-0.03444691002368927) * gru_0_out_t4_45 + (0.022111659869551659) * gru_0_out_t4_46 + (0.00010886295785894617) * gru_0_out_t4_47 + (-0.33459678292274475) * gru_0_out_t4_48 + (0.28829923272132874) * gru_0_out_t4_49 + (0.12606702744960785) * gru_0_out_t4_50 + (-0.2200017124414444) * gru_0_out_t4_51 + (0.1866936981678009) * gru_0_out_t4_52 + (0.057327117770910263) * gru_0_out_t4_53 + (-0.054931327700614929) * gru_0_out_t4_54 + (-0.19174535572528839) * gru_0_out_t4_55 + (0.002056170254945755) * gru_0_out_t4_56 + (-0.28556126356124878) * gru_0_out_t4_57 + (-0.41446033120155334) * gru_0_out_t4_58 + (0.21847237646579742) * gru_0_out_t4_59 + (0.079293161630630493) * gru_0_out_t4_60 + (0.08750731498003006) * gru_0_out_t4_61 + (1.6067353487014771) * gru_0_out_t4_62 + (-0.40200385451316833) * gru_0_out_t4_63 + (0.24674060940742493) * gru_1_fwd_t3_h_0 + (-0.0011159152491018176) * gru_1_fwd_t3_h_1 + (-0.025198619812726974) * gru_1_fwd_t3_h_2 + (0.0063190450891852379) * gru_1_fwd_t3_h_3 + (0.18125554919242859) * gru_1_fwd_t3_h_4 + (0.15080668032169342) * gru_1_fwd_t3_h_5 + (0.034605208784341812) * gru_1_fwd_t3_h_6 + (0.31796035170555115) * gru_1_fwd_t3_h_7 + (0.18267208337783813) * gru_1_fwd_t3_h_8 + (-0.047706462442874908) * gru_1_fwd_t3_h_9 + (0.26399099826812744) * gru_1_fwd_t3_h_10 + (0.9424889087677002) * gru_1_fwd_t3_h_11 + (-0.085302866995334625) * gru_1_fwd_t3_h_12 + (-0.051999066025018692) * gru_1_fwd_t3_h_13 + (-0.046016760170459747) * gru_1_fwd_t3_h_14 + (-0.071490518748760223) * gru_1_fwd_t3_h_15 + (-0.21830558776855469) * gru_1_fwd_t3_h_16 + (-0.13019084930419922) * gru_1_fwd_t3_h_17 + (0.55442208051681519) * gru_1_fwd_t3_h_18 + (-0.1526714563369751) * gru_1_fwd_t3_h_19 + (-0.051631193608045578) * gru_1_fwd_t3_h_20 + (0.05695328488945961) * gru_1_fwd_t3_h_21 + (0.2037513256072998) * gru_1_fwd_t3_h_22 + (-0.27845042943954468) * gru_1_fwd_t3_h_23 + (0.4123711884021759) * gru_1_fwd_t3_h_24 + (-0.24829399585723877) * gru_1_fwd_t3_h_25 + (0.3626922070980072) * gru_1_fwd_t3_h_26 + (0.0037178769707679749) * gru_1_fwd_t3_h_27 + (1.0910708904266357) * gru_1_fwd_t3_h_28 + (0.099506832659244537) * gru_1_fwd_t3_h_29 + (0.096690841019153595) * gru_1_fwd_t3_h_30 + (-0.013727192766964436) * gru_1_fwd_t3_h_31);
    gate_n = tanh((0.011667217127978802) + (-0.17605970799922943) * gru_0_out_t4_0 + (-0.28558093309402466) * gru_0_out_t4_1 + (-0.82366365194320679) * gru_0_out_t4_2 + (-1.3276199102401733) * gru_0_out_t4_3 + (1.5996085405349731) * gru_0_out_t4_4 + (0.14893645048141479) * gru_0_out_t4_5 + (-0.51614552736282349) * gru_0_out_t4_6 + (0.28483825922012329) * gru_0_out_t4_7 + (0.40029403567314148) * gru_0_out_t4_8 + (-0.72730797529220581) * gru_0_out_t4_9 + (0.60510170459747314) * gru_0_out_t4_10 + (-0.23110891878604889) * gru_0_out_t4_11 + (0.16136851906776428) * gru_0_out_t4_12 + (0.55385923385620117) * gru_0_out_t4_13 + (0.14843088388442993) * gru_0_out_t4_14 + (0.042584475129842758) * gru_0_out_t4_15 + (-0.022276997566223145) * gru_0_out_t4_16 + (-0.24395942687988281) * gru_0_out_t4_17 + (-0.082054078578948975) * gru_0_out_t4_18 + (-0.12776866555213928) * gru_0_out_t4_19 + (-0.69251143932342529) * gru_0_out_t4_20 + (-0.48548012971878052) * gru_0_out_t4_21 + (-0.4664052426815033) * gru_0_out_t4_22 + (-0.43287709355354309) * gru_0_out_t4_23 + (-0.62426561117172241) * gru_0_out_t4_24 + (0.28704565763473511) * gru_0_out_t4_25 + (0.52302896976470947) * gru_0_out_t4_26 + (-0.51696532964706421) * gru_0_out_t4_27 + (1.5256439447402954) * gru_0_out_t4_28 + (0.70288169384002686) * gru_0_out_t4_29 + (0.46908754110336304) * gru_0_out_t4_30 + (-2.6174004077911377) * gru_0_out_t4_31 + (0.28437396883964539) * gru_0_out_t4_32 + (-0.21844868361949921) * gru_0_out_t4_33 + (0.19128407537937164) * gru_0_out_t4_34 + (-0.54660451412200928) * gru_0_out_t4_35 + (0.013573847711086273) * gru_0_out_t4_36 + (-0.48077425360679626) * gru_0_out_t4_37 + (-0.054843436926603317) * gru_0_out_t4_38 + (0.45447456836700439) * gru_0_out_t4_39 + (-0.1343790739774704) * gru_0_out_t4_40 + (0.006156042218208313) * gru_0_out_t4_41 + (-0.31759673357009888) * gru_0_out_t4_42 + (0.31766647100448608) * gru_0_out_t4_43 + (-0.71415853500366211) * gru_0_out_t4_44 + (-0.62088453769683838) * gru_0_out_t4_45 + (-0.13849695026874542) * gru_0_out_t4_46 + (-0.21280704438686371) * gru_0_out_t4_47 + (0.062639042735099792) * gru_0_out_t4_48 + (0.014612744562327862) * gru_0_out_t4_49 + (0.02870761975646019) * gru_0_out_t4_50 + (-0.0040994440205395222) * gru_0_out_t4_51 + (0.11520720273256302) * gru_0_out_t4_52 + (-0.010840080678462982) * gru_0_out_t4_53 + (-0.048147425055503845) * gru_0_out_t4_54 + (0.5135035514831543) * gru_0_out_t4_55 + (-0.046957951039075851) * gru_0_out_t4_56 + (0.10739531368017197) * gru_0_out_t4_57 + (0.0012379726395010948) * gru_0_out_t4_58 + (-0.010854272171854973) * gru_0_out_t4_59 + (-0.31454750895500183) * gru_0_out_t4_60 + (-0.1097334697842598) * gru_0_out_t4_61 + (-1.3330061435699463) * gru_0_out_t4_62 + (-0.48009693622589111) * gru_0_out_t4_63 + gate_r * ((0.53222149610519409) + (-0.19964157044887543) * gru_1_fwd_t3_h_0 + (-0.64266508817672729) * gru_1_fwd_t3_h_1 + (0.77700501680374146) * gru_1_fwd_t3_h_2 + (-0.11378323286771774) * gru_1_fwd_t3_h_3 + (0.0045714420266449451) * gru_1_fwd_t3_h_4 + (-0.083188816905021667) * gru_1_fwd_t3_h_5 + (-1.7983860969543457) * gru_1_fwd_t3_h_6 + (-0.13725081086158752) * gru_1_fwd_t3_h_7 + (0.0013769841752946377) * gru_1_fwd_t3_h_8 + (0.53469586372375488) * gru_1_fwd_t3_h_9 + (-1.5929825305938721) * gru_1_fwd_t3_h_10 + (0.84426432847976685) * gru_1_fwd_t3_h_11 + (0.0093040848150849342) * gru_1_fwd_t3_h_12 + (-0.069953300058841705) * gru_1_fwd_t3_h_13 + (0.2974412739276886) * gru_1_fwd_t3_h_14 + (0.53654813766479492) * gru_1_fwd_t3_h_15 + (0.38515326380729675) * gru_1_fwd_t3_h_16 + (-0.29968741536140442) * gru_1_fwd_t3_h_17 + (-0.47595643997192383) * gru_1_fwd_t3_h_18 + (-0.27855798602104187) * gru_1_fwd_t3_h_19 + (0.46855705976486206) * gru_1_fwd_t3_h_20 + (-0.50183564424514771) * gru_1_fwd_t3_h_21 + (-0.32827281951904297) * gru_1_fwd_t3_h_22 + (0.37400898337364197) * gru_1_fwd_t3_h_23 + (0.91426616907119751) * gru_1_fwd_t3_h_24 + (-0.19293954968452454) * gru_1_fwd_t3_h_25 + (-0.54872512817382812) * gru_1_fwd_t3_h_26 + (0.39695465564727783) * gru_1_fwd_t3_h_27 + (-0.93786215782165527) * gru_1_fwd_t3_h_28 + (0.75340127944946289) * gru_1_fwd_t3_h_29 + (0.63832324743270874) * gru_1_fwd_t3_h_30 + (-0.8941267728805542) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_28 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_28;
    // h=29
    gate_r = sigmoid((-0.92251473665237427) + (-0.39038658142089844) * gru_0_out_t4_0 + (0.18780107796192169) * gru_0_out_t4_1 + (-1.0979119539260864) * gru_0_out_t4_2 + (-0.60150808095932007) * gru_0_out_t4_3 + (-0.14528946578502655) * gru_0_out_t4_4 + (-0.90606784820556641) * gru_0_out_t4_5 + (1.3516972064971924) * gru_0_out_t4_6 + (-0.89922827482223511) * gru_0_out_t4_7 + (0.41642627120018005) * gru_0_out_t4_8 + (-2.7407538890838623) * gru_0_out_t4_9 + (0.65814995765686035) * gru_0_out_t4_10 + (0.087023518979549408) * gru_0_out_t4_11 + (0.14722952246665955) * gru_0_out_t4_12 + (-0.4251905083656311) * gru_0_out_t4_13 + (-0.46483990550041199) * gru_0_out_t4_14 + (0.20667056739330292) * gru_0_out_t4_15 + (0.050824549049139023) * gru_0_out_t4_16 + (-0.25552272796630859) * gru_0_out_t4_17 + (-0.23700647056102753) * gru_0_out_t4_18 + (0.23406417667865753) * gru_0_out_t4_19 + (-2.9941120147705078) * gru_0_out_t4_20 + (-0.44341227412223816) * gru_0_out_t4_21 + (2.0404627323150635) * gru_0_out_t4_22 + (-0.4838111400604248) * gru_0_out_t4_23 + (-0.84234941005706787) * gru_0_out_t4_24 + (1.0689977407455444) * gru_0_out_t4_25 + (0.68949627876281738) * gru_0_out_t4_26 + (0.49937337636947632) * gru_0_out_t4_27 + (-1.271941065788269) * gru_0_out_t4_28 + (-0.82917135953903198) * gru_0_out_t4_29 + (-0.67583984136581421) * gru_0_out_t4_30 + (0.60815346240997314) * gru_0_out_t4_31 + (-0.22063110768795013) * gru_0_out_t4_32 + (0.32702028751373291) * gru_0_out_t4_33 + (0.29341697692871094) * gru_0_out_t4_34 + (-1.2571684122085571) * gru_0_out_t4_35 + (-0.16803900897502899) * gru_0_out_t4_36 + (0.073361046612262726) * gru_0_out_t4_37 + (0.36117705702781677) * gru_0_out_t4_38 + (0.61497890949249268) * gru_0_out_t4_39 + (-2.3874959945678711) * gru_0_out_t4_40 + (0.11008328199386597) * gru_0_out_t4_41 + (-0.89313274621963501) * gru_0_out_t4_42 + (-0.055917855352163315) * gru_0_out_t4_43 + (-1.0683904886245728) * gru_0_out_t4_44 + (-1.0985851287841797) * gru_0_out_t4_45 + (-0.0056257913820445538) * gru_0_out_t4_46 + (0.95078510046005249) * gru_0_out_t4_47 + (-0.22642657160758972) * gru_0_out_t4_48 + (0.40927204489707947) * gru_0_out_t4_49 + (-1.3455471992492676) * gru_0_out_t4_50 + (-0.37723469734191895) * gru_0_out_t4_51 + (-0.12355297058820724) * gru_0_out_t4_52 + (0.29326564073562622) * gru_0_out_t4_53 + (0.2992006242275238) * gru_0_out_t4_54 + (0.7466089129447937) * gru_0_out_t4_55 + (0.051136508584022522) * gru_0_out_t4_56 + (0.40840333700180054) * gru_0_out_t4_57 + (-0.078412361443042755) * gru_0_out_t4_58 + (-0.57041716575622559) * gru_0_out_t4_59 + (-0.1657002866268158) * gru_0_out_t4_60 + (0.17158176004886627) * gru_0_out_t4_61 + (-0.18634362518787384) * gru_0_out_t4_62 + (0.025293445214629173) * gru_0_out_t4_63 + (-1.0929297208786011) * gru_1_fwd_t3_h_0 + (0.70284289121627808) * gru_1_fwd_t3_h_1 + (-0.18219971656799316) * gru_1_fwd_t3_h_2 + (0.48118415474891663) * gru_1_fwd_t3_h_3 + (-0.25667822360992432) * gru_1_fwd_t3_h_4 + (0.30920293927192688) * gru_1_fwd_t3_h_5 + (-0.37201675772666931) * gru_1_fwd_t3_h_6 + (-1.4938733577728271) * gru_1_fwd_t3_h_7 + (-0.25639298558235168) * gru_1_fwd_t3_h_8 + (-0.61872786283493042) * gru_1_fwd_t3_h_9 + (-0.040455549955368042) * gru_1_fwd_t3_h_10 + (0.69775509834289551) * gru_1_fwd_t3_h_11 + (-0.91314244270324707) * gru_1_fwd_t3_h_12 + (0.37844234704971313) * gru_1_fwd_t3_h_13 + (-0.38517078757286072) * gru_1_fwd_t3_h_14 + (-0.17661190032958984) * gru_1_fwd_t3_h_15 + (-0.65481746196746826) * gru_1_fwd_t3_h_16 + (0.44163432717323303) * gru_1_fwd_t3_h_17 + (-0.87098026275634766) * gru_1_fwd_t3_h_18 + (0.29194188117980957) * gru_1_fwd_t3_h_19 + (-0.88437032699584961) * gru_1_fwd_t3_h_20 + (-0.14314882457256317) * gru_1_fwd_t3_h_21 + (0.77341514825820923) * gru_1_fwd_t3_h_22 + (1.8835701942443848) * gru_1_fwd_t3_h_23 + (-0.0038290293887257576) * gru_1_fwd_t3_h_24 + (-0.087611503899097443) * gru_1_fwd_t3_h_25 + (-0.1818520575761795) * gru_1_fwd_t3_h_26 + (-0.384307861328125) * gru_1_fwd_t3_h_27 + (1.2861114740371704) * gru_1_fwd_t3_h_28 + (-0.32839804887771606) * gru_1_fwd_t3_h_29 + (-0.88660091161727905) * gru_1_fwd_t3_h_30 + (-0.80877888202667236) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((-0.18232904374599457) + (-0.26437678933143616) * gru_0_out_t4_0 + (-0.4286353588104248) * gru_0_out_t4_1 + (-0.12445326149463654) * gru_0_out_t4_2 + (-0.27898070216178894) * gru_0_out_t4_3 + (-0.67298007011413574) * gru_0_out_t4_4 + (0.10678032785654068) * gru_0_out_t4_5 + (-0.13382937014102936) * gru_0_out_t4_6 + (0.86131185293197632) * gru_0_out_t4_7 + (0.22485291957855225) * gru_0_out_t4_8 + (0.13595423102378845) * gru_0_out_t4_9 + (-0.3052753210067749) * gru_0_out_t4_10 + (-0.20924863219261169) * gru_0_out_t4_11 + (0.30744278430938721) * gru_0_out_t4_12 + (0.061156276613473892) * gru_0_out_t4_13 + (0.48276069760322571) * gru_0_out_t4_14 + (0.025003233924508095) * gru_0_out_t4_15 + (-0.047980852425098419) * gru_0_out_t4_16 + (-0.030386634171009064) * gru_0_out_t4_17 + (-0.19038741290569305) * gru_0_out_t4_18 + (0.84015893936157227) * gru_0_out_t4_19 + (-0.93565154075622559) * gru_0_out_t4_20 + (-0.38451692461967468) * gru_0_out_t4_21 + (0.25221136212348938) * gru_0_out_t4_22 + (0.32603296637535095) * gru_0_out_t4_23 + (-0.019660614430904388) * gru_0_out_t4_24 + (-0.17786833643913269) * gru_0_out_t4_25 + (0.3067183792591095) * gru_0_out_t4_26 + (0.06872229278087616) * gru_0_out_t4_27 + (-0.10167368501424789) * gru_0_out_t4_28 + (-1.7044744491577148) * gru_0_out_t4_29 + (0.024157552048563957) * gru_0_out_t4_30 + (0.34286314249038696) * gru_0_out_t4_31 + (-0.10277240723371506) * gru_0_out_t4_32 + (0.0061269998550415039) * gru_0_out_t4_33 + (-0.038921181112527847) * gru_0_out_t4_34 + (0.20917965471744537) * gru_0_out_t4_35 + (0.16311877965927124) * gru_0_out_t4_36 + (-0.10550557821989059) * gru_0_out_t4_37 + (-0.4192451536655426) * gru_0_out_t4_38 + (-0.29392677545547485) * gru_0_out_t4_39 + (-0.24233916401863098) * gru_0_out_t4_40 + (0.25208958983421326) * gru_0_out_t4_41 + (0.10305343568325043) * gru_0_out_t4_42 + (0.62102681398391724) * gru_0_out_t4_43 + (-0.092553615570068359) * gru_0_out_t4_44 + (0.2716405987739563) * gru_0_out_t4_45 + (-0.64507049322128296) * gru_0_out_t4_46 + (0.12457276880741119) * gru_0_out_t4_47 + (-0.43000948429107666) * gru_0_out_t4_48 + (0.4840741753578186) * gru_0_out_t4_49 + (-0.14294683933258057) * gru_0_out_t4_50 + (0.12674605846405029) * gru_0_out_t4_51 + (-0.14768955111503601) * gru_0_out_t4_52 + (0.3890531063079834) * gru_0_out_t4_53 + (0.10121145099401474) * gru_0_out_t4_54 + (-0.090991459786891937) * gru_0_out_t4_55 + (-0.10262981802225113) * gru_0_out_t4_56 + (0.55476874113082886) * gru_0_out_t4_57 + (-0.29845055937767029) * gru_0_out_t4_58 + (-0.73720848560333252) * gru_0_out_t4_59 + (-0.44876658916473389) * gru_0_out_t4_60 + (-0.035825416445732117) * gru_0_out_t4_61 + (0.27086958289146423) * gru_0_out_t4_62 + (-0.71472722291946411) * gru_0_out_t4_63 + (0.057411674410104752) * gru_1_fwd_t3_h_0 + (-0.15579858422279358) * gru_1_fwd_t3_h_1 + (-0.6229933500289917) * gru_1_fwd_t3_h_2 + (-0.20059424638748169) * gru_1_fwd_t3_h_3 + (-0.38399079442024231) * gru_1_fwd_t3_h_4 + (-0.060798134654760361) * gru_1_fwd_t3_h_5 + (0.14114730060100555) * gru_1_fwd_t3_h_6 + (-0.30177551507949829) * gru_1_fwd_t3_h_7 + (-0.52773034572601318) * gru_1_fwd_t3_h_8 + (-0.18064978718757629) * gru_1_fwd_t3_h_9 + (0.47161322832107544) * gru_1_fwd_t3_h_10 + (0.089969314634799957) * gru_1_fwd_t3_h_11 + (0.086202919483184814) * gru_1_fwd_t3_h_12 + (0.015513378195464611) * gru_1_fwd_t3_h_13 + (0.12318819761276245) * gru_1_fwd_t3_h_14 + (-0.1859833300113678) * gru_1_fwd_t3_h_15 + (-0.53603875637054443) * gru_1_fwd_t3_h_16 + (0.11749225854873657) * gru_1_fwd_t3_h_17 + (0.00500113470479846) * gru_1_fwd_t3_h_18 + (-0.041099566966295242) * gru_1_fwd_t3_h_19 + (0.11230854690074921) * gru_1_fwd_t3_h_20 + (-0.25465580821037292) * gru_1_fwd_t3_h_21 + (0.41686552762985229) * gru_1_fwd_t3_h_22 + (0.34239977598190308) * gru_1_fwd_t3_h_23 + (-0.16125604510307312) * gru_1_fwd_t3_h_24 + (0.20833046734333038) * gru_1_fwd_t3_h_25 + (-0.54144781827926636) * gru_1_fwd_t3_h_26 + (-0.08436419814825058) * gru_1_fwd_t3_h_27 + (0.35974821448326111) * gru_1_fwd_t3_h_28 + (0.12576025724411011) * gru_1_fwd_t3_h_29 + (-0.11114911735057831) * gru_1_fwd_t3_h_30 + (0.12313659489154816) * gru_1_fwd_t3_h_31);
    gate_n = tanh((0.12120528519153595) + (0.28564846515655518) * gru_0_out_t4_0 + (0.22857376933097839) * gru_0_out_t4_1 + (0.17756438255310059) * gru_0_out_t4_2 + (-0.073568843305110931) * gru_0_out_t4_3 + (-0.33869859576225281) * gru_0_out_t4_4 + (0.21034930646419525) * gru_0_out_t4_5 + (0.72564953565597534) * gru_0_out_t4_6 + (0.9947088360786438) * gru_0_out_t4_7 + (-0.40192848443984985) * gru_0_out_t4_8 + (0.64239752292633057) * gru_0_out_t4_9 + (-0.24684731662273407) * gru_0_out_t4_10 + (-0.1534239798784256) * gru_0_out_t4_11 + (-0.0077988333068788052) * gru_0_out_t4_12 + (-0.2785874605178833) * gru_0_out_t4_13 + (0.19792993366718292) * gru_0_out_t4_14 + (-0.054874520748853683) * gru_0_out_t4_15 + (-0.37053728103637695) * gru_0_out_t4_16 + (0.13209408521652222) * gru_0_out_t4_17 + (0.050557289272546768) * gru_0_out_t4_18 + (0.57551783323287964) * gru_0_out_t4_19 + (-0.051689870655536652) * gru_0_out_t4_20 + (-0.69426029920578003) * gru_0_out_t4_21 + (0.10245537012815475) * gru_0_out_t4_22 + (-0.011866878718137741) * gru_0_out_t4_23 + (0.05868472158908844) * gru_0_out_t4_24 + (-0.046631984412670135) * gru_0_out_t4_25 + (0.17341381311416626) * gru_0_out_t4_26 + (0.15153449773788452) * gru_0_out_t4_27 + (0.16346319019794464) * gru_0_out_t4_28 + (0.94332766532897949) * gru_0_out_t4_29 + (0.10900005698204041) * gru_0_out_t4_30 + (0.88893681764602661) * gru_0_out_t4_31 + (-0.069288603961467743) * gru_0_out_t4_32 + (-0.03596058115363121) * gru_0_out_t4_33 + (-0.11243406683206558) * gru_0_out_t4_34 + (0.39156016707420349) * gru_0_out_t4_35 + (0.17132367193698883) * gru_0_out_t4_36 + (0.24726103246212006) * gru_0_out_t4_37 + (0.047508165240287781) * gru_0_out_t4_38 + (-0.33634099364280701) * gru_0_out_t4_39 + (-1.1995304822921753) * gru_0_out_t4_40 + (-0.31652563810348511) * gru_0_out_t4_41 + (-0.15060724318027496) * gru_0_out_t4_42 + (0.47918146848678589) * gru_0_out_t4_43 + (1.3099504709243774) * gru_0_out_t4_44 + (0.62214607000350952) * gru_0_out_t4_45 + (-0.082700416445732117) * gru_0_out_t4_46 + (0.22489620745182037) * gru_0_out_t4_47 + (0.37489819526672363) * gru_0_out_t4_48 + (-0.16318130493164062) * gru_0_out_t4_49 + (-0.032881557941436768) * gru_0_out_t4_50 + (0.090284258127212524) * gru_0_out_t4_51 + (0.22930942475795746) * gru_0_out_t4_52 + (0.3191530704498291) * gru_0_out_t4_53 + (0.29595097899436951) * gru_0_out_t4_54 + (-0.161802738904953) * gru_0_out_t4_55 + (0.0040839491412043571) * gru_0_out_t4_56 + (-0.17017653584480286) * gru_0_out_t4_57 + (-0.22138632833957672) * gru_0_out_t4_58 + (0.075147949159145355) * gru_0_out_t4_59 + (0.032837070524692535) * gru_0_out_t4_60 + (0.092099487781524658) * gru_0_out_t4_61 + (0.75731873512268066) * gru_0_out_t4_62 + (-0.05792517215013504) * gru_0_out_t4_63 + gate_r * ((0.27020663022994995) + (0.42967358231544495) * gru_1_fwd_t3_h_0 + (0.051386225968599319) * gru_1_fwd_t3_h_1 + (0.030685152858495712) * gru_1_fwd_t3_h_2 + (0.15159566700458527) * gru_1_fwd_t3_h_3 + (-0.027563313022255898) * gru_1_fwd_t3_h_4 + (0.36346542835235596) * gru_1_fwd_t3_h_5 + (-0.48427659273147583) * gru_1_fwd_t3_h_6 + (0.25328773260116577) * gru_1_fwd_t3_h_7 + (-0.34390914440155029) * gru_1_fwd_t3_h_8 + (-0.13072216510772705) * gru_1_fwd_t3_h_9 + (0.39448630809783936) * gru_1_fwd_t3_h_10 + (-0.32216966152191162) * gru_1_fwd_t3_h_11 + (0.48105406761169434) * gru_1_fwd_t3_h_12 + (-0.16890552639961243) * gru_1_fwd_t3_h_13 + (-0.38706314563751221) * gru_1_fwd_t3_h_14 + (0.065970517694950104) * gru_1_fwd_t3_h_15 + (-0.74366933107376099) * gru_1_fwd_t3_h_16 + (0.94575279951095581) * gru_1_fwd_t3_h_17 + (0.24756017327308655) * gru_1_fwd_t3_h_18 + (-0.10361628234386444) * gru_1_fwd_t3_h_19 + (-0.057735707610845566) * gru_1_fwd_t3_h_20 + (-0.094727985560894012) * gru_1_fwd_t3_h_21 + (0.34846204519271851) * gru_1_fwd_t3_h_22 + (0.76291912794113159) * gru_1_fwd_t3_h_23 + (-0.076669603586196899) * gru_1_fwd_t3_h_24 + (-1.1638548374176025) * gru_1_fwd_t3_h_25 + (-0.069115489721298218) * gru_1_fwd_t3_h_26 + (-0.80495637655258179) * gru_1_fwd_t3_h_27 + (-0.38515543937683105) * gru_1_fwd_t3_h_28 + (-0.24010039865970612) * gru_1_fwd_t3_h_29 + (1.1315605640411377) * gru_1_fwd_t3_h_30 + (-0.83713710308074951) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_29 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_29;
    // h=30
    gate_r = sigmoid((-0.87800562381744385) + (-0.41584101319313049) * gru_0_out_t4_0 + (0.59360259771347046) * gru_0_out_t4_1 + (-2.2012012004852295) * gru_0_out_t4_2 + (1.5722604990005493) * gru_0_out_t4_3 + (-0.25129833817481995) * gru_0_out_t4_4 + (-0.85926437377929688) * gru_0_out_t4_5 + (0.64337301254272461) * gru_0_out_t4_6 + (-1.6870865821838379) * gru_0_out_t4_7 + (0.76307642459869385) * gru_0_out_t4_8 + (4.9361882209777832) * gru_0_out_t4_9 + (1.5827140808105469) * gru_0_out_t4_10 + (0.080501250922679901) * gru_0_out_t4_11 + (-0.79519248008728027) * gru_0_out_t4_12 + (-0.62619203329086304) * gru_0_out_t4_13 + (0.18324898183345795) * gru_0_out_t4_14 + (-0.12463359534740448) * gru_0_out_t4_15 + (0.18113318085670471) * gru_0_out_t4_16 + (0.013808397576212883) * gru_0_out_t4_17 + (1.13974928855896) * gru_0_out_t4_18 + (-0.44139990210533142) * gru_0_out_t4_19 + (-2.1949512958526611) * gru_0_out_t4_20 + (0.69584202766418457) * gru_0_out_t4_21 + (-0.28655910491943359) * gru_0_out_t4_22 + (0.71894443035125732) * gru_0_out_t4_23 + (0.51268464326858521) * gru_0_out_t4_24 + (0.62979280948638916) * gru_0_out_t4_25 + (-0.10160199552774429) * gru_0_out_t4_26 + (1.2147579193115234) * gru_0_out_t4_27 + (2.3889882564544678) * gru_0_out_t4_28 + (-2.6312212944030762) * gru_0_out_t4_29 + (-0.68045198917388916) * gru_0_out_t4_30 + (1.4183875322341919) * gru_0_out_t4_31 + (-0.31072995066642761) * gru_0_out_t4_32 + (0.041240468621253967) * gru_0_out_t4_33 + (-0.44501224160194397) * gru_0_out_t4_34 + (0.13489139080047607) * gru_0_out_t4_35 + (-0.3802039623260498) * gru_0_out_t4_36 + (0.44867396354675293) * gru_0_out_t4_37 + (-0.13104119896888733) * gru_0_out_t4_38 + (-0.38637632131576538) * gru_0_out_t4_39 + (3.0194530487060547) * gru_0_out_t4_40 + (-0.31058061122894287) * gru_0_out_t4_41 + (-0.37162059545516968) * gru_0_out_t4_42 + (0.25503495335578918) * gru_0_out_t4_43 + (-0.67699432373046875) * gru_0_out_t4_44 + (-2.6132040023803711) * gru_0_out_t4_45 + (-4.2873120307922363) * gru_0_out_t4_46 + (0.43747135996818542) * gru_0_out_t4_47 + (-0.055046122521162033) * gru_0_out_t4_48 + (-0.24431082606315613) * gru_0_out_t4_49 + (-0.20195411145687103) * gru_0_out_t4_50 + (-0.27531734108924866) * gru_0_out_t4_51 + (-0.1162588819861412) * gru_0_out_t4_52 + (0.043718867003917694) * gru_0_out_t4_53 + (1.123220682144165) * gru_0_out_t4_54 + (-0.48221501708030701) * gru_0_out_t4_55 + (-2.667670726776123) * gru_0_out_t4_56 + (-0.2941209077835083) * gru_0_out_t4_57 + (0.55179321765899658) * gru_0_out_t4_58 + (-4.1740527153015137) * gru_0_out_t4_59 + (0.85722410678863525) * gru_0_out_t4_60 + (0.86690986156463623) * gru_0_out_t4_61 + (0.11539726704359055) * gru_0_out_t4_62 + (-0.96707421541213989) * gru_0_out_t4_63 + (-0.61436599493026733) * gru_1_fwd_t3_h_0 + (0.44080919027328491) * gru_1_fwd_t3_h_1 + (-0.48235085606575012) * gru_1_fwd_t3_h_2 + (-0.49386709928512573) * gru_1_fwd_t3_h_3 + (-1.1748334169387817) * gru_1_fwd_t3_h_4 + (1.4584587812423706) * gru_1_fwd_t3_h_5 + (0.38690704107284546) * gru_1_fwd_t3_h_6 + (-0.45707559585571289) * gru_1_fwd_t3_h_7 + (-0.17846176028251648) * gru_1_fwd_t3_h_8 + (-0.21318328380584717) * gru_1_fwd_t3_h_9 + (-0.61539387702941895) * gru_1_fwd_t3_h_10 + (-0.40382620692253113) * gru_1_fwd_t3_h_11 + (-0.20002022385597229) * gru_1_fwd_t3_h_12 + (2.8420925140380859) * gru_1_fwd_t3_h_13 + (0.20315040647983551) * gru_1_fwd_t3_h_14 + (-1.2480728626251221) * gru_1_fwd_t3_h_15 + (0.10917195677757263) * gru_1_fwd_t3_h_16 + (0.11197753995656967) * gru_1_fwd_t3_h_17 + (0.31522572040557861) * gru_1_fwd_t3_h_18 + (-0.69235688447952271) * gru_1_fwd_t3_h_19 + (-0.065415553748607635) * gru_1_fwd_t3_h_20 + (0.077324323356151581) * gru_1_fwd_t3_h_21 + (-0.12152609974145889) * gru_1_fwd_t3_h_22 + (0.80269205570220947) * gru_1_fwd_t3_h_23 + (-3.3419895172119141) * gru_1_fwd_t3_h_24 + (0.16012333333492279) * gru_1_fwd_t3_h_25 + (1.0432395935058594) * gru_1_fwd_t3_h_26 + (-1.8395140171051025) * gru_1_fwd_t3_h_27 + (-0.5039067268371582) * gru_1_fwd_t3_h_28 + (0.55184352397918701) * gru_1_fwd_t3_h_29 + (-0.55008184909820557) * gru_1_fwd_t3_h_30 + (0.36071956157684326) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((0.81773966550827026) + (0.17128559947013855) * gru_0_out_t4_0 + (-0.51793885231018066) * gru_0_out_t4_1 + (0.51331305503845215) * gru_0_out_t4_2 + (-0.44945234060287476) * gru_0_out_t4_3 + (0.13168874382972717) * gru_0_out_t4_4 + (0.016976071521639824) * gru_0_out_t4_5 + (1.5168601274490356) * gru_0_out_t4_6 + (-0.71693128347396851) * gru_0_out_t4_7 + (0.15520215034484863) * gru_0_out_t4_8 + (-0.64068073034286499) * gru_0_out_t4_9 + (-0.66163694858551025) * gru_0_out_t4_10 + (0.49458721280097961) * gru_0_out_t4_11 + (0.018319370225071907) * gru_0_out_t4_12 + (0.17013433575630188) * gru_0_out_t4_13 + (0.37342756986618042) * gru_0_out_t4_14 + (-0.02631581574678421) * gru_0_out_t4_15 + (-0.10172482579946518) * gru_0_out_t4_16 + (-0.43277004361152649) * gru_0_out_t4_17 + (-0.14652739465236664) * gru_0_out_t4_18 + (-0.44512426853179932) * gru_0_out_t4_19 + (0.13564082980155945) * gru_0_out_t4_20 + (-0.78439807891845703) * gru_0_out_t4_21 + (-0.015992544591426849) * gru_0_out_t4_22 + (-0.55673116445541382) * gru_0_out_t4_23 + (-0.49685096740722656) * gru_0_out_t4_24 + (-0.25559842586517334) * gru_0_out_t4_25 + (0.025627493858337402) * gru_0_out_t4_26 + (0.076091594994068146) * gru_0_out_t4_27 + (-0.25891414284706116) * gru_0_out_t4_28 + (0.13967178761959076) * gru_0_out_t4_29 + (0.1750156432390213) * gru_0_out_t4_30 + (0.051146168261766434) * gru_0_out_t4_31 + (-0.66478806734085083) * gru_0_out_t4_32 + (-0.055683236569166183) * gru_0_out_t4_33 + (0.16161510348320007) * gru_0_out_t4_34 + (0.34235835075378418) * gru_0_out_t4_35 + (-0.37824755907058716) * gru_0_out_t4_36 + (0.058202415704727173) * gru_0_out_t4_37 + (-0.18683938682079315) * gru_0_out_t4_38 + (-0.22148546576499939) * gru_0_out_t4_39 + (2.8642311096191406) * gru_0_out_t4_40 + (0.051959097385406494) * gru_0_out_t4_41 + (0.049915306270122528) * gru_0_out_t4_42 + (-0.239407017827034) * gru_0_out_t4_43 + (0.27826902270317078) * gru_0_out_t4_44 + (0.085136577486991882) * gru_0_out_t4_45 + (-0.041466694325208664) * gru_0_out_t4_46 + (-0.1715027391910553) * gru_0_out_t4_47 + (-0.18039460480213165) * gru_0_out_t4_48 + (-0.19996148347854614) * gru_0_out_t4_49 + (-0.35861837863922119) * gru_0_out_t4_50 + (0.024664273485541344) * gru_0_out_t4_51 + (0.29042401909828186) * gru_0_out_t4_52 + (0.25259080529212952) * gru_0_out_t4_53 + (0.21901717782020569) * gru_0_out_t4_54 + (0.35172504186630249) * gru_0_out_t4_55 + (0.21156875789165497) * gru_0_out_t4_56 + (-0.5028001070022583) * gru_0_out_t4_57 + (0.17370127141475677) * gru_0_out_t4_58 + (-0.15604369342327118) * gru_0_out_t4_59 + (0.3632272481918335) * gru_0_out_t4_60 + (0.5702512264251709) * gru_0_out_t4_61 + (-0.28417560458183289) * gru_0_out_t4_62 + (0.22897376120090485) * gru_0_out_t4_63 + (0.39468196034431458) * gru_1_fwd_t3_h_0 + (-0.14721629023551941) * gru_1_fwd_t3_h_1 + (-0.14268027245998383) * gru_1_fwd_t3_h_2 + (0.5336032509803772) * gru_1_fwd_t3_h_3 + (0.061225499957799911) * gru_1_fwd_t3_h_4 + (0.11972998827695847) * gru_1_fwd_t3_h_5 + (0.44489341974258423) * gru_1_fwd_t3_h_6 + (-0.20280379056930542) * gru_1_fwd_t3_h_7 + (0.031419336795806885) * gru_1_fwd_t3_h_8 + (0.25528791546821594) * gru_1_fwd_t3_h_9 + (0.67770892381668091) * gru_1_fwd_t3_h_10 + (1.595887303352356) * gru_1_fwd_t3_h_11 + (0.15991699695587158) * gru_1_fwd_t3_h_12 + (0.43232199549674988) * gru_1_fwd_t3_h_13 + (-0.16868048906326294) * gru_1_fwd_t3_h_14 + (0.30507537722587585) * gru_1_fwd_t3_h_15 + (-0.15547291934490204) * gru_1_fwd_t3_h_16 + (-0.11896631121635437) * gru_1_fwd_t3_h_17 + (0.12108030170202255) * gru_1_fwd_t3_h_18 + (-0.29632341861724854) * gru_1_fwd_t3_h_19 + (0.22881783545017242) * gru_1_fwd_t3_h_20 + (0.024817664176225662) * gru_1_fwd_t3_h_21 + (-0.92640131711959839) * gru_1_fwd_t3_h_22 + (-0.10434645414352417) * gru_1_fwd_t3_h_23 + (-0.32338699698448181) * gru_1_fwd_t3_h_24 + (1.0961728096008301) * gru_1_fwd_t3_h_25 + (0.24012205004692078) * gru_1_fwd_t3_h_26 + (-0.56309175491333008) * gru_1_fwd_t3_h_27 + (-0.38263919949531555) * gru_1_fwd_t3_h_28 + (0.29432976245880127) * gru_1_fwd_t3_h_29 + (-0.5445786714553833) * gru_1_fwd_t3_h_30 + (-0.02663467638194561) * gru_1_fwd_t3_h_31);
    gate_n = tanh((0.17851637303829193) + (0.14289499819278717) * gru_0_out_t4_0 + (0.16936215758323669) * gru_0_out_t4_1 + (0.50309932231903076) * gru_0_out_t4_2 + (-0.18246500194072723) * gru_0_out_t4_3 + (0.10168271511793137) * gru_0_out_t4_4 + (0.54029220342636108) * gru_0_out_t4_5 + (-1.9932767152786255) * gru_0_out_t4_6 + (-0.36201292276382446) * gru_0_out_t4_7 + (0.25891381502151489) * gru_0_out_t4_8 + (1.9638186693191528) * gru_0_out_t4_9 + (-0.36765179038047791) * gru_0_out_t4_10 + (0.0019499900517985225) * gru_0_out_t4_11 + (0.056114867329597473) * gru_0_out_t4_12 + (-0.58612453937530518) * gru_0_out_t4_13 + (-0.18934787809848785) * gru_0_out_t4_14 + (-0.020162424072623253) * gru_0_out_t4_15 + (0.050897553563117981) * gru_0_out_t4_16 + (0.067513041198253632) * gru_0_out_t4_17 + (0.073611602187156677) * gru_0_out_t4_18 + (-1.5869557857513428) * gru_0_out_t4_19 + (2.5913383960723877) * gru_0_out_t4_20 + (-0.033429812639951706) * gru_0_out_t4_21 + (-0.28313186764717102) * gru_0_out_t4_22 + (-0.047054562717676163) * gru_0_out_t4_23 + (-0.52044552564620972) * gru_0_out_t4_24 + (-0.42122718691825867) * gru_0_out_t4_25 + (0.0084508629515767097) * gru_0_out_t4_26 + (0.24854691326618195) * gru_0_out_t4_27 + (-0.97305792570114136) * gru_0_out_t4_28 + (0.52897018194198608) * gru_0_out_t4_29 + (0.11280126124620438) * gru_0_out_t4_30 + (0.31845730543136597) * gru_0_out_t4_31 + (0.16383849084377289) * gru_0_out_t4_32 + (-0.18815319240093231) * gru_0_out_t4_33 + (0.19882600009441376) * gru_0_out_t4_34 + (0.67761373519897461) * gru_0_out_t4_35 + (0.15303881466388702) * gru_0_out_t4_36 + (0.45678576827049255) * gru_0_out_t4_37 + (-0.073499426245689392) * gru_0_out_t4_38 + (1.6164712905883789) * gru_0_out_t4_39 + (-0.9342275857925415) * gru_0_out_t4_40 + (-0.10331630706787109) * gru_0_out_t4_41 + (0.579814612865448) * gru_0_out_t4_42 + (-0.19202439486980438) * gru_0_out_t4_43 + (-0.13954652845859528) * gru_0_out_t4_44 + (0.13703949749469757) * gru_0_out_t4_45 + (0.74812281131744385) * gru_0_out_t4_46 + (0.21106395125389099) * gru_0_out_t4_47 + (-0.19199571013450623) * gru_0_out_t4_48 + (0.082236967980861664) * gru_0_out_t4_49 + (-0.17156831920146942) * gru_0_out_t4_50 + (-0.12784421443939209) * gru_0_out_t4_51 + (-0.21391257643699646) * gru_0_out_t4_52 + (-0.21236398816108704) * gru_0_out_t4_53 + (0.011413926258683205) * gru_0_out_t4_54 + (-0.42029207944869995) * gru_0_out_t4_55 + (0.24968110024929047) * gru_0_out_t4_56 + (-0.27038609981536865) * gru_0_out_t4_57 + (0.12691529095172882) * gru_0_out_t4_58 + (0.20633998513221741) * gru_0_out_t4_59 + (0.097483158111572266) * gru_0_out_t4_60 + (0.19520801305770874) * gru_0_out_t4_61 + (1.0024480819702148) * gru_0_out_t4_62 + (-0.53255677223205566) * gru_0_out_t4_63 + gate_r * ((-0.35194575786590576) + (-0.45696541666984558) * gru_1_fwd_t3_h_0 + (-0.65750789642333984) * gru_1_fwd_t3_h_1 + (0.23430661857128143) * gru_1_fwd_t3_h_2 + (-0.0047439867630600929) * gru_1_fwd_t3_h_3 + (-0.0060073747299611568) * gru_1_fwd_t3_h_4 + (-0.68213802576065063) * gru_1_fwd_t3_h_5 + (-0.41535043716430664) * gru_1_fwd_t3_h_6 + (0.015719737857580185) * gru_1_fwd_t3_h_7 + (-0.030802538618445396) * gru_1_fwd_t3_h_8 + (-0.040794104337692261) * gru_1_fwd_t3_h_9 + (-0.07798420637845993) * gru_1_fwd_t3_h_10 + (0.15590459108352661) * gru_1_fwd_t3_h_11 + (0.16182461380958557) * gru_1_fwd_t3_h_12 + (-0.32864117622375488) * gru_1_fwd_t3_h_13 + (0.15254636108875275) * gru_1_fwd_t3_h_14 + (0.49963536858558655) * gru_1_fwd_t3_h_15 + (-0.069818541407585144) * gru_1_fwd_t3_h_16 + (0.19067126512527466) * gru_1_fwd_t3_h_17 + (0.96171349287033081) * gru_1_fwd_t3_h_18 + (0.21743594110012054) * gru_1_fwd_t3_h_19 + (-0.17560100555419922) * gru_1_fwd_t3_h_20 + (0.068666264414787292) * gru_1_fwd_t3_h_21 + (0.4168703556060791) * gru_1_fwd_t3_h_22 + (-0.72557055950164795) * gru_1_fwd_t3_h_23 + (-0.86604911088943481) * gru_1_fwd_t3_h_24 + (-0.86029863357543945) * gru_1_fwd_t3_h_25 + (1.7546672821044922) * gru_1_fwd_t3_h_26 + (0.16154970228672028) * gru_1_fwd_t3_h_27 + (-0.13596808910369873) * gru_1_fwd_t3_h_28 + (0.032455042004585266) * gru_1_fwd_t3_h_29 + (-1.4149153232574463) * gru_1_fwd_t3_h_30 + (0.62882614135742188) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_30 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_30;
    // h=31
    gate_r = sigmoid((0.20967334508895874) + (-0.29990220069885254) * gru_0_out_t4_0 + (0.19239795207977295) * gru_0_out_t4_1 + (-0.26743611693382263) * gru_0_out_t4_2 + (-0.62649214267730713) * gru_0_out_t4_3 + (0.68589323759078979) * gru_0_out_t4_4 + (-0.014664245769381523) * gru_0_out_t4_5 + (-0.31357425451278687) * gru_0_out_t4_6 + (-0.10155487805604935) * gru_0_out_t4_7 + (-0.04959607869386673) * gru_0_out_t4_8 + (0.63405925035476685) * gru_0_out_t4_9 + (-0.30301511287689209) * gru_0_out_t4_10 + (0.35798567533493042) * gru_0_out_t4_11 + (-0.27502909302711487) * gru_0_out_t4_12 + (0.11775603145360947) * gru_0_out_t4_13 + (-0.15030418336391449) * gru_0_out_t4_14 + (0.12721797823905945) * gru_0_out_t4_15 + (0.48690655827522278) * gru_0_out_t4_16 + (-0.15891537070274353) * gru_0_out_t4_17 + (0.083171702921390533) * gru_0_out_t4_18 + (-1.9511686563491821) * gru_0_out_t4_19 + (0.49278438091278076) * gru_0_out_t4_20 + (0.09223068505525589) * gru_0_out_t4_21 + (-0.48359030485153198) * gru_0_out_t4_22 + (0.34708014130592346) * gru_0_out_t4_23 + (-0.30659160017967224) * gru_0_out_t4_24 + (-0.30823656916618347) * gru_0_out_t4_25 + (-0.39882442355155945) * gru_0_out_t4_26 + (9.6815827419050038e-05) * gru_0_out_t4_27 + (-0.42601487040519714) * gru_0_out_t4_28 + (-0.90354841947555542) * gru_0_out_t4_29 + (0.1208379715681076) * gru_0_out_t4_30 + (-0.77041679620742798) * gru_0_out_t4_31 + (0.93809503316879272) * gru_0_out_t4_32 + (0.16229765117168427) * gru_0_out_t4_33 + (0.31941649317741394) * gru_0_out_t4_34 + (-0.045119088143110275) * gru_0_out_t4_35 + (0.19085857272148132) * gru_0_out_t4_36 + (-0.086860403418540955) * gru_0_out_t4_37 + (0.027238396927714348) * gru_0_out_t4_38 + (0.49798467755317688) * gru_0_out_t4_39 + (-0.64532971382141113) * gru_0_out_t4_40 + (-0.083294875919818878) * gru_0_out_t4_41 + (0.20426000654697418) * gru_0_out_t4_42 + (-0.45308166742324829) * gru_0_out_t4_43 + (-0.0034623797982931137) * gru_0_out_t4_44 + (-0.1962042897939682) * gru_0_out_t4_45 + (0.31427952647209167) * gru_0_out_t4_46 + (-0.80603957176208496) * gru_0_out_t4_47 + (0.58460253477096558) * gru_0_out_t4_48 + (-0.21770013868808746) * gru_0_out_t4_49 + (-0.42251354455947876) * gru_0_out_t4_50 + (-0.35352548956871033) * gru_0_out_t4_51 + (-0.53871268033981323) * gru_0_out_t4_52 + (0.71781891584396362) * gru_0_out_t4_53 + (-2.6819026470184326) * gru_0_out_t4_54 + (-0.51425379514694214) * gru_0_out_t4_55 + (-0.13675147294998169) * gru_0_out_t4_56 + (-0.43949040770530701) * gru_0_out_t4_57 + (0.28085276484489441) * gru_0_out_t4_58 + (0.77072542905807495) * gru_0_out_t4_59 + (-0.49132651090621948) * gru_0_out_t4_60 + (0.3653409481048584) * gru_0_out_t4_61 + (0.75576895475387573) * gru_0_out_t4_62 + (-0.1192517951130867) * gru_0_out_t4_63 + (-0.1809026300907135) * gru_1_fwd_t3_h_0 + (-0.033703815191984177) * gru_1_fwd_t3_h_1 + (-0.00951346755027771) * gru_1_fwd_t3_h_2 + (-0.17121396958827972) * gru_1_fwd_t3_h_3 + (-0.74436593055725098) * gru_1_fwd_t3_h_4 + (1.3062326908111572) * gru_1_fwd_t3_h_5 + (-1.1980996131896973) * gru_1_fwd_t3_h_6 + (-0.51400047540664673) * gru_1_fwd_t3_h_7 + (0.10013008862733841) * gru_1_fwd_t3_h_8 + (0.090408407151699066) * gru_1_fwd_t3_h_9 + (0.21418322622776031) * gru_1_fwd_t3_h_10 + (0.069714032113552094) * gru_1_fwd_t3_h_11 + (-0.21528147161006927) * gru_1_fwd_t3_h_12 + (0.6108701229095459) * gru_1_fwd_t3_h_13 + (-0.40365278720855713) * gru_1_fwd_t3_h_14 + (-0.067411042749881744) * gru_1_fwd_t3_h_15 + (0.45934364199638367) * gru_1_fwd_t3_h_16 + (0.027161072939634323) * gru_1_fwd_t3_h_17 + (-0.16385954618453979) * gru_1_fwd_t3_h_18 + (-0.0067514772526919842) * gru_1_fwd_t3_h_19 + (0.32362991571426392) * gru_1_fwd_t3_h_20 + (0.18444579839706421) * gru_1_fwd_t3_h_21 + (0.096423111855983734) * gru_1_fwd_t3_h_22 + (1.1873027086257935) * gru_1_fwd_t3_h_23 + (0.46057096123695374) * gru_1_fwd_t3_h_24 + (0.10534723848104477) * gru_1_fwd_t3_h_25 + (-0.46146708726882935) * gru_1_fwd_t3_h_26 + (0.1269262433052063) * gru_1_fwd_t3_h_27 + (-0.12155076116323471) * gru_1_fwd_t3_h_28 + (-0.06298595666885376) * gru_1_fwd_t3_h_29 + (-0.0802726149559021) * gru_1_fwd_t3_h_30 + (0.17798225581645966) * gru_1_fwd_t3_h_31);
    gate_z = sigmoid((-1.5708490610122681) + (-0.52364081144332886) * gru_0_out_t4_0 + (-0.24127785861492157) * gru_0_out_t4_1 + (-1.9255368709564209) * gru_0_out_t4_2 + (-0.29298657178878784) * gru_0_out_t4_3 + (-0.12863631546497345) * gru_0_out_t4_4 + (0.26886558532714844) * gru_0_out_t4_5 + (-0.11590530723333359) * gru_0_out_t4_6 + (1.6646939516067505) * gru_0_out_t4_7 + (0.79181891679763794) * gru_0_out_t4_8 + (-0.77106618881225586) * gru_0_out_t4_9 + (2.0734095573425293) * gru_0_out_t4_10 + (0.10390692949295044) * gru_0_out_t4_11 + (-0.30964061617851257) * gru_0_out_t4_12 + (-0.034910280257463455) * gru_0_out_t4_13 + (-0.16313086450099945) * gru_0_out_t4_14 + (-0.69061791896820068) * gru_0_out_t4_15 + (0.28230005502700806) * gru_0_out_t4_16 + (-0.74474287033081055) * gru_0_out_t4_17 + (0.25261691212654114) * gru_0_out_t4_18 + (2.325453519821167) * gru_0_out_t4_19 + (-1.9211370944976807) * gru_0_out_t4_20 + (0.45446920394897461) * gru_0_out_t4_21 + (0.40475079417228699) * gru_0_out_t4_22 + (-0.2659313976764679) * gru_0_out_t4_23 + (1.3477935791015625) * gru_0_out_t4_24 + (0.14540131390094757) * gru_0_out_t4_25 + (0.0052851513028144836) * gru_0_out_t4_26 + (-0.49886664748191833) * gru_0_out_t4_27 + (0.83104908466339111) * gru_0_out_t4_28 + (0.026456732302904129) * gru_0_out_t4_29 + (-0.64608162641525269) * gru_0_out_t4_30 + (-1.1802588701248169) * gru_0_out_t4_31 + (-0.37865176796913147) * gru_0_out_t4_32 + (0.11485591530799866) * gru_0_out_t4_33 + (0.2439369261264801) * gru_0_out_t4_34 + (-0.75955909490585327) * gru_0_out_t4_35 + (0.26272538304328918) * gru_0_out_t4_36 + (0.13270311057567596) * gru_0_out_t4_37 + (0.30327385663986206) * gru_0_out_t4_38 + (0.28111365437507629) * gru_0_out_t4_39 + (-2.9819467067718506) * gru_0_out_t4_40 + (-0.22869941592216492) * gru_0_out_t4_41 + (0.51670557260513306) * gru_0_out_t4_42 + (0.13505245745182037) * gru_0_out_t4_43 + (-0.31707146763801575) * gru_0_out_t4_44 + (-0.39577195048332214) * gru_0_out_t4_45 + (0.18859279155731201) * gru_0_out_t4_46 + (0.55429625511169434) * gru_0_out_t4_47 + (-0.13784430921077728) * gru_0_out_t4_48 + (-0.0028403862379491329) * gru_0_out_t4_49 + (-0.80398917198181152) * gru_0_out_t4_50 + (-0.13821184635162354) * gru_0_out_t4_51 + (-0.035888116806745529) * gru_0_out_t4_52 + (-0.99573326110839844) * gru_0_out_t4_53 + (0.29413333535194397) * gru_0_out_t4_54 + (0.14233855903148651) * gru_0_out_t4_55 + (-0.83636701107025146) * gru_0_out_t4_56 + (-0.023530829697847366) * gru_0_out_t4_57 + (-0.41732168197631836) * gru_0_out_t4_58 + (-0.21330302953720093) * gru_0_out_t4_59 + (0.8921431303024292) * gru_0_out_t4_60 + (-0.87944042682647705) * gru_0_out_t4_61 + (-0.39166903495788574) * gru_0_out_t4_62 + (0.58020478487014771) * gru_0_out_t4_63 + (-0.57574981451034546) * gru_1_fwd_t3_h_0 + (1.6215771436691284) * gru_1_fwd_t3_h_1 + (-0.34320369362831116) * gru_1_fwd_t3_h_2 + (-0.49578666687011719) * gru_1_fwd_t3_h_3 + (0.27507570385932922) * gru_1_fwd_t3_h_4 + (-1.1861916780471802) * gru_1_fwd_t3_h_5 + (0.17442318797111511) * gru_1_fwd_t3_h_6 + (0.49565953016281128) * gru_1_fwd_t3_h_7 + (0.30514419078826904) * gru_1_fwd_t3_h_8 + (0.68545526266098022) * gru_1_fwd_t3_h_9 + (-0.015728786587715149) * gru_1_fwd_t3_h_10 + (2.0072088241577148) * gru_1_fwd_t3_h_11 + (-0.083062402904033661) * gru_1_fwd_t3_h_12 + (0.39044469594955444) * gru_1_fwd_t3_h_13 + (0.23526749014854431) * gru_1_fwd_t3_h_14 + (-0.086912460625171661) * gru_1_fwd_t3_h_15 + (0.19192121922969818) * gru_1_fwd_t3_h_16 + (0.74911558628082275) * gru_1_fwd_t3_h_17 + (-0.14681941270828247) * gru_1_fwd_t3_h_18 + (0.3123525083065033) * gru_1_fwd_t3_h_19 + (0.19948874413967133) * gru_1_fwd_t3_h_20 + (-0.27458778023719788) * gru_1_fwd_t3_h_21 + (-0.46526089310646057) * gru_1_fwd_t3_h_22 + (1.14471435546875) * gru_1_fwd_t3_h_23 + (-0.58947557210922241) * gru_1_fwd_t3_h_24 + (-0.35406193137168884) * gru_1_fwd_t3_h_25 + (-1.3951840400695801) * gru_1_fwd_t3_h_26 + (0.57051306962966919) * gru_1_fwd_t3_h_27 + (0.084670968353748322) * gru_1_fwd_t3_h_28 + (0.42024078965187073) * gru_1_fwd_t3_h_29 + (-0.37332999706268311) * gru_1_fwd_t3_h_30 + (0.042901366949081421) * gru_1_fwd_t3_h_31);
    gate_n = tanh((-0.027732593938708305) + (-0.14300656318664551) * gru_0_out_t4_0 + (-0.08473842591047287) * gru_0_out_t4_1 + (0.21244299411773682) * gru_0_out_t4_2 + (-0.080064944922924042) * gru_0_out_t4_3 + (-0.28786370158195496) * gru_0_out_t4_4 + (0.094129391014575958) * gru_0_out_t4_5 + (-0.036121316254138947) * gru_0_out_t4_6 + (-0.22730052471160889) * gru_0_out_t4_7 + (-0.16333964467048645) * gru_0_out_t4_8 + (-0.45304316282272339) * gru_0_out_t4_9 + (-0.072136290371417999) * gru_0_out_t4_10 + (0.35763850808143616) * gru_0_out_t4_11 + (-0.0019672720227390528) * gru_0_out_t4_12 + (-0.027877481654286385) * gru_0_out_t4_13 + (-0.31174606084823608) * gru_0_out_t4_14 + (0.10973086953163147) * gru_0_out_t4_15 + (-0.021004060283303261) * gru_0_out_t4_16 + (0.15650467574596405) * gru_0_out_t4_17 + (-0.058733168989419937) * gru_0_out_t4_18 + (-0.54861831665039062) * gru_0_out_t4_19 + (-0.33014219999313354) * gru_0_out_t4_20 + (0.18220792710781097) * gru_0_out_t4_21 + (0.11679074913263321) * gru_0_out_t4_22 + (-0.35005933046340942) * gru_0_out_t4_23 + (-0.14914911985397339) * gru_0_out_t4_24 + (-0.76734685897827148) * gru_0_out_t4_25 + (0.051192678511142731) * gru_0_out_t4_26 + (0.10329507291316986) * gru_0_out_t4_27 + (-0.10266322642564774) * gru_0_out_t4_28 + (0.77014082670211792) * gru_0_out_t4_29 + (-1.0773215293884277) * gru_0_out_t4_30 + (0.1286233514547348) * gru_0_out_t4_31 + (0.26050376892089844) * gru_0_out_t4_32 + (-0.53916555643081665) * gru_0_out_t4_33 + (0.2894720733165741) * gru_0_out_t4_34 + (-0.47400009632110596) * gru_0_out_t4_35 + (-0.091160140931606293) * gru_0_out_t4_36 + (0.069460429251194) * gru_0_out_t4_37 + (-0.15595392882823944) * gru_0_out_t4_38 + (-0.0018634696025401354) * gru_0_out_t4_39 + (-0.061337418854236603) * gru_0_out_t4_40 + (0.05213320255279541) * gru_0_out_t4_41 + (-0.42697620391845703) * gru_0_out_t4_42 + (0.28156614303588867) * gru_0_out_t4_43 + (0.042865462601184845) * gru_0_out_t4_44 + (-0.16251970827579498) * gru_0_out_t4_45 + (-0.35042855143547058) * gru_0_out_t4_46 + (-0.54185616970062256) * gru_0_out_t4_47 + (-0.21947178244590759) * gru_0_out_t4_48 + (0.38353753089904785) * gru_0_out_t4_49 + (0.0043533858843147755) * gru_0_out_t4_50 + (0.32753312587738037) * gru_0_out_t4_51 + (-0.29348239302635193) * gru_0_out_t4_52 + (0.50983858108520508) * gru_0_out_t4_53 + (0.080752424895763397) * gru_0_out_t4_54 + (0.072130724787712097) * gru_0_out_t4_55 + (-0.13460832834243774) * gru_0_out_t4_56 + (0.36010941863059998) * gru_0_out_t4_57 + (-0.074413403868675232) * gru_0_out_t4_58 + (-0.12156960368156433) * gru_0_out_t4_59 + (0.004703400656580925) * gru_0_out_t4_60 + (0.11808716505765915) * gru_0_out_t4_61 + (-0.6021302342414856) * gru_0_out_t4_62 + (-0.91609400510787964) * gru_0_out_t4_63 + gate_r * ((0.12262941151857376) + (0.057252276688814163) * gru_1_fwd_t3_h_0 + (0.039879586547613144) * gru_1_fwd_t3_h_1 + (0.018536834046244621) * gru_1_fwd_t3_h_2 + (0.64742529392242432) * gru_1_fwd_t3_h_3 + (-0.18314000964164734) * gru_1_fwd_t3_h_4 + (-0.37682139873504639) * gru_1_fwd_t3_h_5 + (-0.30979776382446289) * gru_1_fwd_t3_h_6 + (0.23698128759860992) * gru_1_fwd_t3_h_7 + (-0.091686457395553589) * gru_1_fwd_t3_h_8 + (0.040832266211509705) * gru_1_fwd_t3_h_9 + (-0.25267067551612854) * gru_1_fwd_t3_h_10 + (0.086815588176250458) * gru_1_fwd_t3_h_11 + (-0.0096743907779455185) * gru_1_fwd_t3_h_12 + (0.058526713401079178) * gru_1_fwd_t3_h_13 + (-0.17420612275600433) * gru_1_fwd_t3_h_14 + (-0.03177221491932869) * gru_1_fwd_t3_h_15 + (0.051403425633907318) * gru_1_fwd_t3_h_16 + (-0.093971900641918182) * gru_1_fwd_t3_h_17 + (0.043977741152048111) * gru_1_fwd_t3_h_18 + (-0.29037961363792419) * gru_1_fwd_t3_h_19 + (-0.33840790390968323) * gru_1_fwd_t3_h_20 + (0.13710835576057434) * gru_1_fwd_t3_h_21 + (-0.085579767823219299) * gru_1_fwd_t3_h_22 + (0.057670138776302338) * gru_1_fwd_t3_h_23 + (0.097161531448364258) * gru_1_fwd_t3_h_24 + (-0.083818145096302032) * gru_1_fwd_t3_h_25 + (0.015383318997919559) * gru_1_fwd_t3_h_26 + (0.031158596277236938) * gru_1_fwd_t3_h_27 + (-0.16118171811103821) * gru_1_fwd_t3_h_28 + (-0.14433081448078156) * gru_1_fwd_t3_h_29 + (-0.07113974541425705) * gru_1_fwd_t3_h_30 + (-0.47427299618721008) * gru_1_fwd_t3_h_31));
    gru_1_fwd_t4_h_31 = (1.0 - gate_z) * gate_n + gate_z * gru_1_fwd_t3_h_31;

    // Reverse sequence
    // RV step t=4
    // h=0
    gate_r = sigmoid((0.58126628398895264) + (0.3461015522480011) * gru_0_out_t4_0 + (-0.2949959933757782) * gru_0_out_t4_1 + (0.42175370454788208) * gru_0_out_t4_2 + (0.62256276607513428) * gru_0_out_t4_3 + (0.23958523571491241) * gru_0_out_t4_4 + (-0.45301467180252075) * gru_0_out_t4_5 + (0.68952316045761108) * gru_0_out_t4_6 + (-0.49925786256790161) * gru_0_out_t4_7 + (-0.068710625171661377) * gru_0_out_t4_8 + (1.3800723552703857) * gru_0_out_t4_9 + (-0.89359819889068604) * gru_0_out_t4_10 + (0.43140432238578796) * gru_0_out_t4_11 + (0.031491909176111221) * gru_0_out_t4_12 + (-0.087643668055534363) * gru_0_out_t4_13 + (0.336295485496521) * gru_0_out_t4_14 + (0.19321420788764954) * gru_0_out_t4_15 + (0.00080590764991939068) * gru_0_out_t4_16 + (0.075453773140907288) * gru_0_out_t4_17 + (-0.41135543584823608) * gru_0_out_t4_18 + (2.0293476581573486) * gru_0_out_t4_19 + (0.72744262218475342) * gru_0_out_t4_20 + (0.53991758823394775) * gru_0_out_t4_21 + (0.31365412473678589) * gru_0_out_t4_22 + (0.68274176120758057) * gru_0_out_t4_23 + (0.10474167019128799) * gru_0_out_t4_24 + (0.62453806400299072) * gru_0_out_t4_25 + (0.41086536645889282) * gru_0_out_t4_26 + (-0.56289297342300415) * gru_0_out_t4_27 + (-0.82757002115249634) * gru_0_out_t4_28 + (1.1187382936477661) * gru_0_out_t4_29 + (0.54665815830230713) * gru_0_out_t4_30 + (-0.21825309097766876) * gru_0_out_t4_31 + (0.2940315306186676) * gru_0_out_t4_32 + (0.053931709378957748) * gru_0_out_t4_33 + (0.24624025821685791) * gru_0_out_t4_34 + (0.31730201840400696) * gru_0_out_t4_35 + (-0.0042199939489364624) * gru_0_out_t4_36 + (-0.099361449480056763) * gru_0_out_t4_37 + (0.32230666279792786) * gru_0_out_t4_38 + (-0.12619507312774658) * gru_0_out_t4_39 + (-1.3094536066055298) * gru_0_out_t4_40 + (1.0639116764068604) * gru_0_out_t4_41 + (-0.2831280529499054) * gru_0_out_t4_42 + (-0.12234871089458466) * gru_0_out_t4_43 + (0.097353234887123108) * gru_0_out_t4_44 + (0.37904301285743713) * gru_0_out_t4_45 + (0.70086753368377686) * gru_0_out_t4_46 + (0.034374512732028961) * gru_0_out_t4_47 + (0.84007364511489868) * gru_0_out_t4_48 + (-1.040581226348877) * gru_0_out_t4_49 + (-0.21705634891986847) * gru_0_out_t4_50 + (0.58707612752914429) * gru_0_out_t4_51 + (0.63053524494171143) * gru_0_out_t4_52 + (0.36505591869354248) * gru_0_out_t4_53 + (-0.49750047922134399) * gru_0_out_t4_54 + (0.17923566699028015) * gru_0_out_t4_55 + (0.89410495758056641) * gru_0_out_t4_56 + (0.0035052259918302298) * gru_0_out_t4_57 + (-0.16507460176944733) * gru_0_out_t4_58 + (0.9692615270614624) * gru_0_out_t4_59 + (-1.9698183536529541) * gru_0_out_t4_60 + (0.017860323190689087) * gru_0_out_t4_61 + (0.62139171361923218) * gru_0_out_t4_62 + (0.24609129130840302) * gru_0_out_t4_63);
    gate_z = sigmoid((0.92658507823944092) + (0.3031025230884552) * gru_0_out_t4_0 + (-1.0290640592575073) * gru_0_out_t4_1 + (1.9438254833221436) * gru_0_out_t4_2 + (0.039532888680696487) * gru_0_out_t4_3 + (-0.56961101293563843) * gru_0_out_t4_4 + (0.030088700354099274) * gru_0_out_t4_5 + (0.055256132036447525) * gru_0_out_t4_6 + (-1.3125280141830444) * gru_0_out_t4_7 + (0.11220762133598328) * gru_0_out_t4_8 + (0.21006862819194794) * gru_0_out_t4_9 + (-2.3677353858947754) * gru_0_out_t4_10 + (0.15025962889194489) * gru_0_out_t4_11 + (1.054884672164917) * gru_0_out_t4_12 + (0.8738444447517395) * gru_0_out_t4_13 + (0.18520714342594147) * gru_0_out_t4_14 + (1.6222653388977051) * gru_0_out_t4_15 + (0.57355082035064697) * gru_0_out_t4_16 + (0.793773353099823) * gru_0_out_t4_17 + (-0.345439612865448) * gru_0_out_t4_18 + (0.026623686775565147) * gru_0_out_t4_19 + (0.82493579387664795) * gru_0_out_t4_20 + (-0.37602835893630981) * gru_0_out_t4_21 + (-0.11914751678705215) * gru_0_out_t4_22 + (-0.67521286010742188) * gru_0_out_t4_23 + (-1.3429644107818604) * gru_0_out_t4_24 + (-0.5212562084197998) * gru_0_out_t4_25 + (0.70230227708816528) * gru_0_out_t4_26 + (0.9508126974105835) * gru_0_out_t4_27 + (-1.569488525390625) * gru_0_out_t4_28 + (0.020253580063581467) * gru_0_out_t4_29 + (0.050608079880475998) * gru_0_out_t4_30 + (0.46613603830337524) * gru_0_out_t4_31 + (-0.40216577053070068) * gru_0_out_t4_32 + (0.34979802370071411) * gru_0_out_t4_33 + (-0.20113091170787811) * gru_0_out_t4_34 + (1.0137882232666016) * gru_0_out_t4_35 + (0.14480744302272797) * gru_0_out_t4_36 + (-0.16547851264476776) * gru_0_out_t4_37 + (-0.24511897563934326) * gru_0_out_t4_38 + (1.006535530090332) * gru_0_out_t4_39 + (0.57186049222946167) * gru_0_out_t4_40 + (1.3397485017776489) * gru_0_out_t4_41 + (0.98700827360153198) * gru_0_out_t4_42 + (-0.24130327999591827) * gru_0_out_t4_43 + (0.65854847431182861) * gru_0_out_t4_44 + (0.47380965948104858) * gru_0_out_t4_45 + (-0.16745896637439728) * gru_0_out_t4_46 + (-0.045964758843183517) * gru_0_out_t4_47 + (-0.25303694605827332) * gru_0_out_t4_48 + (-0.051693916320800781) * gru_0_out_t4_49 + (-0.18152262270450592) * gru_0_out_t4_50 + (-0.23376059532165527) * gru_0_out_t4_51 + (-0.35757845640182495) * gru_0_out_t4_52 + (-0.0040349569171667099) * gru_0_out_t4_53 + (-0.40543285012245178) * gru_0_out_t4_54 + (-0.0019529624842107296) * gru_0_out_t4_55 + (0.46795263886451721) * gru_0_out_t4_56 + (0.17968311905860901) * gru_0_out_t4_57 + (0.11411868035793304) * gru_0_out_t4_58 + (-0.63490390777587891) * gru_0_out_t4_59 + (0.061035852879285812) * gru_0_out_t4_60 + (0.043291643261909485) * gru_0_out_t4_61 + (0.54315197467803955) * gru_0_out_t4_62 + (-1.2224456071853638) * gru_0_out_t4_63);
    gate_n = tanh((-0.17712901532649994) + (-0.19911818206310272) * gru_0_out_t4_0 + (0.071633517742156982) * gru_0_out_t4_1 + (-1.2292951345443726) * gru_0_out_t4_2 + (-0.14776083827018738) * gru_0_out_t4_3 + (0.33671331405639648) * gru_0_out_t4_4 + (1.1010667085647583) * gru_0_out_t4_5 + (-0.6213991641998291) * gru_0_out_t4_6 + (-1.0614986419677734) * gru_0_out_t4_7 + (-0.22221857309341431) * gru_0_out_t4_8 + (-0.51339191198348999) * gru_0_out_t4_9 + (1.3227903842926025) * gru_0_out_t4_10 + (0.26794177293777466) * gru_0_out_t4_11 + (-0.31339377164840698) * gru_0_out_t4_12 + (-0.069509446620941162) * gru_0_out_t4_13 + (-0.65909695625305176) * gru_0_out_t4_14 + (0.29469594359397888) * gru_0_out_t4_15 + (-0.13114316761493683) * gru_0_out_t4_16 + (0.064992554485797882) * gru_0_out_t4_17 + (0.18779313564300537) * gru_0_out_t4_18 + (-2.077904224395752) * gru_0_out_t4_19 + (-0.28640463948249817) * gru_0_out_t4_20 + (-0.26710081100463867) * gru_0_out_t4_21 + (0.54704087972640991) * gru_0_out_t4_22 + (-1.3856691122055054) * gru_0_out_t4_23 + (1.2855089902877808) * gru_0_out_t4_24 + (-0.37560603022575378) * gru_0_out_t4_25 + (-0.16082859039306641) * gru_0_out_t4_26 + (-0.58927625417709351) * gru_0_out_t4_27 + (1.2076035737991333) * gru_0_out_t4_28 + (-0.027270674705505371) * gru_0_out_t4_29 + (-0.35477718710899353) * gru_0_out_t4_30 + (-0.7819594144821167) * gru_0_out_t4_31 + (0.61380308866500854) * gru_0_out_t4_32 + (-0.12947762012481689) * gru_0_out_t4_33 + (-0.13859930634498596) * gru_0_out_t4_34 + (0.30669164657592773) * gru_0_out_t4_35 + (0.21221533417701721) * gru_0_out_t4_36 + (0.073815904557704926) * gru_0_out_t4_37 + (0.0020874117035418749) * gru_0_out_t4_38 + (-0.46144667267799377) * gru_0_out_t4_39 + (2.1233847141265869) * gru_0_out_t4_40 + (-0.27828532457351685) * gru_0_out_t4_41 + (2.5182802677154541) * gru_0_out_t4_42 + (0.067871846258640289) * gru_0_out_t4_43 + (-0.40057769417762756) * gru_0_out_t4_44 + (-0.13372674584388733) * gru_0_out_t4_45 + (0.06801750510931015) * gru_0_out_t4_46 + (-0.69326484203338623) * gru_0_out_t4_47 + (0.30723923444747925) * gru_0_out_t4_48 + (0.25171956419944763) * gru_0_out_t4_49 + (0.067896425724029541) * gru_0_out_t4_50 + (0.015187440440058708) * gru_0_out_t4_51 + (-0.01062028668820858) * gru_0_out_t4_52 + (0.40402901172637939) * gru_0_out_t4_53 + (-0.14724063873291016) * gru_0_out_t4_54 + (0.0067734434269368649) * gru_0_out_t4_55 + (0.87118464708328247) * gru_0_out_t4_56 + (-0.37395113706588745) * gru_0_out_t4_57 + (0.093851692974567413) * gru_0_out_t4_58 + (-0.54271560907363892) * gru_0_out_t4_59 + (2.9927453994750977) * gru_0_out_t4_60 + (1.5603146553039551) * gru_0_out_t4_61 + (-0.023856762796640396) * gru_0_out_t4_62 + (0.12609013915061951) * gru_0_out_t4_63 + gate_r * (-0.58328002691268921));
    gru_1_rev_t4_h_0 = (1.0 - gate_z) * gate_n;
    // h=1
    gate_r = sigmoid((-0.20903995633125305) + (0.30925112962722778) * gru_0_out_t4_0 + (-0.015742391347885132) * gru_0_out_t4_1 + (-0.2368304580450058) * gru_0_out_t4_2 + (-1.1588512659072876) * gru_0_out_t4_3 + (-0.17164070904254913) * gru_0_out_t4_4 + (0.02564871683716774) * gru_0_out_t4_5 + (-1.4705148935317993) * gru_0_out_t4_6 + (-0.61768084764480591) * gru_0_out_t4_7 + (0.079003781080245972) * gru_0_out_t4_8 + (-0.028004871681332588) * gru_0_out_t4_9 + (0.57926177978515625) * gru_0_out_t4_10 + (0.62611490488052368) * gru_0_out_t4_11 + (-0.71592998504638672) * gru_0_out_t4_12 + (-0.28013396263122559) * gru_0_out_t4_13 + (0.64424937963485718) * gru_0_out_t4_14 + (-1.1557599306106567) * gru_0_out_t4_15 + (0.64116787910461426) * gru_0_out_t4_16 + (-0.54434990882873535) * gru_0_out_t4_17 + (0.19131892919540405) * gru_0_out_t4_18 + (1.2721389532089233) * gru_0_out_t4_19 + (-0.19331479072570801) * gru_0_out_t4_20 + (1.0641202926635742) * gru_0_out_t4_21 + (0.40934953093528748) * gru_0_out_t4_22 + (-0.3040870726108551) * gru_0_out_t4_23 + (-0.76493173837661743) * gru_0_out_t4_24 + (-1.6161586046218872) * gru_0_out_t4_25 + (-0.45597133040428162) * gru_0_out_t4_26 + (0.89349943399429321) * gru_0_out_t4_27 + (0.24348098039627075) * gru_0_out_t4_28 + (-3.2238359451293945) * gru_0_out_t4_29 + (-0.26619812846183777) * gru_0_out_t4_30 + (-1.8762181997299194) * gru_0_out_t4_31 + (-0.13870754837989807) * gru_0_out_t4_32 + (0.39376085996627808) * gru_0_out_t4_33 + (0.12738075852394104) * gru_0_out_t4_34 + (-0.66587477922439575) * gru_0_out_t4_35 + (-0.22798031568527222) * gru_0_out_t4_36 + (0.42163008451461792) * gru_0_out_t4_37 + (-0.76521778106689453) * gru_0_out_t4_38 + (-0.83616834878921509) * gru_0_out_t4_39 + (0.48386898636817932) * gru_0_out_t4_40 + (-0.29284533858299255) * gru_0_out_t4_41 + (0.65458744764328003) * gru_0_out_t4_42 + (0.18632990121841431) * gru_0_out_t4_43 + (-0.029939791187644005) * gru_0_out_t4_44 + (-1.6301888227462769) * gru_0_out_t4_45 + (-1.1368800401687622) * gru_0_out_t4_46 + (-0.11000495404005051) * gru_0_out_t4_47 + (-1.2941906452178955) * gru_0_out_t4_48 + (1.0825592279434204) * gru_0_out_t4_49 + (0.64831972122192383) * gru_0_out_t4_50 + (-1.1520640850067139) * gru_0_out_t4_51 + (-0.96388977766036987) * gru_0_out_t4_52 + (0.26267817616462708) * gru_0_out_t4_53 + (0.28491249680519104) * gru_0_out_t4_54 + (0.1249992847442627) * gru_0_out_t4_55 + (-0.81087195873260498) * gru_0_out_t4_56 + (1.149482250213623) * gru_0_out_t4_57 + (-0.22046862542629242) * gru_0_out_t4_58 + (1.2936067581176758) * gru_0_out_t4_59 + (-0.57055181264877319) * gru_0_out_t4_60 + (0.75417762994766235) * gru_0_out_t4_61 + (-1.1933449506759644) * gru_0_out_t4_62 + (2.3391835689544678) * gru_0_out_t4_63);
    gate_z = sigmoid((0.44227322936058044) + (-0.21850600838661194) * gru_0_out_t4_0 + (-0.7310950756072998) * gru_0_out_t4_1 + (0.42367720603942871) * gru_0_out_t4_2 + (0.48620641231536865) * gru_0_out_t4_3 + (-0.67666035890579224) * gru_0_out_t4_4 + (-0.68617582321166992) * gru_0_out_t4_5 + (1.5264557600021362) * gru_0_out_t4_6 + (-1.455356240272522) * gru_0_out_t4_7 + (-0.6247294545173645) * gru_0_out_t4_8 + (-0.50455397367477417) * gru_0_out_t4_9 + (-1.1144506931304932) * gru_0_out_t4_10 + (-0.41711091995239258) * gru_0_out_t4_11 + (0.91959434747695923) * gru_0_out_t4_12 + (0.19608889520168304) * gru_0_out_t4_13 + (-0.18951871991157532) * gru_0_out_t4_14 + (-0.10637872666120529) * gru_0_out_t4_15 + (-0.3021526038646698) * gru_0_out_t4_16 + (-0.73989778757095337) * gru_0_out_t4_17 + (0.29301938414573669) * gru_0_out_t4_18 + (1.5125272274017334) * gru_0_out_t4_19 + (-0.23356017470359802) * gru_0_out_t4_20 + (-0.92266732454299927) * gru_0_out_t4_21 + (-0.3032691478729248) * gru_0_out_t4_22 + (0.75643694400787354) * gru_0_out_t4_23 + (-0.42981496453285217) * gru_0_out_t4_24 + (-0.80385547876358032) * gru_0_out_t4_25 + (-0.81996655464172363) * gru_0_out_t4_26 + (0.44457468390464783) * gru_0_out_t4_27 + (0.49909830093383789) * gru_0_out_t4_28 + (-0.9957730770111084) * gru_0_out_t4_29 + (0.2541067898273468) * gru_0_out_t4_30 + (0.65908408164978027) * gru_0_out_t4_31 + (-0.87052041292190552) * gru_0_out_t4_32 + (-0.33276680111885071) * gru_0_out_t4_33 + (0.4800797700881958) * gru_0_out_t4_34 + (0.54547256231307983) * gru_0_out_t4_35 + (0.38553181290626526) * gru_0_out_t4_36 + (-0.58588927984237671) * gru_0_out_t4_37 + (0.57059282064437866) * gru_0_out_t4_38 + (-0.62960571050643921) * gru_0_out_t4_39 + (1.4591929912567139) * gru_0_out_t4_40 + (0.67755550146102905) * gru_0_out_t4_41 + (-0.77732712030410767) * gru_0_out_t4_42 + (-0.073959782719612122) * gru_0_out_t4_43 + (-0.0013122587697580457) * gru_0_out_t4_44 + (0.28594070672988892) * gru_0_out_t4_45 + (-2.6861422061920166) * gru_0_out_t4_46 + (0.035561736673116684) * gru_0_out_t4_47 + (-0.75469881296157837) * gru_0_out_t4_48 + (-0.2337968498468399) * gru_0_out_t4_49 + (0.1939275711774826) * gru_0_out_t4_50 + (-0.33581367135047913) * gru_0_out_t4_51 + (0.31883317232131958) * gru_0_out_t4_52 + (-0.36054894328117371) * gru_0_out_t4_53 + (-1.1178292036056519) * gru_0_out_t4_54 + (-0.23496320843696594) * gru_0_out_t4_55 + (0.52693843841552734) * gru_0_out_t4_56 + (0.33940580487251282) * gru_0_out_t4_57 + (-0.15926779806613922) * gru_0_out_t4_58 + (1.7501543760299683) * gru_0_out_t4_59 + (0.32313439249992371) * gru_0_out_t4_60 + (-0.20621946454048157) * gru_0_out_t4_61 + (0.13146002590656281) * gru_0_out_t4_62 + (-0.017668968066573143) * gru_0_out_t4_63);
    gate_n = tanh((0.012219520285725594) + (-0.20780402421951294) * gru_0_out_t4_0 + (-0.0026832965668290854) * gru_0_out_t4_1 + (0.45621770620346069) * gru_0_out_t4_2 + (0.22725893557071686) * gru_0_out_t4_3 + (-0.38065177202224731) * gru_0_out_t4_4 + (-0.087196126580238342) * gru_0_out_t4_5 + (0.34167280793190002) * gru_0_out_t4_6 + (-0.21362018585205078) * gru_0_out_t4_7 + (0.28855735063552856) * gru_0_out_t4_8 + (-0.19377273321151733) * gru_0_out_t4_9 + (-0.87108749151229858) * gru_0_out_t4_10 + (-0.47549352049827576) * gru_0_out_t4_11 + (-0.23855489492416382) * gru_0_out_t4_12 + (0.25526523590087891) * gru_0_out_t4_13 + (-0.66180497407913208) * gru_0_out_t4_14 + (0.5743098258972168) * gru_0_out_t4_15 + (-0.58508223295211792) * gru_0_out_t4_16 + (-0.24840687215328217) * gru_0_out_t4_17 + (0.29912793636322021) * gru_0_out_t4_18 + (-0.012425573542714119) * gru_0_out_t4_19 + (0.25449204444885254) * gru_0_out_t4_20 + (-1.8550071716308594) * gru_0_out_t4_21 + (0.2841765284538269) * gru_0_out_t4_22 + (0.25805601477622986) * gru_0_out_t4_23 + (-0.5748213529586792) * gru_0_out_t4_24 + (-0.45939794182777405) * gru_0_out_t4_25 + (-0.0074814409017562866) * gru_0_out_t4_26 + (0.51099127531051636) * gru_0_out_t4_27 + (-0.25700733065605164) * gru_0_out_t4_28 + (0.25135305523872375) * gru_0_out_t4_29 + (-0.18593892455101013) * gru_0_out_t4_30 + (0.76798194646835327) * gru_0_out_t4_31 + (-0.73348087072372437) * gru_0_out_t4_32 + (-0.98755848407745361) * gru_0_out_t4_33 + (-0.1546047031879425) * gru_0_out_t4_34 + (0.30265974998474121) * gru_0_out_t4_35 + (0.4441315233707428) * gru_0_out_t4_36 + (-0.20875450968742371) * gru_0_out_t4_37 + (0.77092307806015015) * gru_0_out_t4_38 + (0.58746165037155151) * gru_0_out_t4_39 + (-1.1697883605957031) * gru_0_out_t4_40 + (0.27910000085830688) * gru_0_out_t4_41 + (-0.16143356263637543) * gru_0_out_t4_42 + (0.2880476713180542) * gru_0_out_t4_43 + (0.48523822426795959) * gru_0_out_t4_44 + (0.32786557078361511) * gru_0_out_t4_45 + (-0.82991600036621094) * gru_0_out_t4_46 + (0.85194498300552368) * gru_0_out_t4_47 + (0.85600399971008301) * gru_0_out_t4_48 + (-0.59633147716522217) * gru_0_out_t4_49 + (-0.94536548852920532) * gru_0_out_t4_50 + (-0.29678067564964294) * gru_0_out_t4_51 + (0.3879534900188446) * gru_0_out_t4_52 + (-0.543770432472229) * gru_0_out_t4_53 + (-0.20589473843574524) * gru_0_out_t4_54 + (0.085477903485298157) * gru_0_out_t4_55 + (0.61352998018264771) * gru_0_out_t4_56 + (-0.57839703559875488) * gru_0_out_t4_57 + (-0.58938181400299072) * gru_0_out_t4_58 + (0.125187948346138) * gru_0_out_t4_59 + (0.70047521591186523) * gru_0_out_t4_60 + (-0.11797461658716202) * gru_0_out_t4_61 + (0.95170670747756958) * gru_0_out_t4_62 + (-0.53871250152587891) * gru_0_out_t4_63 + gate_r * (-0.1497119814157486));
    gru_1_rev_t4_h_1 = (1.0 - gate_z) * gate_n;
    // h=2
    gate_r = sigmoid((-0.29359552264213562) + (-0.30851709842681885) * gru_0_out_t4_0 + (0.10630916059017181) * gru_0_out_t4_1 + (-0.52118217945098877) * gru_0_out_t4_2 + (1.0581414699554443) * gru_0_out_t4_3 + (-0.021844638511538506) * gru_0_out_t4_4 + (1.0310388803482056) * gru_0_out_t4_5 + (4.1587996482849121) * gru_0_out_t4_6 + (0.46692392230033875) * gru_0_out_t4_7 + (0.32975688576698303) * gru_0_out_t4_8 + (-2.77455735206604) * gru_0_out_t4_9 + (1.1535125970840454) * gru_0_out_t4_10 + (0.31193983554840088) * gru_0_out_t4_11 + (0.29254361987113953) * gru_0_out_t4_12 + (0.51572608947753906) * gru_0_out_t4_13 + (-0.22981269657611847) * gru_0_out_t4_14 + (0.26099058985710144) * gru_0_out_t4_15 + (-0.14098379015922546) * gru_0_out_t4_16 + (-0.11069414764642715) * gru_0_out_t4_17 + (-0.34626680612564087) * gru_0_out_t4_18 + (0.99610620737075806) * gru_0_out_t4_19 + (-0.52057719230651855) * gru_0_out_t4_20 + (-1.9270204305648804) * gru_0_out_t4_21 + (2.3346488475799561) * gru_0_out_t4_22 + (-0.0057712085545063019) * gru_0_out_t4_23 + (0.71812915802001953) * gru_0_out_t4_24 + (0.0057410052977502346) * gru_0_out_t4_25 + (-0.29757252335548401) * gru_0_out_t4_26 + (1.0797752141952515) * gru_0_out_t4_27 + (-1.2741584777832031) * gru_0_out_t4_28 + (-1.4562393426895142) * gru_0_out_t4_29 + (-0.065648555755615234) * gru_0_out_t4_30 + (-0.84069466590881348) * gru_0_out_t4_31 + (-0.9378388524055481) * gru_0_out_t4_32 + (0.16944015026092529) * gru_0_out_t4_33 + (0.030433623120188713) * gru_0_out_t4_34 + (0.16765798628330231) * gru_0_out_t4_35 + (0.36457657814025879) * gru_0_out_t4_36 + (0.07195708155632019) * gru_0_out_t4_37 + (-0.12130691111087799) * gru_0_out_t4_38 + (-2.2531247138977051) * gru_0_out_t4_39 + (-6.230186939239502) * gru_0_out_t4_40 + (0.12616020441055298) * gru_0_out_t4_41 + (-0.4558638334274292) * gru_0_out_t4_42 + (0.069745369255542755) * gru_0_out_t4_43 + (-0.11587700247764587) * gru_0_out_t4_44 + (-0.76109570264816284) * gru_0_out_t4_45 + (-2.4116475582122803) * gru_0_out_t4_46 + (0.014376847073435783) * gru_0_out_t4_47 + (-0.15219645202159882) * gru_0_out_t4_48 + (-0.18007808923721313) * gru_0_out_t4_49 + (0.78601598739624023) * gru_0_out_t4_50 + (-0.09346858412027359) * gru_0_out_t4_51 + (0.037853322923183441) * gru_0_out_t4_52 + (0.2071223258972168) * gru_0_out_t4_53 + (-0.56144142150878906) * gru_0_out_t4_54 + (-0.47393777966499329) * gru_0_out_t4_55 + (-0.30988287925720215) * gru_0_out_t4_56 + (0.39365428686141968) * gru_0_out_t4_57 + (-0.36413618922233582) * gru_0_out_t4_58 + (1.4322688579559326) * gru_0_out_t4_59 + (0.55603688955307007) * gru_0_out_t4_60 + (-0.22911778092384338) * gru_0_out_t4_61 + (0.16704843938350677) * gru_0_out_t4_62 + (-0.43199557065963745) * gru_0_out_t4_63);
    gate_z = sigmoid((0.43784698843955994) + (-0.018855109810829163) * gru_0_out_t4_0 + (-0.58723640441894531) * gru_0_out_t4_1 + (0.058743558824062347) * gru_0_out_t4_2 + (0.53357982635498047) * gru_0_out_t4_3 + (-0.428518146276474) * gru_0_out_t4_4 + (-0.3275763988494873) * gru_0_out_t4_5 + (0.68564492464065552) * gru_0_out_t4_6 + (-0.39698010683059692) * gru_0_out_t4_7 + (0.15838627517223358) * gru_0_out_t4_8 + (-1.0199624300003052) * gru_0_out_t4_9 + (-0.38474291563034058) * gru_0_out_t4_10 + (-0.55515635013580322) * gru_0_out_t4_11 + (0.39176470041275024) * gru_0_out_t4_12 + (-0.027490871027112007) * gru_0_out_t4_13 + (0.73575741052627563) * gru_0_out_t4_14 + (0.50056916475296021) * gru_0_out_t4_15 + (-1.2056490182876587) * gru_0_out_t4_16 + (-0.040703266859054565) * gru_0_out_t4_17 + (-0.038887947797775269) * gru_0_out_t4_18 + (0.43591615557670593) * gru_0_out_t4_19 + (-0.0099730277433991432) * gru_0_out_t4_20 + (-1.3062015771865845) * gru_0_out_t4_21 + (0.058146044611930847) * gru_0_out_t4_22 + (0.047639269381761551) * gru_0_out_t4_23 + (0.37951111793518066) * gru_0_out_t4_24 + (-0.25028958916664124) * gru_0_out_t4_25 + (0.80443602800369263) * gru_0_out_t4_26 + (0.28285908699035645) * gru_0_out_t4_27 + (-1.7759672403335571) * gru_0_out_t4_28 + (-0.15853141248226166) * gru_0_out_t4_29 + (-0.36927178502082825) * gru_0_out_t4_30 + (1.172264575958252) * gru_0_out_t4_31 + (0.31176963448524475) * gru_0_out_t4_32 + (0.11376465111970901) * gru_0_out_t4_33 + (0.28411510586738586) * gru_0_out_t4_34 + (0.46776485443115234) * gru_0_out_t4_35 + (0.20641888678073883) * gru_0_out_t4_36 + (-0.46705728769302368) * gru_0_out_t4_37 + (-0.11918076872825623) * gru_0_out_t4_38 + (0.4385235607624054) * gru_0_out_t4_39 + (-1.9194539785385132) * gru_0_out_t4_40 + (0.69094270467758179) * gru_0_out_t4_41 + (0.59324854612350464) * gru_0_out_t4_42 + (0.084542065858840942) * gru_0_out_t4_43 + (0.38348358869552612) * gru_0_out_t4_44 + (0.5126233696937561) * gru_0_out_t4_45 + (0.17638643085956573) * gru_0_out_t4_46 + (0.10237032175064087) * gru_0_out_t4_47 + (-0.50119763612747192) * gru_0_out_t4_48 + (0.59258264303207397) * gru_0_out_t4_49 + (0.064152315258979797) * gru_0_out_t4_50 + (-0.29318258166313171) * gru_0_out_t4_51 + (0.034756578505039215) * gru_0_out_t4_52 + (-0.072132214903831482) * gru_0_out_t4_53 + (1.3972070217132568) * gru_0_out_t4_54 + (1.1079283952713013) * gru_0_out_t4_55 + (0.099384427070617676) * gru_0_out_t4_56 + (0.2537473738193512) * gru_0_out_t4_57 + (-0.59472364187240601) * gru_0_out_t4_58 + (-0.78708744049072266) * gru_0_out_t4_59 + (-0.16626006364822388) * gru_0_out_t4_60 + (0.61122870445251465) * gru_0_out_t4_61 + (0.67303657531738281) * gru_0_out_t4_62 + (0.40167546272277832) * gru_0_out_t4_63);
    gate_n = tanh((0.036338925361633301) + (0.15184362232685089) * gru_0_out_t4_0 + (0.074002064764499664) * gru_0_out_t4_1 + (-0.60322803258895874) * gru_0_out_t4_2 + (-0.49432352185249329) * gru_0_out_t4_3 + (0.13194677233695984) * gru_0_out_t4_4 + (0.15184587240219116) * gru_0_out_t4_5 + (-0.7278296947479248) * gru_0_out_t4_6 + (-0.22918656468391418) * gru_0_out_t4_7 + (0.15080161392688751) * gru_0_out_t4_8 + (0.32200855016708374) * gru_0_out_t4_9 + (1.1495007276535034) * gru_0_out_t4_10 + (0.41310107707977295) * gru_0_out_t4_11 + (-0.35486513376235962) * gru_0_out_t4_12 + (0.24678005278110504) * gru_0_out_t4_13 + (0.029497832059860229) * gru_0_out_t4_14 + (-0.34316501021385193) * gru_0_out_t4_15 + (0.11734772473573685) * gru_0_out_t4_16 + (0.19860650599002838) * gru_0_out_t4_17 + (-0.013839568011462688) * gru_0_out_t4_18 + (-0.25995168089866638) * gru_0_out_t4_19 + (0.85276490449905396) * gru_0_out_t4_20 + (0.56019854545593262) * gru_0_out_t4_21 + (0.057018883526325226) * gru_0_out_t4_22 + (0.056567691266536713) * gru_0_out_t4_23 + (0.84792256355285645) * gru_0_out_t4_24 + (0.35751515626907349) * gru_0_out_t4_25 + (0.12265323847532272) * gru_0_out_t4_26 + (-0.40500184893608093) * gru_0_out_t4_27 + (-0.048174962401390076) * gru_0_out_t4_28 + (-0.1416359543800354) * gru_0_out_t4_29 + (0.15839573740959167) * gru_0_out_t4_30 + (-1.6904621124267578) * gru_0_out_t4_31 + (0.94405484199523926) * gru_0_out_t4_32 + (0.50102978944778442) * gru_0_out_t4_33 + (0.078424066305160522) * gru_0_out_t4_34 + (-0.250348299741745) * gru_0_out_t4_35 + (-0.23872998356819153) * gru_0_out_t4_36 + (0.086814664304256439) * gru_0_out_t4_37 + (-0.36284878849983215) * gru_0_out_t4_38 + (0.34516936540603638) * gru_0_out_t4_39 + (-1.0351132154464722) * gru_0_out_t4_40 + (0.016523202881217003) * gru_0_out_t4_41 + (0.58652973175048828) * gru_0_out_t4_42 + (-0.29010611772537231) * gru_0_out_t4_43 + (-0.3234105110168457) * gru_0_out_t4_44 + (-0.20859168469905853) * gru_0_out_t4_45 + (1.0047365427017212) * gru_0_out_t4_46 + (-0.98380160331726074) * gru_0_out_t4_47 + (-0.77846169471740723) * gru_0_out_t4_48 + (0.79964578151702881) * gru_0_out_t4_49 + (0.47566342353820801) * gru_0_out_t4_50 + (-0.10172613710165024) * gru_0_out_t4_51 + (-0.30825012922286987) * gru_0_out_t4_52 + (0.73772144317626953) * gru_0_out_t4_53 + (0.11490385979413986) * gru_0_out_t4_54 + (0.1627524346113205) * gru_0_out_t4_55 + (-1.2375884056091309) * gru_0_out_t4_56 + (0.63083767890930176) * gru_0_out_t4_57 + (-0.025980975478887558) * gru_0_out_t4_58 + (-1.0682672262191772) * gru_0_out_t4_59 + (-1.1967281103134155) * gru_0_out_t4_60 + (-0.23492655158042908) * gru_0_out_t4_61 + (-0.47744584083557129) * gru_0_out_t4_62 + (-1.0851637125015259) * gru_0_out_t4_63 + gate_r * (0.035252805799245834));
    gru_1_rev_t4_h_2 = (1.0 - gate_z) * gate_n;
    // h=3
    gate_r = sigmoid((0.3057715892791748) + (0.28386944532394409) * gru_0_out_t4_0 + (0.48094919323921204) * gru_0_out_t4_1 + (-0.63467681407928467) * gru_0_out_t4_2 + (-0.67109549045562744) * gru_0_out_t4_3 + (0.30236199498176575) * gru_0_out_t4_4 + (1.1504365205764771) * gru_0_out_t4_5 + (-0.21222943067550659) * gru_0_out_t4_6 + (-0.2851472795009613) * gru_0_out_t4_7 + (0.97742176055908203) * gru_0_out_t4_8 + (-0.43844521045684814) * gru_0_out_t4_9 + (0.63239294290542603) * gru_0_out_t4_10 + (-0.15549629926681519) * gru_0_out_t4_11 + (-0.17926536500453949) * gru_0_out_t4_12 + (0.16486240923404694) * gru_0_out_t4_13 + (-0.031540501862764359) * gru_0_out_t4_14 + (1.069970965385437) * gru_0_out_t4_15 + (0.52673977613449097) * gru_0_out_t4_16 + (-0.0064126881770789623) * gru_0_out_t4_17 + (0.5992472767829895) * gru_0_out_t4_18 + (-0.18491768836975098) * gru_0_out_t4_19 + (-0.11631443351507187) * gru_0_out_t4_20 + (0.70930790901184082) * gru_0_out_t4_21 + (-0.14091587066650391) * gru_0_out_t4_22 + (0.013239732943475246) * gru_0_out_t4_23 + (2.0339243412017822) * gru_0_out_t4_24 + (0.48630067706108093) * gru_0_out_t4_25 + (0.44641673564910889) * gru_0_out_t4_26 + (-1.0603811740875244) * gru_0_out_t4_27 + (0.36119160056114197) * gru_0_out_t4_28 + (0.23778082430362701) * gru_0_out_t4_29 + (0.086604051291942596) * gru_0_out_t4_30 + (-3.326984167098999) * gru_0_out_t4_31 + (-0.34258529543876648) * gru_0_out_t4_32 + (2.2508060932159424) * gru_0_out_t4_33 + (0.71955138444900513) * gru_0_out_t4_34 + (-0.14840622246265411) * gru_0_out_t4_35 + (-0.06038583442568779) * gru_0_out_t4_36 + (0.42593801021575928) * gru_0_out_t4_37 + (-2.3285489082336426) * gru_0_out_t4_38 + (1.4976804256439209) * gru_0_out_t4_39 + (1.3908429145812988) * gru_0_out_t4_40 + (0.20749986171722412) * gru_0_out_t4_41 + (0.86148250102996826) * gru_0_out_t4_42 + (-0.5566285252571106) * gru_0_out_t4_43 + (-0.25818610191345215) * gru_0_out_t4_44 + (-0.51359099149703979) * gru_0_out_t4_45 + (0.90015131235122681) * gru_0_out_t4_46 + (0.53005307912826538) * gru_0_out_t4_47 + (0.010345185175538063) * gru_0_out_t4_48 + (-0.093372732400894165) * gru_0_out_t4_49 + (-1.0434112548828125) * gru_0_out_t4_50 + (0.63623619079589844) * gru_0_out_t4_51 + (-1.6267426013946533) * gru_0_out_t4_52 + (-0.20427854359149933) * gru_0_out_t4_53 + (-0.011858790181577206) * gru_0_out_t4_54 + (-0.13568316400051117) * gru_0_out_t4_55 + (1.0888692140579224) * gru_0_out_t4_56 + (0.16366212069988251) * gru_0_out_t4_57 + (0.1778351217508316) * gru_0_out_t4_58 + (-0.74162346124649048) * gru_0_out_t4_59 + (0.14643973112106323) * gru_0_out_t4_60 + (-0.19997216761112213) * gru_0_out_t4_61 + (-1.9679572582244873) * gru_0_out_t4_62 + (0.91109859943389893) * gru_0_out_t4_63);
    gate_z = sigmoid((-0.90226072072982788) + (-0.57960128784179688) * gru_0_out_t4_0 + (0.27242559194564819) * gru_0_out_t4_1 + (-0.21327109634876251) * gru_0_out_t4_2 + (0.92762881517410278) * gru_0_out_t4_3 + (-0.68291246891021729) * gru_0_out_t4_4 + (-0.0072710723616182804) * gru_0_out_t4_5 + (0.60033214092254639) * gru_0_out_t4_6 + (-0.56621193885803223) * gru_0_out_t4_7 + (0.25618168711662292) * gru_0_out_t4_8 + (-0.076130054891109467) * gru_0_out_t4_9 + (0.51074522733688354) * gru_0_out_t4_10 + (0.3785252571105957) * gru_0_out_t4_11 + (0.39193156361579895) * gru_0_out_t4_12 + (0.016653843224048615) * gru_0_out_t4_13 + (-0.2917608916759491) * gru_0_out_t4_14 + (0.75295233726501465) * gru_0_out_t4_15 + (-0.16976532340049744) * gru_0_out_t4_16 + (-0.36052417755126953) * gru_0_out_t4_17 + (0.058370880782604218) * gru_0_out_t4_18 + (1.475817084312439) * gru_0_out_t4_19 + (-0.67850083112716675) * gru_0_out_t4_20 + (-0.36024388670921326) * gru_0_out_t4_21 + (0.92130082845687866) * gru_0_out_t4_22 + (-0.28144925832748413) * gru_0_out_t4_23 + (0.19770348072052002) * gru_0_out_t4_24 + (0.020706238225102425) * gru_0_out_t4_25 + (-0.47938063740730286) * gru_0_out_t4_26 + (0.17671151459217072) * gru_0_out_t4_27 + (2.200359582901001) * gru_0_out_t4_28 + (0.3864733874797821) * gru_0_out_t4_29 + (-0.8821900486946106) * gru_0_out_t4_30 + (1.5857840776443481) * gru_0_out_t4_31 + (-0.88015270233154297) * gru_0_out_t4_32 + (-0.56279444694519043) * gru_0_out_t4_33 + (-0.17454081773757935) * gru_0_out_t4_34 + (-0.4465658962726593) * gru_0_out_t4_35 + (-0.19824768602848053) * gru_0_out_t4_36 + (-0.026263585314154625) * gru_0_out_t4_37 + (0.34509462118148804) * gru_0_out_t4_38 + (-0.58315318822860718) * gru_0_out_t4_39 + (-1.1590234041213989) * gru_0_out_t4_40 + (1.0535933971405029) * gru_0_out_t4_41 + (0.059686549007892609) * gru_0_out_t4_42 + (0.023495079949498177) * gru_0_out_t4_43 + (-0.018236514180898666) * gru_0_out_t4_44 + (0.35238757729530334) * gru_0_out_t4_45 + (1.5738825798034668) * gru_0_out_t4_46 + (0.33520233631134033) * gru_0_out_t4_47 + (0.21965025365352631) * gru_0_out_t4_48 + (-0.17517662048339844) * gru_0_out_t4_49 + (-0.018518527969717979) * gru_0_out_t4_50 + (0.29251983761787415) * gru_0_out_t4_51 + (0.2362152636051178) * gru_0_out_t4_52 + (0.053717028349637985) * gru_0_out_t4_53 + (0.50045782327651978) * gru_0_out_t4_54 + (-0.17820435762405396) * gru_0_out_t4_55 + (-0.23002518713474274) * gru_0_out_t4_56 + (-0.089104704558849335) * gru_0_out_t4_57 + (-0.16939403116703033) * gru_0_out_t4_58 + (-0.48470273613929749) * gru_0_out_t4_59 + (-0.19589978456497192) * gru_0_out_t4_60 + (-0.51420271396636963) * gru_0_out_t4_61 + (0.69429200887680054) * gru_0_out_t4_62 + (-0.8138156533241272) * gru_0_out_t4_63);
    gate_n = tanh((-0.33182060718536377) + (-0.13364247977733612) * gru_0_out_t4_0 + (0.24215346574783325) * gru_0_out_t4_1 + (-0.40933153033256531) * gru_0_out_t4_2 + (0.20643326640129089) * gru_0_out_t4_3 + (0.04295479878783226) * gru_0_out_t4_4 + (0.54446130990982056) * gru_0_out_t4_5 + (0.87856292724609375) * gru_0_out_t4_6 + (-0.19129401445388794) * gru_0_out_t4_7 + (0.15498967468738556) * gru_0_out_t4_8 + (-0.45175653696060181) * gru_0_out_t4_9 + (0.22597609460353851) * gru_0_out_t4_10 + (-0.5499567985534668) * gru_0_out_t4_11 + (0.2696165144443512) * gru_0_out_t4_12 + (-0.20278584957122803) * gru_0_out_t4_13 + (-0.21225979924201965) * gru_0_out_t4_14 + (0.029270315542817116) * gru_0_out_t4_15 + (0.19798025488853455) * gru_0_out_t4_16 + (0.25304549932479858) * gru_0_out_t4_17 + (0.14713901281356812) * gru_0_out_t4_18 + (-0.029800267890095711) * gru_0_out_t4_19 + (-0.44589462876319885) * gru_0_out_t4_20 + (0.013573138974606991) * gru_0_out_t4_21 + (0.25493788719177246) * gru_0_out_t4_22 + (-0.063758723437786102) * gru_0_out_t4_23 + (-0.075549036264419556) * gru_0_out_t4_24 + (-0.37759989500045776) * gru_0_out_t4_25 + (0.12419699132442474) * gru_0_out_t4_26 + (0.17878140509128571) * gru_0_out_t4_27 + (0.48680248856544495) * gru_0_out_t4_28 + (0.11614207178354263) * gru_0_out_t4_29 + (-0.31561106443405151) * gru_0_out_t4_30 + (0.086778581142425537) * gru_0_out_t4_31 + (-1.0009082555770874) * gru_0_out_t4_32 + (-0.35904493927955627) * gru_0_out_t4_33 + (0.081106528639793396) * gru_0_out_t4_34 + (-0.1042257696390152) * gru_0_out_t4_35 + (0.11687865853309631) * gru_0_out_t4_36 + (0.19868293404579163) * gru_0_out_t4_37 + (0.53360956907272339) * gru_0_out_t4_38 + (-0.58547294139862061) * gru_0_out_t4_39 + (0.53118085861206055) * gru_0_out_t4_40 + (-0.32721793651580811) * gru_0_out_t4_41 + (-0.15219366550445557) * gru_0_out_t4_42 + (-0.038209892809391022) * gru_0_out_t4_43 + (0.040667466819286346) * gru_0_out_t4_44 + (-0.42428091168403625) * gru_0_out_t4_45 + (-1.3792816400527954) * gru_0_out_t4_46 + (0.73484081029891968) * gru_0_out_t4_47 + (0.23021470010280609) * gru_0_out_t4_48 + (-0.65408170223236084) * gru_0_out_t4_49 + (0.043954420834779739) * gru_0_out_t4_50 + (-0.35745447874069214) * gru_0_out_t4_51 + (0.1837688535451889) * gru_0_out_t4_52 + (0.154344841837883) * gru_0_out_t4_53 + (0.36932122707366943) * gru_0_out_t4_54 + (0.49375852942466736) * gru_0_out_t4_55 + (0.04163404181599617) * gru_0_out_t4_56 + (-0.32075077295303345) * gru_0_out_t4_57 + (-0.21929489076137543) * gru_0_out_t4_58 + (1.0108981132507324) * gru_0_out_t4_59 + (0.74859452247619629) * gru_0_out_t4_60 + (0.9753606915473938) * gru_0_out_t4_61 + (-0.074769608676433563) * gru_0_out_t4_62 + (-1.2365801334381104) * gru_0_out_t4_63 + gate_r * (-0.170765221118927));
    gru_1_rev_t4_h_3 = (1.0 - gate_z) * gate_n;
    // h=4
    gate_r = sigmoid((-0.85284173488616943) + (-0.28436857461929321) * gru_0_out_t4_0 + (-0.30776605010032654) * gru_0_out_t4_1 + (-0.52878284454345703) * gru_0_out_t4_2 + (0.6508631706237793) * gru_0_out_t4_3 + (-0.55029314756393433) * gru_0_out_t4_4 + (1.2736679315567017) * gru_0_out_t4_5 + (-1.2393795251846313) * gru_0_out_t4_6 + (-0.64742714166641235) * gru_0_out_t4_7 + (0.68527525663375854) * gru_0_out_t4_8 + (0.21002604067325592) * gru_0_out_t4_9 + (0.47022402286529541) * gru_0_out_t4_10 + (-0.34368842840194702) * gru_0_out_t4_11 + (-1.1928057670593262) * gru_0_out_t4_12 + (-2.0482950210571289) * gru_0_out_t4_13 + (0.32477402687072754) * gru_0_out_t4_14 + (-0.35760572552680969) * gru_0_out_t4_15 + (0.66029900312423706) * gru_0_out_t4_16 + (-0.35550051927566528) * gru_0_out_t4_17 + (-0.063451096415519714) * gru_0_out_t4_18 + (1.3988646268844604) * gru_0_out_t4_19 + (-0.25908598303794861) * gru_0_out_t4_20 + (3.1605510711669922) * gru_0_out_t4_21 + (-0.95725727081298828) * gru_0_out_t4_22 + (-0.33387094736099243) * gru_0_out_t4_23 + (0.52053201198577881) * gru_0_out_t4_24 + (-0.072469927370548248) * gru_0_out_t4_25 + (0.25445547699928284) * gru_0_out_t4_26 + (-0.8192782998085022) * gru_0_out_t4_27 + (0.45953395962715149) * gru_0_out_t4_28 + (-0.17712828516960144) * gru_0_out_t4_29 + (-0.41927602887153625) * gru_0_out_t4_30 + (-1.8506424427032471) * gru_0_out_t4_31 + (-1.3312333822250366) * gru_0_out_t4_32 + (-0.40286582708358765) * gru_0_out_t4_33 + (0.28934758901596069) * gru_0_out_t4_34 + (0.083006151020526886) * gru_0_out_t4_35 + (1.3851670026779175) * gru_0_out_t4_36 + (-0.32928171753883362) * gru_0_out_t4_37 + (0.095163613557815552) * gru_0_out_t4_38 + (-0.66202330589294434) * gru_0_out_t4_39 + (0.28152617812156677) * gru_0_out_t4_40 + (-0.73174697160720825) * gru_0_out_t4_41 + (-0.60733360052108765) * gru_0_out_t4_42 + (-0.35098043084144592) * gru_0_out_t4_43 + (0.12369762361049652) * gru_0_out_t4_44 + (0.12110631912946701) * gru_0_out_t4_45 + (-0.24701137840747833) * gru_0_out_t4_46 + (0.41082018613815308) * gru_0_out_t4_47 + (0.0513291135430336) * gru_0_out_t4_48 + (-0.042957685887813568) * gru_0_out_t4_49 + (1.0406594276428223) * gru_0_out_t4_50 + (0.60547471046447754) * gru_0_out_t4_51 + (0.3280538022518158) * gru_0_out_t4_52 + (0.017066773027181625) * gru_0_out_t4_53 + (0.54390347003936768) * gru_0_out_t4_54 + (-0.004396545235067606) * gru_0_out_t4_55 + (0.064429864287376404) * gru_0_out_t4_56 + (0.18947231769561768) * gru_0_out_t4_57 + (0.10556717962026596) * gru_0_out_t4_58 + (-0.68872976303100586) * gru_0_out_t4_59 + (-0.029299363493919373) * gru_0_out_t4_60 + (-0.57261532545089722) * gru_0_out_t4_61 + (-2.2493383884429932) * gru_0_out_t4_62 + (0.16600167751312256) * gru_0_out_t4_63);
    gate_z = sigmoid((-0.81669348478317261) + (-0.33308026194572449) * gru_0_out_t4_0 + (0.44340571761131287) * gru_0_out_t4_1 + (-1.1071795225143433) * gru_0_out_t4_2 + (-0.56527483463287354) * gru_0_out_t4_3 + (0.023389186710119247) * gru_0_out_t4_4 + (-0.89604169130325317) * gru_0_out_t4_5 + (-0.37035417556762695) * gru_0_out_t4_6 + (0.41716456413269043) * gru_0_out_t4_7 + (-0.20178313553333282) * gru_0_out_t4_8 + (0.020566478371620178) * gru_0_out_t4_9 + (1.8742918968200684) * gru_0_out_t4_10 + (0.34618765115737915) * gru_0_out_t4_11 + (-0.6505962610244751) * gru_0_out_t4_12 + (-0.32015201449394226) * gru_0_out_t4_13 + (-0.20776659250259399) * gru_0_out_t4_14 + (-0.18571199476718903) * gru_0_out_t4_15 + (0.018950192257761955) * gru_0_out_t4_16 + (-0.43294388055801392) * gru_0_out_t4_17 + (-0.19319058954715729) * gru_0_out_t4_18 + (-2.2259612083435059) * gru_0_out_t4_19 + (-0.77732276916503906) * gru_0_out_t4_20 + (0.10494133830070496) * gru_0_out_t4_21 + (0.26847547292709351) * gru_0_out_t4_22 + (-0.0042161582969129086) * gru_0_out_t4_23 + (1.4388601779937744) * gru_0_out_t4_24 + (0.19661867618560791) * gru_0_out_t4_25 + (-0.60716861486434937) * gru_0_out_t4_26 + (-0.52465540170669556) * gru_0_out_t4_27 + (-0.51530247926712036) * gru_0_out_t4_28 + (-0.094727113842964172) * gru_0_out_t4_29 + (-0.48076775670051575) * gru_0_out_t4_30 + (-1.2719722986221313) * gru_0_out_t4_31 + (0.026749864220619202) * gru_0_out_t4_32 + (0.63577008247375488) * gru_0_out_t4_33 + (1.3939803838729858) * gru_0_out_t4_34 + (-1.1500581502914429) * gru_0_out_t4_35 + (-0.25652369856834412) * gru_0_out_t4_36 + (1.0728533267974854) * gru_0_out_t4_37 + (-0.81295448541641235) * gru_0_out_t4_38 + (0.35631087422370911) * gru_0_out_t4_39 + (-0.61456859111785889) * gru_0_out_t4_40 + (-0.17657743394374847) * gru_0_out_t4_41 + (0.32728791236877441) * gru_0_out_t4_42 + (-0.23349383473396301) * gru_0_out_t4_43 + (-0.66113370656967163) * gru_0_out_t4_44 + (-0.77077627182006836) * gru_0_out_t4_45 + (0.65921300649642944) * gru_0_out_t4_46 + (0.3257274329662323) * gru_0_out_t4_47 + (0.4569607675075531) * gru_0_out_t4_48 + (-0.096899032592773438) * gru_0_out_t4_49 + (-0.81703329086303711) * gru_0_out_t4_50 + (-0.40731948614120483) * gru_0_out_t4_51 + (-1.7679767608642578) * gru_0_out_t4_52 + (0.016265247017145157) * gru_0_out_t4_53 + (0.1737811267375946) * gru_0_out_t4_54 + (-0.48866096138954163) * gru_0_out_t4_55 + (0.78875213861465454) * gru_0_out_t4_56 + (-0.20054136216640472) * gru_0_out_t4_57 + (-0.22155278921127319) * gru_0_out_t4_58 + (-0.3206636905670166) * gru_0_out_t4_59 + (0.27638965845108032) * gru_0_out_t4_60 + (-0.15564520657062531) * gru_0_out_t4_61 + (-0.67489278316497803) * gru_0_out_t4_62 + (1.0005848407745361) * gru_0_out_t4_63);
    gate_n = tanh((0.21212151646614075) + (-0.046121343970298767) * gru_0_out_t4_0 + (-0.24999581277370453) * gru_0_out_t4_1 + (-0.16646437346935272) * gru_0_out_t4_2 + (-0.11696069687604904) * gru_0_out_t4_3 + (-0.30428153276443481) * gru_0_out_t4_4 + (0.16541218757629395) * gru_0_out_t4_5 + (0.25294044613838196) * gru_0_out_t4_6 + (-0.72023612260818481) * gru_0_out_t4_7 + (-0.053521167486906052) * gru_0_out_t4_8 + (-0.26079058647155762) * gru_0_out_t4_9 + (-0.32820278406143188) * gru_0_out_t4_10 + (-0.37023371458053589) * gru_0_out_t4_11 + (-0.054795637726783752) * gru_0_out_t4_12 + (0.015303418040275574) * gru_0_out_t4_13 + (0.16191062331199646) * gru_0_out_t4_14 + (0.14692226052284241) * gru_0_out_t4_15 + (-1.6961246728897095) * gru_0_out_t4_16 + (-0.60965836048126221) * gru_0_out_t4_17 + (0.018089858815073967) * gru_0_out_t4_18 + (-0.10476627200841904) * gru_0_out_t4_19 + (-0.31742554903030396) * gru_0_out_t4_20 + (-1.7301788330078125) * gru_0_out_t4_21 + (-0.31704562902450562) * gru_0_out_t4_22 + (0.55906939506530762) * gru_0_out_t4_23 + (-0.18765954673290253) * gru_0_out_t4_24 + (-0.29309350252151489) * gru_0_out_t4_25 + (0.041777607053518295) * gru_0_out_t4_26 + (0.027556486427783966) * gru_0_out_t4_27 + (-0.51574862003326416) * gru_0_out_t4_28 + (0.27060449123382568) * gru_0_out_t4_29 + (0.23513925075531006) * gru_0_out_t4_30 + (-0.017734711989760399) * gru_0_out_t4_31 + (0.68808257579803467) * gru_0_out_t4_32 + (0.19908039271831512) * gru_0_out_t4_33 + (1.306243896484375) * gru_0_out_t4_34 + (-0.045786205679178238) * gru_0_out_t4_35 + (0.68623042106628418) * gru_0_out_t4_36 + (-0.53176707029342651) * gru_0_out_t4_37 + (-0.18421696126461029) * gru_0_out_t4_38 + (0.11281236261129379) * gru_0_out_t4_39 + (0.18654315173625946) * gru_0_out_t4_40 + (0.65099447965621948) * gru_0_out_t4_41 + (-0.14548754692077637) * gru_0_out_t4_42 + (-0.07775086909532547) * gru_0_out_t4_43 + (0.24505141377449036) * gru_0_out_t4_44 + (-0.023782825097441673) * gru_0_out_t4_45 + (0.037717055529356003) * gru_0_out_t4_46 + (-0.50845783948898315) * gru_0_out_t4_47 + (-0.2098768949508667) * gru_0_out_t4_48 + (0.00015663956583011895) * gru_0_out_t4_49 + (-0.14637885987758636) * gru_0_out_t4_50 + (0.016680095344781876) * gru_0_out_t4_51 + (-0.53228509426116943) * gru_0_out_t4_52 + (0.227190762758255) * gru_0_out_t4_53 + (-0.53244978189468384) * gru_0_out_t4_54 + (0.43276244401931763) * gru_0_out_t4_55 + (-0.16802941262722015) * gru_0_out_t4_56 + (-0.071219198405742645) * gru_0_out_t4_57 + (-0.49584150314331055) * gru_0_out_t4_58 + (-0.86083376407623291) * gru_0_out_t4_59 + (0.14458438754081726) * gru_0_out_t4_60 + (0.2383958101272583) * gru_0_out_t4_61 + (0.59970206022262573) * gru_0_out_t4_62 + (0.037024576216936111) * gru_0_out_t4_63 + gate_r * (0.24168875813484192));
    gru_1_rev_t4_h_4 = (1.0 - gate_z) * gate_n;
    // h=5
    gate_r = sigmoid((-0.85275256633758545) + (-0.37231147289276123) * gru_0_out_t4_0 + (-0.41273888945579529) * gru_0_out_t4_1 + (-3.4210171699523926) * gru_0_out_t4_2 + (-0.54595738649368286) * gru_0_out_t4_3 + (-0.9465973973274231) * gru_0_out_t4_4 + (-0.06728006899356842) * gru_0_out_t4_5 + (1.4984585046768188) * gru_0_out_t4_6 + (1.0565659999847412) * gru_0_out_t4_7 + (0.78533220291137695) * gru_0_out_t4_8 + (-0.044619806110858917) * gru_0_out_t4_9 + (2.4052333831787109) * gru_0_out_t4_10 + (-0.24249827861785889) * gru_0_out_t4_11 + (0.062222294509410858) * gru_0_out_t4_12 + (0.334329754114151) * gru_0_out_t4_13 + (-0.39066967368125916) * gru_0_out_t4_14 + (-0.035223193466663361) * gru_0_out_t4_15 + (0.27091357111930847) * gru_0_out_t4_16 + (0.63219565153121948) * gru_0_out_t4_17 + (-0.13513840734958649) * gru_0_out_t4_18 + (-0.26814007759094238) * gru_0_out_t4_19 + (-0.27018803358078003) * gru_0_out_t4_20 + (0.79521393775939941) * gru_0_out_t4_21 + (-0.66086649894714355) * gru_0_out_t4_22 + (-0.57469141483306885) * gru_0_out_t4_23 + (3.9588806629180908) * gru_0_out_t4_24 + (1.1795332431793213) * gru_0_out_t4_25 + (0.61307573318481445) * gru_0_out_t4_26 + (-0.27912133932113647) * gru_0_out_t4_27 + (0.33552464842796326) * gru_0_out_t4_28 + (0.34554785490036011) * gru_0_out_t4_29 + (0.062455631792545319) * gru_0_out_t4_30 + (-1.9817560911178589) * gru_0_out_t4_31 + (-0.2021060436964035) * gru_0_out_t4_32 + (-0.18547999858856201) * gru_0_out_t4_33 + (0.51029932498931885) * gru_0_out_t4_34 + (-0.23184169828891754) * gru_0_out_t4_35 + (0.065086215734481812) * gru_0_out_t4_36 + (-0.30575355887413025) * gru_0_out_t4_37 + (0.46613243222236633) * gru_0_out_t4_38 + (0.058039546012878418) * gru_0_out_t4_39 + (-0.12071848660707474) * gru_0_out_t4_40 + (-0.12016037106513977) * gru_0_out_t4_41 + (1.544541597366333) * gru_0_out_t4_42 + (-0.027319518849253654) * gru_0_out_t4_43 + (0.12062805891036987) * gru_0_out_t4_44 + (-0.088251024484634399) * gru_0_out_t4_45 + (1.4941831827163696) * gru_0_out_t4_46 + (-0.020773140713572502) * gru_0_out_t4_47 + (-2.0313930511474609) * gru_0_out_t4_48 + (1.8216820955276489) * gru_0_out_t4_49 + (-0.48123803734779358) * gru_0_out_t4_50 + (-1.0743937492370605) * gru_0_out_t4_51 + (-0.03249654546380043) * gru_0_out_t4_52 + (-0.17621238529682159) * gru_0_out_t4_53 + (0.078640364110469818) * gru_0_out_t4_54 + (-2.6135110855102539) * gru_0_out_t4_55 + (-0.51477491855621338) * gru_0_out_t4_56 + (0.51743227243423462) * gru_0_out_t4_57 + (-0.33058130741119385) * gru_0_out_t4_58 + (-0.55279242992401123) * gru_0_out_t4_59 + (-2.0494387149810791) * gru_0_out_t4_60 + (0.68700236082077026) * gru_0_out_t4_61 + (0.10782763361930847) * gru_0_out_t4_62 + (0.88686764240264893) * gru_0_out_t4_63);
    gate_z = sigmoid((-0.21083906292915344) + (0.29572367668151855) * gru_0_out_t4_0 + (-0.36876967549324036) * gru_0_out_t4_1 + (-0.63817650079727173) * gru_0_out_t4_2 + (-0.46088972687721252) * gru_0_out_t4_3 + (-0.42738914489746094) * gru_0_out_t4_4 + (0.10379841923713684) * gru_0_out_t4_5 + (0.48813578486442566) * gru_0_out_t4_6 + (-0.062365755438804626) * gru_0_out_t4_7 + (0.054881695657968521) * gru_0_out_t4_8 + (-0.93465691804885864) * gru_0_out_t4_9 + (0.83270353078842163) * gru_0_out_t4_10 + (0.57028490304946899) * gru_0_out_t4_11 + (-0.039887495338916779) * gru_0_out_t4_12 + (0.28312736749649048) * gru_0_out_t4_13 + (0.067829087376594543) * gru_0_out_t4_14 + (-0.26339083909988403) * gru_0_out_t4_15 + (0.04471689835190773) * gru_0_out_t4_16 + (-0.28516590595245361) * gru_0_out_t4_17 + (-0.46176841855049133) * gru_0_out_t4_18 + (-0.3510286808013916) * gru_0_out_t4_19 + (-0.93618220090866089) * gru_0_out_t4_20 + (-0.18463461101055145) * gru_0_out_t4_21 + (0.22288854420185089) * gru_0_out_t4_22 + (0.1839858740568161) * gru_0_out_t4_23 + (0.021833175793290138) * gru_0_out_t4_24 + (0.24573822319507599) * gru_0_out_t4_25 + (-0.85423958301544189) * gru_0_out_t4_26 + (0.27014762163162231) * gru_0_out_t4_27 + (-0.043879296630620956) * gru_0_out_t4_28 + (0.41122725605964661) * gru_0_out_t4_29 + (0.23105558753013611) * gru_0_out_t4_30 + (0.456072598695755) * gru_0_out_t4_31 + (-0.0088172294199466705) * gru_0_out_t4_32 + (0.018507339060306549) * gru_0_out_t4_33 + (0.88905602693557739) * gru_0_out_t4_34 + (-0.13916929066181183) * gru_0_out_t4_35 + (0.071937277913093567) * gru_0_out_t4_36 + (-0.21308133006095886) * gru_0_out_t4_37 + (-0.17475828528404236) * gru_0_out_t4_38 + (0.14793825149536133) * gru_0_out_t4_39 + (-0.94930493831634521) * gru_0_out_t4_40 + (-0.26791998744010925) * gru_0_out_t4_41 + (0.47908896207809448) * gru_0_out_t4_42 + (0.55365163087844849) * gru_0_out_t4_43 + (-0.12477477639913559) * gru_0_out_t4_44 + (-0.092440038919448853) * gru_0_out_t4_45 + (0.63290095329284668) * gru_0_out_t4_46 + (0.13363134860992432) * gru_0_out_t4_47 + (-0.35190102458000183) * gru_0_out_t4_48 + (0.076332330703735352) * gru_0_out_t4_49 + (-0.46334338188171387) * gru_0_out_t4_50 + (0.068668022751808167) * gru_0_out_t4_51 + (0.31255874037742615) * gru_0_out_t4_52 + (-0.25174608826637268) * gru_0_out_t4_53 + (0.49698075652122498) * gru_0_out_t4_54 + (0.41042602062225342) * gru_0_out_t4_55 + (-0.042150698602199554) * gru_0_out_t4_56 + (0.49257576465606689) * gru_0_out_t4_57 + (0.0029996265657246113) * gru_0_out_t4_58 + (-0.70677876472473145) * gru_0_out_t4_59 + (0.72095960378646851) * gru_0_out_t4_60 + (-0.26149541139602661) * gru_0_out_t4_61 + (0.72527992725372314) * gru_0_out_t4_62 + (-0.13292494416236877) * gru_0_out_t4_63);
    gate_n = tanh((0.1485549658536911) + (-0.017309127375483513) * gru_0_out_t4_0 + (0.12968628108501434) * gru_0_out_t4_1 + (-0.16752439737319946) * gru_0_out_t4_2 + (0.29244992136955261) * gru_0_out_t4_3 + (0.29653835296630859) * gru_0_out_t4_4 + (0.083427123725414276) * gru_0_out_t4_5 + (-0.28429359197616577) * gru_0_out_t4_6 + (0.083677999675273895) * gru_0_out_t4_7 + (0.70336079597473145) * gru_0_out_t4_8 + (-0.14761540293693542) * gru_0_out_t4_9 + (0.024268688634037971) * gru_0_out_t4_10 + (0.20479847490787506) * gru_0_out_t4_11 + (0.17941676080226898) * gru_0_out_t4_12 + (0.067435517907142639) * gru_0_out_t4_13 + (-0.084788687527179718) * gru_0_out_t4_14 + (0.15215599536895752) * gru_0_out_t4_15 + (-0.030545994639396667) * gru_0_out_t4_16 + (0.0088785095140337944) * gru_0_out_t4_17 + (0.48280623555183411) * gru_0_out_t4_18 + (0.27373707294464111) * gru_0_out_t4_19 + (0.43739175796508789) * gru_0_out_t4_20 + (-0.17479248344898224) * gru_0_out_t4_21 + (0.14576455950737) * gru_0_out_t4_22 + (-0.70997512340545654) * gru_0_out_t4_23 + (0.1909349113702774) * gru_0_out_t4_24 + (-0.0994129478931427) * gru_0_out_t4_25 + (0.88343942165374756) * gru_0_out_t4_26 + (-0.066545553505420685) * gru_0_out_t4_27 + (-0.44508647918701172) * gru_0_out_t4_28 + (0.79155457019805908) * gru_0_out_t4_29 + (0.052655331790447235) * gru_0_out_t4_30 + (0.053580708801746368) * gru_0_out_t4_31 + (0.61274874210357666) * gru_0_out_t4_32 + (-0.69636642932891846) * gru_0_out_t4_33 + (0.63274300098419189) * gru_0_out_t4_34 + (-0.18186077475547791) * gru_0_out_t4_35 + (-0.039516214281320572) * gru_0_out_t4_36 + (-0.16290475428104401) * gru_0_out_t4_37 + (-0.17495036125183105) * gru_0_out_t4_38 + (-0.048875767737627029) * gru_0_out_t4_39 + (-0.41457238793373108) * gru_0_out_t4_40 + (0.3438030481338501) * gru_0_out_t4_41 + (-1.2345099449157715) * gru_0_out_t4_42 + (-0.29338827729225159) * gru_0_out_t4_43 + (-0.0026426829863339663) * gru_0_out_t4_44 + (-0.0062886504456400871) * gru_0_out_t4_45 + (-0.54791659116744995) * gru_0_out_t4_46 + (-0.50673598051071167) * gru_0_out_t4_47 + (-0.42454195022583008) * gru_0_out_t4_48 + (0.17304053902626038) * gru_0_out_t4_49 + (0.24635446071624756) * gru_0_out_t4_50 + (0.1861598789691925) * gru_0_out_t4_51 + (-0.15734702348709106) * gru_0_out_t4_52 + (0.10103742778301239) * gru_0_out_t4_53 + (0.10149660706520081) * gru_0_out_t4_54 + (0.1851298063993454) * gru_0_out_t4_55 + (-0.12342564761638641) * gru_0_out_t4_56 + (0.24604837596416473) * gru_0_out_t4_57 + (-0.19492115080356598) * gru_0_out_t4_58 + (0.014314576052129269) * gru_0_out_t4_59 + (-1.2897763252258301) * gru_0_out_t4_60 + (0.040037080645561218) * gru_0_out_t4_61 + (0.35444653034210205) * gru_0_out_t4_62 + (-1.009379506111145) * gru_0_out_t4_63 + gate_r * (0.25461798906326294));
    gru_1_rev_t4_h_5 = (1.0 - gate_z) * gate_n;
    // h=6
    gate_r = sigmoid((-0.17845836281776428) + (0.21675291657447815) * gru_0_out_t4_0 + (0.092875413596630096) * gru_0_out_t4_1 + (-1.1024574041366577) * gru_0_out_t4_2 + (-0.93104356527328491) * gru_0_out_t4_3 + (-0.053150732070207596) * gru_0_out_t4_4 + (0.1410113126039505) * gru_0_out_t4_5 + (0.54799103736877441) * gru_0_out_t4_6 + (0.83457398414611816) * gru_0_out_t4_7 + (0.64689141511917114) * gru_0_out_t4_8 + (0.48188823461532593) * gru_0_out_t4_9 + (1.3335813283920288) * gru_0_out_t4_10 + (-0.036059796810150146) * gru_0_out_t4_11 + (-0.043537463992834091) * gru_0_out_t4_12 + (0.058656293898820877) * gru_0_out_t4_13 + (-0.50566655397415161) * gru_0_out_t4_14 + (-0.49999901652336121) * gru_0_out_t4_15 + (-0.5590667724609375) * gru_0_out_t4_16 + (-0.16408759355545044) * gru_0_out_t4_17 + (0.82274937629699707) * gru_0_out_t4_18 + (-1.297120213508606) * gru_0_out_t4_19 + (-0.44155815243721008) * gru_0_out_t4_20 + (-0.42363342642784119) * gru_0_out_t4_21 + (-0.26518735289573669) * gru_0_out_t4_22 + (-1.0361405611038208) * gru_0_out_t4_23 + (2.0992810726165771) * gru_0_out_t4_24 + (0.26762589812278748) * gru_0_out_t4_25 + (-0.41395074129104614) * gru_0_out_t4_26 + (1.0264595746994019) * gru_0_out_t4_27 + (-0.85478192567825317) * gru_0_out_t4_28 + (-0.15358337759971619) * gru_0_out_t4_29 + (-0.040708236396312714) * gru_0_out_t4_30 + (-2.911768913269043) * gru_0_out_t4_31 + (0.28539800643920898) * gru_0_out_t4_32 + (0.24616996943950653) * gru_0_out_t4_33 + (-0.044476039707660675) * gru_0_out_t4_34 + (-0.17438693344593048) * gru_0_out_t4_35 + (0.36470323801040649) * gru_0_out_t4_36 + (-0.1807335764169693) * gru_0_out_t4_37 + (0.28814142942428589) * gru_0_out_t4_38 + (2.0805056095123291) * gru_0_out_t4_39 + (2.7370791435241699) * gru_0_out_t4_40 + (-0.40160742402076721) * gru_0_out_t4_41 + (2.7162458896636963) * gru_0_out_t4_42 + (-0.066900454461574554) * gru_0_out_t4_43 + (-0.3073275089263916) * gru_0_out_t4_44 + (-1.3376997709274292) * gru_0_out_t4_45 + (-1.1060822010040283) * gru_0_out_t4_46 + (0.21107695996761322) * gru_0_out_t4_47 + (-0.29750111699104309) * gru_0_out_t4_48 + (0.26030677556991577) * gru_0_out_t4_49 + (0.84176278114318848) * gru_0_out_t4_50 + (-0.55851274728775024) * gru_0_out_t4_51 + (-0.41278359293937683) * gru_0_out_t4_52 + (0.61996716260910034) * gru_0_out_t4_53 + (-0.70663034915924072) * gru_0_out_t4_54 + (0.12439332157373428) * gru_0_out_t4_55 + (-0.75193262100219727) * gru_0_out_t4_56 + (0.33096596598625183) * gru_0_out_t4_57 + (0.084024727344512939) * gru_0_out_t4_58 + (-0.1535075455904007) * gru_0_out_t4_59 + (2.415604829788208) * gru_0_out_t4_60 + (0.064034506678581238) * gru_0_out_t4_61 + (-0.33720636367797852) * gru_0_out_t4_62 + (-1.5609313249588013) * gru_0_out_t4_63);
    gate_z = sigmoid((-0.06146036833524704) + (0.44913685321807861) * gru_0_out_t4_0 + (-0.27391242980957031) * gru_0_out_t4_1 + (-0.46413803100585938) * gru_0_out_t4_2 + (-0.32556107640266418) * gru_0_out_t4_3 + (0.27135682106018066) * gru_0_out_t4_4 + (-0.23471201956272125) * gru_0_out_t4_5 + (0.54274576902389526) * gru_0_out_t4_6 + (0.3717266321182251) * gru_0_out_t4_7 + (0.17560477554798126) * gru_0_out_t4_8 + (-0.16319505870342255) * gru_0_out_t4_9 + (-0.18928256630897522) * gru_0_out_t4_10 + (0.16382637619972229) * gru_0_out_t4_11 + (0.042524941265583038) * gru_0_out_t4_12 + (0.43431335687637329) * gru_0_out_t4_13 + (-0.032516933977603912) * gru_0_out_t4_14 + (-0.42331540584564209) * gru_0_out_t4_15 + (0.65136253833770752) * gru_0_out_t4_16 + (1.0335118770599365) * gru_0_out_t4_17 + (-0.09628758579492569) * gru_0_out_t4_18 + (0.5561668872833252) * gru_0_out_t4_19 + (-0.57984894514083862) * gru_0_out_t4_20 + (0.55169886350631714) * gru_0_out_t4_21 + (0.69058293104171753) * gru_0_out_t4_22 + (-0.71625840663909912) * gru_0_out_t4_23 + (-0.52281063795089722) * gru_0_out_t4_24 + (-0.140528604388237) * gru_0_out_t4_25 + (0.34718126058578491) * gru_0_out_t4_26 + (-0.18457706272602081) * gru_0_out_t4_27 + (0.24715296924114227) * gru_0_out_t4_28 + (0.36671304702758789) * gru_0_out_t4_29 + (0.21187934279441833) * gru_0_out_t4_30 + (-0.24779236316680908) * gru_0_out_t4_31 + (0.41225123405456543) * gru_0_out_t4_32 + (-0.18090219795703888) * gru_0_out_t4_33 + (-0.13397662341594696) * gru_0_out_t4_34 + (0.07198256254196167) * gru_0_out_t4_35 + (0.19148793816566467) * gru_0_out_t4_36 + (-0.49366483092308044) * gru_0_out_t4_37 + (0.28032845258712769) * gru_0_out_t4_38 + (0.18161429464817047) * gru_0_out_t4_39 + (2.8569481372833252) * gru_0_out_t4_40 + (0.052882842719554901) * gru_0_out_t4_41 + (-1.4003491401672363) * gru_0_out_t4_42 + (-0.41433882713317871) * gru_0_out_t4_43 + (-0.19492824375629425) * gru_0_out_t4_44 + (-0.33201637864112854) * gru_0_out_t4_45 + (-0.75155031681060791) * gru_0_out_t4_46 + (-0.46704643964767456) * gru_0_out_t4_47 + (-0.26899498701095581) * gru_0_out_t4_48 + (0.3152310848236084) * gru_0_out_t4_49 + (0.77922719717025757) * gru_0_out_t4_50 + (0.23441037535667419) * gru_0_out_t4_51 + (0.18127255141735077) * gru_0_out_t4_52 + (0.65731441974639893) * gru_0_out_t4_53 + (-0.019581669941544533) * gru_0_out_t4_54 + (-0.15388335287570953) * gru_0_out_t4_55 + (-0.30094906687736511) * gru_0_out_t4_56 + (-0.14980976283550262) * gru_0_out_t4_57 + (0.5380713939666748) * gru_0_out_t4_58 + (0.011763636022806168) * gru_0_out_t4_59 + (-0.78393971920013428) * gru_0_out_t4_60 + (0.012046000920236111) * gru_0_out_t4_61 + (0.66465836763381958) * gru_0_out_t4_62 + (0.29096764326095581) * gru_0_out_t4_63);
    gate_n = tanh((-0.30533072352409363) + (-0.17566719651222229) * gru_0_out_t4_0 + (0.34896215796470642) * gru_0_out_t4_1 + (0.3281269371509552) * gru_0_out_t4_2 + (-0.48036849498748779) * gru_0_out_t4_3 + (0.71995961666107178) * gru_0_out_t4_4 + (0.24264141917228699) * gru_0_out_t4_5 + (-0.5215153694152832) * gru_0_out_t4_6 + (-0.33348321914672852) * gru_0_out_t4_7 + (-0.59891164302825928) * gru_0_out_t4_8 + (-1.1865718364715576) * gru_0_out_t4_9 + (-0.28748336434364319) * gru_0_out_t4_10 + (-0.21260987222194672) * gru_0_out_t4_11 + (-0.22745898365974426) * gru_0_out_t4_12 + (-0.17176425457000732) * gru_0_out_t4_13 + (0.56581020355224609) * gru_0_out_t4_14 + (-0.58140170574188232) * gru_0_out_t4_15 + (0.97201675176620483) * gru_0_out_t4_16 + (0.39902409911155701) * gru_0_out_t4_17 + (0.23950555920600891) * gru_0_out_t4_18 + (0.87772655487060547) * gru_0_out_t4_19 + (-0.23109288513660431) * gru_0_out_t4_20 + (0.65773093700408936) * gru_0_out_t4_21 + (-0.51127117872238159) * gru_0_out_t4_22 + (-0.84099924564361572) * gru_0_out_t4_23 + (-0.6141931414604187) * gru_0_out_t4_24 + (0.43514353036880493) * gru_0_out_t4_25 + (-0.62288588285446167) * gru_0_out_t4_26 + (-0.0030997730791568756) * gru_0_out_t4_27 + (0.71459883451461792) * gru_0_out_t4_28 + (0.34243413805961609) * gru_0_out_t4_29 + (-0.47076469659805298) * gru_0_out_t4_30 + (-0.087191812694072723) * gru_0_out_t4_31 + (-0.17596466839313507) * gru_0_out_t4_32 + (0.070669032633304596) * gru_0_out_t4_33 + (0.050765011459589005) * gru_0_out_t4_34 + (0.0644540935754776) * gru_0_out_t4_35 + (0.12398400902748108) * gru_0_out_t4_36 + (0.48436924815177917) * gru_0_out_t4_37 + (-0.12967999279499054) * gru_0_out_t4_38 + (-0.25178059935569763) * gru_0_out_t4_39 + (-0.018198166042566299) * gru_0_out_t4_40 + (0.84562450647354126) * gru_0_out_t4_41 + (0.51156789064407349) * gru_0_out_t4_42 + (-0.0087868673726916313) * gru_0_out_t4_43 + (-0.30030035972595215) * gru_0_out_t4_44 + (0.28340163826942444) * gru_0_out_t4_45 + (0.19809317588806152) * gru_0_out_t4_46 + (-0.13871976733207703) * gru_0_out_t4_47 + (-0.49732175469398499) * gru_0_out_t4_48 + (0.43193706870079041) * gru_0_out_t4_49 + (0.03665248304605484) * gru_0_out_t4_50 + (0.12324050068855286) * gru_0_out_t4_51 + (-0.57068496942520142) * gru_0_out_t4_52 + (-0.16301900148391724) * gru_0_out_t4_53 + (-0.1512763649225235) * gru_0_out_t4_54 + (-0.53743451833724976) * gru_0_out_t4_55 + (0.09302183985710144) * gru_0_out_t4_56 + (0.71207916736602783) * gru_0_out_t4_57 + (0.2156778872013092) * gru_0_out_t4_58 + (-0.85477250814437866) * gru_0_out_t4_59 + (1.6861205101013184) * gru_0_out_t4_60 + (2.0069625377655029) * gru_0_out_t4_61 + (0.2782418429851532) * gru_0_out_t4_62 + (-0.378591388463974) * gru_0_out_t4_63 + gate_r * (-0.59461438655853271));
    gru_1_rev_t4_h_6 = (1.0 - gate_z) * gate_n;
    // h=7
    gate_r = sigmoid((-0.39963614940643311) + (-0.20781026780605316) * gru_0_out_t4_0 + (0.25285625457763672) * gru_0_out_t4_1 + (0.69240713119506836) * gru_0_out_t4_2 + (-0.38870251178741455) * gru_0_out_t4_3 + (-0.90489405393600464) * gru_0_out_t4_4 + (-1.7116976976394653) * gru_0_out_t4_5 + (-2.8674414157867432) * gru_0_out_t4_6 + (-1.8308275938034058) * gru_0_out_t4_7 + (1.1673561334609985) * gru_0_out_t4_8 + (2.2644722461700439) * gru_0_out_t4_9 + (-0.39915931224822998) * gru_0_out_t4_10 + (0.15972442924976349) * gru_0_out_t4_11 + (-0.56439942121505737) * gru_0_out_t4_12 + (0.1450999528169632) * gru_0_out_t4_13 + (-0.85274213552474976) * gru_0_out_t4_14 + (0.035599403083324432) * gru_0_out_t4_15 + (0.97642612457275391) * gru_0_out_t4_16 + (0.76823288202285767) * gru_0_out_t4_17 + (-0.16679497063159943) * gru_0_out_t4_18 + (1.3001182079315186) * gru_0_out_t4_19 + (1.2786688804626465) * gru_0_out_t4_20 + (2.2143032550811768) * gru_0_out_t4_21 + (-1.1033473014831543) * gru_0_out_t4_22 + (-1.1909451484680176) * gru_0_out_t4_23 + (2.0598435401916504) * gru_0_out_t4_24 + (0.23246419429779053) * gru_0_out_t4_25 + (-1.4375550746917725) * gru_0_out_t4_26 + (0.83093774318695068) * gru_0_out_t4_27 + (-1.395743727684021) * gru_0_out_t4_28 + (0.094915084540843964) * gru_0_out_t4_29 + (-1.2246594429016113) * gru_0_out_t4_30 + (-4.885129451751709) * gru_0_out_t4_31 + (-1.8223427534103394) * gru_0_out_t4_32 + (-0.20895293354988098) * gru_0_out_t4_33 + (-0.023573823273181915) * gru_0_out_t4_34 + (0.82908523082733154) * gru_0_out_t4_35 + (-0.26990383863449097) * gru_0_out_t4_36 + (-0.10903914272785187) * gru_0_out_t4_37 + (-0.11823330819606781) * gru_0_out_t4_38 + (-1.4108980894088745) * gru_0_out_t4_39 + (-1.0109844207763672) * gru_0_out_t4_40 + (0.13818904757499695) * gru_0_out_t4_41 + (0.56363588571548462) * gru_0_out_t4_42 + (0.22917753458023071) * gru_0_out_t4_43 + (0.11163564771413803) * gru_0_out_t4_44 + (-0.50050032138824463) * gru_0_out_t4_45 + (-1.1346782445907593) * gru_0_out_t4_46 + (1.9189800024032593) * gru_0_out_t4_47 + (0.28631621599197388) * gru_0_out_t4_48 + (-0.56640040874481201) * gru_0_out_t4_49 + (-0.1961047351360321) * gru_0_out_t4_50 + (0.19384555518627167) * gru_0_out_t4_51 + (-0.0068659065291285515) * gru_0_out_t4_52 + (-0.21312031149864197) * gru_0_out_t4_53 + (-0.32830429077148438) * gru_0_out_t4_54 + (-0.27280068397521973) * gru_0_out_t4_55 + (0.046869769692420959) * gru_0_out_t4_56 + (-0.23338806629180908) * gru_0_out_t4_57 + (-0.83372688293457031) * gru_0_out_t4_58 + (0.69545048475265503) * gru_0_out_t4_59 + (-1.1514420509338379) * gru_0_out_t4_60 + (0.099091134965419769) * gru_0_out_t4_61 + (0.11030840873718262) * gru_0_out_t4_62 + (0.23571893572807312) * gru_0_out_t4_63);
    gate_z = sigmoid((0.13404816389083862) + (-0.27194041013717651) * gru_0_out_t4_0 + (-0.63431650400161743) * gru_0_out_t4_1 + (-0.33037671446800232) * gru_0_out_t4_2 + (-0.1796770840883255) * gru_0_out_t4_3 + (-0.72487759590148926) * gru_0_out_t4_4 + (1.204074501991272) * gru_0_out_t4_5 + (0.27649733424186707) * gru_0_out_t4_6 + (-2.6333212852478027) * gru_0_out_t4_7 + (0.083569079637527466) * gru_0_out_t4_8 + (-0.77362829446792603) * gru_0_out_t4_9 + (-0.11932072788476944) * gru_0_out_t4_10 + (0.12006821483373642) * gru_0_out_t4_11 + (0.25559291243553162) * gru_0_out_t4_12 + (0.39614200592041016) * gru_0_out_t4_13 + (-0.66584664583206177) * gru_0_out_t4_14 + (-0.054652508348226547) * gru_0_out_t4_15 + (-0.094513125717639923) * gru_0_out_t4_16 + (0.15297441184520721) * gru_0_out_t4_17 + (-0.20389251410961151) * gru_0_out_t4_18 + (-1.1058746576309204) * gru_0_out_t4_19 + (-0.95929515361785889) * gru_0_out_t4_20 + (-0.33375281095504761) * gru_0_out_t4_21 + (0.14470851421356201) * gru_0_out_t4_22 + (0.28311082720756531) * gru_0_out_t4_23 + (-0.69516021013259888) * gru_0_out_t4_24 + (0.17527972161769867) * gru_0_out_t4_25 + (-0.22358299791812897) * gru_0_out_t4_26 + (1.3507026433944702) * gru_0_out_t4_27 + (-0.21068628132343292) * gru_0_out_t4_28 + (-1.1254456043243408) * gru_0_out_t4_29 + (-0.030660646036267281) * gru_0_out_t4_30 + (0.22548918426036835) * gru_0_out_t4_31 + (-0.25104826688766479) * gru_0_out_t4_32 + (-0.068916171789169312) * gru_0_out_t4_33 + (-0.39429590106010437) * gru_0_out_t4_34 + (0.10499512404203415) * gru_0_out_t4_35 + (0.53096765279769897) * gru_0_out_t4_36 + (-0.79691338539123535) * gru_0_out_t4_37 + (0.11348490417003632) * gru_0_out_t4_38 + (0.10195974260568619) * gru_0_out_t4_39 + (0.11139728128910065) * gru_0_out_t4_40 + (-0.14666184782981873) * gru_0_out_t4_41 + (-0.37623468041419983) * gru_0_out_t4_42 + (0.61835885047912598) * gru_0_out_t4_43 + (0.24388514459133148) * gru_0_out_t4_44 + (-0.53301805257797241) * gru_0_out_t4_45 + (0.7220768928527832) * gru_0_out_t4_46 + (-0.32932466268539429) * gru_0_out_t4_47 + (0.29145592451095581) * gru_0_out_t4_48 + (-0.10063991695642471) * gru_0_out_t4_49 + (0.2701682448387146) * gru_0_out_t4_50 + (-0.013128055259585381) * gru_0_out_t4_51 + (0.789326012134552) * gru_0_out_t4_52 + (-0.070334881544113159) * gru_0_out_t4_53 + (0.41407647728919983) * gru_0_out_t4_54 + (0.55201023817062378) * gru_0_out_t4_55 + (-0.18774272501468658) * gru_0_out_t4_56 + (-0.33452346920967102) * gru_0_out_t4_57 + (0.57453829050064087) * gru_0_out_t4_58 + (0.69652903079986572) * gru_0_out_t4_59 + (0.83067959547042847) * gru_0_out_t4_60 + (0.93279170989990234) * gru_0_out_t4_61 + (-0.21509420871734619) * gru_0_out_t4_62 + (-1.6404600143432617) * gru_0_out_t4_63);
    gate_n = tanh((-0.057324498891830444) + (0.12885567545890808) * gru_0_out_t4_0 + (-0.16960816085338593) * gru_0_out_t4_1 + (-0.99974793195724487) * gru_0_out_t4_2 + (0.1813657283782959) * gru_0_out_t4_3 + (0.050397250801324844) * gru_0_out_t4_4 + (-0.18066485226154327) * gru_0_out_t4_5 + (0.4888407289981842) * gru_0_out_t4_6 + (-0.33440813422203064) * gru_0_out_t4_7 + (-0.79696959257125854) * gru_0_out_t4_8 + (-2.4279558658599854) * gru_0_out_t4_9 + (0.0010142829269170761) * gru_0_out_t4_10 + (0.044484402984380722) * gru_0_out_t4_11 + (0.17596441507339478) * gru_0_out_t4_12 + (-0.12496243417263031) * gru_0_out_t4_13 + (0.048990163952112198) * gru_0_out_t4_14 + (0.027939919382333755) * gru_0_out_t4_15 + (-0.46052828431129456) * gru_0_out_t4_16 + (-0.48433384299278259) * gru_0_out_t4_17 + (0.076170668005943298) * gru_0_out_t4_18 + (-0.31414937973022461) * gru_0_out_t4_19 + (-1.3727266788482666) * gru_0_out_t4_20 + (-0.45654904842376709) * gru_0_out_t4_21 + (0.061530392616987228) * gru_0_out_t4_22 + (0.9483712911605835) * gru_0_out_t4_23 + (0.030208254233002663) * gru_0_out_t4_24 + (0.092941753566265106) * gru_0_out_t4_25 + (0.2545640766620636) * gru_0_out_t4_26 + (-0.27339506149291992) * gru_0_out_t4_27 + (0.41327506303787231) * gru_0_out_t4_28 + (-0.34309592843055725) * gru_0_out_t4_29 + (0.46761488914489746) * gru_0_out_t4_30 + (0.7828977108001709) * gru_0_out_t4_31 + (1.1727195978164673) * gru_0_out_t4_32 + (-0.15018010139465332) * gru_0_out_t4_33 + (-0.022846776992082596) * gru_0_out_t4_34 + (-0.60476672649383545) * gru_0_out_t4_35 + (-0.17181707918643951) * gru_0_out_t4_36 + (0.062443375587463379) * gru_0_out_t4_37 + (-0.010915153659880161) * gru_0_out_t4_38 + (-0.69575458765029907) * gru_0_out_t4_39 + (-2.6814885139465332) * gru_0_out_t4_40 + (-0.27786150574684143) * gru_0_out_t4_41 + (-0.70577716827392578) * gru_0_out_t4_42 + (-0.12238097190856934) * gru_0_out_t4_43 + (-0.26003521680831909) * gru_0_out_t4_44 + (0.056963331997394562) * gru_0_out_t4_45 + (0.26907721161842346) * gru_0_out_t4_46 + (-1.3241549730300903) * gru_0_out_t4_47 + (-0.60639947652816772) * gru_0_out_t4_48 + (0.70621949434280396) * gru_0_out_t4_49 + (0.28451547026634216) * gru_0_out_t4_50 + (-0.23454016447067261) * gru_0_out_t4_51 + (-0.010684038512408733) * gru_0_out_t4_52 + (0.54742014408111572) * gru_0_out_t4_53 + (-0.02742532454431057) * gru_0_out_t4_54 + (0.63999998569488525) * gru_0_out_t4_55 + (-0.37977299094200134) * gru_0_out_t4_56 + (0.15613767504692078) * gru_0_out_t4_57 + (0.31205976009368896) * gru_0_out_t4_58 + (-0.3015894889831543) * gru_0_out_t4_59 + (-1.5931282043457031) * gru_0_out_t4_60 + (-0.039925973862409592) * gru_0_out_t4_61 + (0.97984296083450317) * gru_0_out_t4_62 + (-0.47095397114753723) * gru_0_out_t4_63 + gate_r * (-0.53214973211288452));
    gru_1_rev_t4_h_7 = (1.0 - gate_z) * gate_n;
    // h=8
    gate_r = sigmoid((0.71153897047042847) + (0.22004126012325287) * gru_0_out_t4_0 + (0.084394022822380066) * gru_0_out_t4_1 + (1.1540189981460571) * gru_0_out_t4_2 + (0.43402218818664551) * gru_0_out_t4_3 + (0.02439156174659729) * gru_0_out_t4_4 + (-2.3316409587860107) * gru_0_out_t4_5 + (2.6299624443054199) * gru_0_out_t4_6 + (0.037251260131597519) * gru_0_out_t4_7 + (0.47053521871566772) * gru_0_out_t4_8 + (-2.294872522354126) * gru_0_out_t4_9 + (-1.6050328016281128) * gru_0_out_t4_10 + (0.025158606469631195) * gru_0_out_t4_11 + (0.11859126389026642) * gru_0_out_t4_12 + (-0.056847520172595978) * gru_0_out_t4_13 + (0.25249356031417847) * gru_0_out_t4_14 + (0.0031020641326904297) * gru_0_out_t4_15 + (-0.39286822080612183) * gru_0_out_t4_16 + (0.10026905685663223) * gru_0_out_t4_17 + (-0.1985514760017395) * gru_0_out_t4_18 + (0.043799269944429398) * gru_0_out_t4_19 + (-3.0419051647186279) * gru_0_out_t4_20 + (-4.0739345550537109) * gru_0_out_t4_21 + (2.4771218299865723) * gru_0_out_t4_22 + (-1.2024902105331421) * gru_0_out_t4_23 + (-1.8663249015808105) * gru_0_out_t4_24 + (0.30563938617706299) * gru_0_out_t4_25 + (1.1396386623382568) * gru_0_out_t4_26 + (-0.0025144626852124929) * gru_0_out_t4_27 + (0.3950253427028656) * gru_0_out_t4_28 + (-2.5138969421386719) * gru_0_out_t4_29 + (0.50044119358062744) * gru_0_out_t4_30 + (1.7435456514358521) * gru_0_out_t4_31 + (-0.78345310688018799) * gru_0_out_t4_32 + (0.20089253783226013) * gru_0_out_t4_33 + (0.49300506711006165) * gru_0_out_t4_34 + (0.37557333707809448) * gru_0_out_t4_35 + (-0.56149053573608398) * gru_0_out_t4_36 + (-0.098673194646835327) * gru_0_out_t4_37 + (-0.33790460228919983) * gru_0_out_t4_38 + (0.39689236879348755) * gru_0_out_t4_39 + (-2.7984540462493896) * gru_0_out_t4_40 + (0.063675969839096069) * gru_0_out_t4_41 + (0.93076872825622559) * gru_0_out_t4_42 + (0.16306199133396149) * gru_0_out_t4_43 + (0.057302609086036682) * gru_0_out_t4_44 + (-0.20377486944198608) * gru_0_out_t4_45 + (-1.5684714317321777) * gru_0_out_t4_46 + (0.73373955488204956) * gru_0_out_t4_47 + (2.6406033039093018) * gru_0_out_t4_48 + (-3.0300130844116211) * gru_0_out_t4_49 + (-0.55544793605804443) * gru_0_out_t4_50 + (0.58061659336090088) * gru_0_out_t4_51 + (-0.088741317391395569) * gru_0_out_t4_52 + (-0.012332289479672909) * gru_0_out_t4_53 + (-0.51713311672210693) * gru_0_out_t4_54 + (1.0057578086853027) * gru_0_out_t4_55 + (1.0984698534011841) * gru_0_out_t4_56 + (-1.1095272302627563) * gru_0_out_t4_57 + (-1.1187261343002319) * gru_0_out_t4_58 + (0.9188230037689209) * gru_0_out_t4_59 + (-0.3067842423915863) * gru_0_out_t4_60 + (-1.5359957218170166) * gru_0_out_t4_61 + (-0.11311772465705872) * gru_0_out_t4_62 + (-1.3941941261291504) * gru_0_out_t4_63);
    gate_z = sigmoid((0.066117621958255768) + (-0.23075065016746521) * gru_0_out_t4_0 + (0.14558793604373932) * gru_0_out_t4_1 + (-0.29864183068275452) * gru_0_out_t4_2 + (0.013038829900324345) * gru_0_out_t4_3 + (-0.29638287425041199) * gru_0_out_t4_4 + (-0.12796927988529205) * gru_0_out_t4_5 + (0.66369932889938354) * gru_0_out_t4_6 + (0.20199048519134521) * gru_0_out_t4_7 + (0.23934242129325867) * gru_0_out_t4_8 + (0.78007519245147705) * gru_0_out_t4_9 + (-0.0023384580854326487) * gru_0_out_t4_10 + (0.047696225345134735) * gru_0_out_t4_11 + (0.33212152123451233) * gru_0_out_t4_12 + (0.21583320200443268) * gru_0_out_t4_13 + (-0.83928710222244263) * gru_0_out_t4_14 + (0.2774253785610199) * gru_0_out_t4_15 + (0.68301814794540405) * gru_0_out_t4_16 + (0.72099030017852783) * gru_0_out_t4_17 + (-0.1991993635892868) * gru_0_out_t4_18 + (0.069716572761535645) * gru_0_out_t4_19 + (1.1697835922241211) * gru_0_out_t4_20 + (0.28556370735168457) * gru_0_out_t4_21 + (0.37639766931533813) * gru_0_out_t4_22 + (-0.24117150902748108) * gru_0_out_t4_23 + (-0.42926633358001709) * gru_0_out_t4_24 + (0.31521260738372803) * gru_0_out_t4_25 + (-0.47711893916130066) * gru_0_out_t4_26 + (-0.034905698150396347) * gru_0_out_t4_27 + (-1.001376748085022) * gru_0_out_t4_28 + (1.2923375368118286) * gru_0_out_t4_29 + (-0.45025929808616638) * gru_0_out_t4_30 + (0.57948547601699829) * gru_0_out_t4_31 + (-0.015757497400045395) * gru_0_out_t4_32 + (-0.35433560609817505) * gru_0_out_t4_33 + (0.08323446661233902) * gru_0_out_t4_34 + (0.48028615117073059) * gru_0_out_t4_35 + (0.002413199283182621) * gru_0_out_t4_36 + (0.44470247626304626) * gru_0_out_t4_37 + (0.45901617407798767) * gru_0_out_t4_38 + (0.31168264150619507) * gru_0_out_t4_39 + (-0.72074145078659058) * gru_0_out_t4_40 + (-0.018161414191126823) * gru_0_out_t4_41 + (-0.13495536148548126) * gru_0_out_t4_42 + (0.204763263463974) * gru_0_out_t4_43 + (0.4217873215675354) * gru_0_out_t4_44 + (0.27654930949211121) * gru_0_out_t4_45 + (-1.2024351358413696) * gru_0_out_t4_46 + (-0.12750060856342316) * gru_0_out_t4_47 + (0.13900376856327057) * gru_0_out_t4_48 + (-0.060016505420207977) * gru_0_out_t4_49 + (0.15337757766246796) * gru_0_out_t4_50 + (0.71074867248535156) * gru_0_out_t4_51 + (0.72547560930252075) * gru_0_out_t4_52 + (-0.051597744226455688) * gru_0_out_t4_53 + (-0.43060353398323059) * gru_0_out_t4_54 + (0.4945293664932251) * gru_0_out_t4_55 + (0.22073602676391602) * gru_0_out_t4_56 + (-0.16427269577980042) * gru_0_out_t4_57 + (0.05878506600856781) * gru_0_out_t4_58 + (-1.0619670152664185) * gru_0_out_t4_59 + (0.055974531918764114) * gru_0_out_t4_60 + (0.46138027310371399) * gru_0_out_t4_61 + (0.33064800500869751) * gru_0_out_t4_62 + (-0.941475510597229) * gru_0_out_t4_63);
    gate_n = tanh((-0.1765127032995224) + (-0.2032693475484848) * gru_0_out_t4_0 + (0.2864222526550293) * gru_0_out_t4_1 + (0.18467503786087036) * gru_0_out_t4_2 + (0.20742826163768768) * gru_0_out_t4_3 + (-0.35955667495727539) * gru_0_out_t4_4 + (1.7253692150115967) * gru_0_out_t4_5 + (-0.22611992061138153) * gru_0_out_t4_6 + (-0.013092055916786194) * gru_0_out_t4_7 + (0.79168373346328735) * gru_0_out_t4_8 + (0.29778161644935608) * gru_0_out_t4_9 + (-0.53383076190948486) * gru_0_out_t4_10 + (0.18833756446838379) * gru_0_out_t4_11 + (-0.13303501904010773) * gru_0_out_t4_12 + (-0.25592261552810669) * gru_0_out_t4_13 + (-0.15432451665401459) * gru_0_out_t4_14 + (0.3773345947265625) * gru_0_out_t4_15 + (0.30101439356803894) * gru_0_out_t4_16 + (0.60476857423782349) * gru_0_out_t4_17 + (0.72847181558609009) * gru_0_out_t4_18 + (0.18997417390346527) * gru_0_out_t4_19 + (-0.14102877676486969) * gru_0_out_t4_20 + (1.1750783920288086) * gru_0_out_t4_21 + (0.032312758266925812) * gru_0_out_t4_22 + (-1.1372226476669312) * gru_0_out_t4_23 + (-0.29029104113578796) * gru_0_out_t4_24 + (0.13263790309429169) * gru_0_out_t4_25 + (0.31758987903594971) * gru_0_out_t4_26 + (0.30940437316894531) * gru_0_out_t4_27 + (-0.96354866027832031) * gru_0_out_t4_28 + (-0.28726688027381897) * gru_0_out_t4_29 + (-0.42891284823417664) * gru_0_out_t4_30 + (0.84204387664794922) * gru_0_out_t4_31 + (0.061037201434373856) * gru_0_out_t4_32 + (-0.27039816975593567) * gru_0_out_t4_33 + (0.17178300023078918) * gru_0_out_t4_34 + (-0.096177764236927032) * gru_0_out_t4_35 + (-0.27416259050369263) * gru_0_out_t4_36 + (0.051182910799980164) * gru_0_out_t4_37 + (-0.049445401877164841) * gru_0_out_t4_38 + (-0.11864466965198517) * gru_0_out_t4_39 + (3.4021213054656982) * gru_0_out_t4_40 + (0.063505277037620544) * gru_0_out_t4_41 + (-0.22538509964942932) * gru_0_out_t4_42 + (0.26478204131126404) * gru_0_out_t4_43 + (-0.44433170557022095) * gru_0_out_t4_44 + (0.1209583505988121) * gru_0_out_t4_45 + (-0.21770477294921875) * gru_0_out_t4_46 + (0.64245986938476562) * gru_0_out_t4_47 + (0.11538536846637726) * gru_0_out_t4_48 + (0.28733891248703003) * gru_0_out_t4_49 + (-0.10824068635702133) * gru_0_out_t4_50 + (-0.30104851722717285) * gru_0_out_t4_51 + (0.16962504386901855) * gru_0_out_t4_52 + (-0.21279595792293549) * gru_0_out_t4_53 + (-0.34869846701622009) * gru_0_out_t4_54 + (-0.095038056373596191) * gru_0_out_t4_55 + (0.43824949860572815) * gru_0_out_t4_56 + (0.73620140552520752) * gru_0_out_t4_57 + (-0.82553666830062866) * gru_0_out_t4_58 + (0.014914150349795818) * gru_0_out_t4_59 + (1.4430482387542725) * gru_0_out_t4_60 + (0.63015574216842651) * gru_0_out_t4_61 + (-0.58343571424484253) * gru_0_out_t4_62 + (-1.0278270244598389) * gru_0_out_t4_63 + gate_r * (-0.09362657368183136));
    gru_1_rev_t4_h_8 = (1.0 - gate_z) * gate_n;
    // h=9
    gate_r = sigmoid((-0.95582729578018188) + (0.22742496430873871) * gru_0_out_t4_0 + (-0.82027143239974976) * gru_0_out_t4_1 + (-2.1254136562347412) * gru_0_out_t4_2 + (0.40380755066871643) * gru_0_out_t4_3 + (1.0038113594055176) * gru_0_out_t4_4 + (-0.91966253519058228) * gru_0_out_t4_5 + (2.5666468143463135) * gru_0_out_t4_6 + (-0.18949301540851593) * gru_0_out_t4_7 + (0.052322860807180405) * gru_0_out_t4_8 + (-1.7936608791351318) * gru_0_out_t4_9 + (2.5546557903289795) * gru_0_out_t4_10 + (0.35992297530174255) * gru_0_out_t4_11 + (-0.09709610790014267) * gru_0_out_t4_12 + (0.77677154541015625) * gru_0_out_t4_13 + (-0.22092080116271973) * gru_0_out_t4_14 + (-1.1720876693725586) * gru_0_out_t4_15 + (-0.17545461654663086) * gru_0_out_t4_16 + (0.080530218780040741) * gru_0_out_t4_17 + (-0.75187617540359497) * gru_0_out_t4_18 + (0.29687970876693726) * gru_0_out_t4_19 + (-2.126727819442749) * gru_0_out_t4_20 + (-2.9734723567962646) * gru_0_out_t4_21 + (1.1878939867019653) * gru_0_out_t4_22 + (0.60180628299713135) * gru_0_out_t4_23 + (3.8075850009918213) * gru_0_out_t4_24 + (-1.3874937295913696) * gru_0_out_t4_25 + (-0.13622123003005981) * gru_0_out_t4_26 + (-3.0334861278533936) * gru_0_out_t4_27 + (1.7596381902694702) * gru_0_out_t4_28 + (-0.74893790483474731) * gru_0_out_t4_29 + (-0.085681408643722534) * gru_0_out_t4_30 + (-6.8612689971923828) * gru_0_out_t4_31 + (-1.0411883592605591) * gru_0_out_t4_32 + (0.28089547157287598) * gru_0_out_t4_33 + (-0.32585969567298889) * gru_0_out_t4_34 + (0.35452371835708618) * gru_0_out_t4_35 + (0.7090110182762146) * gru_0_out_t4_36 + (0.13355907797813416) * gru_0_out_t4_37 + (0.044564463198184967) * gru_0_out_t4_38 + (3.6793110370635986) * gru_0_out_t4_39 + (1.3007825613021851) * gru_0_out_t4_40 + (-0.38918843865394592) * gru_0_out_t4_41 + (0.63278090953826904) * gru_0_out_t4_42 + (-0.028625210747122765) * gru_0_out_t4_43 + (-1.4365365505218506) * gru_0_out_t4_44 + (0.13984039425849915) * gru_0_out_t4_45 + (0.28115791082382202) * gru_0_out_t4_46 + (0.60261452198028564) * gru_0_out_t4_47 + (1.1967567205429077) * gru_0_out_t4_48 + (-1.3323121070861816) * gru_0_out_t4_49 + (-0.39995202422142029) * gru_0_out_t4_50 + (0.065876394510269165) * gru_0_out_t4_51 + (-0.11918669193983078) * gru_0_out_t4_52 + (-0.18704232573509216) * gru_0_out_t4_53 + (-0.13107392191886902) * gru_0_out_t4_54 + (0.31169489026069641) * gru_0_out_t4_55 + (0.60715878009796143) * gru_0_out_t4_56 + (-2.0054013729095459) * gru_0_out_t4_57 + (1.537014365196228) * gru_0_out_t4_58 + (0.20031595230102539) * gru_0_out_t4_59 + (-0.53437650203704834) * gru_0_out_t4_60 + (-1.4352445602416992) * gru_0_out_t4_61 + (0.48488056659698486) * gru_0_out_t4_62 + (-0.26031360030174255) * gru_0_out_t4_63);
    gate_z = sigmoid((-0.38916113972663879) + (-0.016015253961086273) * gru_0_out_t4_0 + (-0.09099094569683075) * gru_0_out_t4_1 + (-0.62774235010147095) * gru_0_out_t4_2 + (-0.18479102849960327) * gru_0_out_t4_3 + (-0.075062595307826996) * gru_0_out_t4_4 + (-0.86516851186752319) * gru_0_out_t4_5 + (-0.032120015472173691) * gru_0_out_t4_6 + (-0.73764026165008545) * gru_0_out_t4_7 + (0.35798022150993347) * gru_0_out_t4_8 + (-0.43704059720039368) * gru_0_out_t4_9 + (0.12844806909561157) * gru_0_out_t4_10 + (0.022286530584096909) * gru_0_out_t4_11 + (-0.14540587365627289) * gru_0_out_t4_12 + (-0.07256721705198288) * gru_0_out_t4_13 + (-0.15329913794994354) * gru_0_out_t4_14 + (-0.37834638357162476) * gru_0_out_t4_15 + (1.5076981782913208) * gru_0_out_t4_16 + (0.77316039800643921) * gru_0_out_t4_17 + (-0.13537077605724335) * gru_0_out_t4_18 + (-0.43495118618011475) * gru_0_out_t4_19 + (-0.34728723764419556) * gru_0_out_t4_20 + (1.0125067234039307) * gru_0_out_t4_21 + (-0.13168495893478394) * gru_0_out_t4_22 + (-0.49146994948387146) * gru_0_out_t4_23 + (-0.058019433170557022) * gru_0_out_t4_24 + (-0.25647458434104919) * gru_0_out_t4_25 + (-0.27202773094177246) * gru_0_out_t4_26 + (-0.27573984861373901) * gru_0_out_t4_27 + (0.021275119855999947) * gru_0_out_t4_28 + (0.50234967470169067) * gru_0_out_t4_29 + (0.36092251539230347) * gru_0_out_t4_30 + (-0.12263344973325729) * gru_0_out_t4_31 + (0.42963448166847229) * gru_0_out_t4_32 + (-0.055024158209562302) * gru_0_out_t4_33 + (1.1205470561981201) * gru_0_out_t4_34 + (0.0045593371614813805) * gru_0_out_t4_35 + (-0.28579944372177124) * gru_0_out_t4_36 + (0.15242034196853638) * gru_0_out_t4_37 + (-0.3832181990146637) * gru_0_out_t4_38 + (0.90963762998580933) * gru_0_out_t4_39 + (0.83193045854568481) * gru_0_out_t4_40 + (-0.29524922370910645) * gru_0_out_t4_41 + (-1.3819838762283325) * gru_0_out_t4_42 + (-0.29086121916770935) * gru_0_out_t4_43 + (-0.11405661702156067) * gru_0_out_t4_44 + (0.14874568581581116) * gru_0_out_t4_45 + (1.2852749824523926) * gru_0_out_t4_46 + (-0.59379446506500244) * gru_0_out_t4_47 + (-0.2753269374370575) * gru_0_out_t4_48 + (0.366117924451828) * gru_0_out_t4_49 + (0.40599018335342407) * gru_0_out_t4_50 + (0.49594628810882568) * gru_0_out_t4_51 + (0.30146166682243347) * gru_0_out_t4_52 + (-0.34720969200134277) * gru_0_out_t4_53 + (-0.51009488105773926) * gru_0_out_t4_54 + (-0.24686093628406525) * gru_0_out_t4_55 + (-0.40534922480583191) * gru_0_out_t4_56 + (-0.17689663171768188) * gru_0_out_t4_57 + (-0.001570013933815062) * gru_0_out_t4_58 + (-0.12413228303194046) * gru_0_out_t4_59 + (0.64821285009384155) * gru_0_out_t4_60 + (-0.17016130685806274) * gru_0_out_t4_61 + (0.69290286302566528) * gru_0_out_t4_62 + (1.1252989768981934) * gru_0_out_t4_63);
    gate_n = tanh((0.7128722071647644) + (0.17785514891147614) * gru_0_out_t4_0 + (-0.51816296577453613) * gru_0_out_t4_1 + (-0.43576896190643311) * gru_0_out_t4_2 + (0.011063060723245144) * gru_0_out_t4_3 + (-1.2091711759567261) * gru_0_out_t4_4 + (1.3171011209487915) * gru_0_out_t4_5 + (0.89143598079681396) * gru_0_out_t4_6 + (-0.016015097498893738) * gru_0_out_t4_7 + (-0.66039866209030151) * gru_0_out_t4_8 + (1.2350699901580811) * gru_0_out_t4_9 + (0.77822411060333252) * gru_0_out_t4_10 + (0.10366477072238922) * gru_0_out_t4_11 + (0.42853227257728577) * gru_0_out_t4_12 + (0.28332975506782532) * gru_0_out_t4_13 + (0.40929090976715088) * gru_0_out_t4_14 + (0.72457391023635864) * gru_0_out_t4_15 + (-0.59138822555541992) * gru_0_out_t4_16 + (-0.22661405801773071) * gru_0_out_t4_17 + (-0.65944784879684448) * gru_0_out_t4_18 + (-0.7532656192779541) * gru_0_out_t4_19 + (0.45961669087409973) * gru_0_out_t4_20 + (-2.5869078636169434) * gru_0_out_t4_21 + (-0.57203781604766846) * gru_0_out_t4_22 + (0.13572731614112854) * gru_0_out_t4_23 + (-0.37225049734115601) * gru_0_out_t4_24 + (-1.1241340637207031) * gru_0_out_t4_25 + (0.24399000406265259) * gru_0_out_t4_26 + (0.15046131610870361) * gru_0_out_t4_27 + (-1.2813221216201782) * gru_0_out_t4_28 + (1.5709693431854248) * gru_0_out_t4_29 + (-0.31425023078918457) * gru_0_out_t4_30 + (1.3193283081054688) * gru_0_out_t4_31 + (0.57251620292663574) * gru_0_out_t4_32 + (0.099741712212562561) * gru_0_out_t4_33 + (0.29461359977722168) * gru_0_out_t4_34 + (0.096776977181434631) * gru_0_out_t4_35 + (0.23942793905735016) * gru_0_out_t4_36 + (0.051541943103075027) * gru_0_out_t4_37 + (-0.079779431223869324) * gru_0_out_t4_38 + (-2.3933582305908203) * gru_0_out_t4_39 + (1.3883734941482544) * gru_0_out_t4_40 + (1.0441930294036865) * gru_0_out_t4_41 + (-1.266663670539856) * gru_0_out_t4_42 + (0.044041290879249573) * gru_0_out_t4_43 + (1.3567975759506226) * gru_0_out_t4_44 + (-0.28840398788452148) * gru_0_out_t4_45 + (1.8681256771087646) * gru_0_out_t4_46 + (-0.28131800889968872) * gru_0_out_t4_47 + (-0.29522010684013367) * gru_0_out_t4_48 + (0.10161550343036652) * gru_0_out_t4_49 + (0.16568581759929657) * gru_0_out_t4_50 + (0.83907955884933472) * gru_0_out_t4_51 + (-0.027465905994176865) * gru_0_out_t4_52 + (0.038051750510931015) * gru_0_out_t4_53 + (-0.68684530258178711) * gru_0_out_t4_54 + (-0.87953871488571167) * gru_0_out_t4_55 + (-0.045586708933115005) * gru_0_out_t4_56 + (0.50079959630966187) * gru_0_out_t4_57 + (-0.27477476000785828) * gru_0_out_t4_58 + (1.1459985971450806) * gru_0_out_t4_59 + (-0.033220700919628143) * gru_0_out_t4_60 + (0.40675458312034607) * gru_0_out_t4_61 + (-0.25763052701950073) * gru_0_out_t4_62 + (0.65593850612640381) * gru_0_out_t4_63 + gate_r * (0.065506264567375183));
    gru_1_rev_t4_h_9 = (1.0 - gate_z) * gate_n;
    // h=10
    gate_r = sigmoid((0.47095489501953125) + (0.24449793994426727) * gru_0_out_t4_0 + (-0.47459802031517029) * gru_0_out_t4_1 + (-0.92217493057250977) * gru_0_out_t4_2 + (1.0199098587036133) * gru_0_out_t4_3 + (0.0054923431016504765) * gru_0_out_t4_4 + (-0.28071358799934387) * gru_0_out_t4_5 + (0.86227768659591675) * gru_0_out_t4_6 + (0.65748411417007446) * gru_0_out_t4_7 + (-0.093480944633483887) * gru_0_out_t4_8 + (-0.46785557270050049) * gru_0_out_t4_9 + (0.1957983523607254) * gru_0_out_t4_10 + (-0.26294693350791931) * gru_0_out_t4_11 + (1.0865602493286133) * gru_0_out_t4_12 + (0.41968998312950134) * gru_0_out_t4_13 + (-0.27936941385269165) * gru_0_out_t4_14 + (0.82235217094421387) * gru_0_out_t4_15 + (-0.87077265977859497) * gru_0_out_t4_16 + (-0.83084219694137573) * gru_0_out_t4_17 + (0.0003775887016672641) * gru_0_out_t4_18 + (2.0686995983123779) * gru_0_out_t4_19 + (0.16687051951885223) * gru_0_out_t4_20 + (-4.3913249969482422) * gru_0_out_t4_21 + (-0.047226149588823318) * gru_0_out_t4_22 + (0.54320961236953735) * gru_0_out_t4_23 + (0.076805941760540009) * gru_0_out_t4_24 + (-0.44199436902999878) * gru_0_out_t4_25 + (-0.60653138160705566) * gru_0_out_t4_26 + (-0.77137959003448486) * gru_0_out_t4_27 + (1.4597762823104858) * gru_0_out_t4_28 + (0.36063858866691589) * gru_0_out_t4_29 + (-0.091005146503448486) * gru_0_out_t4_30 + (0.68777775764465332) * gru_0_out_t4_31 + (1.1548449993133545) * gru_0_out_t4_32 + (-0.85319036245346069) * gru_0_out_t4_33 + (0.37774059176445007) * gru_0_out_t4_34 + (-0.061414331197738647) * gru_0_out_t4_35 + (-0.52465742826461792) * gru_0_out_t4_36 + (-0.34949061274528503) * gru_0_out_t4_37 + (0.40617117285728455) * gru_0_out_t4_38 + (-0.72260451316833496) * gru_0_out_t4_39 + (0.94992721080780029) * gru_0_out_t4_40 + (1.1490355730056763) * gru_0_out_t4_41 + (-1.0489106178283691) * gru_0_out_t4_42 + (0.087866246700286865) * gru_0_out_t4_43 + (-0.16399510204792023) * gru_0_out_t4_44 + (-0.42827025055885315) * gru_0_out_t4_45 + (0.23792821168899536) * gru_0_out_t4_46 + (-0.24387429654598236) * gru_0_out_t4_47 + (-0.074392840266227722) * gru_0_out_t4_48 + (0.33696895837783813) * gru_0_out_t4_49 + (0.29080885648727417) * gru_0_out_t4_50 + (0.17987042665481567) * gru_0_out_t4_51 + (0.32324853539466858) * gru_0_out_t4_52 + (0.10650330781936646) * gru_0_out_t4_53 + (0.38436537981033325) * gru_0_out_t4_54 + (1.6900352239608765) * gru_0_out_t4_55 + (0.27365630865097046) * gru_0_out_t4_56 + (0.58376049995422363) * gru_0_out_t4_57 + (0.38681241869926453) * gru_0_out_t4_58 + (0.093173280358314514) * gru_0_out_t4_59 + (-0.80416280031204224) * gru_0_out_t4_60 + (0.24319782853126526) * gru_0_out_t4_61 + (0.050431422889232635) * gru_0_out_t4_62 + (1.0034743547439575) * gru_0_out_t4_63);
    gate_z = sigmoid((0.19287160038948059) + (-0.020836418494582176) * gru_0_out_t4_0 + (-0.28914734721183777) * gru_0_out_t4_1 + (-0.035838831216096878) * gru_0_out_t4_2 + (0.63933730125427246) * gru_0_out_t4_3 + (0.24110192060470581) * gru_0_out_t4_4 + (0.035203497856855392) * gru_0_out_t4_5 + (0.2981848418712616) * gru_0_out_t4_6 + (-0.012165937572717667) * gru_0_out_t4_7 + (-0.78059506416320801) * gru_0_out_t4_8 + (-0.77789968252182007) * gru_0_out_t4_9 + (0.20345319807529449) * gru_0_out_t4_10 + (0.83811140060424805) * gru_0_out_t4_11 + (0.091165468096733093) * gru_0_out_t4_12 + (0.1125512570142746) * gru_0_out_t4_13 + (-0.11979281157255173) * gru_0_out_t4_14 + (0.61500763893127441) * gru_0_out_t4_15 + (-0.72880768775939941) * gru_0_out_t4_16 + (-0.34189015626907349) * gru_0_out_t4_17 + (-0.020100755617022514) * gru_0_out_t4_18 + (-2.0162920951843262) * gru_0_out_t4_19 + (-0.57858353853225708) * gru_0_out_t4_20 + (-0.91432124376296997) * gru_0_out_t4_21 + (0.44179686903953552) * gru_0_out_t4_22 + (0.39030048251152039) * gru_0_out_t4_23 + (0.051939424127340317) * gru_0_out_t4_24 + (-0.61551189422607422) * gru_0_out_t4_25 + (-0.36486610770225525) * gru_0_out_t4_26 + (-0.11924088001251221) * gru_0_out_t4_27 + (-0.67190217971801758) * gru_0_out_t4_28 + (-0.29661765694618225) * gru_0_out_t4_29 + (0.29491320252418518) * gru_0_out_t4_30 + (0.53200632333755493) * gru_0_out_t4_31 + (1.0344574451446533) * gru_0_out_t4_32 + (-0.18927235901355743) * gru_0_out_t4_33 + (-0.11694774776697159) * gru_0_out_t4_34 + (-0.044132817536592484) * gru_0_out_t4_35 + (-0.19063675403594971) * gru_0_out_t4_36 + (-0.014205396175384521) * gru_0_out_t4_37 + (0.3627680242061615) * gru_0_out_t4_38 + (-0.5369638204574585) * gru_0_out_t4_39 + (0.47663787007331848) * gru_0_out_t4_40 + (0.87090271711349487) * gru_0_out_t4_41 + (0.56591928005218506) * gru_0_out_t4_42 + (0.13601863384246826) * gru_0_out_t4_43 + (-0.10182061046361923) * gru_0_out_t4_44 + (-0.7533225417137146) * gru_0_out_t4_45 + (0.42235013842582703) * gru_0_out_t4_46 + (-1.6871215105056763) * gru_0_out_t4_47 + (-0.10893190652132034) * gru_0_out_t4_48 + (0.15453870594501495) * gru_0_out_t4_49 + (-0.03780350461602211) * gru_0_out_t4_50 + (0.16366684436798096) * gru_0_out_t4_51 + (0.57337123155593872) * gru_0_out_t4_52 + (1.4859631061553955) * gru_0_out_t4_53 + (-0.28925248980522156) * gru_0_out_t4_54 + (-0.29481613636016846) * gru_0_out_t4_55 + (0.53825223445892334) * gru_0_out_t4_56 + (0.088309966027736664) * gru_0_out_t4_57 + (1.0518506765365601) * gru_0_out_t4_58 + (-0.066507481038570404) * gru_0_out_t4_59 + (-0.040443312376737595) * gru_0_out_t4_60 + (-0.3602738082408905) * gru_0_out_t4_61 + (1.0710396766662598) * gru_0_out_t4_62 + (0.80204677581787109) * gru_0_out_t4_63);
    gate_n = tanh((-0.19174747169017792) + (0.0041668927296996117) * gru_0_out_t4_0 + (0.42051529884338379) * gru_0_out_t4_1 + (-0.16752134263515472) * gru_0_out_t4_2 + (0.30799797177314758) * gru_0_out_t4_3 + (0.073446698486804962) * gru_0_out_t4_4 + (0.58646696805953979) * gru_0_out_t4_5 + (-0.10167040675878525) * gru_0_out_t4_6 + (-0.8272283673286438) * gru_0_out_t4_7 + (-0.15778851509094238) * gru_0_out_t4_8 + (0.10730674117803574) * gru_0_out_t4_9 + (-0.25722792744636536) * gru_0_out_t4_10 + (0.37327238917350769) * gru_0_out_t4_11 + (-0.080089285969734192) * gru_0_out_t4_12 + (-0.73687148094177246) * gru_0_out_t4_13 + (0.080664172768592834) * gru_0_out_t4_14 + (0.059216871857643127) * gru_0_out_t4_15 + (1.3526006937026978) * gru_0_out_t4_16 + (0.25502777099609375) * gru_0_out_t4_17 + (0.58339470624923706) * gru_0_out_t4_18 + (0.37933892011642456) * gru_0_out_t4_19 + (0.070116057991981506) * gru_0_out_t4_20 + (1.9924936294555664) * gru_0_out_t4_21 + (-0.25710421800613403) * gru_0_out_t4_22 + (-0.98376619815826416) * gru_0_out_t4_23 + (-0.28594756126403809) * gru_0_out_t4_24 + (0.23906919360160828) * gru_0_out_t4_25 + (0.40899637341499329) * gru_0_out_t4_26 + (0.17956526577472687) * gru_0_out_t4_27 + (-0.77264171838760376) * gru_0_out_t4_28 + (0.19151216745376587) * gru_0_out_t4_29 + (-0.47341936826705933) * gru_0_out_t4_30 + (0.71004754304885864) * gru_0_out_t4_31 + (-0.82765382528305054) * gru_0_out_t4_32 + (-0.6582261323928833) * gru_0_out_t4_33 + (-0.3962838351726532) * gru_0_out_t4_34 + (-0.74665462970733643) * gru_0_out_t4_35 + (-0.14727455377578735) * gru_0_out_t4_36 + (-0.1457429975271225) * gru_0_out_t4_37 + (0.55285316705703735) * gru_0_out_t4_38 + (-0.20397403836250305) * gru_0_out_t4_39 + (0.538321852684021) * gru_0_out_t4_40 + (-0.92289626598358154) * gru_0_out_t4_41 + (0.007510072086006403) * gru_0_out_t4_42 + (0.11107008904218674) * gru_0_out_t4_43 + (-0.34468033909797668) * gru_0_out_t4_44 + (-0.45682430267333984) * gru_0_out_t4_45 + (-0.76860231161117554) * gru_0_out_t4_46 + (-0.16847275197505951) * gru_0_out_t4_47 + (-0.80644822120666504) * gru_0_out_t4_48 + (0.31150203943252563) * gru_0_out_t4_49 + (0.0028950660489499569) * gru_0_out_t4_50 + (0.2580418586730957) * gru_0_out_t4_51 + (0.22534795105457306) * gru_0_out_t4_52 + (-0.15924985706806183) * gru_0_out_t4_53 + (0.033330067992210388) * gru_0_out_t4_54 + (-0.23605053126811981) * gru_0_out_t4_55 + (-0.27873170375823975) * gru_0_out_t4_56 + (0.55793726444244385) * gru_0_out_t4_57 + (0.53304654359817505) * gru_0_out_t4_58 + (1.3098394870758057) * gru_0_out_t4_59 + (0.36830827593803406) * gru_0_out_t4_60 + (0.89727324247360229) * gru_0_out_t4_61 + (0.20181956887245178) * gru_0_out_t4_62 + (0.65386676788330078) * gru_0_out_t4_63 + gate_r * (-0.38398337364196777));
    gru_1_rev_t4_h_10 = (1.0 - gate_z) * gate_n;
    // h=11
    gate_r = sigmoid((0.5263209342956543) + (0.031465779989957809) * gru_0_out_t4_0 + (0.2184167355298996) * gru_0_out_t4_1 + (-1.8017576932907104) * gru_0_out_t4_2 + (-1.5981829166412354) * gru_0_out_t4_3 + (-0.35838338732719421) * gru_0_out_t4_4 + (0.92452371120452881) * gru_0_out_t4_5 + (1.7471359968185425) * gru_0_out_t4_6 + (2.9769740104675293) * gru_0_out_t4_7 + (-4.0053133964538574) * gru_0_out_t4_8 + (-1.230539083480835) * gru_0_out_t4_9 + (2.0377259254455566) * gru_0_out_t4_10 + (0.34909006953239441) * gru_0_out_t4_11 + (-0.14591705799102783) * gru_0_out_t4_12 + (-0.11876711249351501) * gru_0_out_t4_13 + (0.40320605039596558) * gru_0_out_t4_14 + (1.7227857112884521) * gru_0_out_t4_15 + (-0.32724878191947937) * gru_0_out_t4_16 + (-0.019064230844378471) * gru_0_out_t4_17 + (-0.39185681939125061) * gru_0_out_t4_18 + (0.36487969756126404) * gru_0_out_t4_19 + (-0.48391419649124146) * gru_0_out_t4_20 + (-2.5831079483032227) * gru_0_out_t4_21 + (-3.5186221599578857) * gru_0_out_t4_22 + (1.4924864768981934) * gru_0_out_t4_23 + (1.7557716369628906) * gru_0_out_t4_24 + (0.22205282747745514) * gru_0_out_t4_25 + (0.980194091796875) * gru_0_out_t4_26 + (-3.1113715171813965) * gru_0_out_t4_27 + (-1.4890928268432617) * gru_0_out_t4_28 + (3.6811778545379639) * gru_0_out_t4_29 + (-1.7621681690216064) * gru_0_out_t4_30 + (-0.71750819683074951) * gru_0_out_t4_31 + (-0.69604945182800293) * gru_0_out_t4_32 + (-0.24934220314025879) * gru_0_out_t4_33 + (-0.085192002356052399) * gru_0_out_t4_34 + (0.8760685920715332) * gru_0_out_t4_35 + (-0.14031018316745758) * gru_0_out_t4_36 + (-0.059557091444730759) * gru_0_out_t4_37 + (0.024215305224061012) * gru_0_out_t4_38 + (-2.1675295829772949) * gru_0_out_t4_39 + (-2.0588951110839844) * gru_0_out_t4_40 + (1.0233920812606812) * gru_0_out_t4_41 + (1.749861478805542) * gru_0_out_t4_42 + (0.34042108058929443) * gru_0_out_t4_43 + (0.7471269965171814) * gru_0_out_t4_44 + (0.56685274839401245) * gru_0_out_t4_45 + (-1.6745529174804688) * gru_0_out_t4_46 + (0.1244903951883316) * gru_0_out_t4_47 + (-1.6372666358947754) * gru_0_out_t4_48 + (1.2231216430664062) * gru_0_out_t4_49 + (0.31237432360649109) * gru_0_out_t4_50 + (0.43429136276245117) * gru_0_out_t4_51 + (-0.16805659234523773) * gru_0_out_t4_52 + (0.027484357357025146) * gru_0_out_t4_53 + (0.1198568269610405) * gru_0_out_t4_54 + (-2.2379529476165771) * gru_0_out_t4_55 + (-0.32773298025131226) * gru_0_out_t4_56 + (2.9345519542694092) * gru_0_out_t4_57 + (-0.17820486426353455) * gru_0_out_t4_58 + (0.25322350859642029) * gru_0_out_t4_59 + (0.23014874756336212) * gru_0_out_t4_60 + (1.2804490327835083) * gru_0_out_t4_61 + (0.61492401361465454) * gru_0_out_t4_62 + (1.3415052890777588) * gru_0_out_t4_63);
    gate_z = sigmoid((1.0985890626907349) + (-0.12075658142566681) * gru_0_out_t4_0 + (-0.20902173221111298) * gru_0_out_t4_1 + (-0.057819545269012451) * gru_0_out_t4_2 + (0.2138725221157074) * gru_0_out_t4_3 + (-0.59575915336608887) * gru_0_out_t4_4 + (-0.58385682106018066) * gru_0_out_t4_5 + (-1.5200724601745605) * gru_0_out_t4_6 + (-1.1863647699356079) * gru_0_out_t4_7 + (-0.87915360927581787) * gru_0_out_t4_8 + (0.61937850713729858) * gru_0_out_t4_9 + (0.65149050951004028) * gru_0_out_t4_10 + (-0.2825259268283844) * gru_0_out_t4_11 + (0.049670461565256119) * gru_0_out_t4_12 + (0.375324547290802) * gru_0_out_t4_13 + (0.17716991901397705) * gru_0_out_t4_14 + (-0.070740848779678345) * gru_0_out_t4_15 + (-0.27941924333572388) * gru_0_out_t4_16 + (-0.15008625388145447) * gru_0_out_t4_17 + (-0.46711871027946472) * gru_0_out_t4_18 + (-1.4724217653274536) * gru_0_out_t4_19 + (0.41659292578697205) * gru_0_out_t4_20 + (-0.6263309121131897) * gru_0_out_t4_21 + (-0.55949586629867554) * gru_0_out_t4_22 + (1.1522021293640137) * gru_0_out_t4_23 + (-0.27533131837844849) * gru_0_out_t4_24 + (-1.7600696086883545) * gru_0_out_t4_25 + (0.20922850072383881) * gru_0_out_t4_26 + (1.025875449180603) * gru_0_out_t4_27 + (-0.64523917436599731) * gru_0_out_t4_28 + (0.083960138261318207) * gru_0_out_t4_29 + (0.36762839555740356) * gru_0_out_t4_30 + (-0.56799417734146118) * gru_0_out_t4_31 + (0.38366034626960754) * gru_0_out_t4_32 + (-0.486615389585495) * gru_0_out_t4_33 + (-0.043490774929523468) * gru_0_out_t4_34 + (-0.10148432105779648) * gru_0_out_t4_35 + (-0.25565183162689209) * gru_0_out_t4_36 + (-0.26415884494781494) * gru_0_out_t4_37 + (0.19147302210330963) * gru_0_out_t4_38 + (0.84261173009872437) * gru_0_out_t4_39 + (0.41532710194587708) * gru_0_out_t4_40 + (-0.37306225299835205) * gru_0_out_t4_41 + (-3.0373170375823975) * gru_0_out_t4_42 + (-0.38512787222862244) * gru_0_out_t4_43 + (0.21071861684322357) * gru_0_out_t4_44 + (0.71162313222885132) * gru_0_out_t4_45 + (0.8636481761932373) * gru_0_out_t4_46 + (0.13854576647281647) * gru_0_out_t4_47 + (1.0471847057342529) * gru_0_out_t4_48 + (-1.1845386028289795) * gru_0_out_t4_49 + (-0.0086968326941132545) * gru_0_out_t4_50 + (-0.28360480070114136) * gru_0_out_t4_51 + (0.88938289880752563) * gru_0_out_t4_52 + (0.064416401088237762) * gru_0_out_t4_53 + (0.45413202047348022) * gru_0_out_t4_54 + (-0.051854189485311508) * gru_0_out_t4_55 + (-0.83563804626464844) * gru_0_out_t4_56 + (-1.3427120447158813) * gru_0_out_t4_57 + (-0.0012287651188671589) * gru_0_out_t4_58 + (-0.020163565874099731) * gru_0_out_t4_59 + (0.63213992118835449) * gru_0_out_t4_60 + (0.35329413414001465) * gru_0_out_t4_61 + (1.397223949432373) * gru_0_out_t4_62 + (-0.39437964558601379) * gru_0_out_t4_63);
    gate_n = tanh((-0.13056708872318268) + (-0.42441973090171814) * gru_0_out_t4_0 + (-0.010928607545793056) * gru_0_out_t4_1 + (1.0633108615875244) * gru_0_out_t4_2 + (0.79951679706573486) * gru_0_out_t4_3 + (0.11152221262454987) * gru_0_out_t4_4 + (-1.8594191074371338) * gru_0_out_t4_5 + (-1.310725212097168) * gru_0_out_t4_6 + (-0.51285749673843384) * gru_0_out_t4_7 + (1.1557357311248779) * gru_0_out_t4_8 + (0.098765693604946136) * gru_0_out_t4_9 + (0.2697070837020874) * gru_0_out_t4_10 + (0.16241906583309174) * gru_0_out_t4_11 + (0.10187835991382599) * gru_0_out_t4_12 + (-0.39879921078681946) * gru_0_out_t4_13 + (-0.24615859985351562) * gru_0_out_t4_14 + (-0.0070961825549602509) * gru_0_out_t4_15 + (0.0092029375955462456) * gru_0_out_t4_16 + (-0.37814703583717346) * gru_0_out_t4_17 + (0.2326066642999649) * gru_0_out_t4_18 + (0.22844210267066956) * gru_0_out_t4_19 + (-0.52714920043945312) * gru_0_out_t4_20 + (-0.019291659817099571) * gru_0_out_t4_21 + (-0.19121949374675751) * gru_0_out_t4_22 + (-0.32753115892410278) * gru_0_out_t4_23 + (-0.64163112640380859) * gru_0_out_t4_24 + (-0.051321979612112045) * gru_0_out_t4_25 + (0.41760945320129395) * gru_0_out_t4_26 + (0.97303676605224609) * gru_0_out_t4_27 + (-0.5230637788772583) * gru_0_out_t4_28 + (-1.1294091939926147) * gru_0_out_t4_29 + (-0.15091943740844727) * gru_0_out_t4_30 + (0.28109657764434814) * gru_0_out_t4_31 + (-0.0083977114409208298) * gru_0_out_t4_32 + (0.14450836181640625) * gru_0_out_t4_33 + (-0.22043183445930481) * gru_0_out_t4_34 + (-0.17287750542163849) * gru_0_out_t4_35 + (0.074599452316761017) * gru_0_out_t4_36 + (-0.024870608001947403) * gru_0_out_t4_37 + (-0.14147335290908813) * gru_0_out_t4_38 + (1.9470188617706299) * gru_0_out_t4_39 + (-0.16478998959064484) * gru_0_out_t4_40 + (-0.40761151909828186) * gru_0_out_t4_41 + (0.63688451051712036) * gru_0_out_t4_42 + (0.1246003657579422) * gru_0_out_t4_43 + (-0.30668261647224426) * gru_0_out_t4_44 + (-0.095980085432529449) * gru_0_out_t4_45 + (-0.49386903643608093) * gru_0_out_t4_46 + (0.49085012078285217) * gru_0_out_t4_47 + (0.34979498386383057) * gru_0_out_t4_48 + (-0.46324214339256287) * gru_0_out_t4_49 + (-0.52545982599258423) * gru_0_out_t4_50 + (-0.2332623153924942) * gru_0_out_t4_51 + (-0.10221260786056519) * gru_0_out_t4_52 + (0.30385118722915649) * gru_0_out_t4_53 + (0.096196793019771576) * gru_0_out_t4_54 + (1.2051459550857544) * gru_0_out_t4_55 + (0.84914171695709229) * gru_0_out_t4_56 + (-0.64589321613311768) * gru_0_out_t4_57 + (0.29056122899055481) * gru_0_out_t4_58 + (-0.39192843437194824) * gru_0_out_t4_59 + (0.33793905377388) * gru_0_out_t4_60 + (-0.61859762668609619) * gru_0_out_t4_61 + (0.59261411428451538) * gru_0_out_t4_62 + (0.26590156555175781) * gru_0_out_t4_63 + gate_r * (-0.24268151819705963));
    gru_1_rev_t4_h_11 = (1.0 - gate_z) * gate_n;
    // h=12
    gate_r = sigmoid((0.39141121506690979) + (0.47022262215614319) * gru_0_out_t4_0 + (-0.25348383188247681) * gru_0_out_t4_1 + (-0.30927491188049316) * gru_0_out_t4_2 + (-0.20886476337909698) * gru_0_out_t4_3 + (-0.16606014966964722) * gru_0_out_t4_4 + (0.61391359567642212) * gru_0_out_t4_5 + (1.8051042556762695) * gru_0_out_t4_6 + (0.64952284097671509) * gru_0_out_t4_7 + (-0.64103364944458008) * gru_0_out_t4_8 + (-4.8754501342773438) * gru_0_out_t4_9 + (0.31093296408653259) * gru_0_out_t4_10 + (0.13337244093418121) * gru_0_out_t4_11 + (-0.14654079079627991) * gru_0_out_t4_12 + (0.13291171193122864) * gru_0_out_t4_13 + (0.19704832136631012) * gru_0_out_t4_14 + (-0.19924171268939972) * gru_0_out_t4_15 + (-0.28898483514785767) * gru_0_out_t4_16 + (-0.12699855864048004) * gru_0_out_t4_17 + (-0.044857554137706757) * gru_0_out_t4_18 + (4.4380149841308594) * gru_0_out_t4_19 + (-4.7677173614501953) * gru_0_out_t4_20 + (-0.59313154220581055) * gru_0_out_t4_21 + (0.27404987812042236) * gru_0_out_t4_22 + (0.54529595375061035) * gru_0_out_t4_23 + (0.032003056257963181) * gru_0_out_t4_24 + (-0.58755034208297729) * gru_0_out_t4_25 + (-0.30044519901275635) * gru_0_out_t4_26 + (-0.79001843929290771) * gru_0_out_t4_27 + (0.6735912561416626) * gru_0_out_t4_28 + (-0.38845634460449219) * gru_0_out_t4_29 + (0.26705923676490784) * gru_0_out_t4_30 + (2.4689083099365234) * gru_0_out_t4_31 + (0.23134134709835052) * gru_0_out_t4_32 + (0.21106834709644318) * gru_0_out_t4_33 + (-0.91481268405914307) * gru_0_out_t4_34 + (1.2150716781616211) * gru_0_out_t4_35 + (0.065189629793167114) * gru_0_out_t4_36 + (-0.32555150985717773) * gru_0_out_t4_37 + (-0.32623988389968872) * gru_0_out_t4_38 + (-2.7442464828491211) * gru_0_out_t4_39 + (-1.3278974294662476) * gru_0_out_t4_40 + (0.19511233270168304) * gru_0_out_t4_41 + (-0.80388039350509644) * gru_0_out_t4_42 + (0.32427871227264404) * gru_0_out_t4_43 + (0.32874324917793274) * gru_0_out_t4_44 + (0.39787280559539795) * gru_0_out_t4_45 + (0.50361686944961548) * gru_0_out_t4_46 + (-0.10364021360874176) * gru_0_out_t4_47 + (1.2198827266693115) * gru_0_out_t4_48 + (-0.94035041332244873) * gru_0_out_t4_49 + (-0.14341700077056885) * gru_0_out_t4_50 + (0.19096796214580536) * gru_0_out_t4_51 + (-0.44098404049873352) * gru_0_out_t4_52 + (0.138204425573349) * gru_0_out_t4_53 + (-0.57855522632598877) * gru_0_out_t4_54 + (0.11707889288663864) * gru_0_out_t4_55 + (-0.64840763807296753) * gru_0_out_t4_56 + (-1.2982920408248901) * gru_0_out_t4_57 + (-0.24858760833740234) * gru_0_out_t4_58 + (0.08419065922498703) * gru_0_out_t4_59 + (0.30213984847068787) * gru_0_out_t4_60 + (-0.20227141678333282) * gru_0_out_t4_61 + (1.0730043649673462) * gru_0_out_t4_62 + (0.49855482578277588) * gru_0_out_t4_63);
    gate_z = sigmoid((0.087044693529605865) + (0.79462945461273193) * gru_0_out_t4_0 + (0.35257366299629211) * gru_0_out_t4_1 + (-0.043707843869924545) * gru_0_out_t4_2 + (0.70485013723373413) * gru_0_out_t4_3 + (0.19893601536750793) * gru_0_out_t4_4 + (-0.34087848663330078) * gru_0_out_t4_5 + (0.17901962995529175) * gru_0_out_t4_6 + (-2.350905179977417) * gru_0_out_t4_7 + (1.5265114307403564) * gru_0_out_t4_8 + (-0.45630970597267151) * gru_0_out_t4_9 + (-0.35234266519546509) * gru_0_out_t4_10 + (0.33722105622291565) * gru_0_out_t4_11 + (-0.20122320950031281) * gru_0_out_t4_12 + (-0.4939160943031311) * gru_0_out_t4_13 + (0.84258353710174561) * gru_0_out_t4_14 + (0.1608310341835022) * gru_0_out_t4_15 + (0.48921921849250793) * gru_0_out_t4_16 + (0.2516903281211853) * gru_0_out_t4_17 + (0.24480263888835907) * gru_0_out_t4_18 + (2.9608440399169922) * gru_0_out_t4_19 + (0.050936568528413773) * gru_0_out_t4_20 + (2.2586729526519775) * gru_0_out_t4_21 + (0.14773081243038177) * gru_0_out_t4_22 + (-0.79892057180404663) * gru_0_out_t4_23 + (0.31867989897727966) * gru_0_out_t4_24 + (-0.63414138555526733) * gru_0_out_t4_25 + (0.34982967376708984) * gru_0_out_t4_26 + (0.33822998404502869) * gru_0_out_t4_27 + (0.38061988353729248) * gru_0_out_t4_28 + (-0.048703711479902267) * gru_0_out_t4_29 + (-0.003598436014726758) * gru_0_out_t4_30 + (0.10290121287107468) * gru_0_out_t4_31 + (-1.1747699975967407) * gru_0_out_t4_32 + (-0.097516804933547974) * gru_0_out_t4_33 + (1.3841280937194824) * gru_0_out_t4_34 + (-0.84746980667114258) * gru_0_out_t4_35 + (-0.68984919786453247) * gru_0_out_t4_36 + (0.65112584829330444) * gru_0_out_t4_37 + (0.21165594458580017) * gru_0_out_t4_38 + (0.20721857249736786) * gru_0_out_t4_39 + (-1.9675354957580566) * gru_0_out_t4_40 + (-0.79474884271621704) * gru_0_out_t4_41 + (-1.8761589527130127) * gru_0_out_t4_42 + (-1.2453190088272095) * gru_0_out_t4_43 + (-0.47919625043869019) * gru_0_out_t4_44 + (-0.0047920187935233116) * gru_0_out_t4_45 + (-1.3887530565261841) * gru_0_out_t4_46 + (0.59561759233474731) * gru_0_out_t4_47 + (0.61858981847763062) * gru_0_out_t4_48 + (-0.052535407245159149) * gru_0_out_t4_49 + (0.10191407799720764) * gru_0_out_t4_50 + (-0.082296684384346008) * gru_0_out_t4_51 + (0.093276269733905792) * gru_0_out_t4_52 + (-0.097830943763256073) * gru_0_out_t4_53 + (0.089157789945602417) * gru_0_out_t4_54 + (0.28810968995094299) * gru_0_out_t4_55 + (-0.29894545674324036) * gru_0_out_t4_56 + (0.25113210082054138) * gru_0_out_t4_57 + (0.27464002370834351) * gru_0_out_t4_58 + (0.6998792290687561) * gru_0_out_t4_59 + (0.37697497010231018) * gru_0_out_t4_60 + (0.11079305410385132) * gru_0_out_t4_61 + (-0.7660071849822998) * gru_0_out_t4_62 + (-0.84549856185913086) * gru_0_out_t4_63);
    gate_n = tanh((-0.028650565072894096) + (-0.075675137341022491) * gru_0_out_t4_0 + (0.35578694939613342) * gru_0_out_t4_1 + (-0.19949404895305634) * gru_0_out_t4_2 + (0.098511815071105957) * gru_0_out_t4_3 + (0.68179678916931152) * gru_0_out_t4_4 + (-0.25390753149986267) * gru_0_out_t4_5 + (0.2472817599773407) * gru_0_out_t4_6 + (-0.37901967763900757) * gru_0_out_t4_7 + (0.22810238599777222) * gru_0_out_t4_8 + (0.1015632227063179) * gru_0_out_t4_9 + (0.13624268770217896) * gru_0_out_t4_10 + (-0.24867111444473267) * gru_0_out_t4_11 + (0.21862886846065521) * gru_0_out_t4_12 + (-0.38916894793510437) * gru_0_out_t4_13 + (0.22855411469936371) * gru_0_out_t4_14 + (0.20934055745601654) * gru_0_out_t4_15 + (0.13557732105255127) * gru_0_out_t4_16 + (0.11597409099340439) * gru_0_out_t4_17 + (0.061765529215335846) * gru_0_out_t4_18 + (0.80761295557022095) * gru_0_out_t4_19 + (0.11664843559265137) * gru_0_out_t4_20 + (-0.11853381246328354) * gru_0_out_t4_21 + (0.15639391541481018) * gru_0_out_t4_22 + (-0.15087810158729553) * gru_0_out_t4_23 + (0.10246942937374115) * gru_0_out_t4_24 + (0.42587012052536011) * gru_0_out_t4_25 + (-0.14839725196361542) * gru_0_out_t4_26 + (-0.023924218490719795) * gru_0_out_t4_27 + (-0.025356853380799294) * gru_0_out_t4_28 + (0.94055944681167603) * gru_0_out_t4_29 + (0.10024741291999817) * gru_0_out_t4_30 + (0.13711702823638916) * gru_0_out_t4_31 + (-0.25347551703453064) * gru_0_out_t4_32 + (-0.36647161841392517) * gru_0_out_t4_33 + (-0.91201770305633545) * gru_0_out_t4_34 + (-0.11644885689020157) * gru_0_out_t4_35 + (-0.028156325221061707) * gru_0_out_t4_36 + (0.09293423593044281) * gru_0_out_t4_37 + (0.38446295261383057) * gru_0_out_t4_38 + (-0.19020146131515503) * gru_0_out_t4_39 + (0.8530159592628479) * gru_0_out_t4_40 + (-0.1537272036075592) * gru_0_out_t4_41 + (0.049706246703863144) * gru_0_out_t4_42 + (-0.12128979712724686) * gru_0_out_t4_43 + (-0.1008281409740448) * gru_0_out_t4_44 + (-0.12327896058559418) * gru_0_out_t4_45 + (-0.79769730567932129) * gru_0_out_t4_46 + (0.28656226396560669) * gru_0_out_t4_47 + (0.45152795314788818) * gru_0_out_t4_48 + (-0.28837427496910095) * gru_0_out_t4_49 + (-0.1009335070848465) * gru_0_out_t4_50 + (-0.14261877536773682) * gru_0_out_t4_51 + (0.25793096423149109) * gru_0_out_t4_52 + (-0.033949136734008789) * gru_0_out_t4_53 + (-0.23612214624881744) * gru_0_out_t4_54 + (-0.020654736086726189) * gru_0_out_t4_55 + (-0.0084608085453510284) * gru_0_out_t4_56 + (-0.56888008117675781) * gru_0_out_t4_57 + (0.024410249665379524) * gru_0_out_t4_58 + (0.40613079071044922) * gru_0_out_t4_59 + (0.018475295975804329) * gru_0_out_t4_60 + (0.096394427120685577) * gru_0_out_t4_61 + (0.43465855717658997) * gru_0_out_t4_62 + (-0.76130110025405884) * gru_0_out_t4_63 + gate_r * (-0.026259757578372955));
    gru_1_rev_t4_h_12 = (1.0 - gate_z) * gate_n;
    // h=13
    gate_r = sigmoid((0.55282759666442871) + (0.46930316090583801) * gru_0_out_t4_0 + (0.16869974136352539) * gru_0_out_t4_1 + (-0.48277100920677185) * gru_0_out_t4_2 + (-0.67939943075180054) * gru_0_out_t4_3 + (-0.2828296422958374) * gru_0_out_t4_4 + (-1.9492646455764771) * gru_0_out_t4_5 + (0.96305632591247559) * gru_0_out_t4_6 + (-0.77842801809310913) * gru_0_out_t4_7 + (0.086645036935806274) * gru_0_out_t4_8 + (-1.0446134805679321) * gru_0_out_t4_9 + (0.53850555419921875) * gru_0_out_t4_10 + (0.59308522939682007) * gru_0_out_t4_11 + (0.29645645618438721) * gru_0_out_t4_12 + (-0.14748677611351013) * gru_0_out_t4_13 + (0.40361317992210388) * gru_0_out_t4_14 + (-0.15618322789669037) * gru_0_out_t4_15 + (-0.042387612164020538) * gru_0_out_t4_16 + (-0.95479404926300049) * gru_0_out_t4_17 + (-0.092936784029006958) * gru_0_out_t4_18 + (0.78182065486907959) * gru_0_out_t4_19 + (-2.1352448463439941) * gru_0_out_t4_20 + (-0.42782464623451233) * gru_0_out_t4_21 + (0.38887870311737061) * gru_0_out_t4_22 + (0.24168454110622406) * gru_0_out_t4_23 + (0.93897342681884766) * gru_0_out_t4_24 + (-0.92255508899688721) * gru_0_out_t4_25 + (-2.1768789291381836) * gru_0_out_t4_26 + (0.29877680540084839) * gru_0_out_t4_27 + (0.13690975308418274) * gru_0_out_t4_28 + (-0.18162770569324493) * gru_0_out_t4_29 + (-0.39664077758789062) * gru_0_out_t4_30 + (-0.51379376649856567) * gru_0_out_t4_31 + (-0.54410123825073242) * gru_0_out_t4_32 + (0.68875879049301147) * gru_0_out_t4_33 + (0.070681281387805939) * gru_0_out_t4_34 + (0.26004967093467712) * gru_0_out_t4_35 + (0.032351478934288025) * gru_0_out_t4_36 + (0.55012685060501099) * gru_0_out_t4_37 + (-0.24916540086269379) * gru_0_out_t4_38 + (-1.4312620162963867) * gru_0_out_t4_39 + (4.0754823684692383) * gru_0_out_t4_40 + (0.91876363754272461) * gru_0_out_t4_41 + (-0.19377319514751434) * gru_0_out_t4_42 + (0.10206512361764908) * gru_0_out_t4_43 + (-0.24957956373691559) * gru_0_out_t4_44 + (-0.37816253304481506) * gru_0_out_t4_45 + (0.10861195623874664) * gru_0_out_t4_46 + (0.35187637805938721) * gru_0_out_t4_47 + (1.5587993860244751) * gru_0_out_t4_48 + (-1.2546470165252686) * gru_0_out_t4_49 + (-0.031119896098971367) * gru_0_out_t4_50 + (0.44745820760726929) * gru_0_out_t4_51 + (-0.37445783615112305) * gru_0_out_t4_52 + (0.49065017700195312) * gru_0_out_t4_53 + (-3.7768495082855225) * gru_0_out_t4_54 + (1.1871341466903687) * gru_0_out_t4_55 + (2.0033385753631592) * gru_0_out_t4_56 + (-0.7372317910194397) * gru_0_out_t4_57 + (0.97337931394577026) * gru_0_out_t4_58 + (0.69543188810348511) * gru_0_out_t4_59 + (0.50765889883041382) * gru_0_out_t4_60 + (1.127550482749939) * gru_0_out_t4_61 + (0.089881733059883118) * gru_0_out_t4_62 + (0.22545161843299866) * gru_0_out_t4_63);
    gate_z = sigmoid((0.7061687707901001) + (-0.22867250442504883) * gru_0_out_t4_0 + (0.078681506216526031) * gru_0_out_t4_1 + (1.4185534715652466) * gru_0_out_t4_2 + (0.14404839277267456) * gru_0_out_t4_3 + (-0.098840929567813873) * gru_0_out_t4_4 + (0.12931083142757416) * gru_0_out_t4_5 + (1.3375471830368042) * gru_0_out_t4_6 + (-0.79176324605941772) * gru_0_out_t4_7 + (0.17090253531932831) * gru_0_out_t4_8 + (-0.27023005485534668) * gru_0_out_t4_9 + (-1.473017692565918) * gru_0_out_t4_10 + (0.053476445376873016) * gru_0_out_t4_11 + (-0.10535344481468201) * gru_0_out_t4_12 + (-0.036493506282567978) * gru_0_out_t4_13 + (-0.41229552030563354) * gru_0_out_t4_14 + (0.19478656351566315) * gru_0_out_t4_15 + (-0.21423773467540741) * gru_0_out_t4_16 + (0.13015945255756378) * gru_0_out_t4_17 + (-0.15622740983963013) * gru_0_out_t4_18 + (0.19699573516845703) * gru_0_out_t4_19 + (-0.26986169815063477) * gru_0_out_t4_20 + (0.069639585912227631) * gru_0_out_t4_21 + (0.30735072493553162) * gru_0_out_t4_22 + (-0.10056216269731522) * gru_0_out_t4_23 + (-0.48153352737426758) * gru_0_out_t4_24 + (-0.22827674448490143) * gru_0_out_t4_25 + (-0.011269029229879379) * gru_0_out_t4_26 + (0.52004694938659668) * gru_0_out_t4_27 + (-1.3361413478851318) * gru_0_out_t4_28 + (1.4852086305618286) * gru_0_out_t4_29 + (0.52874356508255005) * gru_0_out_t4_30 + (-0.081489957869052887) * gru_0_out_t4_31 + (0.30236893892288208) * gru_0_out_t4_32 + (-0.11818500608205795) * gru_0_out_t4_33 + (-0.23642925918102264) * gru_0_out_t4_34 + (0.12331680208444595) * gru_0_out_t4_35 + (0.28372576832771301) * gru_0_out_t4_36 + (-0.08941110223531723) * gru_0_out_t4_37 + (0.18741908669471741) * gru_0_out_t4_38 + (0.11274969577789307) * gru_0_out_t4_39 + (0.63469952344894409) * gru_0_out_t4_40 + (0.26392796635627747) * gru_0_out_t4_41 + (0.36347472667694092) * gru_0_out_t4_42 + (-0.15999746322631836) * gru_0_out_t4_43 + (0.17642650008201599) * gru_0_out_t4_44 + (0.63740557432174683) * gru_0_out_t4_45 + (-0.11664268374443054) * gru_0_out_t4_46 + (-0.091110877692699432) * gru_0_out_t4_47 + (1.0304673910140991) * gru_0_out_t4_48 + (-0.94792187213897705) * gru_0_out_t4_49 + (-0.073847845196723938) * gru_0_out_t4_50 + (0.18382687866687775) * gru_0_out_t4_51 + (1.2514737844467163) * gru_0_out_t4_52 + (0.1104656383395195) * gru_0_out_t4_53 + (0.10962693393230438) * gru_0_out_t4_54 + (-0.15341147780418396) * gru_0_out_t4_55 + (1.4064062833786011) * gru_0_out_t4_56 + (-0.17609779536724091) * gru_0_out_t4_57 + (0.1724238246679306) * gru_0_out_t4_58 + (0.88018465042114258) * gru_0_out_t4_59 + (0.50435012578964233) * gru_0_out_t4_60 + (0.29342493414878845) * gru_0_out_t4_61 + (0.18284812569618225) * gru_0_out_t4_62 + (1.2771998643875122) * gru_0_out_t4_63);
    gate_n = tanh((-0.14634542167186737) + (-0.10877470672130585) * gru_0_out_t4_0 + (0.44668689370155334) * gru_0_out_t4_1 + (-0.066927552223205566) * gru_0_out_t4_2 + (0.90290021896362305) * gru_0_out_t4_3 + (-0.15796409547328949) * gru_0_out_t4_4 + (2.4428954124450684) * gru_0_out_t4_5 + (-0.39837384223937988) * gru_0_out_t4_6 + (-0.055105309933423996) * gru_0_out_t4_7 + (0.44017884135246277) * gru_0_out_t4_8 + (-0.23248408734798431) * gru_0_out_t4_9 + (0.010108479298651218) * gru_0_out_t4_10 + (-0.14040008187294006) * gru_0_out_t4_11 + (-0.054043494164943695) * gru_0_out_t4_12 + (0.022081559523940086) * gru_0_out_t4_13 + (-0.15497320890426636) * gru_0_out_t4_14 + (0.0036570955999195576) * gru_0_out_t4_15 + (-0.021268650889396667) * gru_0_out_t4_16 + (0.31988441944122314) * gru_0_out_t4_17 + (0.26429247856140137) * gru_0_out_t4_18 + (-0.2854037880897522) * gru_0_out_t4_19 + (0.98514550924301147) * gru_0_out_t4_20 + (0.033035799860954285) * gru_0_out_t4_21 + (-0.62623262405395508) * gru_0_out_t4_22 + (-0.29612007737159729) * gru_0_out_t4_23 + (-0.28753894567489624) * gru_0_out_t4_24 + (0.70466494560241699) * gru_0_out_t4_25 + (0.98308408260345459) * gru_0_out_t4_26 + (-0.019664036110043526) * gru_0_out_t4_27 + (-0.4289831817150116) * gru_0_out_t4_28 + (-0.29411828517913818) * gru_0_out_t4_29 + (0.30919179320335388) * gru_0_out_t4_30 + (-0.32188674807548523) * gru_0_out_t4_31 + (-0.20447826385498047) * gru_0_out_t4_32 + (-0.59436649084091187) * gru_0_out_t4_33 + (0.090776540338993073) * gru_0_out_t4_34 + (-0.35331672430038452) * gru_0_out_t4_35 + (0.053213272243738174) * gru_0_out_t4_36 + (0.043515812605619431) * gru_0_out_t4_37 + (0.31444481015205383) * gru_0_out_t4_38 + (0.76933962106704712) * gru_0_out_t4_39 + (4.2920775413513184) * gru_0_out_t4_40 + (-0.12745213508605957) * gru_0_out_t4_41 + (0.43535569310188293) * gru_0_out_t4_42 + (-0.16497918963432312) * gru_0_out_t4_43 + (0.35094770789146423) * gru_0_out_t4_44 + (0.2871164083480835) * gru_0_out_t4_45 + (-0.074349507689476013) * gru_0_out_t4_46 + (0.17089813947677612) * gru_0_out_t4_47 + (0.20119886100292206) * gru_0_out_t4_48 + (-0.13364548981189728) * gru_0_out_t4_49 + (-0.091465473175048828) * gru_0_out_t4_50 + (-0.20156417787075043) * gru_0_out_t4_51 + (-0.10703303664922714) * gru_0_out_t4_52 + (-0.041517496109008789) * gru_0_out_t4_53 + (0.3724835216999054) * gru_0_out_t4_54 + (-0.083921439945697784) * gru_0_out_t4_55 + (-0.13570794463157654) * gru_0_out_t4_56 + (0.59338092803955078) * gru_0_out_t4_57 + (-0.21425510942935944) * gru_0_out_t4_58 + (-0.088959261775016785) * gru_0_out_t4_59 + (0.22802282869815826) * gru_0_out_t4_60 + (0.28701251745223999) * gru_0_out_t4_61 + (-0.017905393615365028) * gru_0_out_t4_62 + (0.010603058151900768) * gru_0_out_t4_63 + gate_r * (-0.45735511183738708));
    gru_1_rev_t4_h_13 = (1.0 - gate_z) * gate_n;
    // h=14
    gate_r = sigmoid((-0.43125519156455994) + (-0.036483027040958405) * gru_0_out_t4_0 + (0.010721863247454166) * gru_0_out_t4_1 + (2.2870337963104248) * gru_0_out_t4_2 + (2.419081449508667) * gru_0_out_t4_3 + (0.57300305366516113) * gru_0_out_t4_4 + (-0.039618436247110367) * gru_0_out_t4_5 + (-4.766944408416748) * gru_0_out_t4_6 + (-1.1026146411895752) * gru_0_out_t4_7 + (-1.2037258148193359) * gru_0_out_t4_8 + (1.5287297964096069) * gru_0_out_t4_9 + (-2.3472139835357666) * gru_0_out_t4_10 + (-0.52688664197921753) * gru_0_out_t4_11 + (0.38571232557296753) * gru_0_out_t4_12 + (0.63007873296737671) * gru_0_out_t4_13 + (0.10150563716888428) * gru_0_out_t4_14 + (0.028008610010147095) * gru_0_out_t4_15 + (0.35803306102752686) * gru_0_out_t4_16 + (0.44225558638572693) * gru_0_out_t4_17 + (-0.33577245473861694) * gru_0_out_t4_18 + (1.7001785039901733) * gru_0_out_t4_19 + (2.1723001003265381) * gru_0_out_t4_20 + (0.34896507859230042) * gru_0_out_t4_21 + (3.4564318656921387) * gru_0_out_t4_22 + (0.0628628209233284) * gru_0_out_t4_23 + (-4.1560626029968262) * gru_0_out_t4_24 + (-2.5850832462310791) * gru_0_out_t4_25 + (-0.2875404953956604) * gru_0_out_t4_26 + (2.9732227325439453) * gru_0_out_t4_27 + (-2.1251034736633301) * gru_0_out_t4_28 + (-1.229794979095459) * gru_0_out_t4_29 + (0.061342082917690277) * gru_0_out_t4_30 + (0.10895950347185135) * gru_0_out_t4_31 + (-1.7743316888809204) * gru_0_out_t4_32 + (-0.29179322719573975) * gru_0_out_t4_33 + (0.050211213529109955) * gru_0_out_t4_34 + (-0.10082656890153885) * gru_0_out_t4_35 + (0.25614804029464722) * gru_0_out_t4_36 + (-0.34795209765434265) * gru_0_out_t4_37 + (0.57002055644989014) * gru_0_out_t4_38 + (0.070922344923019409) * gru_0_out_t4_39 + (-3.6610877513885498) * gru_0_out_t4_40 + (0.0523819699883461) * gru_0_out_t4_41 + (-0.87220287322998047) * gru_0_out_t4_42 + (0.32857683300971985) * gru_0_out_t4_43 + (0.16785827279090881) * gru_0_out_t4_44 + (0.39431846141815186) * gru_0_out_t4_45 + (0.28003385663032532) * gru_0_out_t4_46 + (1.0163894891738892) * gru_0_out_t4_47 + (-0.0051656090654432774) * gru_0_out_t4_48 + (0.12287435680627823) * gru_0_out_t4_49 + (-0.19208748638629913) * gru_0_out_t4_50 + (0.77718925476074219) * gru_0_out_t4_51 + (0.38668709993362427) * gru_0_out_t4_52 + (-0.93473440408706665) * gru_0_out_t4_53 + (0.96336030960083008) * gru_0_out_t4_54 + (-0.59158194065093994) * gru_0_out_t4_55 + (0.8214990496635437) * gru_0_out_t4_56 + (-0.47062316536903381) * gru_0_out_t4_57 + (0.087474696338176727) * gru_0_out_t4_58 + (0.96718847751617432) * gru_0_out_t4_59 + (1.0576953887939453) * gru_0_out_t4_60 + (1.5989686250686646) * gru_0_out_t4_61 + (0.14351846277713776) * gru_0_out_t4_62 + (-0.30119553208351135) * gru_0_out_t4_63);
    gate_z = sigmoid((0.38779670000076294) + (0.4930880069732666) * gru_0_out_t4_0 + (-0.26307573914527893) * gru_0_out_t4_1 + (-0.11037640273571014) * gru_0_out_t4_2 + (-0.86220884323120117) * gru_0_out_t4_3 + (-0.23062802851200104) * gru_0_out_t4_4 + (0.6336553692817688) * gru_0_out_t4_5 + (-0.073547191917896271) * gru_0_out_t4_6 + (-1.0840914249420166) * gru_0_out_t4_7 + (0.10888782888650894) * gru_0_out_t4_8 + (-0.70136898756027222) * gru_0_out_t4_9 + (0.84905225038528442) * gru_0_out_t4_10 + (0.23686504364013672) * gru_0_out_t4_11 + (0.94472920894622803) * gru_0_out_t4_12 + (1.4331356287002563) * gru_0_out_t4_13 + (-0.10078699141740799) * gru_0_out_t4_14 + (-0.71550959348678589) * gru_0_out_t4_15 + (0.23450793325901031) * gru_0_out_t4_16 + (0.25986751914024353) * gru_0_out_t4_17 + (-0.45610859990119934) * gru_0_out_t4_18 + (1.3086800575256348) * gru_0_out_t4_19 + (-0.10698574781417847) * gru_0_out_t4_20 + (-0.55644476413726807) * gru_0_out_t4_21 + (0.87446731328964233) * gru_0_out_t4_22 + (-0.52561748027801514) * gru_0_out_t4_23 + (-2.1796462535858154) * gru_0_out_t4_24 + (-0.27503800392150879) * gru_0_out_t4_25 + (-0.35925936698913574) * gru_0_out_t4_26 + (0.21355515718460083) * gru_0_out_t4_27 + (-0.32807502150535583) * gru_0_out_t4_28 + (1.0220812559127808) * gru_0_out_t4_29 + (0.66365355253219604) * gru_0_out_t4_30 + (0.29825732111930847) * gru_0_out_t4_31 + (0.30209022760391235) * gru_0_out_t4_32 + (-0.53370022773742676) * gru_0_out_t4_33 + (0.25775030255317688) * gru_0_out_t4_34 + (0.31656217575073242) * gru_0_out_t4_35 + (0.39127281308174133) * gru_0_out_t4_36 + (-0.59443557262420654) * gru_0_out_t4_37 + (0.30264142155647278) * gru_0_out_t4_38 + (-0.45668762922286987) * gru_0_out_t4_39 + (1.0874406099319458) * gru_0_out_t4_40 + (0.69131314754486084) * gru_0_out_t4_41 + (0.39688920974731445) * gru_0_out_t4_42 + (-0.55026209354400635) * gru_0_out_t4_43 + (0.14104433357715607) * gru_0_out_t4_44 + (0.034280341118574142) * gru_0_out_t4_45 + (0.41134658455848694) * gru_0_out_t4_46 + (-0.37292084097862244) * gru_0_out_t4_47 + (-0.32384178042411804) * gru_0_out_t4_48 + (0.42310228943824768) * gru_0_out_t4_49 + (1.3887064456939697) * gru_0_out_t4_50 + (0.19236193597316742) * gru_0_out_t4_51 + (0.68265676498413086) * gru_0_out_t4_52 + (-0.024246938526630402) * gru_0_out_t4_53 + (-1.0264245271682739) * gru_0_out_t4_54 + (0.65959912538528442) * gru_0_out_t4_55 + (-0.067892797291278839) * gru_0_out_t4_56 + (0.46456077694892883) * gru_0_out_t4_57 + (-0.15480995178222656) * gru_0_out_t4_58 + (-0.80564957857131958) * gru_0_out_t4_59 + (-0.26363614201545715) * gru_0_out_t4_60 + (-0.028295319527387619) * gru_0_out_t4_61 + (0.59366345405578613) * gru_0_out_t4_62 + (0.035899650305509567) * gru_0_out_t4_63);
    gate_n = tanh((-0.064018242061138153) + (0.1016295850276947) * gru_0_out_t4_0 + (0.50618290901184082) * gru_0_out_t4_1 + (-0.71328818798065186) * gru_0_out_t4_2 + (-0.52660834789276123) * gru_0_out_t4_3 + (0.38836103677749634) * gru_0_out_t4_4 + (0.20739816129207611) * gru_0_out_t4_5 + (0.23486979305744171) * gru_0_out_t4_6 + (0.62533628940582275) * gru_0_out_t4_7 + (0.04528350755572319) * gru_0_out_t4_8 + (-0.9908183217048645) * gru_0_out_t4_9 + (0.53925365209579468) * gru_0_out_t4_10 + (-0.18555212020874023) * gru_0_out_t4_11 + (0.20200242102146149) * gru_0_out_t4_12 + (-0.12502105534076691) * gru_0_out_t4_13 + (0.64741033315658569) * gru_0_out_t4_14 + (-0.66569441556930542) * gru_0_out_t4_15 + (-0.273130863904953) * gru_0_out_t4_16 + (-0.16130624711513519) * gru_0_out_t4_17 + (0.24576514959335327) * gru_0_out_t4_18 + (0.29258561134338379) * gru_0_out_t4_19 + (-0.73457825183868408) * gru_0_out_t4_20 + (0.44154584407806396) * gru_0_out_t4_21 + (-0.87243890762329102) * gru_0_out_t4_22 + (-0.012254567816853523) * gru_0_out_t4_23 + (1.276323676109314) * gru_0_out_t4_24 + (0.81985300779342651) * gru_0_out_t4_25 + (0.098233148455619812) * gru_0_out_t4_26 + (-1.1982781887054443) * gru_0_out_t4_27 + (0.50361496210098267) * gru_0_out_t4_28 + (0.097322165966033936) * gru_0_out_t4_29 + (0.016574881970882416) * gru_0_out_t4_30 + (-0.57937890291213989) * gru_0_out_t4_31 + (1.1466412544250488) * gru_0_out_t4_32 + (0.32577154040336609) * gru_0_out_t4_33 + (0.29312291741371155) * gru_0_out_t4_34 + (-0.40743830800056458) * gru_0_out_t4_35 + (-0.23701648414134979) * gru_0_out_t4_36 + (0.052707906812429428) * gru_0_out_t4_37 + (-0.023208817467093468) * gru_0_out_t4_38 + (-0.69757425785064697) * gru_0_out_t4_39 + (3.0763823986053467) * gru_0_out_t4_40 + (-0.7478291392326355) * gru_0_out_t4_41 + (-0.66132771968841553) * gru_0_out_t4_42 + (-0.41055649518966675) * gru_0_out_t4_43 + (-0.62090998888015747) * gru_0_out_t4_44 + (0.10030172765254974) * gru_0_out_t4_45 + (1.2255206108093262) * gru_0_out_t4_46 + (-0.68026107549667358) * gru_0_out_t4_47 + (0.12329826503992081) * gru_0_out_t4_48 + (0.36275234818458557) * gru_0_out_t4_49 + (0.92877805233001709) * gru_0_out_t4_50 + (0.25730669498443604) * gru_0_out_t4_51 + (0.14606857299804688) * gru_0_out_t4_52 + (0.23232394456863403) * gru_0_out_t4_53 + (-0.32108515501022339) * gru_0_out_t4_54 + (0.23944519460201263) * gru_0_out_t4_55 + (-0.93113183975219727) * gru_0_out_t4_56 + (0.020269701257348061) * gru_0_out_t4_57 + (0.49709156155586243) * gru_0_out_t4_58 + (0.36596882343292236) * gru_0_out_t4_59 + (-1.3830347061157227) * gru_0_out_t4_60 + (0.083709530532360077) * gru_0_out_t4_61 + (-0.46551719307899475) * gru_0_out_t4_62 + (0.66332358121871948) * gru_0_out_t4_63 + gate_r * (-0.07043948769569397));
    gru_1_rev_t4_h_14 = (1.0 - gate_z) * gate_n;
    // h=15
    gate_r = sigmoid((-0.91758573055267334) + (-1.1700328588485718) * gru_0_out_t4_0 + (-1.1264976263046265) * gru_0_out_t4_1 + (-0.60981416702270508) * gru_0_out_t4_2 + (0.92616468667984009) * gru_0_out_t4_3 + (-0.4777604341506958) * gru_0_out_t4_4 + (0.45088359713554382) * gru_0_out_t4_5 + (-0.70253032445907593) * gru_0_out_t4_6 + (0.57655191421508789) * gru_0_out_t4_7 + (-0.16202977299690247) * gru_0_out_t4_8 + (0.10147494822740555) * gru_0_out_t4_9 + (1.034649133682251) * gru_0_out_t4_10 + (-0.07411888986825943) * gru_0_out_t4_11 + (-0.34667250514030457) * gru_0_out_t4_12 + (1.017472505569458) * gru_0_out_t4_13 + (-0.034044675529003143) * gru_0_out_t4_14 + (-0.81048458814620972) * gru_0_out_t4_15 + (0.87078046798706055) * gru_0_out_t4_16 + (0.29149901866912842) * gru_0_out_t4_17 + (-0.25193628668785095) * gru_0_out_t4_18 + (-0.4019697904586792) * gru_0_out_t4_19 + (0.67365646362304688) * gru_0_out_t4_20 + (1.160391092300415) * gru_0_out_t4_21 + (-0.36387372016906738) * gru_0_out_t4_22 + (0.016067188233137131) * gru_0_out_t4_23 + (0.50830590724945068) * gru_0_out_t4_24 + (-1.9985400438308716) * gru_0_out_t4_25 + (-0.068947054445743561) * gru_0_out_t4_26 + (0.56564211845397949) * gru_0_out_t4_27 + (-0.083019398152828217) * gru_0_out_t4_28 + (-1.4010391235351562) * gru_0_out_t4_29 + (-0.6217537522315979) * gru_0_out_t4_30 + (-0.95564889907836914) * gru_0_out_t4_31 + (-0.047187082469463348) * gru_0_out_t4_32 + (0.64469128847122192) * gru_0_out_t4_33 + (0.70081621408462524) * gru_0_out_t4_34 + (0.89910030364990234) * gru_0_out_t4_35 + (-0.68865472078323364) * gru_0_out_t4_36 + (0.67237263917922974) * gru_0_out_t4_37 + (-0.89822167158126831) * gru_0_out_t4_38 + (0.33381950855255127) * gru_0_out_t4_39 + (-0.36286169290542603) * gru_0_out_t4_40 + (1.2126985788345337) * gru_0_out_t4_41 + (1.1262373924255371) * gru_0_out_t4_42 + (0.93429362773895264) * gru_0_out_t4_43 + (0.57002633810043335) * gru_0_out_t4_44 + (0.43336978554725647) * gru_0_out_t4_45 + (2.1344985961914062) * gru_0_out_t4_46 + (-0.96592479944229126) * gru_0_out_t4_47 + (-1.4342771768569946) * gru_0_out_t4_48 + (1.5998274087905884) * gru_0_out_t4_49 + (0.57940340042114258) * gru_0_out_t4_50 + (2.813673734664917) * gru_0_out_t4_51 + (0.38500392436981201) * gru_0_out_t4_52 + (1.1620571613311768) * gru_0_out_t4_53 + (0.31967592239379883) * gru_0_out_t4_54 + (-0.055408138781785965) * gru_0_out_t4_55 + (-1.5085335969924927) * gru_0_out_t4_56 + (1.546358585357666) * gru_0_out_t4_57 + (-0.11812501400709152) * gru_0_out_t4_58 + (-1.6357041597366333) * gru_0_out_t4_59 + (-1.6005769968032837) * gru_0_out_t4_60 + (0.29661813378334045) * gru_0_out_t4_61 + (0.20172688364982605) * gru_0_out_t4_62 + (-0.048460114747285843) * gru_0_out_t4_63);
    gate_z = sigmoid((-0.1730768084526062) + (0.41976276040077209) * gru_0_out_t4_0 + (-0.47231966257095337) * gru_0_out_t4_1 + (0.29114240407943726) * gru_0_out_t4_2 + (-0.18292936682701111) * gru_0_out_t4_3 + (-1.0804359912872314) * gru_0_out_t4_4 + (0.1749674528837204) * gru_0_out_t4_5 + (0.73984611034393311) * gru_0_out_t4_6 + (-0.75696784257888794) * gru_0_out_t4_7 + (-0.037801634520292282) * gru_0_out_t4_8 + (0.3002173900604248) * gru_0_out_t4_9 + (0.086390994489192963) * gru_0_out_t4_10 + (0.8817746639251709) * gru_0_out_t4_11 + (0.57902133464813232) * gru_0_out_t4_12 + (0.47277897596359253) * gru_0_out_t4_13 + (-0.17971764504909515) * gru_0_out_t4_14 + (-0.17547816038131714) * gru_0_out_t4_15 + (-0.71430480480194092) * gru_0_out_t4_16 + (-0.29133647680282593) * gru_0_out_t4_17 + (-0.55194449424743652) * gru_0_out_t4_18 + (0.21053537726402283) * gru_0_out_t4_19 + (-0.26442909240722656) * gru_0_out_t4_20 + (-0.52147918939590454) * gru_0_out_t4_21 + (1.3325002193450928) * gru_0_out_t4_22 + (0.39015597105026245) * gru_0_out_t4_23 + (-0.67202019691467285) * gru_0_out_t4_24 + (0.26101630926132202) * gru_0_out_t4_25 + (-0.29688945412635803) * gru_0_out_t4_26 + (-0.080816082656383514) * gru_0_out_t4_27 + (-0.59967899322509766) * gru_0_out_t4_28 + (-0.40994894504547119) * gru_0_out_t4_29 + (-0.41906729340553284) * gru_0_out_t4_30 + (0.49658608436584473) * gru_0_out_t4_31 + (0.20803818106651306) * gru_0_out_t4_32 + (0.60312503576278687) * gru_0_out_t4_33 + (-0.64511257410049438) * gru_0_out_t4_34 + (0.60894322395324707) * gru_0_out_t4_35 + (0.03946923092007637) * gru_0_out_t4_36 + (0.64040940999984741) * gru_0_out_t4_37 + (-0.93286794424057007) * gru_0_out_t4_38 + (0.66182368993759155) * gru_0_out_t4_39 + (-1.2056287527084351) * gru_0_out_t4_40 + (0.1129717230796814) * gru_0_out_t4_41 + (-0.29094836115837097) * gru_0_out_t4_42 + (0.51638734340667725) * gru_0_out_t4_43 + (0.18743318319320679) * gru_0_out_t4_44 + (0.45757043361663818) * gru_0_out_t4_45 + (-0.57211065292358398) * gru_0_out_t4_46 + (0.10660050064325333) * gru_0_out_t4_47 + (-1.232871413230896) * gru_0_out_t4_48 + (1.0074741840362549) * gru_0_out_t4_49 + (0.063570648431777954) * gru_0_out_t4_50 + (0.061976484954357147) * gru_0_out_t4_51 + (-0.69260138273239136) * gru_0_out_t4_52 + (-0.20531193912029266) * gru_0_out_t4_53 + (-0.50036275386810303) * gru_0_out_t4_54 + (-0.60572916269302368) * gru_0_out_t4_55 + (-0.67944574356079102) * gru_0_out_t4_56 + (0.83759164810180664) * gru_0_out_t4_57 + (-0.73686110973358154) * gru_0_out_t4_58 + (-0.20659460127353668) * gru_0_out_t4_59 + (-0.02800990454852581) * gru_0_out_t4_60 + (0.01516045443713665) * gru_0_out_t4_61 + (0.48323273658752441) * gru_0_out_t4_62 + (0.76625287532806396) * gru_0_out_t4_63);
    gate_n = tanh((-0.28034630417823792) + (-0.28375720977783203) * gru_0_out_t4_0 + (0.1253301203250885) * gru_0_out_t4_1 + (0.62009209394454956) * gru_0_out_t4_2 + (-0.41611015796661377) * gru_0_out_t4_3 + (-0.40418076515197754) * gru_0_out_t4_4 + (0.32010146975517273) * gru_0_out_t4_5 + (-0.21222396194934845) * gru_0_out_t4_6 + (0.21945288777351379) * gru_0_out_t4_7 + (-0.1058482900261879) * gru_0_out_t4_8 + (-0.80151110887527466) * gru_0_out_t4_9 + (-0.39157584309577942) * gru_0_out_t4_10 + (0.064073987305164337) * gru_0_out_t4_11 + (-0.038563944399356842) * gru_0_out_t4_12 + (0.12440196424722672) * gru_0_out_t4_13 + (-0.12557134032249451) * gru_0_out_t4_14 + (0.22077280282974243) * gru_0_out_t4_15 + (0.82181590795516968) * gru_0_out_t4_16 + (0.074750788509845734) * gru_0_out_t4_17 + (0.011940616182982922) * gru_0_out_t4_18 + (0.054791923612356186) * gru_0_out_t4_19 + (-0.25837510824203491) * gru_0_out_t4_20 + (1.2398819923400879) * gru_0_out_t4_21 + (-0.49060541391372681) * gru_0_out_t4_22 + (0.31573206186294556) * gru_0_out_t4_23 + (-0.16863314807415009) * gru_0_out_t4_24 + (-0.51857376098632812) * gru_0_out_t4_25 + (0.090805232524871826) * gru_0_out_t4_26 + (0.20969147980213165) * gru_0_out_t4_27 + (0.92931431531906128) * gru_0_out_t4_28 + (-0.43672165274620056) * gru_0_out_t4_29 + (-0.31509658694267273) * gru_0_out_t4_30 + (-0.37239921092987061) * gru_0_out_t4_31 + (-2.1655068397521973) * gru_0_out_t4_32 + (0.038771104067564011) * gru_0_out_t4_33 + (-0.22815290093421936) * gru_0_out_t4_34 + (0.090722247958183289) * gru_0_out_t4_35 + (-0.22529050707817078) * gru_0_out_t4_36 + (0.17051719129085541) * gru_0_out_t4_37 + (-0.18470057845115662) * gru_0_out_t4_38 + (0.17501306533813477) * gru_0_out_t4_39 + (0.42377099394798279) * gru_0_out_t4_40 + (-0.045453093945980072) * gru_0_out_t4_41 + (0.2568720281124115) * gru_0_out_t4_42 + (0.24731408059597015) * gru_0_out_t4_43 + (0.21805037558078766) * gru_0_out_t4_44 + (0.15108148753643036) * gru_0_out_t4_45 + (-0.36843952536582947) * gru_0_out_t4_46 + (0.87918061017990112) * gru_0_out_t4_47 + (0.4427478015422821) * gru_0_out_t4_48 + (-0.22284023463726044) * gru_0_out_t4_49 + (-0.161911740899086) * gru_0_out_t4_50 + (0.2422240823507309) * gru_0_out_t4_51 + (-0.15053319931030273) * gru_0_out_t4_52 + (-0.47175455093383789) * gru_0_out_t4_53 + (0.12543170154094696) * gru_0_out_t4_54 + (0.42181968688964844) * gru_0_out_t4_55 + (0.17265407741069794) * gru_0_out_t4_56 + (-0.10747390240430832) * gru_0_out_t4_57 + (0.13929717242717743) * gru_0_out_t4_58 + (0.70636749267578125) * gru_0_out_t4_59 + (1.200871467590332) * gru_0_out_t4_60 + (0.53607618808746338) * gru_0_out_t4_61 + (-0.070430479943752289) * gru_0_out_t4_62 + (0.19666442275047302) * gru_0_out_t4_63 + gate_r * (-1.1407738924026489));
    gru_1_rev_t4_h_15 = (1.0 - gate_z) * gate_n;
    // h=16
    gate_r = sigmoid((-0.40385925769805908) + (-0.19056916236877441) * gru_0_out_t4_0 + (-0.040529105812311172) * gru_0_out_t4_1 + (0.82251131534576416) * gru_0_out_t4_2 + (-2.4945104122161865) * gru_0_out_t4_3 + (1.0464355945587158) * gru_0_out_t4_4 + (-0.79890638589859009) * gru_0_out_t4_5 + (-2.4342277050018311) * gru_0_out_t4_6 + (-0.13128486275672913) * gru_0_out_t4_7 + (0.79072427749633789) * gru_0_out_t4_8 + (1.3650590181350708) * gru_0_out_t4_9 + (-0.38055709004402161) * gru_0_out_t4_10 + (0.039253409951925278) * gru_0_out_t4_11 + (-0.77065521478652954) * gru_0_out_t4_12 + (0.12069187313318253) * gru_0_out_t4_13 + (-0.049526020884513855) * gru_0_out_t4_14 + (-1.7804732322692871) * gru_0_out_t4_15 + (1.343528151512146) * gru_0_out_t4_16 + (0.35952088236808777) * gru_0_out_t4_17 + (-0.02160460501909256) * gru_0_out_t4_18 + (0.91316843032836914) * gru_0_out_t4_19 + (0.18083611130714417) * gru_0_out_t4_20 + (2.8002610206604004) * gru_0_out_t4_21 + (0.12944439053535461) * gru_0_out_t4_22 + (-0.3571220338344574) * gru_0_out_t4_23 + (1.8206546306610107) * gru_0_out_t4_24 + (0.89954769611358643) * gru_0_out_t4_25 + (-0.10546304285526276) * gru_0_out_t4_26 + (-1.6504917144775391) * gru_0_out_t4_27 + (-1.2711321115493774) * gru_0_out_t4_28 + (0.18225724995136261) * gru_0_out_t4_29 + (0.24751321971416473) * gru_0_out_t4_30 + (-0.78882324695587158) * gru_0_out_t4_31 + (-3.1962683200836182) * gru_0_out_t4_32 + (-0.50320291519165039) * gru_0_out_t4_33 + (-0.44341471791267395) * gru_0_out_t4_34 + (0.43858391046524048) * gru_0_out_t4_35 + (0.26022240519523621) * gru_0_out_t4_36 + (-0.27681946754455566) * gru_0_out_t4_37 + (0.65182048082351685) * gru_0_out_t4_38 + (-0.020564772188663483) * gru_0_out_t4_39 + (0.75324046611785889) * gru_0_out_t4_40 + (-0.85187774896621704) * gru_0_out_t4_41 + (0.78370571136474609) * gru_0_out_t4_42 + (0.29261231422424316) * gru_0_out_t4_43 + (-0.14714686572551727) * gru_0_out_t4_44 + (-1.0607786178588867) * gru_0_out_t4_45 + (-1.5238769054412842) * gru_0_out_t4_46 + (0.87058806419372559) * gru_0_out_t4_47 + (0.43038040399551392) * gru_0_out_t4_48 + (-0.45924076437950134) * gru_0_out_t4_49 + (-0.80867111682891846) * gru_0_out_t4_50 + (-0.28723543882369995) * gru_0_out_t4_51 + (0.32373145222663879) * gru_0_out_t4_52 + (-0.063979901373386383) * gru_0_out_t4_53 + (-0.14467145502567291) * gru_0_out_t4_54 + (-0.65791410207748413) * gru_0_out_t4_55 + (0.60978657007217407) * gru_0_out_t4_56 + (-0.48486226797103882) * gru_0_out_t4_57 + (0.44036969542503357) * gru_0_out_t4_58 + (0.18189418315887451) * gru_0_out_t4_59 + (0.57297945022583008) * gru_0_out_t4_60 + (-0.10447638481855392) * gru_0_out_t4_61 + (0.54950618743896484) * gru_0_out_t4_62 + (-1.4233361482620239) * gru_0_out_t4_63);
    gate_z = sigmoid((0.57988220453262329) + (-0.21693186461925507) * gru_0_out_t4_0 + (0.1488494873046875) * gru_0_out_t4_1 + (0.53410071134567261) * gru_0_out_t4_2 + (0.20869718492031097) * gru_0_out_t4_3 + (-0.10384370386600494) * gru_0_out_t4_4 + (-0.03397100418806076) * gru_0_out_t4_5 + (-0.46905949711799622) * gru_0_out_t4_6 + (0.97145330905914307) * gru_0_out_t4_7 + (-0.17810654640197754) * gru_0_out_t4_8 + (0.16547642648220062) * gru_0_out_t4_9 + (-0.32255932688713074) * gru_0_out_t4_10 + (0.15726543962955475) * gru_0_out_t4_11 + (-0.19458980858325958) * gru_0_out_t4_12 + (0.58761429786682129) * gru_0_out_t4_13 + (-0.14564372599124908) * gru_0_out_t4_14 + (-0.36928868293762207) * gru_0_out_t4_15 + (-0.54202985763549805) * gru_0_out_t4_16 + (-0.19088089466094971) * gru_0_out_t4_17 + (0.26961743831634521) * gru_0_out_t4_18 + (0.3311760425567627) * gru_0_out_t4_19 + (0.31020963191986084) * gru_0_out_t4_20 + (-0.25863903760910034) * gru_0_out_t4_21 + (1.0270401239395142) * gru_0_out_t4_22 + (0.39626970887184143) * gru_0_out_t4_23 + (-0.89023309946060181) * gru_0_out_t4_24 + (-1.1271336078643799) * gru_0_out_t4_25 + (0.453023761510849) * gru_0_out_t4_26 + (0.147971510887146) * gru_0_out_t4_27 + (-0.30280712246894836) * gru_0_out_t4_28 + (0.45705434679985046) * gru_0_out_t4_29 + (0.30927988886833191) * gru_0_out_t4_30 + (-0.49188673496246338) * gru_0_out_t4_31 + (-0.31653869152069092) * gru_0_out_t4_32 + (-0.027519812807440758) * gru_0_out_t4_33 + (0.10475680232048035) * gru_0_out_t4_34 + (0.18204799294471741) * gru_0_out_t4_35 + (0.15570703148841858) * gru_0_out_t4_36 + (0.8276631236076355) * gru_0_out_t4_37 + (-0.26887872815132141) * gru_0_out_t4_38 + (1.3384737968444824) * gru_0_out_t4_39 + (-0.35139158368110657) * gru_0_out_t4_40 + (-0.16068819165229797) * gru_0_out_t4_41 + (1.5475722551345825) * gru_0_out_t4_42 + (0.095709152519702911) * gru_0_out_t4_43 + (0.25375205278396606) * gru_0_out_t4_44 + (-0.050397597253322601) * gru_0_out_t4_45 + (-0.92746919393539429) * gru_0_out_t4_46 + (0.1209055632352829) * gru_0_out_t4_47 + (0.51284027099609375) * gru_0_out_t4_48 + (-0.20292896032333374) * gru_0_out_t4_49 + (0.41928768157958984) * gru_0_out_t4_50 + (-0.2721254825592041) * gru_0_out_t4_51 + (0.3830828070640564) * gru_0_out_t4_52 + (0.23477780818939209) * gru_0_out_t4_53 + (0.50941181182861328) * gru_0_out_t4_54 + (-0.089572511613368988) * gru_0_out_t4_55 + (0.61348056793212891) * gru_0_out_t4_56 + (-0.38686642050743103) * gru_0_out_t4_57 + (-0.036189470440149307) * gru_0_out_t4_58 + (-0.20263336598873138) * gru_0_out_t4_59 + (0.11454407870769501) * gru_0_out_t4_60 + (0.74444657564163208) * gru_0_out_t4_61 + (0.76675510406494141) * gru_0_out_t4_62 + (-0.43409499526023865) * gru_0_out_t4_63);
    gate_n = tanh((-0.16687101125717163) + (-0.16185379028320312) * gru_0_out_t4_0 + (0.33224537968635559) * gru_0_out_t4_1 + (0.067100226879119873) * gru_0_out_t4_2 + (0.61550378799438477) * gru_0_out_t4_3 + (0.82396554946899414) * gru_0_out_t4_4 + (-1.0709521770477295) * gru_0_out_t4_5 + (0.31438404321670532) * gru_0_out_t4_6 + (0.55568921566009521) * gru_0_out_t4_7 + (0.78195250034332275) * gru_0_out_t4_8 + (0.47761204838752747) * gru_0_out_t4_9 + (0.11514594405889511) * gru_0_out_t4_10 + (1.0892854928970337) * gru_0_out_t4_11 + (0.28379765152931213) * gru_0_out_t4_12 + (0.075282774865627289) * gru_0_out_t4_13 + (-0.64476656913757324) * gru_0_out_t4_14 + (0.26431912183761597) * gru_0_out_t4_15 + (0.71232855319976807) * gru_0_out_t4_16 + (0.21489760279655457) * gru_0_out_t4_17 + (-0.22436267137527466) * gru_0_out_t4_18 + (0.14282378554344177) * gru_0_out_t4_19 + (0.62041199207305908) * gru_0_out_t4_20 + (1.3187369108200073) * gru_0_out_t4_21 + (0.92351102828979492) * gru_0_out_t4_22 + (-0.5967528223991394) * gru_0_out_t4_23 + (-0.36735093593597412) * gru_0_out_t4_24 + (0.5647309422492981) * gru_0_out_t4_25 + (-0.035634748637676239) * gru_0_out_t4_26 + (-1.0368481874465942) * gru_0_out_t4_27 + (-0.12299077957868576) * gru_0_out_t4_28 + (0.35461756587028503) * gru_0_out_t4_29 + (0.36864644289016724) * gru_0_out_t4_30 + (-0.35495498776435852) * gru_0_out_t4_31 + (-0.21914319694042206) * gru_0_out_t4_32 + (-0.19323134422302246) * gru_0_out_t4_33 + (-0.013354081660509109) * gru_0_out_t4_34 + (0.11511501669883728) * gru_0_out_t4_35 + (-0.27835491299629211) * gru_0_out_t4_36 + (0.50314700603485107) * gru_0_out_t4_37 + (-0.05962425097823143) * gru_0_out_t4_38 + (-0.48435461521148682) * gru_0_out_t4_39 + (-0.40078175067901611) * gru_0_out_t4_40 + (-0.91777998208999634) * gru_0_out_t4_41 + (0.43784347176551819) * gru_0_out_t4_42 + (-0.17940615117549896) * gru_0_out_t4_43 + (-0.30672299861907959) * gru_0_out_t4_44 + (0.0096668517217040062) * gru_0_out_t4_45 + (-0.18379616737365723) * gru_0_out_t4_46 + (0.16606619954109192) * gru_0_out_t4_47 + (0.51083821058273315) * gru_0_out_t4_48 + (-0.38505095243453979) * gru_0_out_t4_49 + (-0.27209386229515076) * gru_0_out_t4_50 + (-0.47472718358039856) * gru_0_out_t4_51 + (0.58448582887649536) * gru_0_out_t4_52 + (0.1832723468542099) * gru_0_out_t4_53 + (-0.17374420166015625) * gru_0_out_t4_54 + (0.42756021022796631) * gru_0_out_t4_55 + (1.1190783977508545) * gru_0_out_t4_56 + (-0.38588923215866089) * gru_0_out_t4_57 + (0.41310217976570129) * gru_0_out_t4_58 + (0.49192497134208679) * gru_0_out_t4_59 + (0.19976599514484406) * gru_0_out_t4_60 + (-0.17201313376426697) * gru_0_out_t4_61 + (-0.43440777063369751) * gru_0_out_t4_62 + (0.058129105716943741) * gru_0_out_t4_63 + gate_r * (0.083923175930976868));
    gru_1_rev_t4_h_16 = (1.0 - gate_z) * gate_n;
    // h=17
    gate_r = sigmoid((-0.12562324106693268) + (0.085653685033321381) * gru_0_out_t4_0 + (0.55698984861373901) * gru_0_out_t4_1 + (0.89399755001068115) * gru_0_out_t4_2 + (-0.76996690034866333) * gru_0_out_t4_3 + (-0.46835541725158691) * gru_0_out_t4_4 + (1.9941030740737915) * gru_0_out_t4_5 + (0.51716947555541992) * gru_0_out_t4_6 + (-0.53569412231445312) * gru_0_out_t4_7 + (0.3786281943321228) * gru_0_out_t4_8 + (-1.098930835723877) * gru_0_out_t4_9 + (-0.84516280889511108) * gru_0_out_t4_10 + (-0.1795736700296402) * gru_0_out_t4_11 + (-0.05866386741399765) * gru_0_out_t4_12 + (0.40251424908638) * gru_0_out_t4_13 + (0.69272232055664062) * gru_0_out_t4_14 + (0.36360850930213928) * gru_0_out_t4_15 + (-0.069185473024845123) * gru_0_out_t4_16 + (-0.20157048106193542) * gru_0_out_t4_17 + (-0.47928574681282043) * gru_0_out_t4_18 + (-1.1660399436950684) * gru_0_out_t4_19 + (0.56121730804443359) * gru_0_out_t4_20 + (-4.0058603286743164) * gru_0_out_t4_21 + (1.6947810649871826) * gru_0_out_t4_22 + (-1.1090716123580933) * gru_0_out_t4_23 + (-1.8029855489730835) * gru_0_out_t4_24 + (-1.1732122898101807) * gru_0_out_t4_25 + (0.3174934983253479) * gru_0_out_t4_26 + (2.9602794647216797) * gru_0_out_t4_27 + (-0.65762954950332642) * gru_0_out_t4_28 + (-0.34224909543991089) * gru_0_out_t4_29 + (-0.28384709358215332) * gru_0_out_t4_30 + (1.3211969137191772) * gru_0_out_t4_31 + (0.017934616655111313) * gru_0_out_t4_32 + (-0.18890306353569031) * gru_0_out_t4_33 + (0.20527030527591705) * gru_0_out_t4_34 + (-0.2113373726606369) * gru_0_out_t4_35 + (-0.10468214750289917) * gru_0_out_t4_36 + (-0.12541338801383972) * gru_0_out_t4_37 + (0.28206655383110046) * gru_0_out_t4_38 + (0.1706228107213974) * gru_0_out_t4_39 + (-3.8478071689605713) * gru_0_out_t4_40 + (0.53446274995803833) * gru_0_out_t4_41 + (-0.62497556209564209) * gru_0_out_t4_42 + (0.082209385931491852) * gru_0_out_t4_43 + (0.55138599872589111) * gru_0_out_t4_44 + (0.073295123875141144) * gru_0_out_t4_45 + (-0.53786200284957886) * gru_0_out_t4_46 + (0.077682346105575562) * gru_0_out_t4_47 + (0.14706458151340485) * gru_0_out_t4_48 + (0.040437053889036179) * gru_0_out_t4_49 + (-0.88880771398544312) * gru_0_out_t4_50 + (0.27513983845710754) * gru_0_out_t4_51 + (-0.043255645781755447) * gru_0_out_t4_52 + (0.21940380334854126) * gru_0_out_t4_53 + (0.48417413234710693) * gru_0_out_t4_54 + (-0.46986132860183716) * gru_0_out_t4_55 + (1.0513864755630493) * gru_0_out_t4_56 + (0.45130595564842224) * gru_0_out_t4_57 + (-0.69930964708328247) * gru_0_out_t4_58 + (-0.58879989385604858) * gru_0_out_t4_59 + (1.3638644218444824) * gru_0_out_t4_60 + (0.88145828247070312) * gru_0_out_t4_61 + (0.29753684997558594) * gru_0_out_t4_62 + (0.10217323154211044) * gru_0_out_t4_63);
    gate_z = sigmoid((0.456319659948349) + (-0.053165104240179062) * gru_0_out_t4_0 + (-0.90152430534362793) * gru_0_out_t4_1 + (0.19806905090808868) * gru_0_out_t4_2 + (-1.1520562171936035) * gru_0_out_t4_3 + (-0.46261200308799744) * gru_0_out_t4_4 + (0.065652325749397278) * gru_0_out_t4_5 + (0.1550067812204361) * gru_0_out_t4_6 + (-0.52493453025817871) * gru_0_out_t4_7 + (0.29718217253684998) * gru_0_out_t4_8 + (0.089924879372119904) * gru_0_out_t4_9 + (-0.20680534839630127) * gru_0_out_t4_10 + (0.27234578132629395) * gru_0_out_t4_11 + (0.28782707452774048) * gru_0_out_t4_12 + (0.67073923349380493) * gru_0_out_t4_13 + (0.060374297201633453) * gru_0_out_t4_14 + (-0.33991909027099609) * gru_0_out_t4_15 + (-0.27202045917510986) * gru_0_out_t4_16 + (-0.22569744288921356) * gru_0_out_t4_17 + (-0.69002938270568848) * gru_0_out_t4_18 + (-0.27793538570404053) * gru_0_out_t4_19 + (0.18474416434764862) * gru_0_out_t4_20 + (-0.57669693231582642) * gru_0_out_t4_21 + (0.49824070930480957) * gru_0_out_t4_22 + (-0.54911923408508301) * gru_0_out_t4_23 + (-0.30262526869773865) * gru_0_out_t4_24 + (-0.75730103254318237) * gru_0_out_t4_25 + (-0.02945425733923912) * gru_0_out_t4_26 + (0.33043855428695679) * gru_0_out_t4_27 + (0.41105958819389343) * gru_0_out_t4_28 + (-0.91633987426757812) * gru_0_out_t4_29 + (0.3194638192653656) * gru_0_out_t4_30 + (-0.66543745994567871) * gru_0_out_t4_31 + (0.49333035945892334) * gru_0_out_t4_32 + (0.59869241714477539) * gru_0_out_t4_33 + (0.17675408720970154) * gru_0_out_t4_34 + (-1.2984439134597778) * gru_0_out_t4_35 + (0.11140664666891098) * gru_0_out_t4_36 + (-0.50277054309844971) * gru_0_out_t4_37 + (-0.44644579291343689) * gru_0_out_t4_38 + (1.4768627882003784) * gru_0_out_t4_39 + (0.49128583073616028) * gru_0_out_t4_40 + (0.16697733104228973) * gru_0_out_t4_41 + (0.12081529200077057) * gru_0_out_t4_42 + (-0.64657092094421387) * gru_0_out_t4_43 + (0.41510647535324097) * gru_0_out_t4_44 + (-0.28649657964706421) * gru_0_out_t4_45 + (1.5185443162918091) * gru_0_out_t4_46 + (-0.47994884848594666) * gru_0_out_t4_47 + (-0.35347869992256165) * gru_0_out_t4_48 + (0.83813649415969849) * gru_0_out_t4_49 + (-0.58615052700042725) * gru_0_out_t4_50 + (-0.40006420016288757) * gru_0_out_t4_51 + (-0.58723604679107666) * gru_0_out_t4_52 + (0.24470843374729156) * gru_0_out_t4_53 + (0.23792020976543427) * gru_0_out_t4_54 + (1.4273512363433838) * gru_0_out_t4_55 + (0.14557042717933655) * gru_0_out_t4_56 + (0.18876749277114868) * gru_0_out_t4_57 + (-0.1819598525762558) * gru_0_out_t4_58 + (-0.87617325782775879) * gru_0_out_t4_59 + (-0.53376859426498413) * gru_0_out_t4_60 + (-0.44438394904136658) * gru_0_out_t4_61 + (-0.39132013916969299) * gru_0_out_t4_62 + (0.019674871116876602) * gru_0_out_t4_63);
