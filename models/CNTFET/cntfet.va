    gate_n = tanh((0.16047102212905884) + (0.021440399810671806) * gru_1_out_t2_0 + (0.007651373278349638) * gru_1_out_t2_1 + (-0.8593515157699585) * gru_1_out_t2_2 + (-0.8215785026550293) * gru_1_out_t2_3 + (-0.48472413420677185) * gru_1_out_t2_4 + (-0.84573847055435181) * gru_1_out_t2_5 + (1.4827629327774048) * gru_1_out_t2_6 + (0.017878022044897079) * gru_1_out_t2_7 + (0.53135913610458374) * gru_1_out_t2_8 + (-0.25565704703330994) * gru_1_out_t2_9 + (0.43074721097946167) * gru_1_out_t2_10 + (0.019867515191435814) * gru_1_out_t2_11 + (0.074906542897224426) * gru_1_out_t2_12 + (0.79845809936523438) * gru_1_out_t2_13 + (0.51691937446594238) * gru_1_out_t2_14 + (0.03350086510181427) * gru_1_out_t2_15 + (0.0020999577827751637) * gru_1_out_t2_16 + (0.28663420677185059) * gru_1_out_t2_17 + (0.065601520240306854) * gru_1_out_t2_18 + (-0.31842207908630371) * gru_1_out_t2_19 + (-0.2485838383436203) * gru_1_out_t2_20 + (-0.21872504055500031) * gru_1_out_t2_21 + (1.4855101108551025) * gru_1_out_t2_22 + (0.043136235326528549) * gru_1_out_t2_23 + (0.24001936614513397) * gru_1_out_t2_24 + (0.37624084949493408) * gru_1_out_t2_25 + (-0.19413581490516663) * gru_1_out_t2_26 + (-0.35336112976074219) * gru_1_out_t2_27 + (0.84216463565826416) * gru_1_out_t2_28 + (0.49779850244522095) * gru_1_out_t2_29 + (0.37092763185501099) * gru_1_out_t2_30 + (0.4805438220500946) * gru_1_out_t2_31 + (-0.50003325939178467) * gru_1_out_t2_32 + (1.0426298379898071) * gru_1_out_t2_33 + (-0.063065409660339355) * gru_1_out_t2_34 + (-0.59291648864746094) * gru_1_out_t2_35 + (-0.0097719375044107437) * gru_1_out_t2_36 + (0.61241310834884644) * gru_1_out_t2_37 + (-0.33609381318092346) * gru_1_out_t2_38 + (1.2631243467330933) * gru_1_out_t2_39 + (-0.32283195853233337) * gru_1_out_t2_40 + (0.065902799367904663) * gru_1_out_t2_41 + (0.099688373506069183) * gru_1_out_t2_42 + (0.90038943290710449) * gru_1_out_t2_43 + (-0.44259399175643921) * gru_1_out_t2_44 + (-0.26881229877471924) * gru_1_out_t2_45 + (0.61085647344589233) * gru_1_out_t2_46 + (0.31210371851921082) * gru_1_out_t2_47 + (0.54784387350082397) * gru_1_out_t2_48 + (-0.50492143630981445) * gru_1_out_t2_49 + (0.19248181581497192) * gru_1_out_t2_50 + (-0.14665351808071136) * gru_1_out_t2_51 + (-2.1793737411499023) * gru_1_out_t2_52 + (0.35413509607315063) * gru_1_out_t2_53 + (0.49973165988922119) * gru_1_out_t2_54 + (0.4304165244102478) * gru_1_out_t2_55 + (-0.77305787801742554) * gru_1_out_t2_56 + (0.17965507507324219) * gru_1_out_t2_57 + (-0.017980599775910378) * gru_1_out_t2_58 + (-0.26142865419387817) * gru_1_out_t2_59 + (0.033792994916439056) * gru_1_out_t2_60 + (-1.6278089284896851) * gru_1_out_t2_61 + (-0.15083250403404236) * gru_1_out_t2_62 + (0.29771015048027039) * gru_1_out_t2_63 + gate_r * ((1.7768086194992065) + (0.14942200481891632) * gru_2_rev_t3_h_0 + (-0.06663888692855835) * gru_2_rev_t3_h_1 + (-0.049672342836856842) * gru_2_rev_t3_h_2 + (-0.12648728489875793) * gru_2_rev_t3_h_3 + (-0.0036791171878576279) * gru_2_rev_t3_h_4 + (0.01380469836294651) * gru_2_rev_t3_h_5 + (0.064467594027519226) * gru_2_rev_t3_h_6 + (0.011014529503881931) * gru_2_rev_t3_h_7 + (0.049058966338634491) * gru_2_rev_t3_h_8 + (0.19495415687561035) * gru_2_rev_t3_h_9 + (-0.11490200459957123) * gru_2_rev_t3_h_10 + (-0.057957649230957031) * gru_2_rev_t3_h_11 + (0.067253924906253815) * gru_2_rev_t3_h_12 + (0.0028611226007342339) * gru_2_rev_t3_h_13 + (-0.035147752612829208) * gru_2_rev_t3_h_14 + (-0.18814060091972351) * gru_2_rev_t3_h_15 + (-0.086589254438877106) * gru_2_rev_t3_h_16 + (0.22816254198551178) * gru_2_rev_t3_h_17 + (0.14313173294067383) * gru_2_rev_t3_h_18 + (-0.098398312926292419) * gru_2_rev_t3_h_19 + (-0.10617842525243759) * gru_2_rev_t3_h_20 + (0.015109830535948277) * gru_2_rev_t3_h_21 + (-0.009455529972910881) * gru_2_rev_t3_h_22 + (0.0058081825263798237) * gru_2_rev_t3_h_23 + (0.036684546619653702) * gru_2_rev_t3_h_24 + (0.035930316895246506) * gru_2_rev_t3_h_25 + (-0.20715263485908508) * gru_2_rev_t3_h_26 + (0.014771712012588978) * gru_2_rev_t3_h_27 + (0.019583480432629585) * gru_2_rev_t3_h_28 + (-0.13148404657840729) * gru_2_rev_t3_h_29 + (0.0067883618175983429) * gru_2_rev_t3_h_30 + (0.19683291018009186) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_6 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_6;
    // h=7
    gate_r = sigmoid((1.7361443042755127) + (0.86286664009094238) * gru_1_out_t2_0 + (0.16136729717254639) * gru_1_out_t2_1 + (-0.51443135738372803) * gru_1_out_t2_2 + (-0.17000125348567963) * gru_1_out_t2_3 + (-0.48432481288909912) * gru_1_out_t2_4 + (-0.5779043436050415) * gru_1_out_t2_5 + (0.31827667355537415) * gru_1_out_t2_6 + (-0.39719545841217041) * gru_1_out_t2_7 + (-0.11021362245082855) * gru_1_out_t2_8 + (-0.39959630370140076) * gru_1_out_t2_9 + (1.7606823444366455) * gru_1_out_t2_10 + (0.87061059474945068) * gru_1_out_t2_11 + (0.22470657527446747) * gru_1_out_t2_12 + (0.18127433955669403) * gru_1_out_t2_13 + (-0.0132785364985466) * gru_1_out_t2_14 + (-0.39052814245223999) * gru_1_out_t2_15 + (-0.43932676315307617) * gru_1_out_t2_16 + (0.18730327486991882) * gru_1_out_t2_17 + (0.90324395895004272) * gru_1_out_t2_18 + (-0.53849023580551147) * gru_1_out_t2_19 + (0.20984739065170288) * gru_1_out_t2_20 + (-0.6712343692779541) * gru_1_out_t2_21 + (-1.2013891935348511) * gru_1_out_t2_22 + (-0.14091552793979645) * gru_1_out_t2_23 + (-0.34270268678665161) * gru_1_out_t2_24 + (0.91935670375823975) * gru_1_out_t2_25 + (0.8984602689743042) * gru_1_out_t2_26 + (-1.0397605895996094) * gru_1_out_t2_27 + (-0.37607216835021973) * gru_1_out_t2_28 + (0.26456105709075928) * gru_1_out_t2_29 + (0.32620799541473389) * gru_1_out_t2_30 + (0.036355830729007721) * gru_1_out_t2_31 + (0.32388678193092346) * gru_1_out_t2_32 + (-0.20570090413093567) * gru_1_out_t2_33 + (0.10077348351478577) * gru_1_out_t2_34 + (-0.064565323293209076) * gru_1_out_t2_35 + (0.42750447988510132) * gru_1_out_t2_36 + (0.30756080150604248) * gru_1_out_t2_37 + (-0.68123990297317505) * gru_1_out_t2_38 + (0.31775602698326111) * gru_1_out_t2_39 + (-0.61744242906570435) * gru_1_out_t2_40 + (0.79367649555206299) * gru_1_out_t2_41 + (-0.4244309663772583) * gru_1_out_t2_42 + (-0.51626789569854736) * gru_1_out_t2_43 + (-0.34484744071960449) * gru_1_out_t2_44 + (-0.18257729709148407) * gru_1_out_t2_45 + (-0.39788922667503357) * gru_1_out_t2_46 + (-0.51964277029037476) * gru_1_out_t2_47 + (-0.490643709897995) * gru_1_out_t2_48 + (-0.047774065285921097) * gru_1_out_t2_49 + (-0.80521416664123535) * gru_1_out_t2_50 + (0.72727924585342407) * gru_1_out_t2_51 + (-0.024646788835525513) * gru_1_out_t2_52 + (0.42618343234062195) * gru_1_out_t2_53 + (0.075562901794910431) * gru_1_out_t2_54 + (0.30600139498710632) * gru_1_out_t2_55 + (-0.62501168251037598) * gru_1_out_t2_56 + (0.85719770193099976) * gru_1_out_t2_57 + (0.52631193399429321) * gru_1_out_t2_58 + (-0.6495516300201416) * gru_1_out_t2_59 + (-0.079577378928661346) * gru_1_out_t2_60 + (0.054631583392620087) * gru_1_out_t2_61 + (0.06564224511384964) * gru_1_out_t2_62 + (0.54276424646377563) * gru_1_out_t2_63 + (0.037355970591306686) * gru_2_rev_t3_h_0 + (0.12615382671356201) * gru_2_rev_t3_h_1 + (0.039024647325277328) * gru_2_rev_t3_h_2 + (0.037829406559467316) * gru_2_rev_t3_h_3 + (-0.11376144737005234) * gru_2_rev_t3_h_4 + (0.16380020976066589) * gru_2_rev_t3_h_5 + (-0.074032865464687347) * gru_2_rev_t3_h_6 + (0.030431352555751801) * gru_2_rev_t3_h_7 + (0.17515850067138672) * gru_2_rev_t3_h_8 + (0.086615636944770813) * gru_2_rev_t3_h_9 + (-0.22981938719749451) * gru_2_rev_t3_h_10 + (0.040034927427768707) * gru_2_rev_t3_h_11 + (0.16128884255886078) * gru_2_rev_t3_h_12 + (-0.0060771731659770012) * gru_2_rev_t3_h_13 + (0.0681275874376297) * gru_2_rev_t3_h_14 + (-0.043098676949739456) * gru_2_rev_t3_h_15 + (0.098482348024845123) * gru_2_rev_t3_h_16 + (-0.14984270930290222) * gru_2_rev_t3_h_17 + (0.05131901428103447) * gru_2_rev_t3_h_18 + (-0.01650642603635788) * gru_2_rev_t3_h_19 + (-0.034698877483606339) * gru_2_rev_t3_h_20 + (0.047526855021715164) * gru_2_rev_t3_h_21 + (0.063117489218711853) * gru_2_rev_t3_h_22 + (0.0080967992544174194) * gru_2_rev_t3_h_23 + (-0.031586490571498871) * gru_2_rev_t3_h_24 + (0.088141806423664093) * gru_2_rev_t3_h_25 + (-0.0065621510148048401) * gru_2_rev_t3_h_26 + (-0.0082830339670181274) * gru_2_rev_t3_h_27 + (0.086487658321857452) * gru_2_rev_t3_h_28 + (0.063254483044147491) * gru_2_rev_t3_h_29 + (0.10826320201158524) * gru_2_rev_t3_h_30 + (0.12860086560249329) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.13083033263683319) + (-0.063615337014198303) * gru_1_out_t2_0 + (0.23459434509277344) * gru_1_out_t2_1 + (0.31742677092552185) * gru_1_out_t2_2 + (0.39943045377731323) * gru_1_out_t2_3 + (0.67354333400726318) * gru_1_out_t2_4 + (0.4119773805141449) * gru_1_out_t2_5 + (0.63353675603866577) * gru_1_out_t2_6 + (0.55596882104873657) * gru_1_out_t2_7 + (-0.36504951119422913) * gru_1_out_t2_8 + (-0.4562012255191803) * gru_1_out_t2_9 + (-0.42379516363143921) * gru_1_out_t2_10 + (-0.13524262607097626) * gru_1_out_t2_11 + (-0.62205356359481812) * gru_1_out_t2_12 + (0.18755948543548584) * gru_1_out_t2_13 + (-0.079651527106761932) * gru_1_out_t2_14 + (-0.21194317936897278) * gru_1_out_t2_15 + (-0.22122414410114288) * gru_1_out_t2_16 + (-0.20221562683582306) * gru_1_out_t2_17 + (0.080637559294700623) * gru_1_out_t2_18 + (-0.056710835546255112) * gru_1_out_t2_19 + (0.19184175133705139) * gru_1_out_t2_20 + (-0.018995940685272217) * gru_1_out_t2_21 + (-0.43431735038757324) * gru_1_out_t2_22 + (0.46303927898406982) * gru_1_out_t2_23 + (0.082697577774524689) * gru_1_out_t2_24 + (0.11410228163003922) * gru_1_out_t2_25 + (-0.11901412159204483) * gru_1_out_t2_26 + (0.56533074378967285) * gru_1_out_t2_27 + (0.02513536810874939) * gru_1_out_t2_28 + (-0.67212045192718506) * gru_1_out_t2_29 + (-0.23709802329540253) * gru_1_out_t2_30 + (-0.029461782425642014) * gru_1_out_t2_31 + (-0.5010417103767395) * gru_1_out_t2_32 + (-0.037933308631181717) * gru_1_out_t2_33 + (-0.2674698531627655) * gru_1_out_t2_34 + (0.067276693880558014) * gru_1_out_t2_35 + (-0.063510648906230927) * gru_1_out_t2_36 + (-0.68234467506408691) * gru_1_out_t2_37 + (-0.18749165534973145) * gru_1_out_t2_38 + (-0.25391653180122375) * gru_1_out_t2_39 + (-0.41480076313018799) * gru_1_out_t2_40 + (-0.026855051517486572) * gru_1_out_t2_41 + (-0.41812413930892944) * gru_1_out_t2_42 + (0.31026563048362732) * gru_1_out_t2_43 + (-0.20103989541530609) * gru_1_out_t2_44 + (-0.3424685001373291) * gru_1_out_t2_45 + (-0.74190956354141235) * gru_1_out_t2_46 + (-0.48400235176086426) * gru_1_out_t2_47 + (-0.4025285542011261) * gru_1_out_t2_48 + (0.38459628820419312) * gru_1_out_t2_49 + (0.069893531501293182) * gru_1_out_t2_50 + (0.2595272958278656) * gru_1_out_t2_51 + (0.26308345794677734) * gru_1_out_t2_52 + (0.2949521541595459) * gru_1_out_t2_53 + (-0.24431861937046051) * gru_1_out_t2_54 + (-0.089324593544006348) * gru_1_out_t2_55 + (0.39417093992233276) * gru_1_out_t2_56 + (0.05821990966796875) * gru_1_out_t2_57 + (1.0052711963653564) * gru_1_out_t2_58 + (0.12529800832271576) * gru_1_out_t2_59 + (-0.2037699967622757) * gru_1_out_t2_60 + (0.45260119438171387) * gru_1_out_t2_61 + (0.64249807596206665) * gru_1_out_t2_62 + (0.31449529528617859) * gru_1_out_t2_63 + (0.14750100672245026) * gru_2_rev_t3_h_0 + (-0.039984751492738724) * gru_2_rev_t3_h_1 + (0.018951306119561195) * gru_2_rev_t3_h_2 + (0.18244515359401703) * gru_2_rev_t3_h_3 + (0.099597461521625519) * gru_2_rev_t3_h_4 + (0.15804880857467651) * gru_2_rev_t3_h_5 + (0.059492006897926331) * gru_2_rev_t3_h_6 + (-0.09882470965385437) * gru_2_rev_t3_h_7 + (-0.1189434751868248) * gru_2_rev_t3_h_8 + (-0.059657923877239227) * gru_2_rev_t3_h_9 + (-0.13764367997646332) * gru_2_rev_t3_h_10 + (0.0052220593206584454) * gru_2_rev_t3_h_11 + (-0.015806525945663452) * gru_2_rev_t3_h_12 + (-0.076769314706325531) * gru_2_rev_t3_h_13 + (0.0020416374318301678) * gru_2_rev_t3_h_14 + (-0.13750316202640533) * gru_2_rev_t3_h_15 + (-0.086290314793586731) * gru_2_rev_t3_h_16 + (-0.089879810810089111) * gru_2_rev_t3_h_17 + (-0.076176382601261139) * gru_2_rev_t3_h_18 + (0.032589279115200043) * gru_2_rev_t3_h_19 + (-0.16191880404949188) * gru_2_rev_t3_h_20 + (-0.062053248286247253) * gru_2_rev_t3_h_21 + (0.014125751331448555) * gru_2_rev_t3_h_22 + (0.21393850445747375) * gru_2_rev_t3_h_23 + (-0.02909967303276062) * gru_2_rev_t3_h_24 + (0.19698388874530792) * gru_2_rev_t3_h_25 + (0.026536552235484123) * gru_2_rev_t3_h_26 + (-0.18375706672668457) * gru_2_rev_t3_h_27 + (0.18866388499736786) * gru_2_rev_t3_h_28 + (0.003180832602083683) * gru_2_rev_t3_h_29 + (0.033437948673963547) * gru_2_rev_t3_h_30 + (-0.086945876479148865) * gru_2_rev_t3_h_31);
    gate_n = tanh((-0.616996169090271) + (-0.40547138452529907) * gru_1_out_t2_0 + (0.10367200523614883) * gru_1_out_t2_1 + (0.26511353254318237) * gru_1_out_t2_2 + (-0.10645290464162827) * gru_1_out_t2_3 + (0.48044824600219727) * gru_1_out_t2_4 + (0.27043813467025757) * gru_1_out_t2_5 + (1.4366590976715088) * gru_1_out_t2_6 + (-0.031165970489382744) * gru_1_out_t2_7 + (0.71131110191345215) * gru_1_out_t2_8 + (0.19672767817974091) * gru_1_out_t2_9 + (-0.71016395092010498) * gru_1_out_t2_10 + (-0.290792316198349) * gru_1_out_t2_11 + (-0.090749844908714294) * gru_1_out_t2_12 + (0.095729045569896698) * gru_1_out_t2_13 + (0.74281030893325806) * gru_1_out_t2_14 + (-0.16777509450912476) * gru_1_out_t2_15 + (0.44089877605438232) * gru_1_out_t2_16 + (1.371646523475647) * gru_1_out_t2_17 + (-0.24685183167457581) * gru_1_out_t2_18 + (-0.22187939286231995) * gru_1_out_t2_19 + (-0.065534025430679321) * gru_1_out_t2_20 + (0.52133387327194214) * gru_1_out_t2_21 + (-0.018752360716462135) * gru_1_out_t2_22 + (2.8016388416290283) * gru_1_out_t2_23 + (-0.49452036619186401) * gru_1_out_t2_24 + (-0.25762352347373962) * gru_1_out_t2_25 + (0.27354395389556885) * gru_1_out_t2_26 + (0.33017668128013611) * gru_1_out_t2_27 + (0.18212388455867767) * gru_1_out_t2_28 + (0.17504759132862091) * gru_1_out_t2_29 + (-1.4238917827606201) * gru_1_out_t2_30 + (-0.53854739665985107) * gru_1_out_t2_31 + (-3.1232802867889404) * gru_1_out_t2_32 + (0.75295436382293701) * gru_1_out_t2_33 + (0.71104234457015991) * gru_1_out_t2_34 + (-0.0067405370064079762) * gru_1_out_t2_35 + (-0.40665909647941589) * gru_1_out_t2_36 + (0.90488046407699585) * gru_1_out_t2_37 + (0.27753224968910217) * gru_1_out_t2_38 + (0.20131900906562805) * gru_1_out_t2_39 + (-0.1079728975892067) * gru_1_out_t2_40 + (-0.040845487266778946) * gru_1_out_t2_41 + (2.4596264362335205) * gru_1_out_t2_42 + (-0.78534382581710815) * gru_1_out_t2_43 + (-0.1819646805524826) * gru_1_out_t2_44 + (0.22644424438476562) * gru_1_out_t2_45 + (1.7211408615112305) * gru_1_out_t2_46 + (0.267528235912323) * gru_1_out_t2_47 + (1.2164490222930908) * gru_1_out_t2_48 + (-3.943882942199707) * gru_1_out_t2_49 + (1.4845232963562012) * gru_1_out_t2_50 + (-0.46216562390327454) * gru_1_out_t2_51 + (1.3737339973449707) * gru_1_out_t2_52 + (-0.45504778623580933) * gru_1_out_t2_53 + (0.81720608472824097) * gru_1_out_t2_54 + (0.64952766895294189) * gru_1_out_t2_55 + (1.4031897783279419) * gru_1_out_t2_56 + (-0.46085867285728455) * gru_1_out_t2_57 + (-0.96903729438781738) * gru_1_out_t2_58 + (-0.1494286060333252) * gru_1_out_t2_59 + (-0.020580671727657318) * gru_1_out_t2_60 + (2.5586886405944824) * gru_1_out_t2_61 + (0.40613561868667603) * gru_1_out_t2_62 + (-0.48029333353042603) * gru_1_out_t2_63 + gate_r * ((-0.60400360822677612) + (0.020414549857378006) * gru_2_rev_t3_h_0 + (0.25605279207229614) * gru_2_rev_t3_h_1 + (0.01595303975045681) * gru_2_rev_t3_h_2 + (-0.14176285266876221) * gru_2_rev_t3_h_3 + (0.082674764096736908) * gru_2_rev_t3_h_4 + (0.14913128316402435) * gru_2_rev_t3_h_5 + (-0.21834208071231842) * gru_2_rev_t3_h_6 + (0.035364598035812378) * gru_2_rev_t3_h_7 + (-0.14383813738822937) * gru_2_rev_t3_h_8 + (0.10643225908279419) * gru_2_rev_t3_h_9 + (-0.12203127145767212) * gru_2_rev_t3_h_10 + (0.027338581159710884) * gru_2_rev_t3_h_11 + (0.10984116792678833) * gru_2_rev_t3_h_12 + (0.08703901618719101) * gru_2_rev_t3_h_13 + (-0.023683050647377968) * gru_2_rev_t3_h_14 + (0.038358502089977264) * gru_2_rev_t3_h_15 + (-0.2535284161567688) * gru_2_rev_t3_h_16 + (-0.011550145223736763) * gru_2_rev_t3_h_17 + (0.14678266644477844) * gru_2_rev_t3_h_18 + (-0.021531609818339348) * gru_2_rev_t3_h_19 + (0.07357470691204071) * gru_2_rev_t3_h_20 + (-0.10284025967121124) * gru_2_rev_t3_h_21 + (-0.02812495082616806) * gru_2_rev_t3_h_22 + (0.13974660634994507) * gru_2_rev_t3_h_23 + (0.071941010653972626) * gru_2_rev_t3_h_24 + (0.012641420587897301) * gru_2_rev_t3_h_25 + (-0.001814831979572773) * gru_2_rev_t3_h_26 + (0.034363526850938797) * gru_2_rev_t3_h_27 + (0.12711341679096222) * gru_2_rev_t3_h_28 + (0.11532885581254959) * gru_2_rev_t3_h_29 + (0.018490701913833618) * gru_2_rev_t3_h_30 + (0.15406051278114319) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_7 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_7;
    // h=8
    gate_r = sigmoid((2.8912184238433838) + (1.3659958839416504) * gru_1_out_t2_0 + (0.37391072511672974) * gru_1_out_t2_1 + (-0.2701583206653595) * gru_1_out_t2_2 + (-0.17114348709583282) * gru_1_out_t2_3 + (-0.7491908073425293) * gru_1_out_t2_4 + (-0.35661280155181885) * gru_1_out_t2_5 + (-0.48511156439781189) * gru_1_out_t2_6 + (-0.46984121203422546) * gru_1_out_t2_7 + (-0.65646761655807495) * gru_1_out_t2_8 + (-0.34418141841888428) * gru_1_out_t2_9 + (1.0855814218521118) * gru_1_out_t2_10 + (0.80499154329299927) * gru_1_out_t2_11 + (-0.057312730699777603) * gru_1_out_t2_12 + (0.94051146507263184) * gru_1_out_t2_13 + (-0.71841728687286377) * gru_1_out_t2_14 + (0.11845734715461731) * gru_1_out_t2_15 + (-1.2948552370071411) * gru_1_out_t2_16 + (0.02000700868666172) * gru_1_out_t2_17 + (0.69520890712738037) * gru_1_out_t2_18 + (-0.11902958154678345) * gru_1_out_t2_19 + (-0.072189271450042725) * gru_1_out_t2_20 + (-0.76335853338241577) * gru_1_out_t2_21 + (-0.90423709154129028) * gru_1_out_t2_22 + (0.048479791730642319) * gru_1_out_t2_23 + (-0.06175382062792778) * gru_1_out_t2_24 + (-0.00083022407488897443) * gru_1_out_t2_25 + (0.94238740205764771) * gru_1_out_t2_26 + (-0.87931150197982788) * gru_1_out_t2_27 + (-0.41592901945114136) * gru_1_out_t2_28 + (0.097828969359397888) * gru_1_out_t2_29 + (0.36108642816543579) * gru_1_out_t2_30 + (0.025255316868424416) * gru_1_out_t2_31 + (0.25571557879447937) * gru_1_out_t2_32 + (-0.51506108045578003) * gru_1_out_t2_33 + (0.17512941360473633) * gru_1_out_t2_34 + (-0.21110226213932037) * gru_1_out_t2_35 + (0.21162644028663635) * gru_1_out_t2_36 + (-0.11106965690851212) * gru_1_out_t2_37 + (-0.84037274122238159) * gru_1_out_t2_38 + (0.66389173269271851) * gru_1_out_t2_39 + (-0.66152548789978027) * gru_1_out_t2_40 + (0.93250399827957153) * gru_1_out_t2_41 + (-0.79573988914489746) * gru_1_out_t2_42 + (-0.8231586217880249) * gru_1_out_t2_43 + (-0.86564284563064575) * gru_1_out_t2_44 + (-0.3213161826133728) * gru_1_out_t2_45 + (-0.27515885233879089) * gru_1_out_t2_46 + (-0.90520477294921875) * gru_1_out_t2_47 + (-0.17067475616931915) * gru_1_out_t2_48 + (-0.12949170172214508) * gru_1_out_t2_49 + (-0.42044338583946228) * gru_1_out_t2_50 + (1.0867815017700195) * gru_1_out_t2_51 + (-0.0020332406274974346) * gru_1_out_t2_52 + (0.87233477830886841) * gru_1_out_t2_53 + (0.37425506114959717) * gru_1_out_t2_54 + (0.68979024887084961) * gru_1_out_t2_55 + (-0.58346319198608398) * gru_1_out_t2_56 + (1.0958355665206909) * gru_1_out_t2_57 + (0.87600505352020264) * gru_1_out_t2_58 + (-0.44613385200500488) * gru_1_out_t2_59 + (-0.15184366703033447) * gru_1_out_t2_60 + (0.67669755220413208) * gru_1_out_t2_61 + (-0.49116161465644836) * gru_1_out_t2_62 + (0.80605524778366089) * gru_1_out_t2_63 + (-0.037867676466703415) * gru_2_rev_t3_h_0 + (0.1941920667886734) * gru_2_rev_t3_h_1 + (0.037190135568380356) * gru_2_rev_t3_h_2 + (0.10582128167152405) * gru_2_rev_t3_h_3 + (-0.046370841562747955) * gru_2_rev_t3_h_4 + (-0.01088253315538168) * gru_2_rev_t3_h_5 + (-0.024354327470064163) * gru_2_rev_t3_h_6 + (-0.093048654496669769) * gru_2_rev_t3_h_7 + (-0.04216480627655983) * gru_2_rev_t3_h_8 + (-0.033973190933465958) * gru_2_rev_t3_h_9 + (-0.044926099479198456) * gru_2_rev_t3_h_10 + (-0.12142942100763321) * gru_2_rev_t3_h_11 + (-0.0090780938044190407) * gru_2_rev_t3_h_12 + (-0.013599066063761711) * gru_2_rev_t3_h_13 + (0.14297723770141602) * gru_2_rev_t3_h_14 + (0.10643914341926575) * gru_2_rev_t3_h_15 + (0.1496245265007019) * gru_2_rev_t3_h_16 + (-0.01027067843824625) * gru_2_rev_t3_h_17 + (0.0010186501313000917) * gru_2_rev_t3_h_18 + (-0.096242375671863556) * gru_2_rev_t3_h_19 + (0.018324645236134529) * gru_2_rev_t3_h_20 + (-0.049871638417243958) * gru_2_rev_t3_h_21 + (-0.033122122287750244) * gru_2_rev_t3_h_22 + (-0.017283050343394279) * gru_2_rev_t3_h_23 + (-0.036408055573701859) * gru_2_rev_t3_h_24 + (0.063359767198562622) * gru_2_rev_t3_h_25 + (-0.24265950918197632) * gru_2_rev_t3_h_26 + (0.021725762635469437) * gru_2_rev_t3_h_27 + (-0.20320026576519012) * gru_2_rev_t3_h_28 + (-0.25282728672027588) * gru_2_rev_t3_h_29 + (-0.019241826608777046) * gru_2_rev_t3_h_30 + (0.12570324540138245) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.30297991633415222) + (0.15617324411869049) * gru_1_out_t2_0 + (-0.11846023052930832) * gru_1_out_t2_1 + (0.82219088077545166) * gru_1_out_t2_2 + (-0.051074925810098648) * gru_1_out_t2_3 + (0.73771101236343384) * gru_1_out_t2_4 + (-0.16285145282745361) * gru_1_out_t2_5 + (0.079038947820663452) * gru_1_out_t2_6 + (0.45598158240318298) * gru_1_out_t2_7 + (-0.4218539297580719) * gru_1_out_t2_8 + (0.079477757215499878) * gru_1_out_t2_9 + (-0.48498275876045227) * gru_1_out_t2_10 + (-0.041828803718090057) * gru_1_out_t2_11 + (-0.26014140248298645) * gru_1_out_t2_12 + (-0.0025959240738302469) * gru_1_out_t2_13 + (-0.43136003613471985) * gru_1_out_t2_14 + (-0.28164190053939819) * gru_1_out_t2_15 + (-0.084846027195453644) * gru_1_out_t2_16 + (-0.19277511537075043) * gru_1_out_t2_17 + (-0.070946052670478821) * gru_1_out_t2_18 + (-0.068928025662899017) * gru_1_out_t2_19 + (0.31109797954559326) * gru_1_out_t2_20 + (-0.082748912274837494) * gru_1_out_t2_21 + (-0.85450917482376099) * gru_1_out_t2_22 + (1.0485632419586182) * gru_1_out_t2_23 + (0.15464122593402863) * gru_1_out_t2_24 + (0.075501017272472382) * gru_1_out_t2_25 + (-0.088891111314296722) * gru_1_out_t2_26 + (-0.78270488977432251) * gru_1_out_t2_27 + (0.062542460858821869) * gru_1_out_t2_28 + (-0.336882084608078) * gru_1_out_t2_29 + (0.15171584486961365) * gru_1_out_t2_30 + (-0.096109867095947266) * gru_1_out_t2_31 + (-0.40111997723579407) * gru_1_out_t2_32 + (1.1544331312179565) * gru_1_out_t2_33 + (-0.45905911922454834) * gru_1_out_t2_34 + (0.13736154139041901) * gru_1_out_t2_35 + (0.27253580093383789) * gru_1_out_t2_36 + (-0.20272044837474823) * gru_1_out_t2_37 + (-0.30938586592674255) * gru_1_out_t2_38 + (0.11122874915599823) * gru_1_out_t2_39 + (-0.15485602617263794) * gru_1_out_t2_40 + (0.025585250928997993) * gru_1_out_t2_41 + (-1.0936397314071655) * gru_1_out_t2_42 + (-0.70794218778610229) * gru_1_out_t2_43 + (-0.48404023051261902) * gru_1_out_t2_44 + (-0.20545874536037445) * gru_1_out_t2_45 + (-0.33523067831993103) * gru_1_out_t2_46 + (0.10943949222564697) * gru_1_out_t2_47 + (-0.17867778241634369) * gru_1_out_t2_48 + (0.20783832669258118) * gru_1_out_t2_49 + (0.20718330144882202) * gru_1_out_t2_50 + (0.11238765716552734) * gru_1_out_t2_51 + (0.44948336482048035) * gru_1_out_t2_52 + (0.49291533231735229) * gru_1_out_t2_53 + (-0.30285745859146118) * gru_1_out_t2_54 + (0.29876521229743958) * gru_1_out_t2_55 + (-0.11355029046535492) * gru_1_out_t2_56 + (0.27923256158828735) * gru_1_out_t2_57 + (0.50468498468399048) * gru_1_out_t2_58 + (-0.36672967672348022) * gru_1_out_t2_59 + (-0.16002781689167023) * gru_1_out_t2_60 + (1.3767571449279785) * gru_1_out_t2_61 + (0.89382755756378174) * gru_1_out_t2_62 + (-0.11521207541227341) * gru_1_out_t2_63 + (-0.029191879555583) * gru_2_rev_t3_h_0 + (0.11072370409965515) * gru_2_rev_t3_h_1 + (0.065712161362171173) * gru_2_rev_t3_h_2 + (-0.070465132594108582) * gru_2_rev_t3_h_3 + (-0.20992252230644226) * gru_2_rev_t3_h_4 + (0.078314751386642456) * gru_2_rev_t3_h_5 + (0.084323115646839142) * gru_2_rev_t3_h_6 + (0.19873490929603577) * gru_2_rev_t3_h_7 + (-0.090736426413059235) * gru_2_rev_t3_h_8 + (0.093913674354553223) * gru_2_rev_t3_h_9 + (0.0829944908618927) * gru_2_rev_t3_h_10 + (0.092474326491355896) * gru_2_rev_t3_h_11 + (-0.12424653023481369) * gru_2_rev_t3_h_12 + (-0.15245373547077179) * gru_2_rev_t3_h_13 + (-0.027874529361724854) * gru_2_rev_t3_h_14 + (-0.1080203577876091) * gru_2_rev_t3_h_15 + (0.0071078971959650517) * gru_2_rev_t3_h_16 + (-0.22301094233989716) * gru_2_rev_t3_h_17 + (-0.10232397168874741) * gru_2_rev_t3_h_18 + (-0.030189475044608116) * gru_2_rev_t3_h_19 + (0.025493942201137543) * gru_2_rev_t3_h_20 + (0.0067222514189779758) * gru_2_rev_t3_h_21 + (0.0032009503338485956) * gru_2_rev_t3_h_22 + (0.1037481427192688) * gru_2_rev_t3_h_23 + (-0.11646608263254166) * gru_2_rev_t3_h_24 + (0.0090151475742459297) * gru_2_rev_t3_h_25 + (-0.17936235666275024) * gru_2_rev_t3_h_26 + (-0.016762645915150642) * gru_2_rev_t3_h_27 + (-0.056413576006889343) * gru_2_rev_t3_h_28 + (-0.044948134571313858) * gru_2_rev_t3_h_29 + (0.079234518110752106) * gru_2_rev_t3_h_30 + (0.020778579637408257) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.72831666469573975) + (0.70719897747039795) * gru_1_out_t2_0 + (1.6837884187698364) * gru_1_out_t2_1 + (-0.40223720669746399) * gru_1_out_t2_2 + (0.14199288189411163) * gru_1_out_t2_3 + (-0.31350335478782654) * gru_1_out_t2_4 + (-0.79629254341125488) * gru_1_out_t2_5 + (1.0249882936477661) * gru_1_out_t2_6 + (-0.18187956511974335) * gru_1_out_t2_7 + (-0.35992702841758728) * gru_1_out_t2_8 + (0.21489210426807404) * gru_1_out_t2_9 + (0.78174877166748047) * gru_1_out_t2_10 + (-0.71393889188766479) * gru_1_out_t2_11 + (1.6794614791870117) * gru_1_out_t2_12 + (0.30415689945220947) * gru_1_out_t2_13 + (-0.33632761240005493) * gru_1_out_t2_14 + (0.034651316702365875) * gru_1_out_t2_15 + (-0.15870554745197296) * gru_1_out_t2_16 + (-2.9900581836700439) * gru_1_out_t2_17 + (-0.47141677141189575) * gru_1_out_t2_18 + (-0.4378904402256012) * gru_1_out_t2_19 + (0.33485144376754761) * gru_1_out_t2_20 + (-0.98092889785766602) * gru_1_out_t2_21 + (0.17791855335235596) * gru_1_out_t2_22 + (0.34081122279167175) * gru_1_out_t2_23 + (-1.4455939531326294) * gru_1_out_t2_24 + (-0.11422060430049896) * gru_1_out_t2_25 + (0.12717872858047485) * gru_1_out_t2_26 + (-1.6417419910430908) * gru_1_out_t2_27 + (1.1212698221206665) * gru_1_out_t2_28 + (-0.93666958808898926) * gru_1_out_t2_29 + (0.075910881161689758) * gru_1_out_t2_30 + (-0.17204545438289642) * gru_1_out_t2_31 + (3.0217037200927734) * gru_1_out_t2_32 + (1.0796544551849365) * gru_1_out_t2_33 + (-1.0293595790863037) * gru_1_out_t2_34 + (0.37773129343986511) * gru_1_out_t2_35 + (0.15939047932624817) * gru_1_out_t2_36 + (0.0019978266209363937) * gru_1_out_t2_37 + (-0.85047006607055664) * gru_1_out_t2_38 + (0.24220670759677887) * gru_1_out_t2_39 + (-0.76421529054641724) * gru_1_out_t2_40 + (0.52489912509918213) * gru_1_out_t2_41 + (-1.5276209115982056) * gru_1_out_t2_42 + (-0.39847606420516968) * gru_1_out_t2_43 + (-0.10235689580440521) * gru_1_out_t2_44 + (0.30879762768745422) * gru_1_out_t2_45 + (-1.6738414764404297) * gru_1_out_t2_46 + (-0.3547089695930481) * gru_1_out_t2_47 + (0.690746009349823) * gru_1_out_t2_48 + (0.74036091566085815) * gru_1_out_t2_49 + (-0.91005468368530273) * gru_1_out_t2_50 + (2.28155517578125) * gru_1_out_t2_51 + (-0.18568305671215057) * gru_1_out_t2_52 + (0.49210464954376221) * gru_1_out_t2_53 + (2.2359824180603027) * gru_1_out_t2_54 + (0.9404563307762146) * gru_1_out_t2_55 + (0.59498971700668335) * gru_1_out_t2_56 + (-0.28218474984169006) * gru_1_out_t2_57 + (0.37851646542549133) * gru_1_out_t2_58 + (0.75168931484222412) * gru_1_out_t2_59 + (0.20568723976612091) * gru_1_out_t2_60 + (-0.29816639423370361) * gru_1_out_t2_61 + (-0.79775547981262207) * gru_1_out_t2_62 + (0.047589011490345001) * gru_1_out_t2_63 + gate_r * ((0.73082387447357178) + (0.019692942500114441) * gru_2_rev_t3_h_0 + (-0.018840845674276352) * gru_2_rev_t3_h_1 + (0.07511022686958313) * gru_2_rev_t3_h_2 + (0.01876804418861866) * gru_2_rev_t3_h_3 + (0.16869285702705383) * gru_2_rev_t3_h_4 + (-0.074641190469264984) * gru_2_rev_t3_h_5 + (0.02515750378370285) * gru_2_rev_t3_h_6 + (0.03953947126865387) * gru_2_rev_t3_h_7 + (-0.052385929971933365) * gru_2_rev_t3_h_8 + (-0.03964678943157196) * gru_2_rev_t3_h_9 + (-0.0084356814622879028) * gru_2_rev_t3_h_10 + (0.031821813434362411) * gru_2_rev_t3_h_11 + (0.0027548882644623518) * gru_2_rev_t3_h_12 + (-0.14979134500026703) * gru_2_rev_t3_h_13 + (-0.18153132498264313) * gru_2_rev_t3_h_14 + (-0.18615233898162842) * gru_2_rev_t3_h_15 + (-0.10279751569032669) * gru_2_rev_t3_h_16 + (0.00079517293488606811) * gru_2_rev_t3_h_17 + (0.2039460688829422) * gru_2_rev_t3_h_18 + (-0.0036380116362124681) * gru_2_rev_t3_h_19 + (0.10920612514019012) * gru_2_rev_t3_h_20 + (-0.073644250631332397) * gru_2_rev_t3_h_21 + (0.11419044435024261) * gru_2_rev_t3_h_22 + (-0.091134414076805115) * gru_2_rev_t3_h_23 + (0.093002244830131531) * gru_2_rev_t3_h_24 + (-0.036424450576305389) * gru_2_rev_t3_h_25 + (0.0047894078306853771) * gru_2_rev_t3_h_26 + (-0.019365372136235237) * gru_2_rev_t3_h_27 + (-0.048847898840904236) * gru_2_rev_t3_h_28 + (-0.023874193429946899) * gru_2_rev_t3_h_29 + (0.10586803406476974) * gru_2_rev_t3_h_30 + (-0.044996976852416992) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_8 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_8;
    // h=9
    gate_r = sigmoid((-0.046158067882061005) + (0.16274796426296234) * gru_1_out_t2_0 + (-0.82420188188552856) * gru_1_out_t2_1 + (-0.41793316602706909) * gru_1_out_t2_2 + (0.3969694972038269) * gru_1_out_t2_3 + (-0.0044141947291791439) * gru_1_out_t2_4 + (-1.0491147041320801) * gru_1_out_t2_5 + (-1.5156136751174927) * gru_1_out_t2_6 + (-0.4016588032245636) * gru_1_out_t2_7 + (-0.41182774305343628) * gru_1_out_t2_8 + (2.2344989776611328) * gru_1_out_t2_9 + (-0.053337849676609039) * gru_1_out_t2_10 + (-0.73602145910263062) * gru_1_out_t2_11 + (-0.59054476022720337) * gru_1_out_t2_12 + (-0.12716332077980042) * gru_1_out_t2_13 + (-1.6511714458465576) * gru_1_out_t2_14 + (-0.30321499705314636) * gru_1_out_t2_15 + (0.22171027958393097) * gru_1_out_t2_16 + (-0.068590074777603149) * gru_1_out_t2_17 + (0.31444057822227478) * gru_1_out_t2_18 + (1.0799466371536255) * gru_1_out_t2_19 + (0.50510531663894653) * gru_1_out_t2_20 + (3.8064303398132324) * gru_1_out_t2_21 + (1.3906608819961548) * gru_1_out_t2_22 + (0.26195234060287476) * gru_1_out_t2_23 + (0.49083647131919861) * gru_1_out_t2_24 + (-0.24537220597267151) * gru_1_out_t2_25 + (-1.6803759336471558) * gru_1_out_t2_26 + (0.61915534734725952) * gru_1_out_t2_27 + (-0.1330350935459137) * gru_1_out_t2_28 + (1.0799399614334106) * gru_1_out_t2_29 + (0.85758894681930542) * gru_1_out_t2_30 + (0.27309077978134155) * gru_1_out_t2_31 + (-2.8091335296630859) * gru_1_out_t2_32 + (0.92818200588226318) * gru_1_out_t2_33 + (-2.220139741897583) * gru_1_out_t2_34 + (0.14235745370388031) * gru_1_out_t2_35 + (1.5910048484802246) * gru_1_out_t2_36 + (0.070388399064540863) * gru_1_out_t2_37 + (-0.83015519380569458) * gru_1_out_t2_38 + (0.94223159551620483) * gru_1_out_t2_39 + (-0.45813319087028503) * gru_1_out_t2_40 + (0.82719337940216064) * gru_1_out_t2_41 + (-0.25079643726348877) * gru_1_out_t2_42 + (-0.31412121653556824) * gru_1_out_t2_43 + (-0.11009091138839722) * gru_1_out_t2_44 + (-1.1761648654937744) * gru_1_out_t2_45 + (-2.6508095264434814) * gru_1_out_t2_46 + (3.3954782485961914) * gru_1_out_t2_47 + (-1.1861711740493774) * gru_1_out_t2_48 + (-0.38830450177192688) * gru_1_out_t2_49 + (0.28212225437164307) * gru_1_out_t2_50 + (1.7096714973449707) * gru_1_out_t2_51 + (0.73397660255432129) * gru_1_out_t2_52 + (0.48568400740623474) * gru_1_out_t2_53 + (0.86229574680328369) * gru_1_out_t2_54 + (-0.91182255744934082) * gru_1_out_t2_55 + (0.29025757312774658) * gru_1_out_t2_56 + (-0.33583298325538635) * gru_1_out_t2_57 + (0.24315902590751648) * gru_1_out_t2_58 + (-0.74120527505874634) * gru_1_out_t2_59 + (-0.81176543235778809) * gru_1_out_t2_60 + (-1.3458925485610962) * gru_1_out_t2_61 + (-2.5855891704559326) * gru_1_out_t2_62 + (1.2446860074996948) * gru_1_out_t2_63 + (-0.0034059467725455761) * gru_2_rev_t3_h_0 + (-0.054184474050998688) * gru_2_rev_t3_h_1 + (0.086148843169212341) * gru_2_rev_t3_h_2 + (0.011896795593202114) * gru_2_rev_t3_h_3 + (0.13679708540439606) * gru_2_rev_t3_h_4 + (-0.0076890490017831326) * gru_2_rev_t3_h_5 + (-0.099219679832458496) * gru_2_rev_t3_h_6 + (0.10414914041757584) * gru_2_rev_t3_h_7 + (-0.031078953295946121) * gru_2_rev_t3_h_8 + (0.11334952712059021) * gru_2_rev_t3_h_9 + (-0.16631864011287689) * gru_2_rev_t3_h_10 + (0.081313155591487885) * gru_2_rev_t3_h_11 + (0.11972984671592712) * gru_2_rev_t3_h_12 + (-0.18513631820678711) * gru_2_rev_t3_h_13 + (0.019385144114494324) * gru_2_rev_t3_h_14 + (0.072735972702503204) * gru_2_rev_t3_h_15 + (0.035554509609937668) * gru_2_rev_t3_h_16 + (-0.08243831992149353) * gru_2_rev_t3_h_17 + (-0.15170419216156006) * gru_2_rev_t3_h_18 + (0.095869556069374084) * gru_2_rev_t3_h_19 + (-0.026744022965431213) * gru_2_rev_t3_h_20 + (-0.12988376617431641) * gru_2_rev_t3_h_21 + (0.0089791892096400261) * gru_2_rev_t3_h_22 + (0.15028752386569977) * gru_2_rev_t3_h_23 + (-0.055935550481081009) * gru_2_rev_t3_h_24 + (-0.19820202887058258) * gru_2_rev_t3_h_25 + (0.030099965631961823) * gru_2_rev_t3_h_26 + (0.058990873396396637) * gru_2_rev_t3_h_27 + (-0.067862719297409058) * gru_2_rev_t3_h_28 + (-0.083733111619949341) * gru_2_rev_t3_h_29 + (-0.012692494317889214) * gru_2_rev_t3_h_30 + (0.08981100469827652) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((-0.23375150561332703) + (-0.4674394428730011) * gru_1_out_t2_0 + (-0.039301741868257523) * gru_1_out_t2_1 + (0.62791436910629272) * gru_1_out_t2_2 + (-0.046324986964464188) * gru_1_out_t2_3 + (0.52089995145797729) * gru_1_out_t2_4 + (-0.9625098705291748) * gru_1_out_t2_5 + (-0.13150021433830261) * gru_1_out_t2_6 + (0.3186127245426178) * gru_1_out_t2_7 + (0.060261614620685577) * gru_1_out_t2_8 + (-0.1381811797618866) * gru_1_out_t2_9 + (-0.84035247564315796) * gru_1_out_t2_10 + (-0.6682400107383728) * gru_1_out_t2_11 + (0.04548066109418869) * gru_1_out_t2_12 + (-0.12081862986087799) * gru_1_out_t2_13 + (-0.05027339980006218) * gru_1_out_t2_14 + (-0.094447970390319824) * gru_1_out_t2_15 + (-0.045370381325483322) * gru_1_out_t2_16 + (-0.052928682416677475) * gru_1_out_t2_17 + (-0.085824616253376007) * gru_1_out_t2_18 + (0.58046501874923706) * gru_1_out_t2_19 + (0.14083090424537659) * gru_1_out_t2_20 + (0.098325490951538086) * gru_1_out_t2_21 + (0.039205905050039291) * gru_1_out_t2_22 + (-0.18518008291721344) * gru_1_out_t2_23 + (-0.05732090026140213) * gru_1_out_t2_24 + (-0.30301710963249207) * gru_1_out_t2_25 + (0.092722706496715546) * gru_1_out_t2_26 + (0.40922152996063232) * gru_1_out_t2_27 + (-0.21823945641517639) * gru_1_out_t2_28 + (-0.23358751833438873) * gru_1_out_t2_29 + (-0.12645862996578217) * gru_1_out_t2_30 + (0.17386181652545929) * gru_1_out_t2_31 + (0.11981455236673355) * gru_1_out_t2_32 + (0.26067060232162476) * gru_1_out_t2_33 + (0.27301618456840515) * gru_1_out_t2_34 + (-0.39418959617614746) * gru_1_out_t2_35 + (-0.15523198246955872) * gru_1_out_t2_36 + (0.27875751256942749) * gru_1_out_t2_37 + (-0.067161671817302704) * gru_1_out_t2_38 + (0.020936502143740654) * gru_1_out_t2_39 + (-0.15442089736461639) * gru_1_out_t2_40 + (-0.14912939071655273) * gru_1_out_t2_41 + (0.25015935301780701) * gru_1_out_t2_42 + (0.71949470043182373) * gru_1_out_t2_43 + (0.050782535225152969) * gru_1_out_t2_44 + (-0.10370414704084396) * gru_1_out_t2_45 + (0.11702822148799896) * gru_1_out_t2_46 + (-0.29203048348426819) * gru_1_out_t2_47 + (0.21075592935085297) * gru_1_out_t2_48 + (-0.44223180413246155) * gru_1_out_t2_49 + (0.073264218866825104) * gru_1_out_t2_50 + (-0.25770214200019836) * gru_1_out_t2_51 + (-0.0030673765577375889) * gru_1_out_t2_52 + (0.37885704636573792) * gru_1_out_t2_53 + (-0.21672411262989044) * gru_1_out_t2_54 + (0.040183451026678085) * gru_1_out_t2_55 + (0.17721675336360931) * gru_1_out_t2_56 + (-0.24422821402549744) * gru_1_out_t2_57 + (0.081740707159042358) * gru_1_out_t2_58 + (0.39740920066833496) * gru_1_out_t2_59 + (0.12562514841556549) * gru_1_out_t2_60 + (-0.048601269721984863) * gru_1_out_t2_61 + (0.57756048440933228) * gru_1_out_t2_62 + (0.10028287768363953) * gru_1_out_t2_63 + (0.15814022719860077) * gru_2_rev_t3_h_0 + (-0.10553427040576935) * gru_2_rev_t3_h_1 + (0.22172187268733978) * gru_2_rev_t3_h_2 + (0.10554210841655731) * gru_2_rev_t3_h_3 + (-0.082108601927757263) * gru_2_rev_t3_h_4 + (-0.034656736999750137) * gru_2_rev_t3_h_5 + (-0.13304536044597626) * gru_2_rev_t3_h_6 + (-0.10555379837751389) * gru_2_rev_t3_h_7 + (0.079316914081573486) * gru_2_rev_t3_h_8 + (-0.15813213586807251) * gru_2_rev_t3_h_9 + (-0.026995478197932243) * gru_2_rev_t3_h_10 + (-0.037659082561731339) * gru_2_rev_t3_h_11 + (-0.0034030235838145018) * gru_2_rev_t3_h_12 + (-0.07206503301858902) * gru_2_rev_t3_h_13 + (0.014868317171931267) * gru_2_rev_t3_h_14 + (-0.085808522999286652) * gru_2_rev_t3_h_15 + (0.049420721828937531) * gru_2_rev_t3_h_16 + (0.0011400568764656782) * gru_2_rev_t3_h_17 + (-0.019607318565249443) * gru_2_rev_t3_h_18 + (-0.13456843793392181) * gru_2_rev_t3_h_19 + (0.12759627401828766) * gru_2_rev_t3_h_20 + (0.013828796334564686) * gru_2_rev_t3_h_21 + (0.062844656407833099) * gru_2_rev_t3_h_22 + (0.18873590230941772) * gru_2_rev_t3_h_23 + (-0.056642230600118637) * gru_2_rev_t3_h_24 + (-0.045726638287305832) * gru_2_rev_t3_h_25 + (-0.0090838372707366943) * gru_2_rev_t3_h_26 + (0.24103488028049469) * gru_2_rev_t3_h_27 + (0.028936441987752914) * gru_2_rev_t3_h_28 + (-0.090673498809337616) * gru_2_rev_t3_h_29 + (-0.064370468258857727) * gru_2_rev_t3_h_30 + (0.023201234638690948) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.39274618029594421) + (0.45162102580070496) * gru_1_out_t2_0 + (0.56265127658843994) * gru_1_out_t2_1 + (-0.11764693260192871) * gru_1_out_t2_2 + (-0.087964475154876709) * gru_1_out_t2_3 + (-0.5026366114616394) * gru_1_out_t2_4 + (-0.22815628349781036) * gru_1_out_t2_5 + (0.10606898367404938) * gru_1_out_t2_6 + (-0.35891282558441162) * gru_1_out_t2_7 + (-0.42808377742767334) * gru_1_out_t2_8 + (-0.34395062923431396) * gru_1_out_t2_9 + (0.394979327917099) * gru_1_out_t2_10 + (-0.12251348793506622) * gru_1_out_t2_11 + (0.14665156602859497) * gru_1_out_t2_12 + (-0.44121018052101135) * gru_1_out_t2_13 + (-0.7250707745552063) * gru_1_out_t2_14 + (0.14538778364658356) * gru_1_out_t2_15 + (-0.38179191946983337) * gru_1_out_t2_16 + (-0.78516536951065063) * gru_1_out_t2_17 + (0.16512423753738403) * gru_1_out_t2_18 + (0.097306117415428162) * gru_1_out_t2_19 + (0.20151251554489136) * gru_1_out_t2_20 + (0.40493464469909668) * gru_1_out_t2_21 + (-0.16031484305858612) * gru_1_out_t2_22 + (1.4690033197402954) * gru_1_out_t2_23 + (0.088088259100914001) * gru_1_out_t2_24 + (0.17203868925571442) * gru_1_out_t2_25 + (-0.46422892808914185) * gru_1_out_t2_26 + (0.023816622793674469) * gru_1_out_t2_27 + (2.1247744560241699) * gru_1_out_t2_28 + (0.044469460844993591) * gru_1_out_t2_29 + (-0.8585885763168335) * gru_1_out_t2_30 + (0.51625031232833862) * gru_1_out_t2_31 + (0.74000781774520874) * gru_1_out_t2_32 + (0.26306745409965515) * gru_1_out_t2_33 + (0.10024475306272507) * gru_1_out_t2_34 + (-0.012399571947753429) * gru_1_out_t2_35 + (-0.028310969471931458) * gru_1_out_t2_36 + (-0.12583251297473907) * gru_1_out_t2_37 + (-1.9625841379165649) * gru_1_out_t2_38 + (0.60986733436584473) * gru_1_out_t2_39 + (-0.51223552227020264) * gru_1_out_t2_40 + (0.65830516815185547) * gru_1_out_t2_41 + (-0.91668367385864258) * gru_1_out_t2_42 + (-0.71997886896133423) * gru_1_out_t2_43 + (-0.28440412878990173) * gru_1_out_t2_44 + (-0.8186379075050354) * gru_1_out_t2_45 + (-3.0750877857208252) * gru_1_out_t2_46 + (0.35795596241950989) * gru_1_out_t2_47 + (-0.45460778474807739) * gru_1_out_t2_48 + (0.26644036173820496) * gru_1_out_t2_49 + (-0.48241239786148071) * gru_1_out_t2_50 + (2.6430160999298096) * gru_1_out_t2_51 + (1.1829671859741211) * gru_1_out_t2_52 + (0.8838086724281311) * gru_1_out_t2_53 + (-0.63012504577636719) * gru_1_out_t2_54 + (0.023300549015402794) * gru_1_out_t2_55 + (0.20606166124343872) * gru_1_out_t2_56 + (-0.11747610569000244) * gru_1_out_t2_57 + (0.34311956167221069) * gru_1_out_t2_58 + (0.65120655298233032) * gru_1_out_t2_59 + (-0.70536959171295166) * gru_1_out_t2_60 + (0.067961111664772034) * gru_1_out_t2_61 + (0.10535656660795212) * gru_1_out_t2_62 + (0.63914477825164795) * gru_1_out_t2_63 + gate_r * ((1.6404441595077515) + (-0.011652657762169838) * gru_2_rev_t3_h_0 + (-0.037940390408039093) * gru_2_rev_t3_h_1 + (0.17868505418300629) * gru_2_rev_t3_h_2 + (-0.13442879915237427) * gru_2_rev_t3_h_3 + (0.060014475136995316) * gru_2_rev_t3_h_4 + (0.091816268861293793) * gru_2_rev_t3_h_5 + (0.057029478251934052) * gru_2_rev_t3_h_6 + (0.11586004495620728) * gru_2_rev_t3_h_7 + (-0.077573634684085846) * gru_2_rev_t3_h_8 + (-0.0069155031815171242) * gru_2_rev_t3_h_9 + (-0.034618284553289413) * gru_2_rev_t3_h_10 + (-0.21348942816257477) * gru_2_rev_t3_h_11 + (-0.084686793386936188) * gru_2_rev_t3_h_12 + (-0.10732194781303406) * gru_2_rev_t3_h_13 + (0.12922148406505585) * gru_2_rev_t3_h_14 + (-0.11253689974546432) * gru_2_rev_t3_h_15 + (0.02387319877743721) * gru_2_rev_t3_h_16 + (-0.064370065927505493) * gru_2_rev_t3_h_17 + (0.072794400155544281) * gru_2_rev_t3_h_18 + (0.043783966451883316) * gru_2_rev_t3_h_19 + (-0.21004694700241089) * gru_2_rev_t3_h_20 + (0.08714255690574646) * gru_2_rev_t3_h_21 + (-0.077719748020172119) * gru_2_rev_t3_h_22 + (-0.015530373901128769) * gru_2_rev_t3_h_23 + (-0.10157351940870285) * gru_2_rev_t3_h_24 + (-0.093320637941360474) * gru_2_rev_t3_h_25 + (0.0090476293116807938) * gru_2_rev_t3_h_26 + (0.12915535271167755) * gru_2_rev_t3_h_27 + (0.032315276563167572) * gru_2_rev_t3_h_28 + (-0.14171095192432404) * gru_2_rev_t3_h_29 + (-0.008086727000772953) * gru_2_rev_t3_h_30 + (-0.088494911789894104) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_9 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_9;
    // h=10
    gate_r = sigmoid((1.6573562622070312) + (0.74420821666717529) * gru_1_out_t2_0 + (0.24159027636051178) * gru_1_out_t2_1 + (-0.45785349607467651) * gru_1_out_t2_2 + (-0.15820348262786865) * gru_1_out_t2_3 + (-0.98328256607055664) * gru_1_out_t2_4 + (-0.30548581480979919) * gru_1_out_t2_5 + (-0.84648966789245605) * gru_1_out_t2_6 + (-0.43292820453643799) * gru_1_out_t2_7 + (-0.095287598669528961) * gru_1_out_t2_8 + (-0.099906273186206818) * gru_1_out_t2_9 + (0.85364365577697754) * gru_1_out_t2_10 + (0.10257240384817123) * gru_1_out_t2_11 + (0.56893700361251831) * gru_1_out_t2_12 + (0.55336064100265503) * gru_1_out_t2_13 + (-0.43969696760177612) * gru_1_out_t2_14 + (0.33809617161750793) * gru_1_out_t2_15 + (-1.0441594123840332) * gru_1_out_t2_16 + (-0.2407149076461792) * gru_1_out_t2_17 + (0.40487509965896606) * gru_1_out_t2_18 + (-0.11462440341711044) * gru_1_out_t2_19 + (-0.38037967681884766) * gru_1_out_t2_20 + (-0.061736788600683212) * gru_1_out_t2_21 + (-0.97807163000106812) * gru_1_out_t2_22 + (-0.32937046885490417) * gru_1_out_t2_23 + (0.66118299961090088) * gru_1_out_t2_24 + (0.2741924524307251) * gru_1_out_t2_25 + (0.51142561435699463) * gru_1_out_t2_26 + (-0.72644567489624023) * gru_1_out_t2_27 + (-0.40599867701530457) * gru_1_out_t2_28 + (0.049045193940401077) * gru_1_out_t2_29 + (0.47868889570236206) * gru_1_out_t2_30 + (0.086630970239639282) * gru_1_out_t2_31 + (0.13832724094390869) * gru_1_out_t2_32 + (-0.085709057748317719) * gru_1_out_t2_33 + (0.14447031915187836) * gru_1_out_t2_34 + (0.052218176424503326) * gru_1_out_t2_35 + (-0.14127032458782196) * gru_1_out_t2_36 + (0.44670677185058594) * gru_1_out_t2_37 + (-0.16808396577835083) * gru_1_out_t2_38 + (0.53353643417358398) * gru_1_out_t2_39 + (-0.37512171268463135) * gru_1_out_t2_40 + (0.45429638028144836) * gru_1_out_t2_41 + (0.030687186866998672) * gru_1_out_t2_42 + (-0.28887975215911865) * gru_1_out_t2_43 + (-0.23167923092842102) * gru_1_out_t2_44 + (-0.47692742943763733) * gru_1_out_t2_45 + (-0.4668368399143219) * gru_1_out_t2_46 + (-0.40991055965423584) * gru_1_out_t2_47 + (0.048683378845453262) * gru_1_out_t2_48 + (0.44615903496742249) * gru_1_out_t2_49 + (-0.53203397989273071) * gru_1_out_t2_50 + (0.58708232641220093) * gru_1_out_t2_51 + (-0.097785159945487976) * gru_1_out_t2_52 + (0.12324564158916473) * gru_1_out_t2_53 + (0.21384990215301514) * gru_1_out_t2_54 + (0.53613603115081787) * gru_1_out_t2_55 + (-0.1236562505364418) * gru_1_out_t2_56 + (0.61460584402084351) * gru_1_out_t2_57 + (0.6284986138343811) * gru_1_out_t2_58 + (0.12684181332588196) * gru_1_out_t2_59 + (-0.15662963688373566) * gru_1_out_t2_60 + (-0.15916508436203003) * gru_1_out_t2_61 + (0.35567364096641541) * gru_1_out_t2_62 + (0.52722805738449097) * gru_1_out_t2_63 + (0.017148185521364212) * gru_2_rev_t3_h_0 + (0.0029744049534201622) * gru_2_rev_t3_h_1 + (0.034549910575151443) * gru_2_rev_t3_h_2 + (-0.16972553730010986) * gru_2_rev_t3_h_3 + (0.016145342960953712) * gru_2_rev_t3_h_4 + (-0.064368695020675659) * gru_2_rev_t3_h_5 + (0.073713436722755432) * gru_2_rev_t3_h_6 + (0.071459032595157623) * gru_2_rev_t3_h_7 + (-0.072612017393112183) * gru_2_rev_t3_h_8 + (-0.036934677511453629) * gru_2_rev_t3_h_9 + (-0.031399257481098175) * gru_2_rev_t3_h_10 + (-0.055882468819618225) * gru_2_rev_t3_h_11 + (-0.037620317190885544) * gru_2_rev_t3_h_12 + (-0.11011838167905807) * gru_2_rev_t3_h_13 + (0.01492758747190237) * gru_2_rev_t3_h_14 + (-0.1145339161157608) * gru_2_rev_t3_h_15 + (-0.042628727853298187) * gru_2_rev_t3_h_16 + (-0.054931037127971649) * gru_2_rev_t3_h_17 + (-0.13618510961532593) * gru_2_rev_t3_h_18 + (0.00062985398108139634) * gru_2_rev_t3_h_19 + (-0.075578108429908752) * gru_2_rev_t3_h_20 + (0.047835774719715118) * gru_2_rev_t3_h_21 + (0.03163398802280426) * gru_2_rev_t3_h_22 + (0.00066971831256523728) * gru_2_rev_t3_h_23 + (-0.040736224502325058) * gru_2_rev_t3_h_24 + (0.040373548865318298) * gru_2_rev_t3_h_25 + (0.071426793932914734) * gru_2_rev_t3_h_26 + (-0.090229138731956482) * gru_2_rev_t3_h_27 + (0.19996447861194611) * gru_2_rev_t3_h_28 + (0.14647203683853149) * gru_2_rev_t3_h_29 + (-0.068239606916904449) * gru_2_rev_t3_h_30 + (0.013883091509342194) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.017680613324046135) + (-0.16958534717559814) * gru_1_out_t2_0 + (0.0049692131578922272) * gru_1_out_t2_1 + (0.69258427619934082) * gru_1_out_t2_2 + (0.64224702119827271) * gru_1_out_t2_3 + (0.58346813917160034) * gru_1_out_t2_4 + (0.29848098754882812) * gru_1_out_t2_5 + (-0.012328849174082279) * gru_1_out_t2_6 + (0.29267686605453491) * gru_1_out_t2_7 + (-0.37616744637489319) * gru_1_out_t2_8 + (0.024770991876721382) * gru_1_out_t2_9 + (-0.40454679727554321) * gru_1_out_t2_10 + (-0.78244024515151978) * gru_1_out_t2_11 + (-0.16874715685844421) * gru_1_out_t2_12 + (-0.13272006809711456) * gru_1_out_t2_13 + (-0.0084450924769043922) * gru_1_out_t2_14 + (-0.26570779085159302) * gru_1_out_t2_15 + (-0.13253344595432281) * gru_1_out_t2_16 + (-0.083291135728359222) * gru_1_out_t2_17 + (0.076667889952659607) * gru_1_out_t2_18 + (-0.029406089335680008) * gru_1_out_t2_19 + (0.11921007186174393) * gru_1_out_t2_20 + (0.135454460978508) * gru_1_out_t2_21 + (0.13013485074043274) * gru_1_out_t2_22 + (0.11663292348384857) * gru_1_out_t2_23 + (-0.099027708172798157) * gru_1_out_t2_24 + (-0.11747223883867264) * gru_1_out_t2_25 + (-0.13577431440353394) * gru_1_out_t2_26 + (0.073717020452022552) * gru_1_out_t2_27 + (-0.32056376338005066) * gru_1_out_t2_28 + (-0.34532320499420166) * gru_1_out_t2_29 + (-0.36071309447288513) * gru_1_out_t2_30 + (-0.21737091243267059) * gru_1_out_t2_31 + (-0.60582727193832397) * gru_1_out_t2_32 + (-0.27761790156364441) * gru_1_out_t2_33 + (0.50261837244033813) * gru_1_out_t2_34 + (-0.22476260364055634) * gru_1_out_t2_35 + (0.25740531086921692) * gru_1_out_t2_36 + (-0.085409827530384064) * gru_1_out_t2_37 + (0.063565537333488464) * gru_1_out_t2_38 + (-0.046089768409729004) * gru_1_out_t2_39 + (-0.188197061419487) * gru_1_out_t2_40 + (0.29200237989425659) * gru_1_out_t2_41 + (0.48675033450126648) * gru_1_out_t2_42 + (0.17673458158969879) * gru_1_out_t2_43 + (-0.35782745480537415) * gru_1_out_t2_44 + (-0.19661261141300201) * gru_1_out_t2_45 + (-0.41485807299613953) * gru_1_out_t2_46 + (-0.28009909391403198) * gru_1_out_t2_47 + (0.13361704349517822) * gru_1_out_t2_48 + (-0.46436911821365356) * gru_1_out_t2_49 + (0.22756065428256989) * gru_1_out_t2_50 + (-0.068248845636844635) * gru_1_out_t2_51 + (-0.038457822054624557) * gru_1_out_t2_52 + (-0.025593800470232964) * gru_1_out_t2_53 + (-0.43600180745124817) * gru_1_out_t2_54 + (-0.051534947007894516) * gru_1_out_t2_55 + (0.21534013748168945) * gru_1_out_t2_56 + (-0.12158592790365219) * gru_1_out_t2_57 + (-0.11886131018400192) * gru_1_out_t2_58 + (-0.022168699651956558) * gru_1_out_t2_59 + (0.088109292089939117) * gru_1_out_t2_60 + (0.12734299898147583) * gru_1_out_t2_61 + (-0.032492998987436295) * gru_1_out_t2_62 + (0.092356540262699127) * gru_1_out_t2_63 + (-0.11129166930913925) * gru_2_rev_t3_h_0 + (0.065428465604782104) * gru_2_rev_t3_h_1 + (-0.048623997718095779) * gru_2_rev_t3_h_2 + (0.05840686708688736) * gru_2_rev_t3_h_3 + (-0.077950514853000641) * gru_2_rev_t3_h_4 + (0.023977803066372871) * gru_2_rev_t3_h_5 + (-0.0073264753445982933) * gru_2_rev_t3_h_6 + (0.016382848843932152) * gru_2_rev_t3_h_7 + (-0.12315144389867783) * gru_2_rev_t3_h_8 + (-0.11690162867307663) * gru_2_rev_t3_h_9 + (0.055007670074701309) * gru_2_rev_t3_h_10 + (-0.022933833301067352) * gru_2_rev_t3_h_11 + (0.12046058475971222) * gru_2_rev_t3_h_12 + (-0.066774986684322357) * gru_2_rev_t3_h_13 + (0.088978931307792664) * gru_2_rev_t3_h_14 + (0.035688076168298721) * gru_2_rev_t3_h_15 + (0.059373568743467331) * gru_2_rev_t3_h_16 + (-0.052913408726453781) * gru_2_rev_t3_h_17 + (-0.0039315437898039818) * gru_2_rev_t3_h_18 + (0.017533613368868828) * gru_2_rev_t3_h_19 + (0.24838171899318695) * gru_2_rev_t3_h_20 + (-0.016870051622390747) * gru_2_rev_t3_h_21 + (0.065906397998332977) * gru_2_rev_t3_h_22 + (0.068825513124465942) * gru_2_rev_t3_h_23 + (-0.14451423287391663) * gru_2_rev_t3_h_24 + (-0.088785402476787567) * gru_2_rev_t3_h_25 + (0.0010152184404432774) * gru_2_rev_t3_h_26 + (-0.26478743553161621) * gru_2_rev_t3_h_27 + (0.01057736948132515) * gru_2_rev_t3_h_28 + (0.087836824357509613) * gru_2_rev_t3_h_29 + (-0.066227681934833527) * gru_2_rev_t3_h_30 + (-0.0056648054160177708) * gru_2_rev_t3_h_31);
    gate_n = tanh((-0.69453221559524536) + (-0.9283987283706665) * gru_1_out_t2_0 + (-2.5262739658355713) * gru_1_out_t2_1 + (0.43966206908226013) * gru_1_out_t2_2 + (-0.41518869996070862) * gru_1_out_t2_3 + (0.8633575439453125) * gru_1_out_t2_4 + (-0.88166797161102295) * gru_1_out_t2_5 + (-0.73185956478118896) * gru_1_out_t2_6 + (-0.047279767692089081) * gru_1_out_t2_7 + (-0.054359883069992065) * gru_1_out_t2_8 + (-0.54556775093078613) * gru_1_out_t2_9 + (-0.57946830987930298) * gru_1_out_t2_10 + (-1.7942317724227905) * gru_1_out_t2_11 + (0.093747936189174652) * gru_1_out_t2_12 + (0.041902463883161545) * gru_1_out_t2_13 + (-0.027578158304095268) * gru_1_out_t2_14 + (0.40143033862113953) * gru_1_out_t2_15 + (0.65442883968353271) * gru_1_out_t2_16 + (0.45563775300979614) * gru_1_out_t2_17 + (-0.40736815333366394) * gru_1_out_t2_18 + (-0.82904297113418579) * gru_1_out_t2_19 + (-0.31414312124252319) * gru_1_out_t2_20 + (0.11581448465585709) * gru_1_out_t2_21 + (0.63225442171096802) * gru_1_out_t2_22 + (-0.55892455577850342) * gru_1_out_t2_23 + (0.48975846171379089) * gru_1_out_t2_24 + (0.42612993717193604) * gru_1_out_t2_25 + (-0.18953073024749756) * gru_1_out_t2_26 + (0.68547630310058594) * gru_1_out_t2_27 + (-0.60207104682922363) * gru_1_out_t2_28 + (0.32619833946228027) * gru_1_out_t2_29 + (0.51973479986190796) * gru_1_out_t2_30 + (-0.12107767164707184) * gru_1_out_t2_31 + (0.0082154497504234314) * gru_1_out_t2_32 + (-0.56944555044174194) * gru_1_out_t2_33 + (0.81649923324584961) * gru_1_out_t2_34 + (0.0019860633183270693) * gru_1_out_t2_35 + (-1.3295973539352417) * gru_1_out_t2_36 + (0.47142067551612854) * gru_1_out_t2_37 + (3.0335874557495117) * gru_1_out_t2_38 + (-1.428216814994812) * gru_1_out_t2_39 + (0.59023576974868774) * gru_1_out_t2_40 + (-1.6842174530029297) * gru_1_out_t2_41 + (0.21800883114337921) * gru_1_out_t2_42 + (1.2956506013870239) * gru_1_out_t2_43 + (-0.57000494003295898) * gru_1_out_t2_44 + (0.97534960508346558) * gru_1_out_t2_45 + (1.3986485004425049) * gru_1_out_t2_46 + (-0.28521785140037537) * gru_1_out_t2_47 + (0.670021653175354) * gru_1_out_t2_48 + (-0.050594426691532135) * gru_1_out_t2_49 + (0.99582254886627197) * gru_1_out_t2_50 + (-0.96875590085983276) * gru_1_out_t2_51 + (-1.3601227998733521) * gru_1_out_t2_52 + (-0.90336894989013672) * gru_1_out_t2_53 + (0.0025520226918160915) * gru_1_out_t2_54 + (-1.2225130796432495) * gru_1_out_t2_55 + (1.3654215335845947) * gru_1_out_t2_56 + (-0.97519296407699585) * gru_1_out_t2_57 + (-0.87750697135925293) * gru_1_out_t2_58 + (1.2667268514633179) * gru_1_out_t2_59 + (0.97954171895980835) * gru_1_out_t2_60 + (-0.028523528948426247) * gru_1_out_t2_61 + (0.35927245020866394) * gru_1_out_t2_62 + (-0.44772297143936157) * gru_1_out_t2_63 + gate_r * ((-0.67722666263580322) + (0.1463436633348465) * gru_2_rev_t3_h_0 + (-0.013019487261772156) * gru_2_rev_t3_h_1 + (0.072544433176517487) * gru_2_rev_t3_h_2 + (0.14753609895706177) * gru_2_rev_t3_h_3 + (0.11952804774045944) * gru_2_rev_t3_h_4 + (-0.16732721030712128) * gru_2_rev_t3_h_5 + (-0.029784955084323883) * gru_2_rev_t3_h_6 + (0.034872580319643021) * gru_2_rev_t3_h_7 + (0.029430082067847252) * gru_2_rev_t3_h_8 + (-0.017758112400770187) * gru_2_rev_t3_h_9 + (-0.090939432382583618) * gru_2_rev_t3_h_10 + (-0.11654572188854218) * gru_2_rev_t3_h_11 + (0.19212597608566284) * gru_2_rev_t3_h_12 + (0.021871736273169518) * gru_2_rev_t3_h_13 + (0.090522915124893188) * gru_2_rev_t3_h_14 + (-0.028119362890720367) * gru_2_rev_t3_h_15 + (-0.13253740966320038) * gru_2_rev_t3_h_16 + (-0.15821754932403564) * gru_2_rev_t3_h_17 + (0.08676464855670929) * gru_2_rev_t3_h_18 + (0.020772682502865791) * gru_2_rev_t3_h_19 + (0.065163403749465942) * gru_2_rev_t3_h_20 + (-0.009366932325065136) * gru_2_rev_t3_h_21 + (-0.12174586951732635) * gru_2_rev_t3_h_22 + (0.071316346526145935) * gru_2_rev_t3_h_23 + (0.051304798573255539) * gru_2_rev_t3_h_24 + (0.055670302361249924) * gru_2_rev_t3_h_25 + (0.073112420737743378) * gru_2_rev_t3_h_26 + (-0.099939271807670593) * gru_2_rev_t3_h_27 + (0.11835439503192902) * gru_2_rev_t3_h_28 + (-0.0056306859478354454) * gru_2_rev_t3_h_29 + (0.11342662572860718) * gru_2_rev_t3_h_30 + (0.079959556460380554) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_10 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_10;
    // h=11
    gate_r = sigmoid((0.53601396083831787) + (0.42954179644584656) * gru_1_out_t2_0 + (1.0687710046768188) * gru_1_out_t2_1 + (0.21991240978240967) * gru_1_out_t2_2 + (0.57143348455429077) * gru_1_out_t2_3 + (-0.17299522459506989) * gru_1_out_t2_4 + (-0.82258343696594238) * gru_1_out_t2_5 + (1.5436466932296753) * gru_1_out_t2_6 + (-0.13836486637592316) * gru_1_out_t2_7 + (0.98866164684295654) * gru_1_out_t2_8 + (-0.38555166125297546) * gru_1_out_t2_9 + (0.27042341232299805) * gru_1_out_t2_10 + (-0.057534977793693542) * gru_1_out_t2_11 + (1.199338436126709) * gru_1_out_t2_12 + (0.043413922190666199) * gru_1_out_t2_13 + (3.3316972255706787) * gru_1_out_t2_14 + (0.32432606816291809) * gru_1_out_t2_15 + (-0.16388466954231262) * gru_1_out_t2_16 + (0.60016626119613647) * gru_1_out_t2_17 + (-0.037039056420326233) * gru_1_out_t2_18 + (1.0389169454574585) * gru_1_out_t2_19 + (0.14160344004631042) * gru_1_out_t2_20 + (-0.51587933301925659) * gru_1_out_t2_21 + (-0.45933371782302856) * gru_1_out_t2_22 + (0.38056612014770508) * gru_1_out_t2_23 + (4.4127984046936035) * gru_1_out_t2_24 + (0.34731999039649963) * gru_1_out_t2_25 + (-4.5314321517944336) * gru_1_out_t2_26 + (-0.50726199150085449) * gru_1_out_t2_27 + (0.089509449899196625) * gru_1_out_t2_28 + (0.53662651777267456) * gru_1_out_t2_29 + (0.9408373236656189) * gru_1_out_t2_30 + (-0.084471091628074646) * gru_1_out_t2_31 + (0.49875164031982422) * gru_1_out_t2_32 + (1.7548445463180542) * gru_1_out_t2_33 + (0.70650798082351685) * gru_1_out_t2_34 + (0.21600049734115601) * gru_1_out_t2_35 + (-0.69571727514266968) * gru_1_out_t2_36 + (0.14778988063335419) * gru_1_out_t2_37 + (1.3538656234741211) * gru_1_out_t2_38 + (-1.2213878631591797) * gru_1_out_t2_39 + (1.7144043445587158) * gru_1_out_t2_40 + (-1.0445877313613892) * gru_1_out_t2_41 + (-1.5678838491439819) * gru_1_out_t2_42 + (1.6129311323165894) * gru_1_out_t2_43 + (-0.38988006114959717) * gru_1_out_t2_44 + (2.510817289352417) * gru_1_out_t2_45 + (-1.8450450897216797) * gru_1_out_t2_46 + (0.075626887381076813) * gru_1_out_t2_47 + (-0.2844369113445282) * gru_1_out_t2_48 + (0.29274943470954895) * gru_1_out_t2_49 + (-1.0171365737915039) * gru_1_out_t2_50 + (0.24677857756614685) * gru_1_out_t2_51 + (-1.4239758253097534) * gru_1_out_t2_52 + (-3.3014612197875977) * gru_1_out_t2_53 + (1.5874487161636353) * gru_1_out_t2_54 + (-1.4969521760940552) * gru_1_out_t2_55 + (0.4540630578994751) * gru_1_out_t2_56 + (0.009444650262594223) * gru_1_out_t2_57 + (-0.060405407100915909) * gru_1_out_t2_58 + (0.50370901823043823) * gru_1_out_t2_59 + (-3.5559279918670654) * gru_1_out_t2_60 + (-1.7014693021774292) * gru_1_out_t2_61 + (-1.3061966896057129) * gru_1_out_t2_62 + (-1.006420373916626) * gru_1_out_t2_63 + (0.19949178397655487) * gru_2_rev_t3_h_0 + (0.21461252868175507) * gru_2_rev_t3_h_1 + (0.054434068500995636) * gru_2_rev_t3_h_2 + (0.11477711796760559) * gru_2_rev_t3_h_3 + (0.045871667563915253) * gru_2_rev_t3_h_4 + (-0.22524654865264893) * gru_2_rev_t3_h_5 + (-0.0005570192588493228) * gru_2_rev_t3_h_6 + (-0.04621506854891777) * gru_2_rev_t3_h_7 + (-0.091551467776298523) * gru_2_rev_t3_h_8 + (-0.064279139041900635) * gru_2_rev_t3_h_9 + (-0.14710031449794769) * gru_2_rev_t3_h_10 + (0.10074635595083237) * gru_2_rev_t3_h_11 + (-0.065957129001617432) * gru_2_rev_t3_h_12 + (-0.0038617381360381842) * gru_2_rev_t3_h_13 + (-0.042712129652500153) * gru_2_rev_t3_h_14 + (-0.054776638746261597) * gru_2_rev_t3_h_15 + (0.19894658029079437) * gru_2_rev_t3_h_16 + (0.1255328506231308) * gru_2_rev_t3_h_17 + (-0.087226241827011108) * gru_2_rev_t3_h_18 + (-0.061505619436502457) * gru_2_rev_t3_h_19 + (-0.048184134066104889) * gru_2_rev_t3_h_20 + (-0.006785927340388298) * gru_2_rev_t3_h_21 + (-0.053786598145961761) * gru_2_rev_t3_h_22 + (0.070645041763782501) * gru_2_rev_t3_h_23 + (0.16728056967258453) * gru_2_rev_t3_h_24 + (-0.15978220105171204) * gru_2_rev_t3_h_25 + (0.17660298943519592) * gru_2_rev_t3_h_26 + (-0.018045706674456596) * gru_2_rev_t3_h_27 + (-0.030615739524364471) * gru_2_rev_t3_h_28 + (0.054617714136838913) * gru_2_rev_t3_h_29 + (0.17594870924949646) * gru_2_rev_t3_h_30 + (0.18190592527389526) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.12318301200866699) + (0.084694944322109222) * gru_1_out_t2_0 + (0.3448052704334259) * gru_1_out_t2_1 + (0.46347135305404663) * gru_1_out_t2_2 + (0.046601776033639908) * gru_1_out_t2_3 + (0.068791940808296204) * gru_1_out_t2_4 + (-0.075450055301189423) * gru_1_out_t2_5 + (-0.10797911137342453) * gru_1_out_t2_6 + (-0.032003819942474365) * gru_1_out_t2_7 + (-0.11852442473173141) * gru_1_out_t2_8 + (-0.1955605149269104) * gru_1_out_t2_9 + (0.2598051130771637) * gru_1_out_t2_10 + (-0.15226081013679504) * gru_1_out_t2_11 + (-0.047324091196060181) * gru_1_out_t2_12 + (-0.0085836527869105339) * gru_1_out_t2_13 + (-0.3780343234539032) * gru_1_out_t2_14 + (-0.37210214138031006) * gru_1_out_t2_15 + (0.126527339220047) * gru_1_out_t2_16 + (0.56247341632843018) * gru_1_out_t2_17 + (-0.015653656795620918) * gru_1_out_t2_18 + (0.3253263533115387) * gru_1_out_t2_19 + (0.19556199014186859) * gru_1_out_t2_20 + (-0.14981582760810852) * gru_1_out_t2_21 + (-0.42895689606666565) * gru_1_out_t2_22 + (0.2187378853559494) * gru_1_out_t2_23 + (0.20379173755645752) * gru_1_out_t2_24 + (-0.19297736883163452) * gru_1_out_t2_25 + (0.35717427730560303) * gru_1_out_t2_26 + (-0.28514713048934937) * gru_1_out_t2_27 + (1.0748878717422485) * gru_1_out_t2_28 + (0.016711262986063957) * gru_1_out_t2_29 + (-0.53828519582748413) * gru_1_out_t2_30 + (-0.36063855886459351) * gru_1_out_t2_31 + (0.016768995672464371) * gru_1_out_t2_32 + (-0.090539388358592987) * gru_1_out_t2_33 + (-0.028506943956017494) * gru_1_out_t2_34 + (-0.34987103939056396) * gru_1_out_t2_35 + (0.053747523576021194) * gru_1_out_t2_36 + (0.023943016305565834) * gru_1_out_t2_37 + (0.071831174194812775) * gru_1_out_t2_38 + (0.26462393999099731) * gru_1_out_t2_39 + (0.063947431743144989) * gru_1_out_t2_40 + (-0.34072157740592957) * gru_1_out_t2_41 + (0.17258921265602112) * gru_1_out_t2_42 + (-1.4310466051101685) * gru_1_out_t2_43 + (0.11105348914861679) * gru_1_out_t2_44 + (-0.028331084176898003) * gru_1_out_t2_45 + (0.55217170715332031) * gru_1_out_t2_46 + (-0.51852381229400635) * gru_1_out_t2_47 + (-0.0030800150707364082) * gru_1_out_t2_48 + (0.14299939572811127) * gru_1_out_t2_49 + (-0.10522697865962982) * gru_1_out_t2_50 + (0.072540655732154846) * gru_1_out_t2_51 + (0.20863223075866699) * gru_1_out_t2_52 + (0.42647254467010498) * gru_1_out_t2_53 + (-0.30148294568061829) * gru_1_out_t2_54 + (-0.1785128265619278) * gru_1_out_t2_55 + (0.19447137415409088) * gru_1_out_t2_56 + (-0.078256003558635712) * gru_1_out_t2_57 + (0.16517511010169983) * gru_1_out_t2_58 + (0.31383615732192993) * gru_1_out_t2_59 + (-0.35167026519775391) * gru_1_out_t2_60 + (1.3033316135406494) * gru_1_out_t2_61 + (0.27903857827186584) * gru_1_out_t2_62 + (-0.0079913754016160965) * gru_1_out_t2_63 + (-0.080582655966281891) * gru_2_rev_t3_h_0 + (-0.0027013244107365608) * gru_2_rev_t3_h_1 + (-0.23095034062862396) * gru_2_rev_t3_h_2 + (0.013874229043722153) * gru_2_rev_t3_h_3 + (0.037199843674898148) * gru_2_rev_t3_h_4 + (-0.042343553155660629) * gru_2_rev_t3_h_5 + (-0.10402971506118774) * gru_2_rev_t3_h_6 + (-0.069984748959541321) * gru_2_rev_t3_h_7 + (-0.032317359000444412) * gru_2_rev_t3_h_8 + (0.26229196786880493) * gru_2_rev_t3_h_9 + (0.098558336496353149) * gru_2_rev_t3_h_10 + (-0.10629985481500626) * gru_2_rev_t3_h_11 + (-0.16291090846061707) * gru_2_rev_t3_h_12 + (-0.091944530606269836) * gru_2_rev_t3_h_13 + (-0.018173381686210632) * gru_2_rev_t3_h_14 + (-0.0067642014473676682) * gru_2_rev_t3_h_15 + (-0.032774403691291809) * gru_2_rev_t3_h_16 + (-0.054983321577310562) * gru_2_rev_t3_h_17 + (0.017532201483845711) * gru_2_rev_t3_h_18 + (0.17251518368721008) * gru_2_rev_t3_h_19 + (0.0056968550197780132) * gru_2_rev_t3_h_20 + (0.020362632349133492) * gru_2_rev_t3_h_21 + (0.059009484946727753) * gru_2_rev_t3_h_22 + (0.03277081623673439) * gru_2_rev_t3_h_23 + (-0.16412316262722015) * gru_2_rev_t3_h_24 + (0.022566348314285278) * gru_2_rev_t3_h_25 + (0.10404277592897415) * gru_2_rev_t3_h_26 + (-0.062572099268436432) * gru_2_rev_t3_h_27 + (-0.085304193198680878) * gru_2_rev_t3_h_28 + (0.037590425461530685) * gru_2_rev_t3_h_29 + (0.16010071337223053) * gru_2_rev_t3_h_30 + (-0.017187908291816711) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.81896877288818359) + (0.39840209484100342) * gru_1_out_t2_0 + (-0.34009203314781189) * gru_1_out_t2_1 + (-0.66742676496505737) * gru_1_out_t2_2 + (0.14473828673362732) * gru_1_out_t2_3 + (-0.060454830527305603) * gru_1_out_t2_4 + (0.23150676488876343) * gru_1_out_t2_5 + (0.38808086514472961) * gru_1_out_t2_6 + (0.36123478412628174) * gru_1_out_t2_7 + (-0.15439701080322266) * gru_1_out_t2_8 + (0.46295008063316345) * gru_1_out_t2_9 + (0.51335233449935913) * gru_1_out_t2_10 + (-0.25934436917304993) * gru_1_out_t2_11 + (0.041294477880001068) * gru_1_out_t2_12 + (0.57223325967788696) * gru_1_out_t2_13 + (1.1963133811950684) * gru_1_out_t2_14 + (0.1080976277589798) * gru_1_out_t2_15 + (-0.51442134380340576) * gru_1_out_t2_16 + (-0.7785457968711853) * gru_1_out_t2_17 + (0.63343310356140137) * gru_1_out_t2_18 + (-0.19122807681560516) * gru_1_out_t2_19 + (-0.3591521680355072) * gru_1_out_t2_20 + (0.49600234627723694) * gru_1_out_t2_21 + (-0.16650690138339996) * gru_1_out_t2_22 + (0.42826905846595764) * gru_1_out_t2_23 + (-0.5029868483543396) * gru_1_out_t2_24 + (-0.25696265697479248) * gru_1_out_t2_25 + (0.51770192384719849) * gru_1_out_t2_26 + (0.08490307629108429) * gru_1_out_t2_27 + (-1.3657597303390503) * gru_1_out_t2_28 + (0.028518920764327049) * gru_1_out_t2_29 + (0.79895859956741333) * gru_1_out_t2_30 + (-0.016219690442085266) * gru_1_out_t2_31 + (5.5884337425231934) * gru_1_out_t2_32 + (0.18898861110210419) * gru_1_out_t2_33 + (-0.38737112283706665) * gru_1_out_t2_34 + (0.22144116461277008) * gru_1_out_t2_35 + (-0.10683559626340866) * gru_1_out_t2_36 + (0.52534991502761841) * gru_1_out_t2_37 + (-0.41287821531295776) * gru_1_out_t2_38 + (-0.07456236332654953) * gru_1_out_t2_39 + (-0.062714092433452606) * gru_1_out_t2_40 + (0.17380295693874359) * gru_1_out_t2_41 + (-0.30956804752349854) * gru_1_out_t2_42 + (1.7229512929916382) * gru_1_out_t2_43 + (-0.13441887497901917) * gru_1_out_t2_44 + (0.3106214702129364) * gru_1_out_t2_45 + (-0.53196203708648682) * gru_1_out_t2_46 + (0.79901814460754395) * gru_1_out_t2_47 + (-1.2467665672302246) * gru_1_out_t2_48 + (-0.72424948215484619) * gru_1_out_t2_49 + (0.73601573705673218) * gru_1_out_t2_50 + (-0.21914464235305786) * gru_1_out_t2_51 + (0.021461760625243187) * gru_1_out_t2_52 + (0.12086697667837143) * gru_1_out_t2_53 + (1.3515750169754028) * gru_1_out_t2_54 + (-0.075442090630531311) * gru_1_out_t2_55 + (0.26983791589736938) * gru_1_out_t2_56 + (1.0512642860412598) * gru_1_out_t2_57 + (0.4892389178276062) * gru_1_out_t2_58 + (0.012273711152374744) * gru_1_out_t2_59 + (1.6009327173233032) * gru_1_out_t2_60 + (-0.84933245182037354) * gru_1_out_t2_61 + (-0.84187829494476318) * gru_1_out_t2_62 + (0.86131435632705688) * gru_1_out_t2_63 + gate_r * ((0.45445385575294495) + (0.020922346040606499) * gru_2_rev_t3_h_0 + (-0.11559836566448212) * gru_2_rev_t3_h_1 + (-0.010848000645637512) * gru_2_rev_t3_h_2 + (0.11104333400726318) * gru_2_rev_t3_h_3 + (0.016269635409116745) * gru_2_rev_t3_h_4 + (0.24839791655540466) * gru_2_rev_t3_h_5 + (-0.13045485317707062) * gru_2_rev_t3_h_6 + (0.00057200592709705234) * gru_2_rev_t3_h_7 + (-0.11952187865972519) * gru_2_rev_t3_h_8 + (0.071349218487739563) * gru_2_rev_t3_h_9 + (0.080870427191257477) * gru_2_rev_t3_h_10 + (-0.18119046092033386) * gru_2_rev_t3_h_11 + (-0.0350971519947052) * gru_2_rev_t3_h_12 + (-0.065723530948162079) * gru_2_rev_t3_h_13 + (0.020935522392392159) * gru_2_rev_t3_h_14 + (-0.19883668422698975) * gru_2_rev_t3_h_15 + (-0.012182526290416718) * gru_2_rev_t3_h_16 + (0.039951041340827942) * gru_2_rev_t3_h_17 + (0.15436859428882599) * gru_2_rev_t3_h_18 + (-0.073421202600002289) * gru_2_rev_t3_h_19 + (0.18441919982433319) * gru_2_rev_t3_h_20 + (-0.013507070019841194) * gru_2_rev_t3_h_21 + (-0.0087731191888451576) * gru_2_rev_t3_h_22 + (-0.085594922304153442) * gru_2_rev_t3_h_23 + (0.0064552966505289078) * gru_2_rev_t3_h_24 + (0.12779980897903442) * gru_2_rev_t3_h_25 + (0.12290758639574051) * gru_2_rev_t3_h_26 + (0.026296677067875862) * gru_2_rev_t3_h_27 + (-0.06432216614484787) * gru_2_rev_t3_h_28 + (0.059318460524082184) * gru_2_rev_t3_h_29 + (0.22687315940856934) * gru_2_rev_t3_h_30 + (-0.10034259408712387) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_11 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_11;
    // h=12
    gate_r = sigmoid((0.10859739035367966) + (-0.093650460243225098) * gru_1_out_t2_0 + (-1.1655739545822144) * gru_1_out_t2_1 + (0.33960694074630737) * gru_1_out_t2_2 + (0.24963507056236267) * gru_1_out_t2_3 + (0.65445190668106079) * gru_1_out_t2_4 + (0.58480566740036011) * gru_1_out_t2_5 + (-0.057822763919830322) * gru_1_out_t2_6 + (0.48106783628463745) * gru_1_out_t2_7 + (-0.82918256521224976) * gru_1_out_t2_8 + (0.51407551765441895) * gru_1_out_t2_9 + (0.034572936594486237) * gru_1_out_t2_10 + (-0.42080888152122498) * gru_1_out_t2_11 + (-0.29523521661758423) * gru_1_out_t2_12 + (0.62116760015487671) * gru_1_out_t2_13 + (-0.1742670089006424) * gru_1_out_t2_14 + (-0.20891426503658295) * gru_1_out_t2_15 + (-0.071220599114894867) * gru_1_out_t2_16 + (-2.00620436668396) * gru_1_out_t2_17 + (-0.46124053001403809) * gru_1_out_t2_18 + (-0.61630618572235107) * gru_1_out_t2_19 + (0.89832782745361328) * gru_1_out_t2_20 + (-1.5387418270111084) * gru_1_out_t2_21 + (0.015415268950164318) * gru_1_out_t2_22 + (-1.6592693328857422) * gru_1_out_t2_23 + (0.64091312885284424) * gru_1_out_t2_24 + (-0.47617071866989136) * gru_1_out_t2_25 + (0.75800186395645142) * gru_1_out_t2_26 + (0.74814975261688232) * gru_1_out_t2_27 + (-2.4059817790985107) * gru_1_out_t2_28 + (-0.8660959005355835) * gru_1_out_t2_29 + (-0.39988788962364197) * gru_1_out_t2_30 + (-0.51208037137985229) * gru_1_out_t2_31 + (0.86013811826705933) * gru_1_out_t2_32 + (-0.2178487628698349) * gru_1_out_t2_33 + (0.49048295617103577) * gru_1_out_t2_34 + (-0.19061875343322754) * gru_1_out_t2_35 + (0.73427975177764893) * gru_1_out_t2_36 + (-0.13268287479877472) * gru_1_out_t2_37 + (-2.6685121059417725) * gru_1_out_t2_38 + (1.1717914342880249) * gru_1_out_t2_39 + (2.003690242767334) * gru_1_out_t2_40 + (1.1897737979888916) * gru_1_out_t2_41 + (0.80442178249359131) * gru_1_out_t2_42 + (-0.13457426428794861) * gru_1_out_t2_43 + (-0.61377620697021484) * gru_1_out_t2_44 + (1.5288569927215576) * gru_1_out_t2_45 + (-1.0046157836914062) * gru_1_out_t2_46 + (-0.062124285846948624) * gru_1_out_t2_47 + (-0.57553046941757202) * gru_1_out_t2_48 + (-0.93100756406784058) * gru_1_out_t2_49 + (-0.95473438501358032) * gru_1_out_t2_50 + (-1.0190349817276001) * gru_1_out_t2_51 + (-0.82848042249679565) * gru_1_out_t2_52 + (-4.0847020149230957) * gru_1_out_t2_53 + (-1.5806440114974976) * gru_1_out_t2_54 + (0.529735267162323) * gru_1_out_t2_55 + (2.1133930683135986) * gru_1_out_t2_56 + (0.76807284355163574) * gru_1_out_t2_57 + (0.046888642013072968) * gru_1_out_t2_58 + (1.5671981573104858) * gru_1_out_t2_59 + (2.1135745048522949) * gru_1_out_t2_60 + (-0.6059800386428833) * gru_1_out_t2_61 + (0.86753326654434204) * gru_1_out_t2_62 + (-0.9869999885559082) * gru_1_out_t2_63 + (0.0066565708257257938) * gru_2_rev_t3_h_0 + (-0.098635673522949219) * gru_2_rev_t3_h_1 + (-0.060053657740354538) * gru_2_rev_t3_h_2 + (0.026209911331534386) * gru_2_rev_t3_h_3 + (0.047080084681510925) * gru_2_rev_t3_h_4 + (0.03140060231089592) * gru_2_rev_t3_h_5 + (0.09264422208070755) * gru_2_rev_t3_h_6 + (0.048108547925949097) * gru_2_rev_t3_h_7 + (-0.17564432322978973) * gru_2_rev_t3_h_8 + (-0.27767279744148254) * gru_2_rev_t3_h_9 + (-0.029514947906136513) * gru_2_rev_t3_h_10 + (0.057912394404411316) * gru_2_rev_t3_h_11 + (0.056734967976808548) * gru_2_rev_t3_h_12 + (0.02075251005589962) * gru_2_rev_t3_h_13 + (0.049303583800792694) * gru_2_rev_t3_h_14 + (-0.063500262796878815) * gru_2_rev_t3_h_15 + (-0.049871284514665604) * gru_2_rev_t3_h_16 + (-0.11061826348304749) * gru_2_rev_t3_h_17 + (0.080064341425895691) * gru_2_rev_t3_h_18 + (0.061750467866659164) * gru_2_rev_t3_h_19 + (-0.15257556736469269) * gru_2_rev_t3_h_20 + (0.0016094411257654428) * gru_2_rev_t3_h_21 + (0.028150927275419235) * gru_2_rev_t3_h_22 + (-0.053282909095287323) * gru_2_rev_t3_h_23 + (-0.062580309808254242) * gru_2_rev_t3_h_24 + (0.0081216432154178619) * gru_2_rev_t3_h_25 + (-0.11554960906505585) * gru_2_rev_t3_h_26 + (0.009305260144174099) * gru_2_rev_t3_h_27 + (0.01930389367043972) * gru_2_rev_t3_h_28 + (0.16021445393562317) * gru_2_rev_t3_h_29 + (0.044092826545238495) * gru_2_rev_t3_h_30 + (0.13859856128692627) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((1.9011927843093872) + (0.73502916097640991) * gru_1_out_t2_0 + (1.1715983152389526) * gru_1_out_t2_1 + (-0.32913565635681152) * gru_1_out_t2_2 + (0.83520305156707764) * gru_1_out_t2_3 + (-0.058169707655906677) * gru_1_out_t2_4 + (0.7957921028137207) * gru_1_out_t2_5 + (0.85205280780792236) * gru_1_out_t2_6 + (0.044952556490898132) * gru_1_out_t2_7 + (-0.7542794942855835) * gru_1_out_t2_8 + (0.59705322980880737) * gru_1_out_t2_9 + (0.43878224492073059) * gru_1_out_t2_10 + (0.17357476055622101) * gru_1_out_t2_11 + (0.36081263422966003) * gru_1_out_t2_12 + (0.4470272958278656) * gru_1_out_t2_13 + (1.1751596927642822) * gru_1_out_t2_14 + (0.31784489750862122) * gru_1_out_t2_15 + (-1.0806795358657837) * gru_1_out_t2_16 + (0.65887933969497681) * gru_1_out_t2_17 + (0.10030870884656906) * gru_1_out_t2_18 + (0.97342342138290405) * gru_1_out_t2_19 + (0.46966654062271118) * gru_1_out_t2_20 + (-0.15689434111118317) * gru_1_out_t2_21 + (-0.51305443048477173) * gru_1_out_t2_22 + (1.0156940221786499) * gru_1_out_t2_23 + (0.12187568843364716) * gru_1_out_t2_24 + (0.25989744067192078) * gru_1_out_t2_25 + (-0.74668121337890625) * gru_1_out_t2_26 + (0.35253673791885376) * gru_1_out_t2_27 + (-0.13385501503944397) * gru_1_out_t2_28 + (-0.058449063450098038) * gru_1_out_t2_29 + (0.71925204992294312) * gru_1_out_t2_30 + (-0.24188810586929321) * gru_1_out_t2_31 + (2.1526758670806885) * gru_1_out_t2_32 + (-0.75464200973510742) * gru_1_out_t2_33 + (-0.3766988217830658) * gru_1_out_t2_34 + (0.85570812225341797) * gru_1_out_t2_35 + (0.22175683081150055) * gru_1_out_t2_36 + (-1.1223968267440796) * gru_1_out_t2_37 + (-0.64480245113372803) * gru_1_out_t2_38 + (0.64168632030487061) * gru_1_out_t2_39 + (0.46738842129707336) * gru_1_out_t2_40 + (0.18410967290401459) * gru_1_out_t2_41 + (-0.5619242787361145) * gru_1_out_t2_42 + (0.44278675317764282) * gru_1_out_t2_43 + (-0.18046890199184418) * gru_1_out_t2_44 + (-1.3859223127365112) * gru_1_out_t2_45 + (-1.9331049919128418) * gru_1_out_t2_46 + (-0.80898672342300415) * gru_1_out_t2_47 + (0.21959182620048523) * gru_1_out_t2_48 + (-0.20547696948051453) * gru_1_out_t2_49 + (-0.96156054735183716) * gru_1_out_t2_50 + (2.3149318695068359) * gru_1_out_t2_51 + (1.1883975267410278) * gru_1_out_t2_52 + (0.49476000666618347) * gru_1_out_t2_53 + (-1.1507444381713867) * gru_1_out_t2_54 + (1.1124509572982788) * gru_1_out_t2_55 + (1.7288568019866943) * gru_1_out_t2_56 + (0.93839150667190552) * gru_1_out_t2_57 + (1.8346993923187256) * gru_1_out_t2_58 + (0.073384083807468414) * gru_1_out_t2_59 + (-0.93501967191696167) * gru_1_out_t2_60 + (-1.3463970422744751) * gru_1_out_t2_61 + (1.1276026964187622) * gru_1_out_t2_62 + (-0.14689365029335022) * gru_1_out_t2_63 + (-0.051585819572210312) * gru_2_rev_t3_h_0 + (0.11064371466636658) * gru_2_rev_t3_h_1 + (0.01493759173899889) * gru_2_rev_t3_h_2 + (0.057407226413488388) * gru_2_rev_t3_h_3 + (-0.045654494315385818) * gru_2_rev_t3_h_4 + (-0.0017009066650643945) * gru_2_rev_t3_h_5 + (-0.012796452268958092) * gru_2_rev_t3_h_6 + (0.0021609291434288025) * gru_2_rev_t3_h_7 + (0.065775193274021149) * gru_2_rev_t3_h_8 + (-0.22261792421340942) * gru_2_rev_t3_h_9 + (-0.14519903063774109) * gru_2_rev_t3_h_10 + (0.05994727835059166) * gru_2_rev_t3_h_11 + (-0.10589755326509476) * gru_2_rev_t3_h_12 + (0.011676066555082798) * gru_2_rev_t3_h_13 + (-0.025631645694375038) * gru_2_rev_t3_h_14 + (-0.14152176678180695) * gru_2_rev_t3_h_15 + (-0.13125568628311157) * gru_2_rev_t3_h_16 + (0.0075697721913456917) * gru_2_rev_t3_h_17 + (0.1364348977804184) * gru_2_rev_t3_h_18 + (0.12675635516643524) * gru_2_rev_t3_h_19 + (0.049759764224290848) * gru_2_rev_t3_h_20 + (0.11020664125680923) * gru_2_rev_t3_h_21 + (-0.014095918275415897) * gru_2_rev_t3_h_22 + (0.16829684376716614) * gru_2_rev_t3_h_23 + (-0.084742538630962372) * gru_2_rev_t3_h_24 + (0.021543662995100021) * gru_2_rev_t3_h_25 + (0.11367194354534149) * gru_2_rev_t3_h_26 + (-0.13501293957233429) * gru_2_rev_t3_h_27 + (-0.13526716828346252) * gru_2_rev_t3_h_28 + (0.15108771622180939) * gru_2_rev_t3_h_29 + (0.018362078815698624) * gru_2_rev_t3_h_30 + (0.044463846832513809) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.27790921926498413) + (0.26844677329063416) * gru_1_out_t2_0 + (1.0210690498352051) * gru_1_out_t2_1 + (0.64003652334213257) * gru_1_out_t2_2 + (0.44159162044525146) * gru_1_out_t2_3 + (0.09622308611869812) * gru_1_out_t2_4 + (-0.17005801200866699) * gru_1_out_t2_5 + (-0.1490398496389389) * gru_1_out_t2_6 + (-0.051330752670764923) * gru_1_out_t2_7 + (-0.60636419057846069) * gru_1_out_t2_8 + (-1.334484338760376) * gru_1_out_t2_9 + (0.41490772366523743) * gru_1_out_t2_10 + (-0.026437010616064072) * gru_1_out_t2_11 + (-0.49586406350135803) * gru_1_out_t2_12 + (0.2260492742061615) * gru_1_out_t2_13 + (0.078427143394947052) * gru_1_out_t2_14 + (-0.38259240984916687) * gru_1_out_t2_15 + (-0.14445284008979797) * gru_1_out_t2_16 + (0.71032118797302246) * gru_1_out_t2_17 + (-1.3678214550018311) * gru_1_out_t2_18 + (0.52560955286026001) * gru_1_out_t2_19 + (0.88369286060333252) * gru_1_out_t2_20 + (0.58398884534835815) * gru_1_out_t2_21 + (-0.34030658006668091) * gru_1_out_t2_22 + (1.2997705936431885) * gru_1_out_t2_23 + (0.26621156930923462) * gru_1_out_t2_24 + (0.59275895357131958) * gru_1_out_t2_25 + (0.21438337862491608) * gru_1_out_t2_26 + (-0.086410053074359894) * gru_1_out_t2_27 + (1.2796100378036499) * gru_1_out_t2_28 + (-0.71417587995529175) * gru_1_out_t2_29 + (0.22486764192581177) * gru_1_out_t2_30 + (-0.19255681335926056) * gru_1_out_t2_31 + (1.0725934505462646) * gru_1_out_t2_32 + (0.2090628445148468) * gru_1_out_t2_33 + (0.40877264738082886) * gru_1_out_t2_34 + (0.16676238179206848) * gru_1_out_t2_35 + (0.83209705352783203) * gru_1_out_t2_36 + (-0.45717647671699524) * gru_1_out_t2_37 + (0.68218165636062622) * gru_1_out_t2_38 + (0.54498964548110962) * gru_1_out_t2_39 + (3.2669517993927002) * gru_1_out_t2_40 + (0.54477256536483765) * gru_1_out_t2_41 + (1.6392462253570557) * gru_1_out_t2_42 + (-0.81668305397033691) * gru_1_out_t2_43 + (-0.032113470137119293) * gru_1_out_t2_44 + (0.72083377838134766) * gru_1_out_t2_45 + (-2.4702718257904053) * gru_1_out_t2_46 + (-0.11209224164485931) * gru_1_out_t2_47 + (-0.0067417193204164505) * gru_1_out_t2_48 + (-0.62148714065551758) * gru_1_out_t2_49 + (0.41857051849365234) * gru_1_out_t2_50 + (-0.54569351673126221) * gru_1_out_t2_51 + (0.004400892648845911) * gru_1_out_t2_52 + (-0.9255058765411377) * gru_1_out_t2_53 + (2.1333498954772949) * gru_1_out_t2_54 + (0.42896574735641479) * gru_1_out_t2_55 + (0.2559700608253479) * gru_1_out_t2_56 + (0.35964667797088623) * gru_1_out_t2_57 + (0.40868082642555237) * gru_1_out_t2_58 + (0.51408708095550537) * gru_1_out_t2_59 + (0.75293427705764771) * gru_1_out_t2_60 + (-0.71318513154983521) * gru_1_out_t2_61 + (-0.060381617397069931) * gru_1_out_t2_62 + (0.25807607173919678) * gru_1_out_t2_63 + gate_r * ((2.422940731048584) + (-0.060497656464576721) * gru_2_rev_t3_h_0 + (-0.024873355403542519) * gru_2_rev_t3_h_1 + (-0.11855645477771759) * gru_2_rev_t3_h_2 + (0.2522737979888916) * gru_2_rev_t3_h_3 + (-0.14204517006874084) * gru_2_rev_t3_h_4 + (-0.084421001374721527) * gru_2_rev_t3_h_5 + (0.10365361720323563) * gru_2_rev_t3_h_6 + (0.042303480207920074) * gru_2_rev_t3_h_7 + (-0.016941625624895096) * gru_2_rev_t3_h_8 + (0.00086828944040462375) * gru_2_rev_t3_h_9 + (-0.0023424997925758362) * gru_2_rev_t3_h_10 + (0.057151723653078079) * gru_2_rev_t3_h_11 + (-0.027514563873410225) * gru_2_rev_t3_h_12 + (-0.0076654525473713875) * gru_2_rev_t3_h_13 + (0.12230373173952103) * gru_2_rev_t3_h_14 + (-0.1087336540222168) * gru_2_rev_t3_h_15 + (-0.069936960935592651) * gru_2_rev_t3_h_16 + (-0.043765183538198471) * gru_2_rev_t3_h_17 + (-0.0018790352623909712) * gru_2_rev_t3_h_18 + (-0.039653975516557693) * gru_2_rev_t3_h_19 + (-0.079334504902362823) * gru_2_rev_t3_h_20 + (-0.087709680199623108) * gru_2_rev_t3_h_21 + (0.16238538920879364) * gru_2_rev_t3_h_22 + (-0.054289855062961578) * gru_2_rev_t3_h_23 + (0.035963799804449081) * gru_2_rev_t3_h_24 + (0.087862119078636169) * gru_2_rev_t3_h_25 + (-0.11097808927297592) * gru_2_rev_t3_h_26 + (-0.0067578861489892006) * gru_2_rev_t3_h_27 + (-0.034083914011716843) * gru_2_rev_t3_h_28 + (0.031479351222515106) * gru_2_rev_t3_h_29 + (-0.082717500627040863) * gru_2_rev_t3_h_30 + (-0.042919956147670746) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_12 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_12;
    // h=13
    gate_r = sigmoid((0.61264687776565552) + (-0.01401209644973278) * gru_1_out_t2_0 + (1.1893656253814697) * gru_1_out_t2_1 + (0.46476686000823975) * gru_1_out_t2_2 + (0.85927605628967285) * gru_1_out_t2_3 + (-0.46102797985076904) * gru_1_out_t2_4 + (-1.3899279832839966) * gru_1_out_t2_5 + (1.7321523427963257) * gru_1_out_t2_6 + (0.19108234345912933) * gru_1_out_t2_7 + (0.056505728513002396) * gru_1_out_t2_8 + (0.50374907255172729) * gru_1_out_t2_9 + (-0.28160768747329712) * gru_1_out_t2_10 + (0.57455199956893921) * gru_1_out_t2_11 + (-0.2182207852602005) * gru_1_out_t2_12 + (-0.49598267674446106) * gru_1_out_t2_13 + (1.0055460929870605) * gru_1_out_t2_14 + (-2.0252799987792969) * gru_1_out_t2_15 + (-0.24981509149074554) * gru_1_out_t2_16 + (-1.4846100807189941) * gru_1_out_t2_17 + (0.89476394653320312) * gru_1_out_t2_18 + (-2.3440003395080566) * gru_1_out_t2_19 + (0.50809788703918457) * gru_1_out_t2_20 + (-1.0258426666259766) * gru_1_out_t2_21 + (1.1407257318496704) * gru_1_out_t2_22 + (0.81490784883499146) * gru_1_out_t2_23 + (-2.1732099056243896) * gru_1_out_t2_24 + (1.0170117616653442) * gru_1_out_t2_25 + (-1.1224772930145264) * gru_1_out_t2_26 + (1.3114140033721924) * gru_1_out_t2_27 + (1.0865211486816406) * gru_1_out_t2_28 + (-0.90696686506271362) * gru_1_out_t2_29 + (-0.13740652799606323) * gru_1_out_t2_30 + (-0.32378238439559937) * gru_1_out_t2_31 + (-0.85588127374649048) * gru_1_out_t2_32 + (0.72234350442886353) * gru_1_out_t2_33 + (-0.43575325608253479) * gru_1_out_t2_34 + (-0.042898271232843399) * gru_1_out_t2_35 + (0.86660230159759521) * gru_1_out_t2_36 + (-2.1674001216888428) * gru_1_out_t2_37 + (-1.4806026220321655) * gru_1_out_t2_38 + (-0.15424938499927521) * gru_1_out_t2_39 + (-0.87803822755813599) * gru_1_out_t2_40 + (1.9059542417526245) * gru_1_out_t2_41 + (0.21120256185531616) * gru_1_out_t2_42 + (0.79092144966125488) * gru_1_out_t2_43 + (0.006467270664870739) * gru_1_out_t2_44 + (-0.95251023769378662) * gru_1_out_t2_45 + (-0.606833815574646) * gru_1_out_t2_46 + (0.89171296358108521) * gru_1_out_t2_47 + (-1.1681452989578247) * gru_1_out_t2_48 + (-0.48029381036758423) * gru_1_out_t2_49 + (-0.37117850780487061) * gru_1_out_t2_50 + (-0.28743407130241394) * gru_1_out_t2_51 + (-0.20493112504482269) * gru_1_out_t2_52 + (0.98122000694274902) * gru_1_out_t2_53 + (-1.6571619510650635) * gru_1_out_t2_54 + (1.1399600505828857) * gru_1_out_t2_55 + (-0.21760991215705872) * gru_1_out_t2_56 + (1.0045653581619263) * gru_1_out_t2_57 + (0.71128970384597778) * gru_1_out_t2_58 + (-0.73988485336303711) * gru_1_out_t2_59 + (-0.68703985214233398) * gru_1_out_t2_60 + (0.89326184988021851) * gru_1_out_t2_61 + (-3.1908745765686035) * gru_1_out_t2_62 + (0.64793527126312256) * gru_1_out_t2_63 + (0.10097423940896988) * gru_2_rev_t3_h_0 + (-0.034966256469488144) * gru_2_rev_t3_h_1 + (-0.088193438947200775) * gru_2_rev_t3_h_2 + (-0.091637611389160156) * gru_2_rev_t3_h_3 + (-0.10184501856565475) * gru_2_rev_t3_h_4 + (-0.051073640584945679) * gru_2_rev_t3_h_5 + (-0.058279059827327728) * gru_2_rev_t3_h_6 + (-0.0829610675573349) * gru_2_rev_t3_h_7 + (0.090556755661964417) * gru_2_rev_t3_h_8 + (-0.037825543433427811) * gru_2_rev_t3_h_9 + (-0.011581909842789173) * gru_2_rev_t3_h_10 + (-0.049249790608882904) * gru_2_rev_t3_h_11 + (-0.024293513968586922) * gru_2_rev_t3_h_12 + (0.096001580357551575) * gru_2_rev_t3_h_13 + (-0.1349690705537796) * gru_2_rev_t3_h_14 + (-0.14409923553466797) * gru_2_rev_t3_h_15 + (0.033220734447240829) * gru_2_rev_t3_h_16 + (0.21869927644729614) * gru_2_rev_t3_h_17 + (0.081662654876708984) * gru_2_rev_t3_h_18 + (-0.062769055366516113) * gru_2_rev_t3_h_19 + (-0.23417410254478455) * gru_2_rev_t3_h_20 + (0.0806870236992836) * gru_2_rev_t3_h_21 + (-0.04968014732003212) * gru_2_rev_t3_h_22 + (-0.018236855044960976) * gru_2_rev_t3_h_23 + (-0.1558806449174881) * gru_2_rev_t3_h_24 + (-0.091692507266998291) * gru_2_rev_t3_h_25 + (0.044483061879873276) * gru_2_rev_t3_h_26 + (0.056721646338701248) * gru_2_rev_t3_h_27 + (-0.018816208466887474) * gru_2_rev_t3_h_28 + (0.13245660066604614) * gru_2_rev_t3_h_29 + (0.13446502387523651) * gru_2_rev_t3_h_30 + (-0.029040271416306496) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((-0.71352481842041016) + (-0.41259101033210754) * gru_1_out_t2_0 + (-0.14872053265571594) * gru_1_out_t2_1 + (0.49572610855102539) * gru_1_out_t2_2 + (0.095973759889602661) * gru_1_out_t2_3 + (0.34313681721687317) * gru_1_out_t2_4 + (0.20949873328208923) * gru_1_out_t2_5 + (-0.0082624992355704308) * gru_1_out_t2_6 + (0.058275468647480011) * gru_1_out_t2_7 + (0.07715248316526413) * gru_1_out_t2_8 + (0.24346156418323517) * gru_1_out_t2_9 + (-0.66778123378753662) * gru_1_out_t2_10 + (-0.54570299386978149) * gru_1_out_t2_11 + (0.28629627823829651) * gru_1_out_t2_12 + (-0.23991967737674713) * gru_1_out_t2_13 + (-0.14912161231040955) * gru_1_out_t2_14 + (0.11335330456495285) * gru_1_out_t2_15 + (0.20561788976192474) * gru_1_out_t2_16 + (-0.075203239917755127) * gru_1_out_t2_17 + (-0.17665120959281921) * gru_1_out_t2_18 + (0.71953737735748291) * gru_1_out_t2_19 + (0.018371123820543289) * gru_1_out_t2_20 + (0.065297544002532959) * gru_1_out_t2_21 + (0.73350411653518677) * gru_1_out_t2_22 + (0.19128495454788208) * gru_1_out_t2_23 + (-0.1031661182641983) * gru_1_out_t2_24 + (-0.65593111515045166) * gru_1_out_t2_25 + (0.12038484960794449) * gru_1_out_t2_26 + (0.77568894624710083) * gru_1_out_t2_27 + (-0.15247273445129395) * gru_1_out_t2_28 + (-0.31464281678199768) * gru_1_out_t2_29 + (-0.18216307461261749) * gru_1_out_t2_30 + (0.13714481890201569) * gru_1_out_t2_31 + (-0.26373642683029175) * gru_1_out_t2_32 + (-1.0377597808837891) * gru_1_out_t2_33 + (0.9019508957862854) * gru_1_out_t2_34 + (-0.18022908270359039) * gru_1_out_t2_35 + (-0.10350760817527771) * gru_1_out_t2_36 + (0.23127336800098419) * gru_1_out_t2_37 + (0.13024228811264038) * gru_1_out_t2_38 + (-0.032375384122133255) * gru_1_out_t2_39 + (-0.013261923566460609) * gru_1_out_t2_40 + (-0.47737085819244385) * gru_1_out_t2_41 + (1.3691335916519165) * gru_1_out_t2_42 + (0.71625030040740967) * gru_1_out_t2_43 + (0.10422981530427933) * gru_1_out_t2_44 + (0.14477816224098206) * gru_1_out_t2_45 + (0.31744295358657837) * gru_1_out_t2_46 + (-0.45000007748603821) * gru_1_out_t2_47 + (0.13798253238201141) * gru_1_out_t2_48 + (0.55043995380401611) * gru_1_out_t2_49 + (0.50996989011764526) * gru_1_out_t2_50 + (-1.4264926910400391) * gru_1_out_t2_51 + (-0.058162275701761246) * gru_1_out_t2_52 + (0.14944261312484741) * gru_1_out_t2_53 + (0.22652381658554077) * gru_1_out_t2_54 + (0.02274610847234726) * gru_1_out_t2_55 + (0.20244118571281433) * gru_1_out_t2_56 + (-0.45750033855438232) * gru_1_out_t2_57 + (-0.17679888010025024) * gru_1_out_t2_58 + (0.76911455392837524) * gru_1_out_t2_59 + (0.0085713109001517296) * gru_1_out_t2_60 + (-0.75504869222640991) * gru_1_out_t2_61 + (0.78171157836914062) * gru_1_out_t2_62 + (-0.28508555889129639) * gru_1_out_t2_63 + (0.20416118204593658) * gru_2_rev_t3_h_0 + (0.044210944324731827) * gru_2_rev_t3_h_1 + (-0.30282482504844666) * gru_2_rev_t3_h_2 + (-0.074015073478221893) * gru_2_rev_t3_h_3 + (-0.033032473176717758) * gru_2_rev_t3_h_4 + (-0.037490114569664001) * gru_2_rev_t3_h_5 + (0.10715527087450027) * gru_2_rev_t3_h_6 + (-0.12222691625356674) * gru_2_rev_t3_h_7 + (0.10003714263439178) * gru_2_rev_t3_h_8 + (-0.065179735422134399) * gru_2_rev_t3_h_9 + (0.070799380540847778) * gru_2_rev_t3_h_10 + (0.024960359558463097) * gru_2_rev_t3_h_11 + (-0.0289605762809515) * gru_2_rev_t3_h_12 + (-0.02038208395242691) * gru_2_rev_t3_h_13 + (0.032478567212820053) * gru_2_rev_t3_h_14 + (-0.071205489337444305) * gru_2_rev_t3_h_15 + (-0.14171002805233002) * gru_2_rev_t3_h_16 + (-0.085608422756195068) * gru_2_rev_t3_h_17 + (-0.13689424097537994) * gru_2_rev_t3_h_18 + (0.065486438572406769) * gru_2_rev_t3_h_19 + (0.051779236644506454) * gru_2_rev_t3_h_20 + (-0.21655881404876709) * gru_2_rev_t3_h_21 + (0.020765673369169235) * gru_2_rev_t3_h_22 + (-0.10340523719787598) * gru_2_rev_t3_h_23 + (0.15859316289424896) * gru_2_rev_t3_h_24 + (-0.08629077672958374) * gru_2_rev_t3_h_25 + (-0.035698994994163513) * gru_2_rev_t3_h_26 + (-0.02566872164607048) * gru_2_rev_t3_h_27 + (-0.047932829707860947) * gru_2_rev_t3_h_28 + (-0.055116403847932816) * gru_2_rev_t3_h_29 + (0.13490292429924011) * gru_2_rev_t3_h_30 + (0.021941466256976128) * gru_2_rev_t3_h_31);
    gate_n = tanh((-0.66636615991592407) + (-0.88969963788986206) * gru_1_out_t2_0 + (1.2770154476165771) * gru_1_out_t2_1 + (0.053097616881132126) * gru_1_out_t2_2 + (-0.21490418910980225) * gru_1_out_t2_3 + (0.21760264039039612) * gru_1_out_t2_4 + (-0.1381646990776062) * gru_1_out_t2_5 + (0.059845544397830963) * gru_1_out_t2_6 + (0.19501714408397675) * gru_1_out_t2_7 + (-0.63639378547668457) * gru_1_out_t2_8 + (0.30296921730041504) * gru_1_out_t2_9 + (-2.7293126583099365) * gru_1_out_t2_10 + (0.11513166874647141) * gru_1_out_t2_11 + (-0.079933919012546539) * gru_1_out_t2_12 + (0.043703079223632812) * gru_1_out_t2_13 + (0.08717653900384903) * gru_1_out_t2_14 + (0.32187527418136597) * gru_1_out_t2_15 + (0.57712876796722412) * gru_1_out_t2_16 + (-0.60789638757705688) * gru_1_out_t2_17 + (-0.54325032234191895) * gru_1_out_t2_18 + (0.76628696918487549) * gru_1_out_t2_19 + (-0.40095522999763489) * gru_1_out_t2_20 + (0.096288822591304779) * gru_1_out_t2_21 + (0.777274489402771) * gru_1_out_t2_22 + (-0.72855377197265625) * gru_1_out_t2_23 + (0.043388091027736664) * gru_1_out_t2_24 + (-2.4696967601776123) * gru_1_out_t2_25 + (0.27605125308036804) * gru_1_out_t2_26 + (1.6053804159164429) * gru_1_out_t2_27 + (-0.58805680274963379) * gru_1_out_t2_28 + (-0.23901423811912537) * gru_1_out_t2_29 + (-1.1669930219650269) * gru_1_out_t2_30 + (-0.37038791179656982) * gru_1_out_t2_31 + (-0.20668855309486389) * gru_1_out_t2_32 + (-0.14167018234729767) * gru_1_out_t2_33 + (0.55547487735748291) * gru_1_out_t2_34 + (-0.39654719829559326) * gru_1_out_t2_35 + (-0.4918043315410614) * gru_1_out_t2_36 + (-0.16874630749225616) * gru_1_out_t2_37 + (0.63287979364395142) * gru_1_out_t2_38 + (-0.034562822431325912) * gru_1_out_t2_39 + (0.2020052969455719) * gru_1_out_t2_40 + (-0.92084240913391113) * gru_1_out_t2_41 + (0.32190325856208801) * gru_1_out_t2_42 + (0.042168434709310532) * gru_1_out_t2_43 + (-0.28190982341766357) * gru_1_out_t2_44 + (0.052780982106924057) * gru_1_out_t2_45 + (3.7869625091552734) * gru_1_out_t2_46 + (-0.41500622034072876) * gru_1_out_t2_47 + (-0.46720504760742188) * gru_1_out_t2_48 + (0.97432321310043335) * gru_1_out_t2_49 + (1.3157709836959839) * gru_1_out_t2_50 + (-1.5206855535507202) * gru_1_out_t2_51 + (0.60914063453674316) * gru_1_out_t2_52 + (-0.046274110674858093) * gru_1_out_t2_53 + (0.0052009150385856628) * gru_1_out_t2_54 + (-1.1346448659896851) * gru_1_out_t2_55 + (1.2225328683853149) * gru_1_out_t2_56 + (-0.76181513071060181) * gru_1_out_t2_57 + (-0.35454973578453064) * gru_1_out_t2_58 + (0.99287021160125732) * gru_1_out_t2_59 + (2.1393349170684814) * gru_1_out_t2_60 + (-1.8002321720123291) * gru_1_out_t2_61 + (0.23816403746604919) * gru_1_out_t2_62 + (-0.78869873285293579) * gru_1_out_t2_63 + gate_r * ((-0.51376581192016602) + (0.010519717819988728) * gru_2_rev_t3_h_0 + (-0.10939396172761917) * gru_2_rev_t3_h_1 + (-0.1507912278175354) * gru_2_rev_t3_h_2 + (0.010490678250789642) * gru_2_rev_t3_h_3 + (-0.019341230392456055) * gru_2_rev_t3_h_4 + (-0.11230992525815964) * gru_2_rev_t3_h_5 + (-0.026324538514018059) * gru_2_rev_t3_h_6 + (0.018482057377696037) * gru_2_rev_t3_h_7 + (-0.11592649668455124) * gru_2_rev_t3_h_8 + (-0.060029316693544388) * gru_2_rev_t3_h_9 + (0.052799031138420105) * gru_2_rev_t3_h_10 + (-0.046835761517286301) * gru_2_rev_t3_h_11 + (-0.071121513843536377) * gru_2_rev_t3_h_12 + (-0.023626139387488365) * gru_2_rev_t3_h_13 + (0.19007323682308197) * gru_2_rev_t3_h_14 + (-0.13191530108451843) * gru_2_rev_t3_h_15 + (-0.13360390067100525) * gru_2_rev_t3_h_16 + (0.09154142439365387) * gru_2_rev_t3_h_17 + (0.091608792543411255) * gru_2_rev_t3_h_18 + (0.012648507952690125) * gru_2_rev_t3_h_19 + (-0.17221915721893311) * gru_2_rev_t3_h_20 + (-0.0041389712132513523) * gru_2_rev_t3_h_21 + (0.076488316059112549) * gru_2_rev_t3_h_22 + (-0.059053439646959305) * gru_2_rev_t3_h_23 + (-0.10864847153425217) * gru_2_rev_t3_h_24 + (0.027301939204335213) * gru_2_rev_t3_h_25 + (-0.028540017083287239) * gru_2_rev_t3_h_26 + (-0.13245119154453278) * gru_2_rev_t3_h_27 + (-0.012944299727678299) * gru_2_rev_t3_h_28 + (0.0012406466994434595) * gru_2_rev_t3_h_29 + (-0.1677870899438858) * gru_2_rev_t3_h_30 + (0.24797196686267853) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_13 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_13;
    // h=14
    gate_r = sigmoid((-0.52004843950271606) + (-0.52166849374771118) * gru_1_out_t2_0 + (-0.17159244418144226) * gru_1_out_t2_1 + (5.1807675361633301) * gru_1_out_t2_2 + (-0.088910363614559174) * gru_1_out_t2_3 + (2.0023722648620605) * gru_1_out_t2_4 + (-1.4160523414611816) * gru_1_out_t2_5 + (1.3994898796081543) * gru_1_out_t2_6 + (0.31257101893424988) * gru_1_out_t2_7 + (0.62761902809143066) * gru_1_out_t2_8 + (0.058205176144838333) * gru_1_out_t2_9 + (-0.06749340146780014) * gru_1_out_t2_10 + (0.3065125048160553) * gru_1_out_t2_11 + (0.14677752554416656) * gru_1_out_t2_12 + (-1.927876353263855) * gru_1_out_t2_13 + (-0.18417099118232727) * gru_1_out_t2_14 + (-0.033483684062957764) * gru_1_out_t2_15 + (0.34989276528358459) * gru_1_out_t2_16 + (-1.1673709154129028) * gru_1_out_t2_17 + (0.7928890585899353) * gru_1_out_t2_18 + (1.0748476982116699) * gru_1_out_t2_19 + (0.33847299218177795) * gru_1_out_t2_20 + (1.2762054204940796) * gru_1_out_t2_21 + (1.7467063665390015) * gru_1_out_t2_22 + (0.094279617071151733) * gru_1_out_t2_23 + (-2.3034970760345459) * gru_1_out_t2_24 + (-0.3420671820640564) * gru_1_out_t2_25 + (-0.91890281438827515) * gru_1_out_t2_26 + (3.7782101631164551) * gru_1_out_t2_27 + (-3.1675858497619629) * gru_1_out_t2_28 + (-0.71188193559646606) * gru_1_out_t2_29 + (-0.67736601829528809) * gru_1_out_t2_30 + (0.041309542953968048) * gru_1_out_t2_31 + (0.66725426912307739) * gru_1_out_t2_32 + (-0.0142440190538764) * gru_1_out_t2_33 + (0.22404210269451141) * gru_1_out_t2_34 + (-1.9161640405654907) * gru_1_out_t2_35 + (-0.21534854173660278) * gru_1_out_t2_36 + (0.70285767316818237) * gru_1_out_t2_37 + (0.62431859970092773) * gru_1_out_t2_38 + (-5.0520401000976562) * gru_1_out_t2_39 + (-0.4738776683807373) * gru_1_out_t2_40 + (-0.27911257743835449) * gru_1_out_t2_41 + (-0.85483402013778687) * gru_1_out_t2_42 + (2.1535172462463379) * gru_1_out_t2_43 + (-0.48192405700683594) * gru_1_out_t2_44 + (0.2654958963394165) * gru_1_out_t2_45 + (0.86459916830062866) * gru_1_out_t2_46 + (0.17563477158546448) * gru_1_out_t2_47 + (-1.063991904258728) * gru_1_out_t2_48 + (1.2192986011505127) * gru_1_out_t2_49 + (-1.0524306297302246) * gru_1_out_t2_50 + (0.45613199472427368) * gru_1_out_t2_51 + (-1.8079380989074707) * gru_1_out_t2_52 + (-2.1762509346008301) * gru_1_out_t2_53 + (1.0100634098052979) * gru_1_out_t2_54 + (-3.6775486469268799) * gru_1_out_t2_55 + (6.6928057670593262) * gru_1_out_t2_56 + (-0.33992478251457214) * gru_1_out_t2_57 + (-0.36672940850257874) * gru_1_out_t2_58 + (0.58681237697601318) * gru_1_out_t2_59 + (4.8429107666015625) * gru_1_out_t2_60 + (-5.315277099609375) * gru_1_out_t2_61 + (2.2039153575897217) * gru_1_out_t2_62 + (-0.45200580358505249) * gru_1_out_t2_63 + (0.045434221625328064) * gru_2_rev_t3_h_0 + (-0.043543383479118347) * gru_2_rev_t3_h_1 + (-0.0053046103566884995) * gru_2_rev_t3_h_2 + (-0.015243677422404289) * gru_2_rev_t3_h_3 + (-0.076979078352451324) * gru_2_rev_t3_h_4 + (0.048341318964958191) * gru_2_rev_t3_h_5 + (-0.034314215183258057) * gru_2_rev_t3_h_6 + (-0.03227798268198967) * gru_2_rev_t3_h_7 + (-0.011951414868235588) * gru_2_rev_t3_h_8 + (0.11880563944578171) * gru_2_rev_t3_h_9 + (-0.20334003865718842) * gru_2_rev_t3_h_10 + (0.062920011579990387) * gru_2_rev_t3_h_11 + (0.10158073902130127) * gru_2_rev_t3_h_12 + (0.03720422089099884) * gru_2_rev_t3_h_13 + (0.10296766459941864) * gru_2_rev_t3_h_14 + (0.073383435606956482) * gru_2_rev_t3_h_15 + (-0.01028155442327261) * gru_2_rev_t3_h_16 + (0.007862909696996212) * gru_2_rev_t3_h_17 + (-0.021761594340205193) * gru_2_rev_t3_h_18 + (0.12962257862091064) * gru_2_rev_t3_h_19 + (-0.24597808718681335) * gru_2_rev_t3_h_20 + (0.021849939599633217) * gru_2_rev_t3_h_21 + (-0.21154822409152985) * gru_2_rev_t3_h_22 + (-0.15200524032115936) * gru_2_rev_t3_h_23 + (0.20380334556102753) * gru_2_rev_t3_h_24 + (-0.057398669421672821) * gru_2_rev_t3_h_25 + (0.032167013734579086) * gru_2_rev_t3_h_26 + (-0.19258277118206024) * gru_2_rev_t3_h_27 + (-0.03686022013425827) * gru_2_rev_t3_h_28 + (-0.037753723561763763) * gru_2_rev_t3_h_29 + (-0.0056870398111641407) * gru_2_rev_t3_h_30 + (-0.079904690384864807) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.076649613678455353) + (0.14967988431453705) * gru_1_out_t2_0 + (0.034819059073925018) * gru_1_out_t2_1 + (0.96578073501586914) * gru_1_out_t2_2 + (0.23474891483783722) * gru_1_out_t2_3 + (0.79582470655441284) * gru_1_out_t2_4 + (-0.062104232609272003) * gru_1_out_t2_5 + (-0.062948234379291534) * gru_1_out_t2_6 + (0.58715194463729858) * gru_1_out_t2_7 + (-0.54593044519424438) * gru_1_out_t2_8 + (-0.2232980877161026) * gru_1_out_t2_9 + (-0.60679000616073608) * gru_1_out_t2_10 + (-0.58960717916488647) * gru_1_out_t2_11 + (-0.41486746072769165) * gru_1_out_t2_12 + (-0.093590661883354187) * gru_1_out_t2_13 + (-0.38715389370918274) * gru_1_out_t2_14 + (-0.3458310067653656) * gru_1_out_t2_15 + (-0.04766291007399559) * gru_1_out_t2_16 + (0.10484921932220459) * gru_1_out_t2_17 + (0.074559539556503296) * gru_1_out_t2_18 + (0.16773535311222076) * gru_1_out_t2_19 + (-0.069630071520805359) * gru_1_out_t2_20 + (-0.11183423548936844) * gru_1_out_t2_21 + (-0.14504118263721466) * gru_1_out_t2_22 + (-0.099373362958431244) * gru_1_out_t2_23 + (0.10285200923681259) * gru_1_out_t2_24 + (0.017055319622159004) * gru_1_out_t2_25 + (0.12596900761127472) * gru_1_out_t2_26 + (-0.2104489654302597) * gru_1_out_t2_27 + (0.12565210461616516) * gru_1_out_t2_28 + (-0.39037355780601501) * gru_1_out_t2_29 + (-0.059341810643672943) * gru_1_out_t2_30 + (-0.23828823864459991) * gru_1_out_t2_31 + (0.1129818931221962) * gru_1_out_t2_32 + (-0.040848847478628159) * gru_1_out_t2_33 + (0.12403006851673126) * gru_1_out_t2_34 + (-0.053076297044754028) * gru_1_out_t2_35 + (0.32615238428115845) * gru_1_out_t2_36 + (-0.40062770247459412) * gru_1_out_t2_37 + (-0.0099247042089700699) * gru_1_out_t2_38 + (-0.40705803036689758) * gru_1_out_t2_39 + (-0.1450931578874588) * gru_1_out_t2_40 + (0.10214933007955551) * gru_1_out_t2_41 + (-0.34352844953536987) * gru_1_out_t2_42 + (0.41939616203308105) * gru_1_out_t2_43 + (-0.079897761344909668) * gru_1_out_t2_44 + (-0.11045993864536285) * gru_1_out_t2_45 + (-0.74490374326705933) * gru_1_out_t2_46 + (0.94002300500869751) * gru_1_out_t2_47 + (-0.62688291072845459) * gru_1_out_t2_48 + (-0.27008557319641113) * gru_1_out_t2_49 + (0.49967858195304871) * gru_1_out_t2_50 + (0.056464985013008118) * gru_1_out_t2_51 + (-0.2350182980298996) * gru_1_out_t2_52 + (0.24239273369312286) * gru_1_out_t2_53 + (-0.15517501533031464) * gru_1_out_t2_54 + (-0.052868172526359558) * gru_1_out_t2_55 + (-0.5908052921295166) * gru_1_out_t2_56 + (0.037232246249914169) * gru_1_out_t2_57 + (0.57131540775299072) * gru_1_out_t2_58 + (-0.061468549072742462) * gru_1_out_t2_59 + (-0.16892790794372559) * gru_1_out_t2_60 + (0.28549572825431824) * gru_1_out_t2_61 + (0.27768987417221069) * gru_1_out_t2_62 + (0.020312400534749031) * gru_1_out_t2_63 + (0.018326489254832268) * gru_2_rev_t3_h_0 + (0.13701681792736053) * gru_2_rev_t3_h_1 + (0.29565972089767456) * gru_2_rev_t3_h_2 + (0.021206537261605263) * gru_2_rev_t3_h_3 + (-0.08731929212808609) * gru_2_rev_t3_h_4 + (0.036695379763841629) * gru_2_rev_t3_h_5 + (0.21167321503162384) * gru_2_rev_t3_h_6 + (-0.046215761452913284) * gru_2_rev_t3_h_7 + (-0.079305768013000488) * gru_2_rev_t3_h_8 + (0.084114342927932739) * gru_2_rev_t3_h_9 + (0.10973349958658218) * gru_2_rev_t3_h_10 + (0.14035147428512573) * gru_2_rev_t3_h_11 + (-0.013709393329918385) * gru_2_rev_t3_h_12 + (0.078343547880649567) * gru_2_rev_t3_h_13 + (0.049127306789159775) * gru_2_rev_t3_h_14 + (-0.077598944306373596) * gru_2_rev_t3_h_15 + (-0.10518147051334381) * gru_2_rev_t3_h_16 + (-0.026229189708828926) * gru_2_rev_t3_h_17 + (0.094631195068359375) * gru_2_rev_t3_h_18 + (-0.0035748262889683247) * gru_2_rev_t3_h_19 + (0.024583261460065842) * gru_2_rev_t3_h_20 + (0.030563998967409134) * gru_2_rev_t3_h_21 + (-0.27303165197372437) * gru_2_rev_t3_h_22 + (-0.1161981001496315) * gru_2_rev_t3_h_23 + (-0.050048038363456726) * gru_2_rev_t3_h_24 + (-0.0035998367238789797) * gru_2_rev_t3_h_25 + (-0.12010668218135834) * gru_2_rev_t3_h_26 + (-0.12627136707305908) * gru_2_rev_t3_h_27 + (-0.20266787707805634) * gru_2_rev_t3_h_28 + (-0.098273232579231262) * gru_2_rev_t3_h_29 + (-0.14397051930427551) * gru_2_rev_t3_h_30 + (-0.00070814805803820491) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.37050506472587585) + (0.28709319233894348) * gru_1_out_t2_0 + (-0.53150981664657593) * gru_1_out_t2_1 + (-0.60948652029037476) * gru_1_out_t2_2 + (-1.0374951362609863) * gru_1_out_t2_3 + (-0.16194482147693634) * gru_1_out_t2_4 + (-0.34754043817520142) * gru_1_out_t2_5 + (-0.39278358221054077) * gru_1_out_t2_6 + (0.20474226772785187) * gru_1_out_t2_7 + (-0.12141861021518707) * gru_1_out_t2_8 + (-0.3275223970413208) * gru_1_out_t2_9 + (0.077874131500720978) * gru_1_out_t2_10 + (0.280699223279953) * gru_1_out_t2_11 + (0.61639803647994995) * gru_1_out_t2_12 + (0.043668482452630997) * gru_1_out_t2_13 + (0.37510553002357483) * gru_1_out_t2_14 + (-0.39967584609985352) * gru_1_out_t2_15 + (-0.65784168243408203) * gru_1_out_t2_16 + (0.11554513871669769) * gru_1_out_t2_17 + (0.95039826631546021) * gru_1_out_t2_18 + (-0.34139132499694824) * gru_1_out_t2_19 + (0.069048278033733368) * gru_1_out_t2_20 + (-0.8174317479133606) * gru_1_out_t2_21 + (0.90175998210906982) * gru_1_out_t2_22 + (-0.29701882600784302) * gru_1_out_t2_23 + (-0.18850906193256378) * gru_1_out_t2_24 + (0.49510806798934937) * gru_1_out_t2_25 + (0.10073567181825638) * gru_1_out_t2_26 + (0.16862578690052032) * gru_1_out_t2_27 + (0.23471418023109436) * gru_1_out_t2_28 + (0.43637639284133911) * gru_1_out_t2_29 + (0.13701717555522919) * gru_1_out_t2_30 + (0.81576943397521973) * gru_1_out_t2_31 + (-0.1425633579492569) * gru_1_out_t2_32 + (1.5432109832763672) * gru_1_out_t2_33 + (-0.56619960069656372) * gru_1_out_t2_34 + (-0.20040316879749298) * gru_1_out_t2_35 + (-0.015718871727585793) * gru_1_out_t2_36 + (0.18002298474311829) * gru_1_out_t2_37 + (0.12416938692331314) * gru_1_out_t2_38 + (2.3033244609832764) * gru_1_out_t2_39 + (0.072469927370548248) * gru_1_out_t2_40 + (0.099276922643184662) * gru_1_out_t2_41 + (-0.55155444145202637) * gru_1_out_t2_42 + (0.92959451675415039) * gru_1_out_t2_43 + (-0.77420133352279663) * gru_1_out_t2_44 + (0.51185792684555054) * gru_1_out_t2_45 + (1.4123477935791016) * gru_1_out_t2_46 + (-3.1719026565551758) * gru_1_out_t2_47 + (0.74454700946807861) * gru_1_out_t2_48 + (-0.96140605211257935) * gru_1_out_t2_49 + (0.79436248540878296) * gru_1_out_t2_50 + (0.62289750576019287) * gru_1_out_t2_51 + (-0.87537115812301636) * gru_1_out_t2_52 + (-0.6165962815284729) * gru_1_out_t2_53 + (2.0129127502441406) * gru_1_out_t2_54 + (-0.42063844203948975) * gru_1_out_t2_55 + (-1.2897906303405762) * gru_1_out_t2_56 + (0.18772599101066589) * gru_1_out_t2_57 + (0.30848699808120728) * gru_1_out_t2_58 + (-0.21562355756759644) * gru_1_out_t2_59 + (-0.77269434928894043) * gru_1_out_t2_60 + (-1.3552745580673218) * gru_1_out_t2_61 + (0.89613634347915649) * gru_1_out_t2_62 + (0.47352868318557739) * gru_1_out_t2_63 + gate_r * ((2.9249591827392578) + (-0.09667661041021347) * gru_2_rev_t3_h_0 + (0.072089515626430511) * gru_2_rev_t3_h_1 + (-0.036599684506654739) * gru_2_rev_t3_h_2 + (0.11573515087366104) * gru_2_rev_t3_h_3 + (0.01791471429169178) * gru_2_rev_t3_h_4 + (-0.03135378286242485) * gru_2_rev_t3_h_5 + (0.022771716117858887) * gru_2_rev_t3_h_6 + (0.11483550816774368) * gru_2_rev_t3_h_7 + (-0.052848897874355316) * gru_2_rev_t3_h_8 + (0.099833168089389801) * gru_2_rev_t3_h_9 + (-0.089662618935108185) * gru_2_rev_t3_h_10 + (0.25769615173339844) * gru_2_rev_t3_h_11 + (-0.028268128633499146) * gru_2_rev_t3_h_12 + (0.046881504356861115) * gru_2_rev_t3_h_13 + (-0.15469586849212646) * gru_2_rev_t3_h_14 + (0.10889905691146851) * gru_2_rev_t3_h_15 + (-0.036221999675035477) * gru_2_rev_t3_h_16 + (0.21077723801136017) * gru_2_rev_t3_h_17 + (0.053946699947118759) * gru_2_rev_t3_h_18 + (-0.17076520621776581) * gru_2_rev_t3_h_19 + (0.05781015008687973) * gru_2_rev_t3_h_20 + (-0.13598960638046265) * gru_2_rev_t3_h_21 + (0.16408737003803253) * gru_2_rev_t3_h_22 + (-0.051414929330348969) * gru_2_rev_t3_h_23 + (-0.25236350297927856) * gru_2_rev_t3_h_24 + (0.19018042087554932) * gru_2_rev_t3_h_25 + (-0.16084688901901245) * gru_2_rev_t3_h_26 + (0.016324251890182495) * gru_2_rev_t3_h_27 + (0.077229596674442291) * gru_2_rev_t3_h_28 + (-0.0017403340898454189) * gru_2_rev_t3_h_29 + (0.039791285991668701) * gru_2_rev_t3_h_30 + (0.18991574645042419) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_14 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_14;
    // h=15
    gate_r = sigmoid((0.72947525978088379) + (-0.022303545847535133) * gru_1_out_t2_0 + (-0.026139296591281891) * gru_1_out_t2_1 + (-0.11120835691690445) * gru_1_out_t2_2 + (0.16612853109836578) * gru_1_out_t2_3 + (0.16181418299674988) * gru_1_out_t2_4 + (-0.1505705863237381) * gru_1_out_t2_5 + (0.34857684373855591) * gru_1_out_t2_6 + (0.12769512832164764) * gru_1_out_t2_7 + (0.3933473527431488) * gru_1_out_t2_8 + (-1.379785418510437) * gru_1_out_t2_9 + (0.34886139631271362) * gru_1_out_t2_10 + (0.069966688752174377) * gru_1_out_t2_11 + (-0.29992860555648804) * gru_1_out_t2_12 + (0.44492718577384949) * gru_1_out_t2_13 + (-0.69007366895675659) * gru_1_out_t2_14 + (-0.73447304964065552) * gru_1_out_t2_15 + (-0.17360711097717285) * gru_1_out_t2_16 + (0.34715291857719421) * gru_1_out_t2_17 + (1.4037023782730103) * gru_1_out_t2_18 + (-1.5904912948608398) * gru_1_out_t2_19 + (0.24511599540710449) * gru_1_out_t2_20 + (-1.0433336496353149) * gru_1_out_t2_21 + (0.49529048800468445) * gru_1_out_t2_22 + (-0.57786297798156738) * gru_1_out_t2_23 + (-0.43647485971450806) * gru_1_out_t2_24 + (-0.34322458505630493) * gru_1_out_t2_25 + (1.0122861862182617) * gru_1_out_t2_26 + (0.07970893383026123) * gru_1_out_t2_27 + (-2.275566577911377) * gru_1_out_t2_28 + (0.15435080230236053) * gru_1_out_t2_29 + (0.38388258218765259) * gru_1_out_t2_30 + (0.56043940782546997) * gru_1_out_t2_31 + (0.51487904787063599) * gru_1_out_t2_32 + (0.33823698759078979) * gru_1_out_t2_33 + (-0.61920207738876343) * gru_1_out_t2_34 + (0.25618645548820496) * gru_1_out_t2_35 + (1.8967082500457764) * gru_1_out_t2_36 + (-0.20773407816886902) * gru_1_out_t2_37 + (-0.61071228981018066) * gru_1_out_t2_38 + (0.66163104772567749) * gru_1_out_t2_39 + (-1.8205702304840088) * gru_1_out_t2_40 + (0.68615341186523438) * gru_1_out_t2_41 + (-0.45790243148803711) * gru_1_out_t2_42 + (0.90287762880325317) * gru_1_out_t2_43 + (-0.43719285726547241) * gru_1_out_t2_44 + (-0.42465347051620483) * gru_1_out_t2_45 + (-0.47414785623550415) * gru_1_out_t2_46 + (-0.44144102931022644) * gru_1_out_t2_47 + (-2.1431574821472168) * gru_1_out_t2_48 + (0.23270441591739655) * gru_1_out_t2_49 + (-0.69276821613311768) * gru_1_out_t2_50 + (0.53854745626449585) * gru_1_out_t2_51 + (-0.70491784811019897) * gru_1_out_t2_52 + (0.40314397215843201) * gru_1_out_t2_53 + (0.13695614039897919) * gru_1_out_t2_54 + (0.22422562539577484) * gru_1_out_t2_55 + (-0.044118069112300873) * gru_1_out_t2_56 + (0.3574410080909729) * gru_1_out_t2_57 + (0.51054012775421143) * gru_1_out_t2_58 + (0.063237756490707397) * gru_1_out_t2_59 + (0.20521864295005798) * gru_1_out_t2_60 + (-0.17130334675312042) * gru_1_out_t2_61 + (0.18497006595134735) * gru_1_out_t2_62 + (0.62373632192611694) * gru_1_out_t2_63 + (0.098803132772445679) * gru_2_rev_t3_h_0 + (-0.14035405218601227) * gru_2_rev_t3_h_1 + (0.10547539591789246) * gru_2_rev_t3_h_2 + (0.0393972247838974) * gru_2_rev_t3_h_3 + (-0.13264232873916626) * gru_2_rev_t3_h_4 + (-0.13730992376804352) * gru_2_rev_t3_h_5 + (-0.0076085040345788002) * gru_2_rev_t3_h_6 + (-0.071372762322425842) * gru_2_rev_t3_h_7 + (0.064133316278457642) * gru_2_rev_t3_h_8 + (0.090793028473854065) * gru_2_rev_t3_h_9 + (-0.17190316319465637) * gru_2_rev_t3_h_10 + (-0.12868133187294006) * gru_2_rev_t3_h_11 + (0.071253202855587006) * gru_2_rev_t3_h_12 + (0.0011826448608189821) * gru_2_rev_t3_h_13 + (-0.049725882709026337) * gru_2_rev_t3_h_14 + (0.084352664649486542) * gru_2_rev_t3_h_15 + (-0.040013525635004044) * gru_2_rev_t3_h_16 + (0.080999076366424561) * gru_2_rev_t3_h_17 + (-0.0037085949443280697) * gru_2_rev_t3_h_18 + (-0.037504475563764572) * gru_2_rev_t3_h_19 + (-0.066250145435333252) * gru_2_rev_t3_h_20 + (0.095976904034614563) * gru_2_rev_t3_h_21 + (0.22432874143123627) * gru_2_rev_t3_h_22 + (0.15839384496212006) * gru_2_rev_t3_h_23 + (0.0063899192027747631) * gru_2_rev_t3_h_24 + (-0.10144340991973877) * gru_2_rev_t3_h_25 + (-0.095382846891880035) * gru_2_rev_t3_h_26 + (0.018796613439917564) * gru_2_rev_t3_h_27 + (0.024632252752780914) * gru_2_rev_t3_h_28 + (0.13450869917869568) * gru_2_rev_t3_h_29 + (-0.19447615742683411) * gru_2_rev_t3_h_30 + (-0.011560795828700066) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((-1.7404909133911133) + (-0.89727240800857544) * gru_1_out_t2_0 + (1.0746326446533203) * gru_1_out_t2_1 + (0.3149029016494751) * gru_1_out_t2_2 + (-0.16097906231880188) * gru_1_out_t2_3 + (0.18615281581878662) * gru_1_out_t2_4 + (0.27013212442398071) * gru_1_out_t2_5 + (0.098043292760848999) * gru_1_out_t2_6 + (-0.10988715291023254) * gru_1_out_t2_7 + (-0.14674928784370422) * gru_1_out_t2_8 + (0.16877008974552155) * gru_1_out_t2_9 + (-0.96823692321777344) * gru_1_out_t2_10 + (0.057530101388692856) * gru_1_out_t2_11 + (-1.6057969331741333) * gru_1_out_t2_12 + (-0.338030606508255) * gru_1_out_t2_13 + (0.16643743216991425) * gru_1_out_t2_14 + (-0.26763936877250671) * gru_1_out_t2_15 + (0.70132642984390259) * gru_1_out_t2_16 + (0.68405318260192871) * gru_1_out_t2_17 + (1.0002861022949219) * gru_1_out_t2_18 + (0.020808488130569458) * gru_1_out_t2_19 + (-0.73811739683151245) * gru_1_out_t2_20 + (-0.32983970642089844) * gru_1_out_t2_21 + (1.1426000595092773) * gru_1_out_t2_22 + (-0.66904491186141968) * gru_1_out_t2_23 + (-0.44741806387901306) * gru_1_out_t2_24 + (-0.98083454370498657) * gru_1_out_t2_25 + (-1.039461612701416) * gru_1_out_t2_26 + (1.9155359268188477) * gru_1_out_t2_27 + (-1.4394592046737671) * gru_1_out_t2_28 + (0.31847372651100159) * gru_1_out_t2_29 + (-0.67258810997009277) * gru_1_out_t2_30 + (0.036325514316558838) * gru_1_out_t2_31 + (-0.64632761478424072) * gru_1_out_t2_32 + (-0.77134984731674194) * gru_1_out_t2_33 + (0.689125657081604) * gru_1_out_t2_34 + (0.15346048772335052) * gru_1_out_t2_35 + (-1.2697478532791138) * gru_1_out_t2_36 + (0.14658766984939575) * gru_1_out_t2_37 + (1.1950854063034058) * gru_1_out_t2_38 + (-0.072306007146835327) * gru_1_out_t2_39 + (0.48699647188186646) * gru_1_out_t2_40 + (-1.525425910949707) * gru_1_out_t2_41 + (0.41789871454238892) * gru_1_out_t2_42 + (-0.15131717920303345) * gru_1_out_t2_43 + (0.11187327653169632) * gru_1_out_t2_44 + (-0.1101599857211113) * gru_1_out_t2_45 + (3.4777152538299561) * gru_1_out_t2_46 + (0.092684954404830933) * gru_1_out_t2_47 + (0.11734005063772202) * gru_1_out_t2_48 + (0.081191398203372955) * gru_1_out_t2_49 + (1.5378588438034058) * gru_1_out_t2_50 + (-1.7757362127304077) * gru_1_out_t2_51 + (0.50589674711227417) * gru_1_out_t2_52 + (-0.47342538833618164) * gru_1_out_t2_53 + (-0.51591777801513672) * gru_1_out_t2_54 + (-1.9446356296539307) * gru_1_out_t2_55 + (-0.73851269483566284) * gru_1_out_t2_56 + (-2.0252213478088379) * gru_1_out_t2_57 + (-0.57100754976272583) * gru_1_out_t2_58 + (0.52743786573410034) * gru_1_out_t2_59 + (0.39198824763298035) * gru_1_out_t2_60 + (-1.5783818960189819) * gru_1_out_t2_61 + (0.96494972705841064) * gru_1_out_t2_62 + (-0.95986223220825195) * gru_1_out_t2_63 + (-0.032290592789649963) * gru_2_rev_t3_h_0 + (0.019761312752962112) * gru_2_rev_t3_h_1 + (-0.048818543553352356) * gru_2_rev_t3_h_2 + (0.066602453589439392) * gru_2_rev_t3_h_3 + (-0.024903321638703346) * gru_2_rev_t3_h_4 + (-0.084015972912311554) * gru_2_rev_t3_h_5 + (0.099788002669811249) * gru_2_rev_t3_h_6 + (-0.10610561072826385) * gru_2_rev_t3_h_7 + (0.11020743101835251) * gru_2_rev_t3_h_8 + (0.011961082927882671) * gru_2_rev_t3_h_9 + (-0.18479824066162109) * gru_2_rev_t3_h_10 + (0.073529653251171112) * gru_2_rev_t3_h_11 + (0.050624772906303406) * gru_2_rev_t3_h_12 + (0.11687963455915451) * gru_2_rev_t3_h_13 + (-0.10381600260734558) * gru_2_rev_t3_h_14 + (-0.20959363877773285) * gru_2_rev_t3_h_15 + (0.10109211504459381) * gru_2_rev_t3_h_16 + (0.026847515255212784) * gru_2_rev_t3_h_17 + (-0.057036213576793671) * gru_2_rev_t3_h_18 + (0.08164580911397934) * gru_2_rev_t3_h_19 + (-0.016150152310729027) * gru_2_rev_t3_h_20 + (-0.066731870174407959) * gru_2_rev_t3_h_21 + (-0.12042967230081558) * gru_2_rev_t3_h_22 + (0.069235667586326599) * gru_2_rev_t3_h_23 + (0.14413301646709442) * gru_2_rev_t3_h_24 + (0.10215968638658524) * gru_2_rev_t3_h_25 + (-0.05943746492266655) * gru_2_rev_t3_h_26 + (-0.16047365963459015) * gru_2_rev_t3_h_27 + (-0.041731137782335281) * gru_2_rev_t3_h_28 + (-0.26483070850372314) * gru_2_rev_t3_h_29 + (-0.01981709897518158) * gru_2_rev_t3_h_30 + (-0.011950433254241943) * gru_2_rev_t3_h_31);
    gate_n = tanh((-0.84262549877166748) + (-0.82774901390075684) * gru_1_out_t2_0 + (-0.41509228944778442) * gru_1_out_t2_1 + (-0.047895036637783051) * gru_1_out_t2_2 + (-0.51118361949920654) * gru_1_out_t2_3 + (0.22141289710998535) * gru_1_out_t2_4 + (-0.32939717173576355) * gru_1_out_t2_5 + (0.95649975538253784) * gru_1_out_t2_6 + (-0.18798378109931946) * gru_1_out_t2_7 + (0.038090918213129044) * gru_1_out_t2_8 + (0.59585905075073242) * gru_1_out_t2_9 + (-0.7638697624206543) * gru_1_out_t2_10 + (-0.95676147937774658) * gru_1_out_t2_11 + (0.42525151371955872) * gru_1_out_t2_12 + (0.025433238595724106) * gru_1_out_t2_13 + (0.81789159774780273) * gru_1_out_t2_14 + (0.4420580267906189) * gru_1_out_t2_15 + (0.71781384944915771) * gru_1_out_t2_16 + (-1.4452439546585083) * gru_1_out_t2_17 + (0.17542612552642822) * gru_1_out_t2_18 + (-0.12552085518836975) * gru_1_out_t2_19 + (-0.29190534353256226) * gru_1_out_t2_20 + (1.6399898529052734) * gru_1_out_t2_21 + (0.63288187980651855) * gru_1_out_t2_22 + (-0.16800649464130402) * gru_1_out_t2_23 + (1.0159249305725098) * gru_1_out_t2_24 + (0.05202343687415123) * gru_1_out_t2_25 + (-1.3397111892700195) * gru_1_out_t2_26 + (1.398784875869751) * gru_1_out_t2_27 + (-0.030920004472136497) * gru_1_out_t2_28 + (0.84539520740509033) * gru_1_out_t2_29 + (-0.02339441142976284) * gru_1_out_t2_30 + (0.28686437010765076) * gru_1_out_t2_31 + (-1.9169389009475708) * gru_1_out_t2_32 + (-0.1658247709274292) * gru_1_out_t2_33 + (0.21703019738197327) * gru_1_out_t2_34 + (-0.47848451137542725) * gru_1_out_t2_35 + (-0.58535724878311157) * gru_1_out_t2_36 + (0.27987810969352722) * gru_1_out_t2_37 + (0.46407705545425415) * gru_1_out_t2_38 + (-1.1021131277084351) * gru_1_out_t2_39 + (-0.26660144329071045) * gru_1_out_t2_40 + (-0.55315941572189331) * gru_1_out_t2_41 + (1.1416912078857422) * gru_1_out_t2_42 + (0.5579795241355896) * gru_1_out_t2_43 + (-0.41593700647354126) * gru_1_out_t2_44 + (0.4088059663772583) * gru_1_out_t2_45 + (0.19009546935558319) * gru_1_out_t2_46 + (0.75249487161636353) * gru_1_out_t2_47 + (0.69992119073867798) * gru_1_out_t2_48 + (-0.051740385591983795) * gru_1_out_t2_49 + (1.2721575498580933) * gru_1_out_t2_50 + (-0.72361469268798828) * gru_1_out_t2_51 + (0.38217529654502869) * gru_1_out_t2_52 + (0.16422870755195618) * gru_1_out_t2_53 + (-0.18281133472919464) * gru_1_out_t2_54 + (-0.59855109453201294) * gru_1_out_t2_55 + (0.40504315495491028) * gru_1_out_t2_56 + (-0.670948326587677) * gru_1_out_t2_57 + (-0.37597763538360596) * gru_1_out_t2_58 + (0.3864554762840271) * gru_1_out_t2_59 + (0.2220260351896286) * gru_1_out_t2_60 + (-0.41969037055969238) * gru_1_out_t2_61 + (-0.50049382448196411) * gru_1_out_t2_62 + (0.3439958393573761) * gru_1_out_t2_63 + gate_r * ((-0.87470310926437378) + (0.017436951398849487) * gru_2_rev_t3_h_0 + (0.13250772655010223) * gru_2_rev_t3_h_1 + (0.024064835160970688) * gru_2_rev_t3_h_2 + (0.024430854246020317) * gru_2_rev_t3_h_3 + (-0.055033251643180847) * gru_2_rev_t3_h_4 + (-0.030188256874680519) * gru_2_rev_t3_h_5 + (0.099127925932407379) * gru_2_rev_t3_h_6 + (0.03367527574300766) * gru_2_rev_t3_h_7 + (0.13652393221855164) * gru_2_rev_t3_h_8 + (0.038733027875423431) * gru_2_rev_t3_h_9 + (0.23047088086605072) * gru_2_rev_t3_h_10 + (-0.096359744668006897) * gru_2_rev_t3_h_11 + (0.27664729952812195) * gru_2_rev_t3_h_12 + (0.087351344525814056) * gru_2_rev_t3_h_13 + (-0.15848319232463837) * gru_2_rev_t3_h_14 + (-0.096668817102909088) * gru_2_rev_t3_h_15 + (-0.05881277471780777) * gru_2_rev_t3_h_16 + (-0.20075727999210358) * gru_2_rev_t3_h_17 + (-0.068401865661144257) * gru_2_rev_t3_h_18 + (0.0096914526075124741) * gru_2_rev_t3_h_19 + (-0.008379792794585228) * gru_2_rev_t3_h_20 + (0.066190809011459351) * gru_2_rev_t3_h_21 + (0.13829518854618073) * gru_2_rev_t3_h_22 + (-0.13074840605258942) * gru_2_rev_t3_h_23 + (0.051322143524885178) * gru_2_rev_t3_h_24 + (-0.15113438665866852) * gru_2_rev_t3_h_25 + (-0.1310240775346756) * gru_2_rev_t3_h_26 + (-0.1259879469871521) * gru_2_rev_t3_h_27 + (0.061816968023777008) * gru_2_rev_t3_h_28 + (-0.02489432692527771) * gru_2_rev_t3_h_29 + (0.031291190534830093) * gru_2_rev_t3_h_30 + (0.16007980704307556) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_15 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_15;
    // h=16
    gate_r = sigmoid((1.9213616847991943) + (0.80191349983215332) * gru_1_out_t2_0 + (-1.0755983591079712) * gru_1_out_t2_1 + (0.4123045802116394) * gru_1_out_t2_2 + (-0.62200671434402466) * gru_1_out_t2_3 + (-1.635619044303894) * gru_1_out_t2_4 + (0.31832760572433472) * gru_1_out_t2_5 + (-2.0784268379211426) * gru_1_out_t2_6 + (-0.30028179287910461) * gru_1_out_t2_7 + (0.10635640472173691) * gru_1_out_t2_8 + (-0.35392826795578003) * gru_1_out_t2_9 + (1.6381356716156006) * gru_1_out_t2_10 + (1.2288467884063721) * gru_1_out_t2_11 + (0.70907461643218994) * gru_1_out_t2_12 + (1.0796160697937012) * gru_1_out_t2_13 + (0.030833212658762932) * gru_1_out_t2_14 + (0.35298663377761841) * gru_1_out_t2_15 + (-0.79476922750473022) * gru_1_out_t2_16 + (1.0373742580413818) * gru_1_out_t2_17 + (1.246477484703064) * gru_1_out_t2_18 + (-0.41894969344139099) * gru_1_out_t2_19 + (-0.57384979724884033) * gru_1_out_t2_20 + (-1.5620846748352051) * gru_1_out_t2_21 + (-1.2057693004608154) * gru_1_out_t2_22 + (0.73329263925552368) * gru_1_out_t2_23 + (-0.57186931371688843) * gru_1_out_t2_24 + (0.19045150279998779) * gru_1_out_t2_25 + (-0.37338399887084961) * gru_1_out_t2_26 + (-1.8803176879882812) * gru_1_out_t2_27 + (-0.045740377157926559) * gru_1_out_t2_28 + (0.82845562696456909) * gru_1_out_t2_29 + (0.4995257556438446) * gru_1_out_t2_30 + (0.57214599847793579) * gru_1_out_t2_31 + (4.8275060653686523) * gru_1_out_t2_32 + (0.43619692325592041) * gru_1_out_t2_33 + (-2.3990659713745117) * gru_1_out_t2_34 + (0.95757424831390381) * gru_1_out_t2_35 + (-0.027314724400639534) * gru_1_out_t2_36 + (0.7561500072479248) * gru_1_out_t2_37 + (-0.91960006952285767) * gru_1_out_t2_38 + (0.015334836207330227) * gru_1_out_t2_39 + (-0.087376132607460022) * gru_1_out_t2_40 + (0.80501627922058105) * gru_1_out_t2_41 + (-1.0258505344390869) * gru_1_out_t2_42 + (-0.455118328332901) * gru_1_out_t2_43 + (0.081079393625259399) * gru_1_out_t2_44 + (0.011367802508175373) * gru_1_out_t2_45 + (-1.1995065212249756) * gru_1_out_t2_46 + (-0.92324477434158325) * gru_1_out_t2_47 + (0.39022129774093628) * gru_1_out_t2_48 + (-0.28066974878311157) * gru_1_out_t2_49 + (-1.3987911939620972) * gru_1_out_t2_50 + (2.0019347667694092) * gru_1_out_t2_51 + (-0.027273369953036308) * gru_1_out_t2_52 + (0.12424509227275848) * gru_1_out_t2_53 + (0.2088264524936676) * gru_1_out_t2_54 + (0.73096984624862671) * gru_1_out_t2_55 + (-1.5213284492492676) * gru_1_out_t2_56 + (0.91290533542633057) * gru_1_out_t2_57 + (0.60070896148681641) * gru_1_out_t2_58 + (0.19060581922531128) * gru_1_out_t2_59 + (-0.19445241987705231) * gru_1_out_t2_60 + (-0.14415623247623444) * gru_1_out_t2_61 + (-1.3705402612686157) * gru_1_out_t2_62 + (0.17392316460609436) * gru_1_out_t2_63 + (0.050983663648366928) * gru_2_rev_t3_h_0 + (-0.088608130812644958) * gru_2_rev_t3_h_1 + (0.026418086141347885) * gru_2_rev_t3_h_2 + (0.06640460342168808) * gru_2_rev_t3_h_3 + (0.17020371556282043) * gru_2_rev_t3_h_4 + (-0.066049940884113312) * gru_2_rev_t3_h_5 + (-0.21590150892734528) * gru_2_rev_t3_h_6 + (-0.051484670490026474) * gru_2_rev_t3_h_7 + (0.11932790279388428) * gru_2_rev_t3_h_8 + (0.16828198730945587) * gru_2_rev_t3_h_9 + (-0.050861548632383347) * gru_2_rev_t3_h_10 + (0.0045364131219685078) * gru_2_rev_t3_h_11 + (0.029189087450504303) * gru_2_rev_t3_h_12 + (-0.11775552481412888) * gru_2_rev_t3_h_13 + (-3.8434161979239434e-05) * gru_2_rev_t3_h_14 + (0.14486485719680786) * gru_2_rev_t3_h_15 + (-0.049318894743919373) * gru_2_rev_t3_h_16 + (-0.13830047845840454) * gru_2_rev_t3_h_17 + (-0.15180903673171997) * gru_2_rev_t3_h_18 + (0.013457883149385452) * gru_2_rev_t3_h_19 + (-0.1485704779624939) * gru_2_rev_t3_h_20 + (-0.10231437534093857) * gru_2_rev_t3_h_21 + (-0.04700314998626709) * gru_2_rev_t3_h_22 + (-0.12892766296863556) * gru_2_rev_t3_h_23 + (-0.07964690774679184) * gru_2_rev_t3_h_24 + (0.051513470709323883) * gru_2_rev_t3_h_25 + (-0.15386992692947388) * gru_2_rev_t3_h_26 + (0.064849592745304108) * gru_2_rev_t3_h_27 + (-0.12282835692167282) * gru_2_rev_t3_h_28 + (0.065424464643001556) * gru_2_rev_t3_h_29 + (0.11787242442369461) * gru_2_rev_t3_h_30 + (-0.32024037837982178) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((-1.2624661922454834) + (-0.41791725158691406) * gru_1_out_t2_0 + (-1.4050534963607788) * gru_1_out_t2_1 + (0.20824542641639709) * gru_1_out_t2_2 + (-0.48358246684074402) * gru_1_out_t2_3 + (0.40238046646118164) * gru_1_out_t2_4 + (0.29443207383155823) * gru_1_out_t2_5 + (-1.5166134834289551) * gru_1_out_t2_6 + (-0.28599342703819275) * gru_1_out_t2_7 + (0.098368987441062927) * gru_1_out_t2_8 + (0.37022921442985535) * gru_1_out_t2_9 + (-0.62452143430709839) * gru_1_out_t2_10 + (-0.29817360639572144) * gru_1_out_t2_11 + (0.2824113667011261) * gru_1_out_t2_12 + (0.29993376135826111) * gru_1_out_t2_13 + (0.091077528893947601) * gru_1_out_t2_14 + (0.58251440525054932) * gru_1_out_t2_15 + (0.55540305376052856) * gru_1_out_t2_16 + (-0.34049773216247559) * gru_1_out_t2_17 + (-0.14234979450702667) * gru_1_out_t2_18 + (1.1566134691238403) * gru_1_out_t2_19 + (-0.31548401713371277) * gru_1_out_t2_20 + (0.65435785055160522) * gru_1_out_t2_21 + (0.37839585542678833) * gru_1_out_t2_22 + (-0.76834344863891602) * gru_1_out_t2_23 + (-0.16625870764255524) * gru_1_out_t2_24 + (-0.68651974201202393) * gru_1_out_t2_25 + (-0.55851960182189941) * gru_1_out_t2_26 + (0.67408746480941772) * gru_1_out_t2_27 + (-1.3670505285263062) * gru_1_out_t2_28 + (0.22238372266292572) * gru_1_out_t2_29 + (-0.61462831497192383) * gru_1_out_t2_30 + (0.38202306628227234) * gru_1_out_t2_31 + (0.36242884397506714) * gru_1_out_t2_32 + (-0.46617060899734497) * gru_1_out_t2_33 + (0.45293322205543518) * gru_1_out_t2_34 + (0.062418144196271896) * gru_1_out_t2_35 + (-0.49842280149459839) * gru_1_out_t2_36 + (0.50590288639068604) * gru_1_out_t2_37 + (0.49992495775222778) * gru_1_out_t2_38 + (0.67366832494735718) * gru_1_out_t2_39 + (0.17689900100231171) * gru_1_out_t2_40 + (-0.91229450702667236) * gru_1_out_t2_41 + (0.30723139643669128) * gru_1_out_t2_42 + (0.39710178971290588) * gru_1_out_t2_43 + (-0.035487454384565353) * gru_1_out_t2_44 + (0.019224004819989204) * gru_1_out_t2_45 + (1.9563798904418945) * gru_1_out_t2_46 + (-0.05553799495100975) * gru_1_out_t2_47 + (-0.040234386920928955) * gru_1_out_t2_48 + (-0.58679687976837158) * gru_1_out_t2_49 + (1.5023955106735229) * gru_1_out_t2_50 + (-2.2525491714477539) * gru_1_out_t2_51 + (0.041773729026317596) * gru_1_out_t2_52 + (-0.30624011158943176) * gru_1_out_t2_53 + (-0.31027206778526306) * gru_1_out_t2_54 + (-1.2216356992721558) * gru_1_out_t2_55 + (0.19506311416625977) * gru_1_out_t2_56 + (-0.55562645196914673) * gru_1_out_t2_57 + (0.15284621715545654) * gru_1_out_t2_58 + (-0.015824513509869576) * gru_1_out_t2_59 + (-0.38007062673568726) * gru_1_out_t2_60 + (-0.37519633769989014) * gru_1_out_t2_61 + (0.34145864844322205) * gru_1_out_t2_62 + (-0.87473767995834351) * gru_1_out_t2_63 + (-0.03816903755068779) * gru_2_rev_t3_h_0 + (-0.11080847680568695) * gru_2_rev_t3_h_1 + (0.062448572367429733) * gru_2_rev_t3_h_2 + (0.13025638461112976) * gru_2_rev_t3_h_3 + (-0.18019294738769531) * gru_2_rev_t3_h_4 + (0.09707939624786377) * gru_2_rev_t3_h_5 + (-0.26437026262283325) * gru_2_rev_t3_h_6 + (-0.10451534390449524) * gru_2_rev_t3_h_7 + (-0.039806947112083435) * gru_2_rev_t3_h_8 + (0.09746474027633667) * gru_2_rev_t3_h_9 + (0.15694904327392578) * gru_2_rev_t3_h_10 + (0.114054836332798) * gru_2_rev_t3_h_11 + (-0.036948464810848236) * gru_2_rev_t3_h_12 + (0.055094338953495026) * gru_2_rev_t3_h_13 + (-0.089710518717765808) * gru_2_rev_t3_h_14 + (-0.020180698484182358) * gru_2_rev_t3_h_15 + (0.020680613815784454) * gru_2_rev_t3_h_16 + (-0.069166794419288635) * gru_2_rev_t3_h_17 + (0.15670233964920044) * gru_2_rev_t3_h_18 + (0.031701806932687759) * gru_2_rev_t3_h_19 + (-0.03191731870174408) * gru_2_rev_t3_h_20 + (-0.12378695607185364) * gru_2_rev_t3_h_21 + (-0.14681187272071838) * gru_2_rev_t3_h_22 + (0.15038929879665375) * gru_2_rev_t3_h_23 + (0.063202746212482452) * gru_2_rev_t3_h_24 + (-0.054400287568569183) * gru_2_rev_t3_h_25 + (-0.14950035512447357) * gru_2_rev_t3_h_26 + (0.0091634374111890793) * gru_2_rev_t3_h_27 + (0.067163705825805664) * gru_2_rev_t3_h_28 + (0.085038900375366211) * gru_2_rev_t3_h_29 + (0.004981103353202343) * gru_2_rev_t3_h_30 + (0.071395121514797211) * gru_2_rev_t3_h_31);
    gate_n = tanh((-0.89789861440658569) + (-0.57806462049484253) * gru_1_out_t2_0 + (-0.31548252701759338) * gru_1_out_t2_1 + (-0.66244500875473022) * gru_1_out_t2_2 + (-0.16261386871337891) * gru_1_out_t2_3 + (0.82774722576141357) * gru_1_out_t2_4 + (-0.47737717628479004) * gru_1_out_t2_5 + (0.67732042074203491) * gru_1_out_t2_6 + (0.31343227624893188) * gru_1_out_t2_7 + (-0.48235288262367249) * gru_1_out_t2_8 + (0.022334475070238113) * gru_1_out_t2_9 + (-0.91750919818878174) * gru_1_out_t2_10 + (-0.44732540845870972) * gru_1_out_t2_11 + (-0.63776695728302002) * gru_1_out_t2_12 + (-0.40079912543296814) * gru_1_out_t2_13 + (0.22453577816486359) * gru_1_out_t2_14 + (-0.052937604486942291) * gru_1_out_t2_15 + (0.77967262268066406) * gru_1_out_t2_16 + (-1.0364693403244019) * gru_1_out_t2_17 + (-1.1027895212173462) * gru_1_out_t2_18 + (0.60251933336257935) * gru_1_out_t2_19 + (0.39837181568145752) * gru_1_out_t2_20 + (1.9008160829544067) * gru_1_out_t2_21 + (0.43430611491203308) * gru_1_out_t2_22 + (-1.848781943321228) * gru_1_out_t2_23 + (1.0282925367355347) * gru_1_out_t2_24 + (0.42734596133232117) * gru_1_out_t2_25 + (0.59314841032028198) * gru_1_out_t2_26 + (1.6749999523162842) * gru_1_out_t2_27 + (-0.68755483627319336) * gru_1_out_t2_28 + (-0.15433041751384735) * gru_1_out_t2_29 + (0.80239439010620117) * gru_1_out_t2_30 + (1.2267475128173828) * gru_1_out_t2_31 + (-2.8660869598388672) * gru_1_out_t2_32 + (1.1214308738708496) * gru_1_out_t2_33 + (1.2973901033401489) * gru_1_out_t2_34 + (-0.33228534460067749) * gru_1_out_t2_35 + (-0.64411729574203491) * gru_1_out_t2_36 + (0.26739612221717834) * gru_1_out_t2_37 + (0.70975524187088013) * gru_1_out_t2_38 + (-0.47256457805633545) * gru_1_out_t2_39 + (0.36850285530090332) * gru_1_out_t2_40 + (-0.67634868621826172) * gru_1_out_t2_41 + (2.3144681453704834) * gru_1_out_t2_42 + (0.67139440774917603) * gru_1_out_t2_43 + (0.0077012483961880207) * gru_1_out_t2_44 + (-0.30177676677703857) * gru_1_out_t2_45 + (3.1783909797668457) * gru_1_out_t2_46 + (0.36266517639160156) * gru_1_out_t2_47 + (0.52212262153625488) * gru_1_out_t2_48 + (1.1986936330795288) * gru_1_out_t2_49 + (2.0088315010070801) * gru_1_out_t2_50 + (-2.5815439224243164) * gru_1_out_t2_51 + (1.9774227142333984) * gru_1_out_t2_52 + (-0.25953817367553711) * gru_1_out_t2_53 + (1.0133218765258789) * gru_1_out_t2_54 + (-1.3285238742828369) * gru_1_out_t2_55 + (0.73807162046432495) * gru_1_out_t2_56 + (-1.4226444959640503) * gru_1_out_t2_57 + (-0.11980514973402023) * gru_1_out_t2_58 + (0.44774320721626282) * gru_1_out_t2_59 + (-1.0728851556777954) * gru_1_out_t2_60 + (-2.9578957557678223) * gru_1_out_t2_61 + (1.6369014978408813) * gru_1_out_t2_62 + (-0.35787659883499146) * gru_1_out_t2_63 + gate_r * ((-1.2894237041473389) + (0.12615218758583069) * gru_2_rev_t3_h_0 + (0.067606136202812195) * gru_2_rev_t3_h_1 + (-0.1444597989320755) * gru_2_rev_t3_h_2 + (0.11718571186065674) * gru_2_rev_t3_h_3 + (-0.033724155277013779) * gru_2_rev_t3_h_4 + (0.068825200200080872) * gru_2_rev_t3_h_5 + (0.066760122776031494) * gru_2_rev_t3_h_6 + (-0.015232361853122711) * gru_2_rev_t3_h_7 + (-0.070981979370117188) * gru_2_rev_t3_h_8 + (0.036652028560638428) * gru_2_rev_t3_h_9 + (0.049914520233869553) * gru_2_rev_t3_h_10 + (-0.013517308980226517) * gru_2_rev_t3_h_11 + (-0.063294351100921631) * gru_2_rev_t3_h_12 + (-0.16742309927940369) * gru_2_rev_t3_h_13 + (0.13896007835865021) * gru_2_rev_t3_h_14 + (0.052335530519485474) * gru_2_rev_t3_h_15 + (-0.16308055818080902) * gru_2_rev_t3_h_16 + (0.1706116795539856) * gru_2_rev_t3_h_17 + (0.084728814661502838) * gru_2_rev_t3_h_18 + (0.048519544303417206) * gru_2_rev_t3_h_19 + (0.037222392857074738) * gru_2_rev_t3_h_20 + (-0.072732508182525635) * gru_2_rev_t3_h_21 + (-0.0022439672611653805) * gru_2_rev_t3_h_22 + (-0.023370364680886269) * gru_2_rev_t3_h_23 + (0.16962940990924835) * gru_2_rev_t3_h_24 + (-0.091476522386074066) * gru_2_rev_t3_h_25 + (-0.09497041255235672) * gru_2_rev_t3_h_26 + (0.16695964336395264) * gru_2_rev_t3_h_27 + (0.058717232197523117) * gru_2_rev_t3_h_28 + (-0.049295060336589813) * gru_2_rev_t3_h_29 + (-0.16811211407184601) * gru_2_rev_t3_h_30 + (-0.00077585165854543447) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_16 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_16;
    // h=17
    gate_r = sigmoid((0.096465848386287689) + (-0.090765021741390228) * gru_1_out_t2_0 + (1.6514859199523926) * gru_1_out_t2_1 + (-1.1378346681594849) * gru_1_out_t2_2 + (-0.39927443861961365) * gru_1_out_t2_3 + (-1.2839212417602539) * gru_1_out_t2_4 + (2.5280745029449463) * gru_1_out_t2_5 + (-1.4978926181793213) * gru_1_out_t2_6 + (-3.9336667060852051) * gru_1_out_t2_7 + (-0.17517754435539246) * gru_1_out_t2_8 + (0.27753260731697083) * gru_1_out_t2_9 + (0.98275822401046753) * gru_1_out_t2_10 + (-0.38829982280731201) * gru_1_out_t2_11 + (1.0690603256225586) * gru_1_out_t2_12 + (-0.1279386579990387) * gru_1_out_t2_13 + (1.4801956415176392) * gru_1_out_t2_14 + (0.30581432580947876) * gru_1_out_t2_15 + (-0.067519709467887878) * gru_1_out_t2_16 + (-0.2598147988319397) * gru_1_out_t2_17 + (-2.826460599899292) * gru_1_out_t2_18 + (0.34204325079917908) * gru_1_out_t2_19 + (-1.2011153697967529) * gru_1_out_t2_20 + (0.58191055059432983) * gru_1_out_t2_21 + (-2.0751442909240723) * gru_1_out_t2_22 + (2.5436809062957764) * gru_1_out_t2_23 + (3.9033675193786621) * gru_1_out_t2_24 + (-0.17586766183376312) * gru_1_out_t2_25 + (-1.0666728019714355) * gru_1_out_t2_26 + (0.34455186128616333) * gru_1_out_t2_27 + (4.3160743713378906) * gru_1_out_t2_28 + (-2.5100905895233154) * gru_1_out_t2_29 + (-1.615425705909729) * gru_1_out_t2_30 + (-0.14286890625953674) * gru_1_out_t2_31 + (0.95950555801391602) * gru_1_out_t2_32 + (-0.88616228103637695) * gru_1_out_t2_33 + (1.9763634204864502) * gru_1_out_t2_34 + (-0.17213815450668335) * gru_1_out_t2_35 + (-0.33603611588478088) * gru_1_out_t2_36 + (-3.9541001319885254) * gru_1_out_t2_37 + (0.16461308300495148) * gru_1_out_t2_38 + (0.38869631290435791) * gru_1_out_t2_39 + (0.58529436588287354) * gru_1_out_t2_40 + (-0.17578847706317902) * gru_1_out_t2_41 + (0.63488924503326416) * gru_1_out_t2_42 + (-0.12910111248493195) * gru_1_out_t2_43 + (0.1850004643201828) * gru_1_out_t2_44 + (-0.35915929079055786) * gru_1_out_t2_45 + (0.52539753913879395) * gru_1_out_t2_46 + (-1.2939226627349854) * gru_1_out_t2_47 + (0.85029548406600952) * gru_1_out_t2_48 + (1.0940637588500977) * gru_1_out_t2_49 + (-0.63784885406494141) * gru_1_out_t2_50 + (-0.28975141048431396) * gru_1_out_t2_51 + (4.654332160949707) * gru_1_out_t2_52 + (-0.05048307403922081) * gru_1_out_t2_53 + (-0.45669767260551453) * gru_1_out_t2_54 + (3.2242751121520996) * gru_1_out_t2_55 + (3.9809913635253906) * gru_1_out_t2_56 + (-0.22697758674621582) * gru_1_out_t2_57 + (-1.3957870006561279) * gru_1_out_t2_58 + (0.033704612404108047) * gru_1_out_t2_59 + (-0.11025817692279816) * gru_1_out_t2_60 + (0.57724857330322266) * gru_1_out_t2_61 + (-1.1906088590621948) * gru_1_out_t2_62 + (-0.46066835522651672) * gru_1_out_t2_63 + (0.048996210098266602) * gru_2_rev_t3_h_0 + (-0.23880238831043243) * gru_2_rev_t3_h_1 + (-0.10870750993490219) * gru_2_rev_t3_h_2 + (-0.11826343089342117) * gru_2_rev_t3_h_3 + (0.10501623898744583) * gru_2_rev_t3_h_4 + (0.099952451884746552) * gru_2_rev_t3_h_5 + (-0.038918450474739075) * gru_2_rev_t3_h_6 + (0.047522500157356262) * gru_2_rev_t3_h_7 + (0.10595767199993134) * gru_2_rev_t3_h_8 + (-0.097166217863559723) * gru_2_rev_t3_h_9 + (0.051396261900663376) * gru_2_rev_t3_h_10 + (0.077448129653930664) * gru_2_rev_t3_h_11 + (0.015691930428147316) * gru_2_rev_t3_h_12 + (0.14246150851249695) * gru_2_rev_t3_h_13 + (-0.03678339347243309) * gru_2_rev_t3_h_14 + (0.10059095919132233) * gru_2_rev_t3_h_15 + (-0.13092917203903198) * gru_2_rev_t3_h_16 + (0.10820052027702332) * gru_2_rev_t3_h_17 + (-0.039826773107051849) * gru_2_rev_t3_h_18 + (-0.11962691694498062) * gru_2_rev_t3_h_19 + (0.12986604869365692) * gru_2_rev_t3_h_20 + (0.13099129498004913) * gru_2_rev_t3_h_21 + (-0.10354040563106537) * gru_2_rev_t3_h_22 + (0.16088975965976715) * gru_2_rev_t3_h_23 + (-0.036392383277416229) * gru_2_rev_t3_h_24 + (0.17739088833332062) * gru_2_rev_t3_h_25 + (-0.15591396391391754) * gru_2_rev_t3_h_26 + (0.006519724614918232) * gru_2_rev_t3_h_27 + (-0.042984660714864731) * gru_2_rev_t3_h_28 + (-0.17487739026546478) * gru_2_rev_t3_h_29 + (0.14035457372665405) * gru_2_rev_t3_h_30 + (-0.02107822522521019) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.15402700006961823) + (0.19712045788764954) * gru_1_out_t2_0 + (0.33192315697669983) * gru_1_out_t2_1 + (0.54148238897323608) * gru_1_out_t2_2 + (1.1610279083251953) * gru_1_out_t2_3 + (0.70523130893707275) * gru_1_out_t2_4 + (0.32611295580863953) * gru_1_out_t2_5 + (0.25491586327552795) * gru_1_out_t2_6 + (1.4171173572540283) * gru_1_out_t2_7 + (-0.59778374433517456) * gru_1_out_t2_8 + (-0.27623423933982849) * gru_1_out_t2_9 + (-0.46518358588218689) * gru_1_out_t2_10 + (-0.63650798797607422) * gru_1_out_t2_11 + (-1.1299324035644531) * gru_1_out_t2_12 + (-0.18515360355377197) * gru_1_out_t2_13 + (-0.60984224081039429) * gru_1_out_t2_14 + (-0.53449642658233643) * gru_1_out_t2_15 + (-0.1328369528055191) * gru_1_out_t2_16 + (0.19735214114189148) * gru_1_out_t2_17 + (0.43056827783584595) * gru_1_out_t2_18 + (-0.51767480373382568) * gru_1_out_t2_19 + (1.5969361066818237) * gru_1_out_t2_20 + (0.39054569602012634) * gru_1_out_t2_21 + (-0.52287197113037109) * gru_1_out_t2_22 + (0.20546671748161316) * gru_1_out_t2_23 + (-0.033080492168664932) * gru_1_out_t2_24 + (0.090716682374477386) * gru_1_out_t2_25 + (0.23324255645275116) * gru_1_out_t2_26 + (0.014045346528291702) * gru_1_out_t2_27 + (-0.16786259412765503) * gru_1_out_t2_28 + (-1.5184518098831177) * gru_1_out_t2_29 + (-0.37097626924514771) * gru_1_out_t2_30 + (-0.64742422103881836) * gru_1_out_t2_31 + (-0.63535338640213013) * gru_1_out_t2_32 + (-0.25831672549247742) * gru_1_out_t2_33 + (0.37675574421882629) * gru_1_out_t2_34 + (-0.37467622756958008) * gru_1_out_t2_35 + (0.12568025290966034) * gru_1_out_t2_36 + (-0.57496899366378784) * gru_1_out_t2_37 + (0.014881339855492115) * gru_1_out_t2_38 + (-0.17543476819992065) * gru_1_out_t2_39 + (-0.2530367374420166) * gru_1_out_t2_40 + (0.25141510367393494) * gru_1_out_t2_41 + (0.034619305282831192) * gru_1_out_t2_42 + (0.3242136538028717) * gru_1_out_t2_43 + (-0.081947676837444305) * gru_1_out_t2_44 + (-0.88736999034881592) * gru_1_out_t2_45 + (-0.17881160974502563) * gru_1_out_t2_46 + (0.42963340878486633) * gru_1_out_t2_47 + (-1.2010366916656494) * gru_1_out_t2_48 + (-0.59058022499084473) * gru_1_out_t2_49 + (0.11653738468885422) * gru_1_out_t2_50 + (0.22647850215435028) * gru_1_out_t2_51 + (0.0063720610924065113) * gru_1_out_t2_52 + (0.4711635410785675) * gru_1_out_t2_53 + (1.2950675487518311) * gru_1_out_t2_54 + (-0.38546749949455261) * gru_1_out_t2_55 + (0.80822312831878662) * gru_1_out_t2_56 + (0.1164686530828476) * gru_1_out_t2_57 + (1.0646176338195801) * gru_1_out_t2_58 + (-0.13396660983562469) * gru_1_out_t2_59 + (0.31600135564804077) * gru_1_out_t2_60 + (-1.2458000183105469) * gru_1_out_t2_61 + (0.76597630977630615) * gru_1_out_t2_62 + (0.41845488548278809) * gru_1_out_t2_63 + (-0.11455453932285309) * gru_2_rev_t3_h_0 + (0.12142738699913025) * gru_2_rev_t3_h_1 + (-0.066482529044151306) * gru_2_rev_t3_h_2 + (0.090884700417518616) * gru_2_rev_t3_h_3 + (0.06863962858915329) * gru_2_rev_t3_h_4 + (0.20494973659515381) * gru_2_rev_t3_h_5 + (-0.024049334228038788) * gru_2_rev_t3_h_6 + (0.013016195967793465) * gru_2_rev_t3_h_7 + (-0.077670678496360779) * gru_2_rev_t3_h_8 + (-0.14263129234313965) * gru_2_rev_t3_h_9 + (-0.056537549942731857) * gru_2_rev_t3_h_10 + (0.12171578407287598) * gru_2_rev_t3_h_11 + (-0.050475642085075378) * gru_2_rev_t3_h_12 + (0.083502888679504395) * gru_2_rev_t3_h_13 + (0.079025693237781525) * gru_2_rev_t3_h_14 + (-0.008354920893907547) * gru_2_rev_t3_h_15 + (-0.0072716879658401012) * gru_2_rev_t3_h_16 + (-0.12857459485530853) * gru_2_rev_t3_h_17 + (-0.02950492687523365) * gru_2_rev_t3_h_18 + (-0.26776358485221863) * gru_2_rev_t3_h_19 + (0.059346374124288559) * gru_2_rev_t3_h_20 + (0.15425008535385132) * gru_2_rev_t3_h_21 + (0.015288956463336945) * gru_2_rev_t3_h_22 + (-0.024639153853058815) * gru_2_rev_t3_h_23 + (0.030937980860471725) * gru_2_rev_t3_h_24 + (-0.1648118793964386) * gru_2_rev_t3_h_25 + (-0.11417238414287567) * gru_2_rev_t3_h_26 + (0.068839855492115021) * gru_2_rev_t3_h_27 + (-0.009190065786242485) * gru_2_rev_t3_h_28 + (-0.12736804783344269) * gru_2_rev_t3_h_29 + (0.031466517597436905) * gru_2_rev_t3_h_30 + (-0.029003698378801346) * gru_2_rev_t3_h_31);
    gate_n = tanh((-0.22205880284309387) + (-0.50841909646987915) * gru_1_out_t2_0 + (-0.12369619309902191) * gru_1_out_t2_1 + (-0.43248194456100464) * gru_1_out_t2_2 + (0.76625478267669678) * gru_1_out_t2_3 + (0.65424478054046631) * gru_1_out_t2_4 + (-0.2673976719379425) * gru_1_out_t2_5 + (-0.39875152707099915) * gru_1_out_t2_6 + (-0.52860110998153687) * gru_1_out_t2_7 + (-1.6611645221710205) * gru_1_out_t2_8 + (-0.054731126874685287) * gru_1_out_t2_9 + (-0.63304096460342407) * gru_1_out_t2_10 + (0.40386307239532471) * gru_1_out_t2_11 + (-0.75464600324630737) * gru_1_out_t2_12 + (-0.20066675543785095) * gru_1_out_t2_13 + (-0.80136352777481079) * gru_1_out_t2_14 + (0.056439828127622604) * gru_1_out_t2_15 + (0.066574685275554657) * gru_1_out_t2_16 + (0.27188578248023987) * gru_1_out_t2_17 + (-0.19624964892864227) * gru_1_out_t2_18 + (-0.050851780921220779) * gru_1_out_t2_19 + (0.14210917055606842) * gru_1_out_t2_20 + (0.41237711906433105) * gru_1_out_t2_21 + (-0.65654885768890381) * gru_1_out_t2_22 + (0.49707174301147461) * gru_1_out_t2_23 + (0.50801509618759155) * gru_1_out_t2_24 + (-0.13051636517047882) * gru_1_out_t2_25 + (-0.56179571151733398) * gru_1_out_t2_26 + (0.94237309694290161) * gru_1_out_t2_27 + (-0.042365767061710358) * gru_1_out_t2_28 + (-0.67355728149414062) * gru_1_out_t2_29 + (-0.44955608248710632) * gru_1_out_t2_30 + (-0.80717825889587402) * gru_1_out_t2_31 + (-0.46199440956115723) * gru_1_out_t2_32 + (0.073250673711299896) * gru_1_out_t2_33 + (0.33420151472091675) * gru_1_out_t2_34 + (-0.4744991660118103) * gru_1_out_t2_35 + (0.02456224337220192) * gru_1_out_t2_36 + (-0.58215051889419556) * gru_1_out_t2_37 + (0.4039519727230072) * gru_1_out_t2_38 + (-1.0211414098739624) * gru_1_out_t2_39 + (0.1283690482378006) * gru_1_out_t2_40 + (0.12435676157474518) * gru_1_out_t2_41 + (1.0838433504104614) * gru_1_out_t2_42 + (0.99929261207580566) * gru_1_out_t2_43 + (-0.045626096427440643) * gru_1_out_t2_44 + (1.4346281290054321) * gru_1_out_t2_45 + (-1.1181105375289917) * gru_1_out_t2_46 + (0.82993417978286743) * gru_1_out_t2_47 + (-1.0465728044509888) * gru_1_out_t2_48 + (2.6595721244812012) * gru_1_out_t2_49 + (0.21527475118637085) * gru_1_out_t2_50 + (0.26823851466178894) * gru_1_out_t2_51 + (-2.1741197109222412) * gru_1_out_t2_52 + (-0.025576360523700714) * gru_1_out_t2_53 + (0.85823392868041992) * gru_1_out_t2_54 + (-0.28357642889022827) * gru_1_out_t2_55 + (0.72210139036178589) * gru_1_out_t2_56 + (0.13995406031608582) * gru_1_out_t2_57 + (-0.18446940183639526) * gru_1_out_t2_58 + (0.20492401719093323) * gru_1_out_t2_59 + (0.25121787190437317) * gru_1_out_t2_60 + (0.15761278569698334) * gru_1_out_t2_61 + (2.0837917327880859) * gru_1_out_t2_62 + (0.23383383452892303) * gru_1_out_t2_63 + gate_r * ((-0.33889096975326538) + (-0.11084852367639542) * gru_2_rev_t3_h_0 + (-0.026666982099413872) * gru_2_rev_t3_h_1 + (-0.06265626847743988) * gru_2_rev_t3_h_2 + (-0.098455682396888733) * gru_2_rev_t3_h_3 + (0.10437792539596558) * gru_2_rev_t3_h_4 + (-0.012135401368141174) * gru_2_rev_t3_h_5 + (0.091865494847297668) * gru_2_rev_t3_h_6 + (3.9959813875611871e-05) * gru_2_rev_t3_h_7 + (0.030909083783626556) * gru_2_rev_t3_h_8 + (0.23287303745746613) * gru_2_rev_t3_h_9 + (-0.084275901317596436) * gru_2_rev_t3_h_10 + (-0.16076529026031494) * gru_2_rev_t3_h_11 + (0.16617217659950256) * gru_2_rev_t3_h_12 + (0.019039176404476166) * gru_2_rev_t3_h_13 + (0.03444267064332962) * gru_2_rev_t3_h_14 + (-0.016597216948866844) * gru_2_rev_t3_h_15 + (0.091966606676578522) * gru_2_rev_t3_h_16 + (-0.060648392885923386) * gru_2_rev_t3_h_17 + (-0.085129030048847198) * gru_2_rev_t3_h_18 + (-0.06233876571059227) * gru_2_rev_t3_h_19 + (-0.027244057506322861) * gru_2_rev_t3_h_20 + (-0.039892811328172684) * gru_2_rev_t3_h_21 + (0.046269726008176804) * gru_2_rev_t3_h_22 + (0.082103870809078217) * gru_2_rev_t3_h_23 + (-0.035215172916650772) * gru_2_rev_t3_h_24 + (0.099516816437244415) * gru_2_rev_t3_h_25 + (-0.1489129364490509) * gru_2_rev_t3_h_26 + (0.14113500714302063) * gru_2_rev_t3_h_27 + (-0.048489745706319809) * gru_2_rev_t3_h_28 + (0.16092437505722046) * gru_2_rev_t3_h_29 + (0.0099595626816153526) * gru_2_rev_t3_h_30 + (0.10567028075456619) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_17 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_17;
    // h=18
    gate_r = sigmoid((0.99572283029556274) + (0.48604938387870789) * gru_1_out_t2_0 + (0.26498201489448547) * gru_1_out_t2_1 + (0.14473898708820343) * gru_1_out_t2_2 + (0.19903756678104401) * gru_1_out_t2_3 + (-0.39227965474128723) * gru_1_out_t2_4 + (0.063927702605724335) * gru_1_out_t2_5 + (-0.64832818508148193) * gru_1_out_t2_6 + (-0.055056728422641754) * gru_1_out_t2_7 + (-0.40839368104934692) * gru_1_out_t2_8 + (-0.18138280510902405) * gru_1_out_t2_9 + (0.53572213649749756) * gru_1_out_t2_10 + (0.14052063226699829) * gru_1_out_t2_11 + (0.054180551320314407) * gru_1_out_t2_12 + (0.19285625219345093) * gru_1_out_t2_13 + (0.074608445167541504) * gru_1_out_t2_14 + (-0.082684896886348724) * gru_1_out_t2_15 + (-0.17316025495529175) * gru_1_out_t2_16 + (-0.10590830445289612) * gru_1_out_t2_17 + (0.41041308641433716) * gru_1_out_t2_18 + (-0.27446562051773071) * gru_1_out_t2_19 + (-0.16368521749973297) * gru_1_out_t2_20 + (-0.65804678201675415) * gru_1_out_t2_21 + (-0.2467166930437088) * gru_1_out_t2_22 + (-0.012002918869256973) * gru_1_out_t2_23 + (0.025220440700650215) * gru_1_out_t2_24 + (0.27508464455604553) * gru_1_out_t2_25 + (0.42799746990203857) * gru_1_out_t2_26 + (-0.69904053211212158) * gru_1_out_t2_27 + (-0.34315794706344604) * gru_1_out_t2_28 + (0.42761486768722534) * gru_1_out_t2_29 + (0.39012038707733154) * gru_1_out_t2_30 + (0.063509300351142883) * gru_1_out_t2_31 + (0.79637372493743896) * gru_1_out_t2_32 + (0.45486393570899963) * gru_1_out_t2_33 + (0.14982239902019501) * gru_1_out_t2_34 + (0.058759141713380814) * gru_1_out_t2_35 + (0.31736785173416138) * gru_1_out_t2_36 + (0.011666891165077686) * gru_1_out_t2_37 + (0.11924608796834946) * gru_1_out_t2_38 + (0.47624349594116211) * gru_1_out_t2_39 + (-0.56546205282211304) * gru_1_out_t2_40 + (0.47296023368835449) * gru_1_out_t2_41 + (-0.44135630130767822) * gru_1_out_t2_42 + (-0.43713128566741943) * gru_1_out_t2_43 + (-0.13283242285251617) * gru_1_out_t2_44 + (-0.17513976991176605) * gru_1_out_t2_45 + (-0.33672583103179932) * gru_1_out_t2_46 + (-0.43392401933670044) * gru_1_out_t2_47 + (-0.17973381280899048) * gru_1_out_t2_48 + (0.11581375449895859) * gru_1_out_t2_49 + (-0.35302573442459106) * gru_1_out_t2_50 + (0.53807753324508667) * gru_1_out_t2_51 + (-0.071250110864639282) * gru_1_out_t2_52 + (0.47729608416557312) * gru_1_out_t2_53 + (-0.22209703922271729) * gru_1_out_t2_54 + (0.0090676406398415565) * gru_1_out_t2_55 + (-0.47113350033760071) * gru_1_out_t2_56 + (0.32278656959533691) * gru_1_out_t2_57 + (0.36914300918579102) * gru_1_out_t2_58 + (-0.4411342442035675) * gru_1_out_t2_59 + (0.002188446931540966) * gru_1_out_t2_60 + (0.43665239214897156) * gru_1_out_t2_61 + (-0.43981119990348816) * gru_1_out_t2_62 + (0.23119167983531952) * gru_1_out_t2_63 + (0.062130577862262726) * gru_2_rev_t3_h_0 + (-0.081092514097690582) * gru_2_rev_t3_h_1 + (-0.0042371400631964207) * gru_2_rev_t3_h_2 + (0.07060665637254715) * gru_2_rev_t3_h_3 + (-0.0038037456106394529) * gru_2_rev_t3_h_4 + (0.044353421777486801) * gru_2_rev_t3_h_5 + (-0.066292166709899902) * gru_2_rev_t3_h_6 + (-0.20151631534099579) * gru_2_rev_t3_h_7 + (-0.068214654922485352) * gru_2_rev_t3_h_8 + (-0.065849453210830688) * gru_2_rev_t3_h_9 + (0.13403467833995819) * gru_2_rev_t3_h_10 + (-0.078678436577320099) * gru_2_rev_t3_h_11 + (0.20084042847156525) * gru_2_rev_t3_h_12 + (-0.032436542212963104) * gru_2_rev_t3_h_13 + (-0.027038343250751495) * gru_2_rev_t3_h_14 + (-0.12023262679576874) * gru_2_rev_t3_h_15 + (0.082909606397151947) * gru_2_rev_t3_h_16 + (0.025285474956035614) * gru_2_rev_t3_h_17 + (0.009560232050716877) * gru_2_rev_t3_h_18 + (0.012672056443989277) * gru_2_rev_t3_h_19 + (-0.083144150674343109) * gru_2_rev_t3_h_20 + (-0.0036893747746944427) * gru_2_rev_t3_h_21 + (0.0436541847884655) * gru_2_rev_t3_h_22 + (-0.10875322669744492) * gru_2_rev_t3_h_23 + (-0.060114767402410507) * gru_2_rev_t3_h_24 + (0.16935440897941589) * gru_2_rev_t3_h_25 + (-0.064300112426280975) * gru_2_rev_t3_h_26 + (-0.068443097174167633) * gru_2_rev_t3_h_27 + (0.051846016198396683) * gru_2_rev_t3_h_28 + (0.051924008876085281) * gru_2_rev_t3_h_29 + (0.023776218295097351) * gru_2_rev_t3_h_30 + (0.028403997421264648) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((-3.4540023803710938) + (-1.731419563293457) * gru_1_out_t2_0 + (0.12523254752159119) * gru_1_out_t2_1 + (0.48350059986114502) * gru_1_out_t2_2 + (-0.086563162505626678) * gru_1_out_t2_3 + (-0.052749920636415482) * gru_1_out_t2_4 + (0.91698181629180908) * gru_1_out_t2_5 + (0.38469982147216797) * gru_1_out_t2_6 + (0.2006172239780426) * gru_1_out_t2_7 + (0.7929610013961792) * gru_1_out_t2_8 + (0.88068538904190063) * gru_1_out_t2_9 + (-2.2028272151947021) * gru_1_out_t2_10 + (-0.35102403163909912) * gru_1_out_t2_11 + (-0.2071310430765152) * gru_1_out_t2_12 + (-0.37910005450248718) * gru_1_out_t2_13 + (0.56864619255065918) * gru_1_out_t2_14 + (0.44159126281738281) * gru_1_out_t2_15 + (1.7592622041702271) * gru_1_out_t2_16 + (-0.5145910382270813) * gru_1_out_t2_17 + (-0.66982358694076538) * gru_1_out_t2_18 + (0.40550795197486877) * gru_1_out_t2_19 + (-0.029319021850824356) * gru_1_out_t2_20 + (-0.22251172363758087) * gru_1_out_t2_21 + (1.7872731685638428) * gru_1_out_t2_22 + (-0.89777636528015137) * gru_1_out_t2_23 + (-0.87170511484146118) * gru_1_out_t2_24 + (-1.063628077507019) * gru_1_out_t2_25 + (-1.2600295543670654) * gru_1_out_t2_26 + (0.82736426591873169) * gru_1_out_t2_27 + (0.37782940268516541) * gru_1_out_t2_28 + (0.60551488399505615) * gru_1_out_t2_29 + (-0.76977306604385376) * gru_1_out_t2_30 + (0.10069522261619568) * gru_1_out_t2_31 + (-0.2354201078414917) * gru_1_out_t2_32 + (-0.49135652184486389) * gru_1_out_t2_33 + (0.31130343675613403) * gru_1_out_t2_34 + (0.58366358280181885) * gru_1_out_t2_35 + (-0.89845514297485352) * gru_1_out_t2_36 + (0.26952853798866272) * gru_1_out_t2_37 + (1.1817214488983154) * gru_1_out_t2_38 + (-0.71741670370101929) * gru_1_out_t2_39 + (0.81312114000320435) * gru_1_out_t2_40 + (-1.3640357255935669) * gru_1_out_t2_41 + (1.6501055955886841) * gru_1_out_t2_42 + (1.2896077632904053) * gru_1_out_t2_43 + (0.4191720187664032) * gru_1_out_t2_44 + (0.52696460485458374) * gru_1_out_t2_45 + (2.4576513767242432) * gru_1_out_t2_46 + (0.42150720953941345) * gru_1_out_t2_47 + (0.26053249835968018) * gru_1_out_t2_48 + (-0.55497884750366211) * gru_1_out_t2_49 + (1.4164824485778809) * gru_1_out_t2_50 + (-3.0738649368286133) * gru_1_out_t2_51 + (-0.52361702919006348) * gru_1_out_t2_52 + (-0.88209456205368042) * gru_1_out_t2_53 + (-0.60219442844390869) * gru_1_out_t2_54 + (-1.1707160472869873) * gru_1_out_t2_55 + (0.3001059889793396) * gru_1_out_t2_56 + (-1.548640251159668) * gru_1_out_t2_57 + (-1.2993520498275757) * gru_1_out_t2_58 + (1.07640540599823) * gru_1_out_t2_59 + (-0.45093521475791931) * gru_1_out_t2_60 + (-1.1872140169143677) * gru_1_out_t2_61 + (0.051068846136331558) * gru_1_out_t2_62 + (-1.0229431390762329) * gru_1_out_t2_63 + (-0.22226010262966156) * gru_2_rev_t3_h_0 + (-0.05154024064540863) * gru_2_rev_t3_h_1 + (-0.064673900604248047) * gru_2_rev_t3_h_2 + (0.068618424236774445) * gru_2_rev_t3_h_3 + (0.10760771483182907) * gru_2_rev_t3_h_4 + (-0.015086103230714798) * gru_2_rev_t3_h_5 + (-0.01714598573744297) * gru_2_rev_t3_h_6 + (0.059116344898939133) * gru_2_rev_t3_h_7 + (0.052098672837018967) * gru_2_rev_t3_h_8 + (-0.2103135734796524) * gru_2_rev_t3_h_9 + (-0.10983980447053909) * gru_2_rev_t3_h_10 + (-0.095139950513839722) * gru_2_rev_t3_h_11 + (0.060072045773267746) * gru_2_rev_t3_h_12 + (0.067407123744487762) * gru_2_rev_t3_h_13 + (0.11360752582550049) * gru_2_rev_t3_h_14 + (0.058475110679864883) * gru_2_rev_t3_h_15 + (0.010663283057510853) * gru_2_rev_t3_h_16 + (0.22829611599445343) * gru_2_rev_t3_h_17 + (0.040443830192089081) * gru_2_rev_t3_h_18 + (0.057057715952396393) * gru_2_rev_t3_h_19 + (0.076390914618968964) * gru_2_rev_t3_h_20 + (-0.081387482583522797) * gru_2_rev_t3_h_21 + (-0.078089311718940735) * gru_2_rev_t3_h_22 + (0.013582512736320496) * gru_2_rev_t3_h_23 + (-0.0626521036028862) * gru_2_rev_t3_h_24 + (0.026329942047595978) * gru_2_rev_t3_h_25 + (0.0052344384603202343) * gru_2_rev_t3_h_26 + (0.097963854670524597) * gru_2_rev_t3_h_27 + (0.079488575458526611) * gru_2_rev_t3_h_28 + (0.014790469780564308) * gru_2_rev_t3_h_29 + (-0.0080534061416983604) * gru_2_rev_t3_h_30 + (-0.10536181926727295) * gru_2_rev_t3_h_31);
    gate_n = tanh((1.1144556999206543) + (0.76401090621948242) * gru_1_out_t2_0 + (0.61034327745437622) * gru_1_out_t2_1 + (0.025216354057192802) * gru_1_out_t2_2 + (0.25145134329795837) * gru_1_out_t2_3 + (-0.88774609565734863) * gru_1_out_t2_4 + (0.063409328460693359) * gru_1_out_t2_5 + (-0.3842414915561676) * gru_1_out_t2_6 + (0.23518061637878418) * gru_1_out_t2_7 + (-0.54881662130355835) * gru_1_out_t2_8 + (-0.44352298974990845) * gru_1_out_t2_9 + (1.027991771697998) * gru_1_out_t2_10 + (0.81279098987579346) * gru_1_out_t2_11 + (0.097579479217529297) * gru_1_out_t2_12 + (0.009026775136590004) * gru_1_out_t2_13 + (-0.49104127287864685) * gru_1_out_t2_14 + (-0.41957935690879822) * gru_1_out_t2_15 + (-1.2377264499664307) * gru_1_out_t2_16 + (0.1840534508228302) * gru_1_out_t2_17 + (0.62052792310714722) * gru_1_out_t2_18 + (0.19102956354618073) * gru_1_out_t2_19 + (0.03510090708732605) * gru_1_out_t2_20 + (-0.71421647071838379) * gru_1_out_t2_21 + (-1.1526365280151367) * gru_1_out_t2_22 + (-0.25156578421592712) * gru_1_out_t2_23 + (0.54283761978149414) * gru_1_out_t2_24 + (0.090770520269870758) * gru_1_out_t2_25 + (1.1269868612289429) * gru_1_out_t2_26 + (-0.91225475072860718) * gru_1_out_t2_27 + (-0.10462088882923126) * gru_1_out_t2_28 + (-0.092751786112785339) * gru_1_out_t2_29 + (0.66578578948974609) * gru_1_out_t2_30 + (0.25333043932914734) * gru_1_out_t2_31 + (0.74245095252990723) * gru_1_out_t2_32 + (-0.3984026312828064) * gru_1_out_t2_33 + (-0.21132303774356842) * gru_1_out_t2_34 + (0.028194263577461243) * gru_1_out_t2_35 + (0.66679447889328003) * gru_1_out_t2_36 + (0.020513992756605148) * gru_1_out_t2_37 + (-0.8092694878578186) * gru_1_out_t2_38 + (0.43740558624267578) * gru_1_out_t2_39 + (-0.62308263778686523) * gru_1_out_t2_40 + (1.0678421258926392) * gru_1_out_t2_41 + (-0.51222115755081177) * gru_1_out_t2_42 + (-0.71936905384063721) * gru_1_out_t2_43 + (-0.015470663085579872) * gru_1_out_t2_44 + (-0.87979662418365479) * gru_1_out_t2_45 + (-0.63560670614242554) * gru_1_out_t2_46 + (-0.50613439083099365) * gru_1_out_t2_47 + (-0.14425945281982422) * gru_1_out_t2_48 + (0.16022807359695435) * gru_1_out_t2_49 + (-0.67906016111373901) * gru_1_out_t2_50 + (0.88729351758956909) * gru_1_out_t2_51 + (0.0056625404395163059) * gru_1_out_t2_52 + (0.76149040460586548) * gru_1_out_t2_53 + (-0.19609487056732178) * gru_1_out_t2_54 + (0.53109586238861084) * gru_1_out_t2_55 + (-0.98123830556869507) * gru_1_out_t2_56 + (0.68420451879501343) * gru_1_out_t2_57 + (0.94806939363479614) * gru_1_out_t2_58 + (-0.59494215250015259) * gru_1_out_t2_59 + (-0.21724142134189606) * gru_1_out_t2_60 + (0.32094699144363403) * gru_1_out_t2_61 + (-0.021364064887166023) * gru_1_out_t2_62 + (0.64642107486724854) * gru_1_out_t2_63 + gate_r * ((1.0737320184707642) + (-0.11444894969463348) * gru_2_rev_t3_h_0 + (-0.047958351671695709) * gru_2_rev_t3_h_1 + (0.082668431103229523) * gru_2_rev_t3_h_2 + (0.027475962415337563) * gru_2_rev_t3_h_3 + (-0.040664970874786377) * gru_2_rev_t3_h_4 + (0.001148373237811029) * gru_2_rev_t3_h_5 + (0.069487787783145905) * gru_2_rev_t3_h_6 + (-0.20392805337905884) * gru_2_rev_t3_h_7 + (0.066029399633407593) * gru_2_rev_t3_h_8 + (-0.014500202611088753) * gru_2_rev_t3_h_9 + (-0.01092134416103363) * gru_2_rev_t3_h_10 + (0.039316479116678238) * gru_2_rev_t3_h_11 + (-0.18602688610553741) * gru_2_rev_t3_h_12 + (-0.02557884156703949) * gru_2_rev_t3_h_13 + (-0.085918724536895752) * gru_2_rev_t3_h_14 + (0.064037986099720001) * gru_2_rev_t3_h_15 + (-0.050412479788064957) * gru_2_rev_t3_h_16 + (-0.091434933245182037) * gru_2_rev_t3_h_17 + (0.26705792546272278) * gru_2_rev_t3_h_18 + (-0.10743287205696106) * gru_2_rev_t3_h_19 + (-0.1571490466594696) * gru_2_rev_t3_h_20 + (0.11635515093803406) * gru_2_rev_t3_h_21 + (0.12803612649440765) * gru_2_rev_t3_h_22 + (-0.021697878837585449) * gru_2_rev_t3_h_23 + (-0.13070730865001678) * gru_2_rev_t3_h_24 + (-0.12852126359939575) * gru_2_rev_t3_h_25 + (-0.053944043815135956) * gru_2_rev_t3_h_26 + (-0.04425409808754921) * gru_2_rev_t3_h_27 + (0.047826267778873444) * gru_2_rev_t3_h_28 + (-0.040443990379571915) * gru_2_rev_t3_h_29 + (0.080580659210681915) * gru_2_rev_t3_h_30 + (-0.10019166022539139) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_18 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_18;
    // h=19
    gate_r = sigmoid((1.7417181730270386) + (0.63693064451217651) * gru_1_out_t2_0 + (2.0464012622833252) * gru_1_out_t2_1 + (0.50824165344238281) * gru_1_out_t2_2 + (0.71851843595504761) * gru_1_out_t2_3 + (-0.00099973764736205339) * gru_1_out_t2_4 + (-0.43561181426048279) * gru_1_out_t2_5 + (-0.89625078439712524) * gru_1_out_t2_6 + (0.78772813081741333) * gru_1_out_t2_7 + (-0.43200570344924927) * gru_1_out_t2_8 + (-0.74918907880783081) * gru_1_out_t2_9 + (0.1395399272441864) * gru_1_out_t2_10 + (0.17439930140972137) * gru_1_out_t2_11 + (-0.27126389741897583) * gru_1_out_t2_12 + (2.4426822662353516) * gru_1_out_t2_13 + (-1.2355241775512695) * gru_1_out_t2_14 + (-1.2547475099563599) * gru_1_out_t2_15 + (-0.76947599649429321) * gru_1_out_t2_16 + (-1.9778498411178589) * gru_1_out_t2_17 + (2.7537250518798828) * gru_1_out_t2_18 + (-0.61413770914077759) * gru_1_out_t2_19 + (-0.21419879794120789) * gru_1_out_t2_20 + (-3.031529426574707) * gru_1_out_t2_21 + (0.27306896448135376) * gru_1_out_t2_22 + (-0.040258925408124924) * gru_1_out_t2_23 + (1.5582935810089111) * gru_1_out_t2_24 + (-0.050679583102464676) * gru_1_out_t2_25 + (0.83436596393585205) * gru_1_out_t2_26 + (-0.29919800162315369) * gru_1_out_t2_27 + (-1.0659792423248291) * gru_1_out_t2_28 + (-0.2218802273273468) * gru_1_out_t2_29 + (0.51351052522659302) * gru_1_out_t2_30 + (-1.0428774356842041) * gru_1_out_t2_31 + (0.15454472601413727) * gru_1_out_t2_32 + (0.99472564458847046) * gru_1_out_t2_33 + (0.65908956527709961) * gru_1_out_t2_34 + (0.57560932636260986) * gru_1_out_t2_35 + (-1.0900864601135254) * gru_1_out_t2_36 + (0.1821821928024292) * gru_1_out_t2_37 + (-0.878609299659729) * gru_1_out_t2_38 + (-1.3678746223449707) * gru_1_out_t2_39 + (0.42658558487892151) * gru_1_out_t2_40 + (0.19436240196228027) * gru_1_out_t2_41 + (3.0094761848449707) * gru_1_out_t2_42 + (-0.7169727087020874) * gru_1_out_t2_43 + (0.49970227479934692) * gru_1_out_t2_44 + (1.1332899332046509) * gru_1_out_t2_45 + (1.3436542749404907) * gru_1_out_t2_46 + (-6.4541535377502441) * gru_1_out_t2_47 + (0.13873904943466187) * gru_1_out_t2_48 + (0.2233332097530365) * gru_1_out_t2_49 + (-0.093337558209896088) * gru_1_out_t2_50 + (-2.6698236465454102) * gru_1_out_t2_51 + (-0.40740269422531128) * gru_1_out_t2_52 + (-0.58850604295730591) * gru_1_out_t2_53 + (-1.7383158206939697) * gru_1_out_t2_54 + (2.7986960411071777) * gru_1_out_t2_55 + (-0.76037490367889404) * gru_1_out_t2_56 + (0.46462926268577576) * gru_1_out_t2_57 + (0.079063601791858673) * gru_1_out_t2_58 + (0.54307448863983154) * gru_1_out_t2_59 + (0.43783226609230042) * gru_1_out_t2_60 + (2.1442029476165771) * gru_1_out_t2_61 + (3.2423074245452881) * gru_1_out_t2_62 + (-0.40946081280708313) * gru_1_out_t2_63 + (0.13184492290019989) * gru_2_rev_t3_h_0 + (-0.008791038766503334) * gru_2_rev_t3_h_1 + (-0.008558313362300396) * gru_2_rev_t3_h_2 + (-0.099482789635658264) * gru_2_rev_t3_h_3 + (-0.062479984015226364) * gru_2_rev_t3_h_4 + (-0.11219756305217743) * gru_2_rev_t3_h_5 + (0.061243221163749695) * gru_2_rev_t3_h_6 + (-0.16131529211997986) * gru_2_rev_t3_h_7 + (-0.078246161341667175) * gru_2_rev_t3_h_8 + (0.14726236462593079) * gru_2_rev_t3_h_9 + (0.0059098592028021812) * gru_2_rev_t3_h_10 + (-0.016413837671279907) * gru_2_rev_t3_h_11 + (-0.057072859257459641) * gru_2_rev_t3_h_12 + (0.046182934194803238) * gru_2_rev_t3_h_13 + (0.014265325851738453) * gru_2_rev_t3_h_14 + (-0.16699379682540894) * gru_2_rev_t3_h_15 + (0.096843846142292023) * gru_2_rev_t3_h_16 + (-0.11454112827777863) * gru_2_rev_t3_h_17 + (-0.090394079685211182) * gru_2_rev_t3_h_18 + (-0.0062798331491649151) * gru_2_rev_t3_h_19 + (0.11496259272098541) * gru_2_rev_t3_h_20 + (-0.13840572535991669) * gru_2_rev_t3_h_21 + (0.035390846431255341) * gru_2_rev_t3_h_22 + (0.079107567667961121) * gru_2_rev_t3_h_23 + (-0.04802500456571579) * gru_2_rev_t3_h_24 + (-0.12232352793216705) * gru_2_rev_t3_h_25 + (0.0072142994031310081) * gru_2_rev_t3_h_26 + (0.14223663508892059) * gru_2_rev_t3_h_27 + (0.26245564222335815) * gru_2_rev_t3_h_28 + (-0.071825690567493439) * gru_2_rev_t3_h_29 + (0.22565481066703796) * gru_2_rev_t3_h_30 + (-0.050625212490558624) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.31251382827758789) + (0.14121267199516296) * gru_1_out_t2_0 + (0.059126511216163635) * gru_1_out_t2_1 + (0.32356247305870056) * gru_1_out_t2_2 + (-0.15278835594654083) * gru_1_out_t2_3 + (0.28107622265815735) * gru_1_out_t2_4 + (0.0035206028260290623) * gru_1_out_t2_5 + (-0.19146035611629486) * gru_1_out_t2_6 + (0.11710876971483231) * gru_1_out_t2_7 + (-0.44447910785675049) * gru_1_out_t2_8 + (-0.3396449089050293) * gru_1_out_t2_9 + (-0.37012869119644165) * gru_1_out_t2_10 + (-0.62742990255355835) * gru_1_out_t2_11 + (-0.21888981759548187) * gru_1_out_t2_12 + (-0.1289345771074295) * gru_1_out_t2_13 + (-0.1190774142742157) * gru_1_out_t2_14 + (-0.24291287362575531) * gru_1_out_t2_15 + (-0.12612465023994446) * gru_1_out_t2_16 + (0.48876538872718811) * gru_1_out_t2_17 + (-0.061551827937364578) * gru_1_out_t2_18 + (-0.24431554973125458) * gru_1_out_t2_19 + (0.050812579691410065) * gru_1_out_t2_20 + (-0.37145382165908813) * gru_1_out_t2_21 + (0.6526634693145752) * gru_1_out_t2_22 + (0.38211566209793091) * gru_1_out_t2_23 + (0.36417132616043091) * gru_1_out_t2_24 + (-0.028526036068797112) * gru_1_out_t2_25 + (-0.006653056014329195) * gru_1_out_t2_26 + (-0.23059077560901642) * gru_1_out_t2_27 + (-0.65106093883514404) * gru_1_out_t2_28 + (-0.71656864881515503) * gru_1_out_t2_29 + (0.02981366403400898) * gru_1_out_t2_30 + (-0.31977531313896179) * gru_1_out_t2_31 + (-0.17330393195152283) * gru_1_out_t2_32 + (-0.26099535822868347) * gru_1_out_t2_33 + (0.66051286458969116) * gru_1_out_t2_34 + (-0.50147968530654907) * gru_1_out_t2_35 + (0.016324354335665703) * gru_1_out_t2_36 + (-0.39322525262832642) * gru_1_out_t2_37 + (-0.062875688076019287) * gru_1_out_t2_38 + (-0.0031366217881441116) * gru_1_out_t2_39 + (-0.50203388929367065) * gru_1_out_t2_40 + (0.19874671101570129) * gru_1_out_t2_41 + (0.69395691156387329) * gru_1_out_t2_42 + (-0.5952344536781311) * gru_1_out_t2_43 + (-0.091094151139259338) * gru_1_out_t2_44 + (0.22255699336528778) * gru_1_out_t2_45 + (0.41322168707847595) * gru_1_out_t2_46 + (-0.57608294486999512) * gru_1_out_t2_47 + (-0.55731409788131714) * gru_1_out_t2_48 + (-1.8079755306243896) * gru_1_out_t2_49 + (0.18262204527854919) * gru_1_out_t2_50 + (-0.49906530976295471) * gru_1_out_t2_51 + (0.50962835550308228) * gru_1_out_t2_52 + (0.68994611501693726) * gru_1_out_t2_53 + (0.37196052074432373) * gru_1_out_t2_54 + (0.41055560111999512) * gru_1_out_t2_55 + (-0.80507749319076538) * gru_1_out_t2_56 + (0.30193150043487549) * gru_1_out_t2_57 + (0.31141895055770874) * gru_1_out_t2_58 + (-0.12683473527431488) * gru_1_out_t2_59 + (-0.55647939443588257) * gru_1_out_t2_60 + (0.94176638126373291) * gru_1_out_t2_61 + (0.54093384742736816) * gru_1_out_t2_62 + (0.17222695052623749) * gru_1_out_t2_63 + (0.13054175674915314) * gru_2_rev_t3_h_0 + (-0.077429488301277161) * gru_2_rev_t3_h_1 + (-0.13029414415359497) * gru_2_rev_t3_h_2 + (-0.10293189436197281) * gru_2_rev_t3_h_3 + (-0.036621671169996262) * gru_2_rev_t3_h_4 + (0.020164094865322113) * gru_2_rev_t3_h_5 + (-0.10976126044988632) * gru_2_rev_t3_h_6 + (0.19235812127590179) * gru_2_rev_t3_h_7 + (0.0020315994042903185) * gru_2_rev_t3_h_8 + (0.1061059758067131) * gru_2_rev_t3_h_9 + (-0.0056870346888899803) * gru_2_rev_t3_h_10 + (0.0086243860423564911) * gru_2_rev_t3_h_11 + (0.037775173783302307) * gru_2_rev_t3_h_12 + (-0.045161258429288864) * gru_2_rev_t3_h_13 + (-0.16702304780483246) * gru_2_rev_t3_h_14 + (0.12266945838928223) * gru_2_rev_t3_h_15 + (0.055703587830066681) * gru_2_rev_t3_h_16 + (0.020396474748849869) * gru_2_rev_t3_h_17 + (0.24692888557910919) * gru_2_rev_t3_h_18 + (0.015201193280518055) * gru_2_rev_t3_h_19 + (0.1490127295255661) * gru_2_rev_t3_h_20 + (-0.019594455137848854) * gru_2_rev_t3_h_21 + (-0.11063297837972641) * gru_2_rev_t3_h_22 + (-0.016809387132525444) * gru_2_rev_t3_h_23 + (-0.043359361588954926) * gru_2_rev_t3_h_24 + (-0.19954290986061096) * gru_2_rev_t3_h_25 + (0.14705239236354828) * gru_2_rev_t3_h_26 + (-0.20538966357707977) * gru_2_rev_t3_h_27 + (0.070555627346038818) * gru_2_rev_t3_h_28 + (-0.04334317147731781) * gru_2_rev_t3_h_29 + (-0.25817015767097473) * gru_2_rev_t3_h_30 + (0.0625201016664505) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.29590922594070435) + (0.29538103938102722) * gru_1_out_t2_0 + (-1.3690735101699829) * gru_1_out_t2_1 + (0.077776864171028137) * gru_1_out_t2_2 + (-0.44751718640327454) * gru_1_out_t2_3 + (-0.49558702111244202) * gru_1_out_t2_4 + (0.54432046413421631) * gru_1_out_t2_5 + (-1.5020579099655151) * gru_1_out_t2_6 + (-0.49836263060569763) * gru_1_out_t2_7 + (-0.24647937715053558) * gru_1_out_t2_8 + (-0.13716492056846619) * gru_1_out_t2_9 + (0.58814513683319092) * gru_1_out_t2_10 + (-0.38049638271331787) * gru_1_out_t2_11 + (-0.53577089309692383) * gru_1_out_t2_12 + (-0.73934698104858398) * gru_1_out_t2_13 + (-0.085010819137096405) * gru_1_out_t2_14 + (-0.17330330610275269) * gru_1_out_t2_15 + (-0.54945313930511475) * gru_1_out_t2_16 + (0.98730361461639404) * gru_1_out_t2_17 + (0.59500283002853394) * gru_1_out_t2_18 + (0.14068257808685303) * gru_1_out_t2_19 + (-0.38908213376998901) * gru_1_out_t2_20 + (0.58494943380355835) * gru_1_out_t2_21 + (0.28526923060417175) * gru_1_out_t2_22 + (0.61106908321380615) * gru_1_out_t2_23 + (1.1110624074935913) * gru_1_out_t2_24 + (0.054021399468183517) * gru_1_out_t2_25 + (0.92556238174438477) * gru_1_out_t2_26 + (0.32280200719833374) * gru_1_out_t2_27 + (-1.0196102857589722) * gru_1_out_t2_28 + (-0.24044060707092285) * gru_1_out_t2_29 + (1.2399026155471802) * gru_1_out_t2_30 + (-0.12204824388027191) * gru_1_out_t2_31 + (5.1646513938903809) * gru_1_out_t2_32 + (-0.65159618854522705) * gru_1_out_t2_33 + (-0.20891866087913513) * gru_1_out_t2_34 + (0.30631342530250549) * gru_1_out_t2_35 + (0.021416738629341125) * gru_1_out_t2_36 + (0.83401012420654297) * gru_1_out_t2_37 + (0.053288079798221588) * gru_1_out_t2_38 + (-0.29041513800621033) * gru_1_out_t2_39 + (0.1591898649930954) * gru_1_out_t2_40 + (0.63410502672195435) * gru_1_out_t2_41 + (-0.47607013583183289) * gru_1_out_t2_42 + (-0.89106249809265137) * gru_1_out_t2_43 + (-0.30707180500030518) * gru_1_out_t2_44 + (0.38552924990653992) * gru_1_out_t2_45 + (2.1306440830230713) * gru_1_out_t2_46 + (-0.21748332679271698) * gru_1_out_t2_47 + (0.0097685987129807472) * gru_1_out_t2_48 + (-1.1523048877716064) * gru_1_out_t2_49 + (-0.16244760155677795) * gru_1_out_t2_50 + (1.1328127384185791) * gru_1_out_t2_51 + (-0.16104200482368469) * gru_1_out_t2_52 + (0.079886205494403839) * gru_1_out_t2_53 + (-0.15676087141036987) * gru_1_out_t2_54 + (-0.31707119941711426) * gru_1_out_t2_55 + (0.25483772158622742) * gru_1_out_t2_56 + (0.44933676719665527) * gru_1_out_t2_57 + (0.15214851498603821) * gru_1_out_t2_58 + (0.32734161615371704) * gru_1_out_t2_59 + (0.094394013285636902) * gru_1_out_t2_60 + (-0.50507152080535889) * gru_1_out_t2_61 + (-0.97429221868515015) * gru_1_out_t2_62 + (0.053873244673013687) * gru_1_out_t2_63 + gate_r * ((0.50581520795822144) + (-0.18918003141880035) * gru_2_rev_t3_h_0 + (-0.02479080855846405) * gru_2_rev_t3_h_1 + (0.11887861043214798) * gru_2_rev_t3_h_2 + (0.065457619726657867) * gru_2_rev_t3_h_3 + (0.09586682915687561) * gru_2_rev_t3_h_4 + (0.105904720723629) * gru_2_rev_t3_h_5 + (-0.040065947920084) * gru_2_rev_t3_h_6 + (-0.083302788436412811) * gru_2_rev_t3_h_7 + (-0.083654724061489105) * gru_2_rev_t3_h_8 + (0.012751869857311249) * gru_2_rev_t3_h_9 + (-0.010340148583054543) * gru_2_rev_t3_h_10 + (-0.40008655190467834) * gru_2_rev_t3_h_11 + (-0.0050062388181686401) * gru_2_rev_t3_h_12 + (-0.098327532410621643) * gru_2_rev_t3_h_13 + (-0.16968071460723877) * gru_2_rev_t3_h_14 + (0.085418373346328735) * gru_2_rev_t3_h_15 + (0.038933902978897095) * gru_2_rev_t3_h_16 + (0.089269563555717468) * gru_2_rev_t3_h_17 + (-0.17649745941162109) * gru_2_rev_t3_h_18 + (-0.18658901751041412) * gru_2_rev_t3_h_19 + (-0.013686138205230236) * gru_2_rev_t3_h_20 + (-0.020523043349385262) * gru_2_rev_t3_h_21 + (-0.086706310510635376) * gru_2_rev_t3_h_22 + (0.039079681038856506) * gru_2_rev_t3_h_23 + (0.097587674856185913) * gru_2_rev_t3_h_24 + (0.030436772853136063) * gru_2_rev_t3_h_25 + (0.019201494753360748) * gru_2_rev_t3_h_26 + (-0.11368461698293686) * gru_2_rev_t3_h_27 + (-0.095254838466644287) * gru_2_rev_t3_h_28 + (0.018121110275387764) * gru_2_rev_t3_h_29 + (-0.079742603003978729) * gru_2_rev_t3_h_30 + (0.082657173275947571) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_19 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_19;
    // h=20
    gate_r = sigmoid((0.53055405616760254) + (0.062070231884717941) * gru_1_out_t2_0 + (-0.29076313972473145) * gru_1_out_t2_1 + (-0.032755114138126373) * gru_1_out_t2_2 + (0.37695369124412537) * gru_1_out_t2_3 + (0.44182419776916504) * gru_1_out_t2_4 + (0.48760724067687988) * gru_1_out_t2_5 + (0.26224079728126526) * gru_1_out_t2_6 + (0.18863621354103088) * gru_1_out_t2_7 + (0.077820844948291779) * gru_1_out_t2_8 + (-0.55260801315307617) * gru_1_out_t2_9 + (0.39448139071464539) * gru_1_out_t2_10 + (0.24652764201164246) * gru_1_out_t2_11 + (0.20171162486076355) * gru_1_out_t2_12 + (-0.060018490999937057) * gru_1_out_t2_13 + (-0.35708862543106079) * gru_1_out_t2_14 + (-0.29554376006126404) * gru_1_out_t2_15 + (-0.091511189937591553) * gru_1_out_t2_16 + (-0.2324342280626297) * gru_1_out_t2_17 + (-1.2462164163589478) * gru_1_out_t2_18 + (-0.56968152523040771) * gru_1_out_t2_19 + (0.5364118218421936) * gru_1_out_t2_20 + (-1.1271744966506958) * gru_1_out_t2_21 + (-0.39854583144187927) * gru_1_out_t2_22 + (0.7546919584274292) * gru_1_out_t2_23 + (-0.25287714600563049) * gru_1_out_t2_24 + (0.014375541359186172) * gru_1_out_t2_25 + (0.6734386682510376) * gru_1_out_t2_26 + (0.43948796391487122) * gru_1_out_t2_27 + (-0.8121604323387146) * gru_1_out_t2_28 + (0.074657648801803589) * gru_1_out_t2_29 + (1.0267924070358276) * gru_1_out_t2_30 + (0.047167316079139709) * gru_1_out_t2_31 + (0.63138371706008911) * gru_1_out_t2_32 + (-0.1115059033036232) * gru_1_out_t2_33 + (-0.72284996509552002) * gru_1_out_t2_34 + (0.19522072374820709) * gru_1_out_t2_35 + (2.1618380546569824) * gru_1_out_t2_36 + (-0.46195349097251892) * gru_1_out_t2_37 + (-0.77798807621002197) * gru_1_out_t2_38 + (1.209460973739624) * gru_1_out_t2_39 + (0.25586080551147461) * gru_1_out_t2_40 + (0.88479888439178467) * gru_1_out_t2_41 + (-3.3772475719451904) * gru_1_out_t2_42 + (-0.43222123384475708) * gru_1_out_t2_43 + (-1.2651747465133667) * gru_1_out_t2_44 + (-0.27425652742385864) * gru_1_out_t2_45 + (-0.88263571262359619) * gru_1_out_t2_46 + (0.40656301379203796) * gru_1_out_t2_47 + (-0.065162867307662964) * gru_1_out_t2_48 + (-0.77097302675247192) * gru_1_out_t2_49 + (-1.6697729825973511) * gru_1_out_t2_50 + (0.55666959285736084) * gru_1_out_t2_51 + (-0.4490908682346344) * gru_1_out_t2_52 + (0.83751451969146729) * gru_1_out_t2_53 + (-0.88243699073791504) * gru_1_out_t2_54 + (-0.013334494084119797) * gru_1_out_t2_55 + (0.80649435520172119) * gru_1_out_t2_56 + (0.14038786292076111) * gru_1_out_t2_57 + (0.94556123018264771) * gru_1_out_t2_58 + (-0.46963062882423401) * gru_1_out_t2_59 + (-0.42205291986465454) * gru_1_out_t2_60 + (-0.060432203114032745) * gru_1_out_t2_61 + (-0.48844122886657715) * gru_1_out_t2_62 + (0.19167259335517883) * gru_1_out_t2_63 + (0.021946826949715614) * gru_2_rev_t3_h_0 + (0.062081567943096161) * gru_2_rev_t3_h_1 + (0.0088662393391132355) * gru_2_rev_t3_h_2 + (0.088469818234443665) * gru_2_rev_t3_h_3 + (0.023366190493106842) * gru_2_rev_t3_h_4 + (-0.085102982819080353) * gru_2_rev_t3_h_5 + (0.0081614265218377113) * gru_2_rev_t3_h_6 + (0.11198054254055023) * gru_2_rev_t3_h_7 + (-0.14083953201770782) * gru_2_rev_t3_h_8 + (0.12435054033994675) * gru_2_rev_t3_h_9 + (-0.094872482120990753) * gru_2_rev_t3_h_10 + (-0.10562125593423843) * gru_2_rev_t3_h_11 + (0.045911252498626709) * gru_2_rev_t3_h_12 + (-0.051875624805688858) * gru_2_rev_t3_h_13 + (-0.073363363742828369) * gru_2_rev_t3_h_14 + (-0.015077170915901661) * gru_2_rev_t3_h_15 + (-0.043580066412687302) * gru_2_rev_t3_h_16 + (0.030256755650043488) * gru_2_rev_t3_h_17 + (0.08661244809627533) * gru_2_rev_t3_h_18 + (0.19522038102149963) * gru_2_rev_t3_h_19 + (0.24014075100421906) * gru_2_rev_t3_h_20 + (0.28012770414352417) * gru_2_rev_t3_h_21 + (-0.031751520931720734) * gru_2_rev_t3_h_22 + (0.11524859815835953) * gru_2_rev_t3_h_23 + (-0.0014261914184316993) * gru_2_rev_t3_h_24 + (-0.024099700152873993) * gru_2_rev_t3_h_25 + (-0.13373042643070221) * gru_2_rev_t3_h_26 + (0.046389058232307434) * gru_2_rev_t3_h_27 + (-0.0089959334582090378) * gru_2_rev_t3_h_28 + (-0.057943038642406464) * gru_2_rev_t3_h_29 + (0.15237389504909515) * gru_2_rev_t3_h_30 + (0.056311853229999542) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((-0.14022941887378693) + (0.15052413940429688) * gru_1_out_t2_0 + (-0.028776062652468681) * gru_1_out_t2_1 + (0.58015429973602295) * gru_1_out_t2_2 + (-0.092146620154380798) * gru_1_out_t2_3 + (0.32553791999816895) * gru_1_out_t2_4 + (-0.27402454614639282) * gru_1_out_t2_5 + (0.067144125699996948) * gru_1_out_t2_6 + (0.520224928855896) * gru_1_out_t2_7 + (-0.36299824714660645) * gru_1_out_t2_8 + (-0.035479225218296051) * gru_1_out_t2_9 + (-0.45735716819763184) * gru_1_out_t2_10 + (-0.32836070656776428) * gru_1_out_t2_11 + (0.087318263947963715) * gru_1_out_t2_12 + (-0.10971465706825256) * gru_1_out_t2_13 + (-0.27167218923568726) * gru_1_out_t2_14 + (0.24219653010368347) * gru_1_out_t2_15 + (0.25794976949691772) * gru_1_out_t2_16 + (-0.0087473541498184204) * gru_1_out_t2_17 + (0.27470442652702332) * gru_1_out_t2_18 + (0.16951873898506165) * gru_1_out_t2_19 + (0.11791925132274628) * gru_1_out_t2_20 + (0.038024164736270905) * gru_1_out_t2_21 + (0.45460319519042969) * gru_1_out_t2_22 + (0.16323663294315338) * gru_1_out_t2_23 + (0.0073522971943020821) * gru_1_out_t2_24 + (-0.097962766885757446) * gru_1_out_t2_25 + (0.064699999988079071) * gru_1_out_t2_26 + (0.28746581077575684) * gru_1_out_t2_27 + (-0.48734566569328308) * gru_1_out_t2_28 + (-0.58089101314544678) * gru_1_out_t2_29 + (-0.16157729923725128) * gru_1_out_t2_30 + (0.17882685363292694) * gru_1_out_t2_31 + (-0.33352175354957581) * gru_1_out_t2_32 + (0.077403783798217773) * gru_1_out_t2_33 + (0.6155359148979187) * gru_1_out_t2_34 + (-0.48869559168815613) * gru_1_out_t2_35 + (-0.29362863302230835) * gru_1_out_t2_36 + (-0.37345394492149353) * gru_1_out_t2_37 + (-0.29537472128868103) * gru_1_out_t2_38 + (0.12447776645421982) * gru_1_out_t2_39 + (-0.014632899314165115) * gru_1_out_t2_40 + (0.16198591887950897) * gru_1_out_t2_41 + (0.45964756608009338) * gru_1_out_t2_42 + (0.83726704120635986) * gru_1_out_t2_43 + (-0.50765281915664673) * gru_1_out_t2_44 + (-0.06206134706735611) * gru_1_out_t2_45 + (0.25724095106124878) * gru_1_out_t2_46 + (-0.23129534721374512) * gru_1_out_t2_47 + (-0.19571347534656525) * gru_1_out_t2_48 + (-0.12087731063365936) * gru_1_out_t2_49 + (0.17959289252758026) * gru_1_out_t2_50 + (-0.52793192863464355) * gru_1_out_t2_51 + (0.59083360433578491) * gru_1_out_t2_52 + (0.080479703843593597) * gru_1_out_t2_53 + (-0.25873908400535583) * gru_1_out_t2_54 + (0.02318328432738781) * gru_1_out_t2_55 + (0.38098388910293579) * gru_1_out_t2_56 + (-0.077250882983207703) * gru_1_out_t2_57 + (0.11400610953569412) * gru_1_out_t2_58 + (0.028924429789185524) * gru_1_out_t2_59 + (0.31365513801574707) * gru_1_out_t2_60 + (-0.64798760414123535) * gru_1_out_t2_61 + (-0.54575300216674805) * gru_1_out_t2_62 + (-0.083663143217563629) * gru_1_out_t2_63 + (-0.14723455905914307) * gru_2_rev_t3_h_0 + (-0.15001802146434784) * gru_2_rev_t3_h_1 + (-0.19152039289474487) * gru_2_rev_t3_h_2 + (0.00686687882989645) * gru_2_rev_t3_h_3 + (-0.15687626600265503) * gru_2_rev_t3_h_4 + (-0.09053308516740799) * gru_2_rev_t3_h_5 + (-0.083860792219638824) * gru_2_rev_t3_h_6 + (0.074413754045963287) * gru_2_rev_t3_h_7 + (0.096099495887756348) * gru_2_rev_t3_h_8 + (0.067663758993148804) * gru_2_rev_t3_h_9 + (-0.053633764386177063) * gru_2_rev_t3_h_10 + (-0.13942678272724152) * gru_2_rev_t3_h_11 + (0.047540705651044846) * gru_2_rev_t3_h_12 + (-0.079385541379451752) * gru_2_rev_t3_h_13 + (-0.099432356655597687) * gru_2_rev_t3_h_14 + (-0.025919968262314796) * gru_2_rev_t3_h_15 + (0.080142959952354431) * gru_2_rev_t3_h_16 + (-0.03868379071354866) * gru_2_rev_t3_h_17 + (0.2151331901550293) * gru_2_rev_t3_h_18 + (-0.1874866783618927) * gru_2_rev_t3_h_19 + (-0.094628095626831055) * gru_2_rev_t3_h_20 + (-0.06032060831785202) * gru_2_rev_t3_h_21 + (-0.02408510260283947) * gru_2_rev_t3_h_22 + (-0.0033063478767871857) * gru_2_rev_t3_h_23 + (0.072051800787448883) * gru_2_rev_t3_h_24 + (0.016851970925927162) * gru_2_rev_t3_h_25 + (0.014750768430531025) * gru_2_rev_t3_h_26 + (0.037131804972887039) * gru_2_rev_t3_h_27 + (0.073631256818771362) * gru_2_rev_t3_h_28 + (-0.13766150176525116) * gru_2_rev_t3_h_29 + (-0.00017960622790269554) * gru_2_rev_t3_h_30 + (0.070205375552177429) * gru_2_rev_t3_h_31);
    gate_n = tanh((-0.76510465145111084) + (-0.71495747566223145) * gru_1_out_t2_0 + (0.53321754932403564) * gru_1_out_t2_1 + (0.033662516623735428) * gru_1_out_t2_2 + (-0.14677898585796356) * gru_1_out_t2_3 + (0.24819968640804291) * gru_1_out_t2_4 + (-0.4097379744052887) * gru_1_out_t2_5 + (-0.75256413221359253) * gru_1_out_t2_6 + (-0.28329601883888245) * gru_1_out_t2_7 + (0.29777461290359497) * gru_1_out_t2_8 + (1.0497907400131226) * gru_1_out_t2_9 + (-0.76142370700836182) * gru_1_out_t2_10 + (-0.7671210765838623) * gru_1_out_t2_11 + (0.40162962675094604) * gru_1_out_t2_12 + (0.12183228880167007) * gru_1_out_t2_13 + (0.74885332584381104) * gru_1_out_t2_14 + (0.55525219440460205) * gru_1_out_t2_15 + (0.60334014892578125) * gru_1_out_t2_16 + (-0.10034526139497757) * gru_1_out_t2_17 + (0.44538068771362305) * gru_1_out_t2_18 + (-0.12070762366056442) * gru_1_out_t2_19 + (-0.54650259017944336) * gru_1_out_t2_20 + (1.4081287384033203) * gru_1_out_t2_21 + (0.59486293792724609) * gru_1_out_t2_22 + (-0.55928868055343628) * gru_1_out_t2_23 + (-0.36069792509078979) * gru_1_out_t2_24 + (-0.15601634979248047) * gru_1_out_t2_25 + (-1.1700301170349121) * gru_1_out_t2_26 + (-0.25326287746429443) * gru_1_out_t2_27 + (0.4217374324798584) * gru_1_out_t2_28 + (-0.059817146509885788) * gru_1_out_t2_29 + (-1.2082036733627319) * gru_1_out_t2_30 + (0.22007282078266144) * gru_1_out_t2_31 + (-1.2679351568222046) * gru_1_out_t2_32 + (0.058104302734136581) * gru_1_out_t2_33 + (0.34264284372329712) * gru_1_out_t2_34 + (-0.1986013799905777) * gru_1_out_t2_35 + (-2.0210502147674561) * gru_1_out_t2_36 + (0.060523398220539093) * gru_1_out_t2_37 + (1.6048765182495117) * gru_1_out_t2_38 + (-0.96041494607925415) * gru_1_out_t2_39 + (0.17224502563476562) * gru_1_out_t2_40 + (-1.4048161506652832) * gru_1_out_t2_41 + (3.1624770164489746) * gru_1_out_t2_42 + (0.65075629949569702) * gru_1_out_t2_43 + (0.80051273107528687) * gru_1_out_t2_44 + (0.29381689429283142) * gru_1_out_t2_45 + (1.3497735261917114) * gru_1_out_t2_46 + (-0.29764527082443237) * gru_1_out_t2_47 + (0.55006992816925049) * gru_1_out_t2_48 + (0.15086986124515533) * gru_1_out_t2_49 + (1.7117294073104858) * gru_1_out_t2_50 + (-1.0827180147171021) * gru_1_out_t2_51 + (-0.031612899154424667) * gru_1_out_t2_52 + (-0.76330238580703735) * gru_1_out_t2_53 + (-0.034434810280799866) * gru_1_out_t2_54 + (-0.14310212433338165) * gru_1_out_t2_55 + (-0.47156459093093872) * gru_1_out_t2_56 + (-0.62264233827590942) * gru_1_out_t2_57 + (-1.1979222297668457) * gru_1_out_t2_58 + (0.7676926851272583) * gru_1_out_t2_59 + (0.63247507810592651) * gru_1_out_t2_60 + (0.1801883727312088) * gru_1_out_t2_61 + (0.073805741965770721) * gru_1_out_t2_62 + (0.14921607077121735) * gru_1_out_t2_63 + gate_r * ((-0.92351341247558594) + (0.077219001948833466) * gru_2_rev_t3_h_0 + (0.044287987053394318) * gru_2_rev_t3_h_1 + (0.057257533073425293) * gru_2_rev_t3_h_2 + (0.22800686955451965) * gru_2_rev_t3_h_3 + (0.042529415339231491) * gru_2_rev_t3_h_4 + (-0.15044631063938141) * gru_2_rev_t3_h_5 + (0.0079056043177843094) * gru_2_rev_t3_h_6 + (0.14371024072170258) * gru_2_rev_t3_h_7 + (0.033410582691431046) * gru_2_rev_t3_h_8 + (-0.10119717568159103) * gru_2_rev_t3_h_9 + (0.20578913390636444) * gru_2_rev_t3_h_10 + (-0.11734206229448318) * gru_2_rev_t3_h_11 + (0.049093849956989288) * gru_2_rev_t3_h_12 + (0.18912254273891449) * gru_2_rev_t3_h_13 + (-0.069901883602142334) * gru_2_rev_t3_h_14 + (0.13442851603031158) * gru_2_rev_t3_h_15 + (0.039466198533773422) * gru_2_rev_t3_h_16 + (0.039810087531805038) * gru_2_rev_t3_h_17 + (0.012841708958148956) * gru_2_rev_t3_h_18 + (-0.030992252752184868) * gru_2_rev_t3_h_19 + (-0.041896682232618332) * gru_2_rev_t3_h_20 + (0.030507346615195274) * gru_2_rev_t3_h_21 + (-0.17160272598266602) * gru_2_rev_t3_h_22 + (0.071326971054077148) * gru_2_rev_t3_h_23 + (-0.16819119453430176) * gru_2_rev_t3_h_24 + (0.0071102762594819069) * gru_2_rev_t3_h_25 + (-0.051575738936662674) * gru_2_rev_t3_h_26 + (-0.050095971673727036) * gru_2_rev_t3_h_27 + (0.098674289882183075) * gru_2_rev_t3_h_28 + (-0.036235600709915161) * gru_2_rev_t3_h_29 + (0.19323672354221344) * gru_2_rev_t3_h_30 + (0.02205173671245575) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_20 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_20;
    // h=21
    gate_r = sigmoid((0.220859095454216) + (0.44899243116378784) * gru_1_out_t2_0 + (0.69808512926101685) * gru_1_out_t2_1 + (-0.11525356024503708) * gru_1_out_t2_2 + (0.39882910251617432) * gru_1_out_t2_3 + (1.0972262620925903) * gru_1_out_t2_4 + (2.3350808620452881) * gru_1_out_t2_5 + (1.2139313220977783) * gru_1_out_t2_6 + (0.25600939989089966) * gru_1_out_t2_7 + (1.4599994421005249) * gru_1_out_t2_8 + (-2.3879354000091553) * gru_1_out_t2_9 + (-0.40155726671218872) * gru_1_out_t2_10 + (-2.6389858722686768) * gru_1_out_t2_11 + (-2.5677344799041748) * gru_1_out_t2_12 + (-0.34158682823181152) * gru_1_out_t2_13 + (-1.4150234460830688) * gru_1_out_t2_14 + (-1.4930094480514526) * gru_1_out_t2_15 + (-0.017177030444145203) * gru_1_out_t2_16 + (-0.16479723155498505) * gru_1_out_t2_17 + (-0.68275398015975952) * gru_1_out_t2_18 + (-0.86749476194381714) * gru_1_out_t2_19 + (0.27531683444976807) * gru_1_out_t2_20 + (0.26960057020187378) * gru_1_out_t2_21 + (-0.4169059693813324) * gru_1_out_t2_22 + (0.077197253704071045) * gru_1_out_t2_23 + (1.6523244380950928) * gru_1_out_t2_24 + (0.14131510257720947) * gru_1_out_t2_25 + (2.1571073532104492) * gru_1_out_t2_26 + (-0.40372183918952942) * gru_1_out_t2_27 + (0.50809162855148315) * gru_1_out_t2_28 + (-0.96660637855529785) * gru_1_out_t2_29 + (-3.6926853656768799) * gru_1_out_t2_30 + (0.046820618212223053) * gru_1_out_t2_31 + (0.39136102795600891) * gru_1_out_t2_32 + (0.75733482837677002) * gru_1_out_t2_33 + (-0.37219735980033875) * gru_1_out_t2_34 + (0.90365022420883179) * gru_1_out_t2_35 + (-0.45352533459663391) * gru_1_out_t2_36 + (-0.80833655595779419) * gru_1_out_t2_37 + (-1.2834683656692505) * gru_1_out_t2_38 + (-2.1082994937896729) * gru_1_out_t2_39 + (-0.19075530767440796) * gru_1_out_t2_40 + (1.1244586706161499) * gru_1_out_t2_41 + (-0.81827998161315918) * gru_1_out_t2_42 + (2.1292383670806885) * gru_1_out_t2_43 + (0.44656997919082642) * gru_1_out_t2_44 + (2.8119809627532959) * gru_1_out_t2_45 + (-1.8309484720230103) * gru_1_out_t2_46 + (-0.38556587696075439) * gru_1_out_t2_47 + (-0.19093261659145355) * gru_1_out_t2_48 + (1.6844483613967896) * gru_1_out_t2_49 + (-1.2408483028411865) * gru_1_out_t2_50 + (0.91311466693878174) * gru_1_out_t2_51 + (-4.3233532905578613) * gru_1_out_t2_52 + (-0.17276237905025482) * gru_1_out_t2_53 + (0.67318451404571533) * gru_1_out_t2_54 + (0.16131153702735901) * gru_1_out_t2_55 + (3.8040390014648438) * gru_1_out_t2_56 + (1.1117124557495117) * gru_1_out_t2_57 + (-0.64682012796401978) * gru_1_out_t2_58 + (1.5238001346588135) * gru_1_out_t2_59 + (1.011198878288269) * gru_1_out_t2_60 + (1.1511451005935669) * gru_1_out_t2_61 + (0.40709564089775085) * gru_1_out_t2_62 + (0.17069472372531891) * gru_1_out_t2_63 + (-0.13071185350418091) * gru_2_rev_t3_h_0 + (0.053618118166923523) * gru_2_rev_t3_h_1 + (0.023354345932602882) * gru_2_rev_t3_h_2 + (-0.030972106382250786) * gru_2_rev_t3_h_3 + (-0.0067970529198646545) * gru_2_rev_t3_h_4 + (-0.061691179871559143) * gru_2_rev_t3_h_5 + (-0.060657069087028503) * gru_2_rev_t3_h_6 + (0.21103085577487946) * gru_2_rev_t3_h_7 + (-0.023606207221746445) * gru_2_rev_t3_h_8 + (-0.069847710430622101) * gru_2_rev_t3_h_9 + (0.043759241700172424) * gru_2_rev_t3_h_10 + (0.047385942190885544) * gru_2_rev_t3_h_11 + (0.19498278200626373) * gru_2_rev_t3_h_12 + (0.0054131811484694481) * gru_2_rev_t3_h_13 + (0.11464156210422516) * gru_2_rev_t3_h_14 + (-0.059083700180053711) * gru_2_rev_t3_h_15 + (0.12380742281675339) * gru_2_rev_t3_h_16 + (0.0099353445693850517) * gru_2_rev_t3_h_17 + (0.0051652914844453335) * gru_2_rev_t3_h_18 + (-0.057062599807977676) * gru_2_rev_t3_h_19 + (-0.1054861769080162) * gru_2_rev_t3_h_20 + (0.068902693688869476) * gru_2_rev_t3_h_21 + (0.0054450556635856628) * gru_2_rev_t3_h_22 + (-0.11045026034116745) * gru_2_rev_t3_h_23 + (0.14372070133686066) * gru_2_rev_t3_h_24 + (0.22283606231212616) * gru_2_rev_t3_h_25 + (0.027193346992135048) * gru_2_rev_t3_h_26 + (0.087818123400211334) * gru_2_rev_t3_h_27 + (0.034556612372398376) * gru_2_rev_t3_h_28 + (0.15198920667171478) * gru_2_rev_t3_h_29 + (-0.064036615192890167) * gru_2_rev_t3_h_30 + (-0.135029137134552) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.38908180594444275) + (0.14269097149372101) * gru_1_out_t2_0 + (-0.13928996026515961) * gru_1_out_t2_1 + (0.46844503283500671) * gru_1_out_t2_2 + (-0.08355974406003952) * gru_1_out_t2_3 + (0.010565843433141708) * gru_1_out_t2_4 + (0.13406623899936676) * gru_1_out_t2_5 + (-0.31693333387374878) * gru_1_out_t2_6 + (0.32617524266242981) * gru_1_out_t2_7 + (-0.99073970317840576) * gru_1_out_t2_8 + (0.10327491909265518) * gru_1_out_t2_9 + (-0.17201942205429077) * gru_1_out_t2_10 + (-0.057986371219158173) * gru_1_out_t2_11 + (-0.033754918724298477) * gru_1_out_t2_12 + (-0.062479715794324875) * gru_1_out_t2_13 + (0.11984173953533173) * gru_1_out_t2_14 + (-0.55017852783203125) * gru_1_out_t2_15 + (-0.068565055727958679) * gru_1_out_t2_16 + (0.23087091743946075) * gru_1_out_t2_17 + (0.05883416160941124) * gru_1_out_t2_18 + (0.19841831922531128) * gru_1_out_t2_19 + (0.37315985560417175) * gru_1_out_t2_20 + (0.039082404226064682) * gru_1_out_t2_21 + (-0.70940828323364258) * gru_1_out_t2_22 + (0.43187126517295837) * gru_1_out_t2_23 + (0.12597212195396423) * gru_1_out_t2_24 + (0.20922450721263885) * gru_1_out_t2_25 + (0.17951394617557526) * gru_1_out_t2_26 + (0.016206573694944382) * gru_1_out_t2_27 + (0.78335714340209961) * gru_1_out_t2_28 + (-0.26795664429664612) * gru_1_out_t2_29 + (-0.11619125306606293) * gru_1_out_t2_30 + (0.047610897570848465) * gru_1_out_t2_31 + (0.99679851531982422) * gru_1_out_t2_32 + (-0.85352432727813721) * gru_1_out_t2_33 + (0.72064393758773804) * gru_1_out_t2_34 + (0.12773983180522919) * gru_1_out_t2_35 + (0.20809796452522278) * gru_1_out_t2_36 + (0.0026485307607799768) * gru_1_out_t2_37 + (-0.23864054679870605) * gru_1_out_t2_38 + (0.23999188840389252) * gru_1_out_t2_39 + (-0.40174737572669983) * gru_1_out_t2_40 + (0.26401537656784058) * gru_1_out_t2_41 + (-0.54162991046905518) * gru_1_out_t2_42 + (-1.3463935852050781) * gru_1_out_t2_43 + (-0.38855069875717163) * gru_1_out_t2_44 + (-0.093644902110099792) * gru_1_out_t2_45 + (-0.27690413594245911) * gru_1_out_t2_46 + (0.35508161783218384) * gru_1_out_t2_47 + (-0.49163275957107544) * gru_1_out_t2_48 + (-0.26696592569351196) * gru_1_out_t2_49 + (-0.21662336587905884) * gru_1_out_t2_50 + (0.19978612661361694) * gru_1_out_t2_51 + (1.4396688938140869) * gru_1_out_t2_52 + (0.63652694225311279) * gru_1_out_t2_53 + (0.87761151790618896) * gru_1_out_t2_54 + (0.17373229563236237) * gru_1_out_t2_55 + (0.044945571571588516) * gru_1_out_t2_56 + (0.37705627083778381) * gru_1_out_t2_57 + (0.33952361345291138) * gru_1_out_t2_58 + (0.19207319617271423) * gru_1_out_t2_59 + (-0.42798212170600891) * gru_1_out_t2_60 + (0.73374801874160767) * gru_1_out_t2_61 + (0.011677231639623642) * gru_1_out_t2_62 + (0.3885892927646637) * gru_1_out_t2_63 + (0.066362582147121429) * gru_2_rev_t3_h_0 + (-0.079506680369377136) * gru_2_rev_t3_h_1 + (0.15770342946052551) * gru_2_rev_t3_h_2 + (-0.16849073767662048) * gru_2_rev_t3_h_3 + (0.088300861418247223) * gru_2_rev_t3_h_4 + (-0.16989563405513763) * gru_2_rev_t3_h_5 + (-0.29523751139640808) * gru_2_rev_t3_h_6 + (0.061920188367366791) * gru_2_rev_t3_h_7 + (-0.12209579348564148) * gru_2_rev_t3_h_8 + (-0.098411627113819122) * gru_2_rev_t3_h_9 + (0.0013686525635421276) * gru_2_rev_t3_h_10 + (0.026538865640759468) * gru_2_rev_t3_h_11 + (-0.04069121927022934) * gru_2_rev_t3_h_12 + (0.058758117258548737) * gru_2_rev_t3_h_13 + (-0.064775682985782623) * gru_2_rev_t3_h_14 + (-0.072841286659240723) * gru_2_rev_t3_h_15 + (-0.092666909098625183) * gru_2_rev_t3_h_16 + (0.046568181365728378) * gru_2_rev_t3_h_17 + (-0.075681321322917938) * gru_2_rev_t3_h_18 + (0.10238195955753326) * gru_2_rev_t3_h_19 + (0.063464418053627014) * gru_2_rev_t3_h_20 + (0.013652482070028782) * gru_2_rev_t3_h_21 + (0.0074711181223392487) * gru_2_rev_t3_h_22 + (-0.21442680060863495) * gru_2_rev_t3_h_23 + (0.1548694372177124) * gru_2_rev_t3_h_24 + (0.12742334604263306) * gru_2_rev_t3_h_25 + (-0.15373508632183075) * gru_2_rev_t3_h_26 + (-0.028970969840884209) * gru_2_rev_t3_h_27 + (-0.029190797358751297) * gru_2_rev_t3_h_28 + (-0.15374051034450531) * gru_2_rev_t3_h_29 + (0.12765482068061829) * gru_2_rev_t3_h_30 + (0.01545515563338995) * gru_2_rev_t3_h_31);
    gate_n = tanh((-0.58625245094299316) + (-0.55126935243606567) * gru_1_out_t2_0 + (0.33990639448165894) * gru_1_out_t2_1 + (0.27186653017997742) * gru_1_out_t2_2 + (0.18262031674385071) * gru_1_out_t2_3 + (-0.12666314840316772) * gru_1_out_t2_4 + (0.15369066596031189) * gru_1_out_t2_5 + (-0.89760613441467285) * gru_1_out_t2_6 + (0.36762604117393494) * gru_1_out_t2_7 + (-0.49366727471351624) * gru_1_out_t2_8 + (-0.73558449745178223) * gru_1_out_t2_9 + (-0.81233972311019897) * gru_1_out_t2_10 + (1.4498592615127563) * gru_1_out_t2_11 + (-0.19061264395713806) * gru_1_out_t2_12 + (0.73801422119140625) * gru_1_out_t2_13 + (0.57409018278121948) * gru_1_out_t2_14 + (-0.53309231996536255) * gru_1_out_t2_15 + (-0.051859818398952484) * gru_1_out_t2_16 + (0.36065775156021118) * gru_1_out_t2_17 + (0.5889473557472229) * gru_1_out_t2_18 + (0.35235944390296936) * gru_1_out_t2_19 + (-0.04797700047492981) * gru_1_out_t2_20 + (0.0066071529872715473) * gru_1_out_t2_21 + (0.31517541408538818) * gru_1_out_t2_22 + (0.8690837025642395) * gru_1_out_t2_23 + (0.15756747126579285) * gru_1_out_t2_24 + (-0.49496299028396606) * gru_1_out_t2_25 + (1.0101159811019897) * gru_1_out_t2_26 + (0.77677273750305176) * gru_1_out_t2_27 + (-1.4705407619476318) * gru_1_out_t2_28 + (-0.37652292847633362) * gru_1_out_t2_29 + (-0.50803279876708984) * gru_1_out_t2_30 + (-0.42014110088348389) * gru_1_out_t2_31 + (-1.256975531578064) * gru_1_out_t2_32 + (-0.4600263237953186) * gru_1_out_t2_33 + (0.40367135405540466) * gru_1_out_t2_34 + (0.092961408197879791) * gru_1_out_t2_35 + (-0.15191331505775452) * gru_1_out_t2_36 + (-0.77265077829360962) * gru_1_out_t2_37 + (2.6132833957672119) * gru_1_out_t2_38 + (-0.45988237857818604) * gru_1_out_t2_39 + (0.49809432029724121) * gru_1_out_t2_40 + (-0.6588025689125061) * gru_1_out_t2_41 + (0.83899378776550293) * gru_1_out_t2_42 + (0.23565489053726196) * gru_1_out_t2_43 + (-0.18972672522068024) * gru_1_out_t2_44 + (0.70594894886016846) * gru_1_out_t2_45 + (2.8493225574493408) * gru_1_out_t2_46 + (0.51982766389846802) * gru_1_out_t2_47 + (-1.1560531854629517) * gru_1_out_t2_48 + (-1.3984233140945435) * gru_1_out_t2_49 + (1.4217846393585205) * gru_1_out_t2_50 + (-1.9120779037475586) * gru_1_out_t2_51 + (0.26725995540618896) * gru_1_out_t2_52 + (-1.0145372152328491) * gru_1_out_t2_53 + (-1.0475815534591675) * gru_1_out_t2_54 + (-0.52659982442855835) * gru_1_out_t2_55 + (-0.52546876668930054) * gru_1_out_t2_56 + (-0.25025668740272522) * gru_1_out_t2_57 + (-0.73280787467956543) * gru_1_out_t2_58 + (-0.75162827968597412) * gru_1_out_t2_59 + (-0.30689358711242676) * gru_1_out_t2_60 + (-0.69465756416320801) * gru_1_out_t2_61 + (-0.17077238857746124) * gru_1_out_t2_62 + (0.76920819282531738) * gru_1_out_t2_63 + gate_r * ((-2.3429839611053467) + (-0.034774873405694962) * gru_2_rev_t3_h_0 + (-0.022641606628894806) * gru_2_rev_t3_h_1 + (-0.047279931604862213) * gru_2_rev_t3_h_2 + (-0.079068772494792938) * gru_2_rev_t3_h_3 + (-0.10198311507701874) * gru_2_rev_t3_h_4 + (-0.067132361233234406) * gru_2_rev_t3_h_5 + (-0.11928866803646088) * gru_2_rev_t3_h_6 + (-0.11630751937627792) * gru_2_rev_t3_h_7 + (-0.12697486579418182) * gru_2_rev_t3_h_8 + (-0.031938835978507996) * gru_2_rev_t3_h_9 + (0.02026759460568428) * gru_2_rev_t3_h_10 + (0.061895623803138733) * gru_2_rev_t3_h_11 + (0.01351410336792469) * gru_2_rev_t3_h_12 + (-0.11244461685419083) * gru_2_rev_t3_h_13 + (0.14310987293720245) * gru_2_rev_t3_h_14 + (-0.030257346108555794) * gru_2_rev_t3_h_15 + (-0.049975842237472534) * gru_2_rev_t3_h_16 + (0.18075352907180786) * gru_2_rev_t3_h_17 + (-0.13266728818416595) * gru_2_rev_t3_h_18 + (0.20331667363643646) * gru_2_rev_t3_h_19 + (0.1290830671787262) * gru_2_rev_t3_h_20 + (-0.062281005084514618) * gru_2_rev_t3_h_21 + (-0.046815782785415649) * gru_2_rev_t3_h_22 + (0.054181329905986786) * gru_2_rev_t3_h_23 + (-0.12777581810951233) * gru_2_rev_t3_h_24 + (-0.13676206767559052) * gru_2_rev_t3_h_25 + (-0.043725691735744476) * gru_2_rev_t3_h_26 + (0.11123058199882507) * gru_2_rev_t3_h_27 + (-0.030124055221676826) * gru_2_rev_t3_h_28 + (-0.019085278734564781) * gru_2_rev_t3_h_29 + (-0.15471978485584259) * gru_2_rev_t3_h_30 + (-0.050550509244203568) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_21 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_21;
    // h=22
    gate_r = sigmoid((0.29917919635772705) + (0.9545634388923645) * gru_1_out_t2_0 + (4.2096595764160156) * gru_1_out_t2_1 + (0.12921082973480225) * gru_1_out_t2_2 + (-0.52933597564697266) * gru_1_out_t2_3 + (-0.96891754865646362) * gru_1_out_t2_4 + (-3.632082462310791) * gru_1_out_t2_5 + (2.7645139694213867) * gru_1_out_t2_6 + (-0.75453054904937744) * gru_1_out_t2_7 + (0.23063623905181885) * gru_1_out_t2_8 + (-0.17593680322170258) * gru_1_out_t2_9 + (4.2941451072692871) * gru_1_out_t2_10 + (-1.5255481004714966) * gru_1_out_t2_11 + (-0.65377390384674072) * gru_1_out_t2_12 + (-1.6815414428710938) * gru_1_out_t2_13 + (4.8567705154418945) * gru_1_out_t2_14 + (1.213988184928894) * gru_1_out_t2_15 + (-0.25789505243301392) * gru_1_out_t2_16 + (2.9711904525756836) * gru_1_out_t2_17 + (0.60265427827835083) * gru_1_out_t2_18 + (-0.10987908393144608) * gru_1_out_t2_19 + (-1.1957911252975464) * gru_1_out_t2_20 + (-0.18365597724914551) * gru_1_out_t2_21 + (2.2743492126464844) * gru_1_out_t2_22 + (6.374208927154541) * gru_1_out_t2_23 + (6.4880003929138184) * gru_1_out_t2_24 + (-0.73732352256774902) * gru_1_out_t2_25 + (-0.2606586217880249) * gru_1_out_t2_26 + (-0.93909239768981934) * gru_1_out_t2_27 + (-1.871091365814209) * gru_1_out_t2_28 + (0.59654194116592407) * gru_1_out_t2_29 + (0.17715714871883392) * gru_1_out_t2_30 + (0.8819955587387085) * gru_1_out_t2_31 + (-0.38941293954849243) * gru_1_out_t2_32 + (-0.46702960133552551) * gru_1_out_t2_33 + (0.99404358863830566) * gru_1_out_t2_34 + (-0.52435600757598877) * gru_1_out_t2_35 + (-0.4570472240447998) * gru_1_out_t2_36 + (0.16871652007102966) * gru_1_out_t2_37 + (0.19200435280799866) * gru_1_out_t2_38 + (0.41595715284347534) * gru_1_out_t2_39 + (1.1818313598632812) * gru_1_out_t2_40 + (0.025887755677103996) * gru_1_out_t2_41 + (0.56130194664001465) * gru_1_out_t2_42 + (-0.32167431712150574) * gru_1_out_t2_43 + (-0.13613764941692352) * gru_1_out_t2_44 + (-0.7457728385925293) * gru_1_out_t2_45 + (-0.22568155825138092) * gru_1_out_t2_46 + (-0.52536278963088989) * gru_1_out_t2_47 + (1.1264965534210205) * gru_1_out_t2_48 + (2.1319241523742676) * gru_1_out_t2_49 + (0.40097522735595703) * gru_1_out_t2_50 + (0.1546003669500351) * gru_1_out_t2_51 + (0.80697685480117798) * gru_1_out_t2_52 + (-0.83071917295455933) * gru_1_out_t2_53 + (0.25503435730934143) * gru_1_out_t2_54 + (-4.2415485382080078) * gru_1_out_t2_55 + (0.63490593433380127) * gru_1_out_t2_56 + (0.62489807605743408) * gru_1_out_t2_57 + (-0.1087232232093811) * gru_1_out_t2_58 + (0.34368300437927246) * gru_1_out_t2_59 + (2.1385281085968018) * gru_1_out_t2_60 + (0.17271876335144043) * gru_1_out_t2_61 + (0.70077675580978394) * gru_1_out_t2_62 + (-0.34150043129920959) * gru_1_out_t2_63 + (-0.17296183109283447) * gru_2_rev_t3_h_0 + (0.032891262322664261) * gru_2_rev_t3_h_1 + (0.084502018988132477) * gru_2_rev_t3_h_2 + (0.034894254058599472) * gru_2_rev_t3_h_3 + (-0.080487355589866638) * gru_2_rev_t3_h_4 + (0.030167762190103531) * gru_2_rev_t3_h_5 + (0.065156593918800354) * gru_2_rev_t3_h_6 + (0.030912633985280991) * gru_2_rev_t3_h_7 + (0.029024021700024605) * gru_2_rev_t3_h_8 + (0.097419403493404388) * gru_2_rev_t3_h_9 + (0.14276087284088135) * gru_2_rev_t3_h_10 + (-0.044518325477838516) * gru_2_rev_t3_h_11 + (0.12447866797447205) * gru_2_rev_t3_h_12 + (-0.020983036607503891) * gru_2_rev_t3_h_13 + (-0.0027551967650651932) * gru_2_rev_t3_h_14 + (-0.0851936936378479) * gru_2_rev_t3_h_15 + (0.16403262317180634) * gru_2_rev_t3_h_16 + (0.18623337149620056) * gru_2_rev_t3_h_17 + (-0.043941713869571686) * gru_2_rev_t3_h_18 + (-0.076768822968006134) * gru_2_rev_t3_h_19 + (0.037610162049531937) * gru_2_rev_t3_h_20 + (-0.084547854959964752) * gru_2_rev_t3_h_21 + (-0.047631252557039261) * gru_2_rev_t3_h_22 + (-0.045378603041172028) * gru_2_rev_t3_h_23 + (0.04580843448638916) * gru_2_rev_t3_h_24 + (-0.13439184427261353) * gru_2_rev_t3_h_25 + (0.075037136673927307) * gru_2_rev_t3_h_26 + (0.0010676395613700151) * gru_2_rev_t3_h_27 + (0.11542472988367081) * gru_2_rev_t3_h_28 + (-0.06271640956401825) * gru_2_rev_t3_h_29 + (-0.014911717735230923) * gru_2_rev_t3_h_30 + (0.088219687342643738) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((-0.042775720357894897) + (-0.40569174289703369) * gru_1_out_t2_0 + (-0.037787862122058868) * gru_1_out_t2_1 + (0.44913706183433533) * gru_1_out_t2_2 + (0.32780322432518005) * gru_1_out_t2_3 + (0.4762822687625885) * gru_1_out_t2_4 + (-0.58303487300872803) * gru_1_out_t2_5 + (0.042073946446180344) * gru_1_out_t2_6 + (0.23157444596290588) * gru_1_out_t2_7 + (-0.65899711847305298) * gru_1_out_t2_8 + (-0.033376090228557587) * gru_1_out_t2_9 + (-0.30389699339866638) * gru_1_out_t2_10 + (-0.5297316312789917) * gru_1_out_t2_11 + (0.1187271922826767) * gru_1_out_t2_12 + (0.12447088956832886) * gru_1_out_t2_13 + (-0.13075241446495056) * gru_1_out_t2_14 + (-0.17131780087947845) * gru_1_out_t2_15 + (0.33379876613616943) * gru_1_out_t2_16 + (0.0082800835371017456) * gru_1_out_t2_17 + (-0.15813715755939484) * gru_1_out_t2_18 + (0.29541510343551636) * gru_1_out_t2_19 + (0.22861441969871521) * gru_1_out_t2_20 + (0.14272856712341309) * gru_1_out_t2_21 + (0.11353062838315964) * gru_1_out_t2_22 + (0.0066856704652309418) * gru_1_out_t2_23 + (0.044301852583885193) * gru_1_out_t2_24 + (-0.19895501434803009) * gru_1_out_t2_25 + (0.28916499018669128) * gru_1_out_t2_26 + (0.26150572299957275) * gru_1_out_t2_27 + (-0.11350090801715851) * gru_1_out_t2_28 + (-0.15167500078678131) * gru_1_out_t2_29 + (-0.09360765665769577) * gru_1_out_t2_30 + (-0.33965250849723816) * gru_1_out_t2_31 + (-0.095785267651081085) * gru_1_out_t2_32 + (0.088198401033878326) * gru_1_out_t2_33 + (-0.17617852985858917) * gru_1_out_t2_34 + (0.12101200968027115) * gru_1_out_t2_35 + (0.27970755100250244) * gru_1_out_t2_36 + (-0.2313629537820816) * gru_1_out_t2_37 + (0.10553582012653351) * gru_1_out_t2_38 + (-0.51890301704406738) * gru_1_out_t2_39 + (-0.34875711798667908) * gru_1_out_t2_40 + (0.32597678899765015) * gru_1_out_t2_41 + (-0.25529634952545166) * gru_1_out_t2_42 + (0.52770978212356567) * gru_1_out_t2_43 + (0.20030669867992401) * gru_1_out_t2_44 + (0.040347158908843994) * gru_1_out_t2_45 + (-0.12394038587808609) * gru_1_out_t2_46 + (-0.14841994643211365) * gru_1_out_t2_47 + (-0.27689620852470398) * gru_1_out_t2_48 + (0.24200737476348877) * gru_1_out_t2_49 + (0.10096801817417145) * gru_1_out_t2_50 + (-0.057490907609462738) * gru_1_out_t2_51 + (0.14853686094284058) * gru_1_out_t2_52 + (-0.047065768390893936) * gru_1_out_t2_53 + (-0.0071460530161857605) * gru_1_out_t2_54 + (-0.1608140766620636) * gru_1_out_t2_55 + (0.042831815779209137) * gru_1_out_t2_56 + (-0.016263892874121666) * gru_1_out_t2_57 + (0.18458129465579987) * gru_1_out_t2_58 + (0.2406286895275116) * gru_1_out_t2_59 + (-0.1175646185874939) * gru_1_out_t2_60 + (0.68072777986526489) * gru_1_out_t2_61 + (0.014201316982507706) * gru_1_out_t2_62 + (0.35666662454605103) * gru_1_out_t2_63 + (-0.00037359513225965202) * gru_2_rev_t3_h_0 + (-0.0051128086633980274) * gru_2_rev_t3_h_1 + (0.117572121322155) * gru_2_rev_t3_h_2 + (0.024753062054514885) * gru_2_rev_t3_h_3 + (0.043866582214832306) * gru_2_rev_t3_h_4 + (0.0690450519323349) * gru_2_rev_t3_h_5 + (0.014265075325965881) * gru_2_rev_t3_h_6 + (-0.12829944491386414) * gru_2_rev_t3_h_7 + (0.086517930030822754) * gru_2_rev_t3_h_8 + (0.19594311714172363) * gru_2_rev_t3_h_9 + (-0.076516181230545044) * gru_2_rev_t3_h_10 + (0.040563151240348816) * gru_2_rev_t3_h_11 + (-0.14839532971382141) * gru_2_rev_t3_h_12 + (0.11956194788217545) * gru_2_rev_t3_h_13 + (0.12371119856834412) * gru_2_rev_t3_h_14 + (-0.094070859253406525) * gru_2_rev_t3_h_15 + (0.095468558371067047) * gru_2_rev_t3_h_16 + (0.10092993080615997) * gru_2_rev_t3_h_17 + (0.027975160628557205) * gru_2_rev_t3_h_18 + (-0.040628340095281601) * gru_2_rev_t3_h_19 + (0.07661660760641098) * gru_2_rev_t3_h_20 + (-0.081992536783218384) * gru_2_rev_t3_h_21 + (-0.087092481553554535) * gru_2_rev_t3_h_22 + (0.030236734077334404) * gru_2_rev_t3_h_23 + (-0.1251036524772644) * gru_2_rev_t3_h_24 + (-0.034933160990476608) * gru_2_rev_t3_h_25 + (0.19466570019721985) * gru_2_rev_t3_h_26 + (-0.1352563202381134) * gru_2_rev_t3_h_27 + (-0.043491281569004059) * gru_2_rev_t3_h_28 + (-0.049082390964031219) * gru_2_rev_t3_h_29 + (0.11766497790813446) * gru_2_rev_t3_h_30 + (0.049653004854917526) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.58447909355163574) + (0.91147363185882568) * gru_1_out_t2_0 + (-0.59643477201461792) * gru_1_out_t2_1 + (-0.18888214230537415) * gru_1_out_t2_2 + (-0.8744962215423584) * gru_1_out_t2_3 + (-1.0075784921646118) * gru_1_out_t2_4 + (-0.74101287126541138) * gru_1_out_t2_5 + (-1.0678693056106567) * gru_1_out_t2_6 + (0.030837850645184517) * gru_1_out_t2_7 + (-0.10237070918083191) * gru_1_out_t2_8 + (-0.19037821888923645) * gru_1_out_t2_9 + (0.43065515160560608) * gru_1_out_t2_10 + (-0.83298671245574951) * gru_1_out_t2_11 + (-0.84972834587097168) * gru_1_out_t2_12 + (-0.70169538259506226) * gru_1_out_t2_13 + (-0.39087757468223572) * gru_1_out_t2_14 + (-0.7032274603843689) * gru_1_out_t2_15 + (-1.0178000926971436) * gru_1_out_t2_16 + (0.82778322696685791) * gru_1_out_t2_17 + (0.56514686346054077) * gru_1_out_t2_18 + (-1.3584905862808228) * gru_1_out_t2_19 + (-0.37879833579063416) * gru_1_out_t2_20 + (-0.31072399020195007) * gru_1_out_t2_21 + (-1.4121963977813721) * gru_1_out_t2_22 + (2.719646692276001) * gru_1_out_t2_23 + (1.6593167781829834) * gru_1_out_t2_24 + (1.0647832155227661) * gru_1_out_t2_25 + (0.16964937746524811) * gru_1_out_t2_26 + (-0.71681898832321167) * gru_1_out_t2_27 + (-1.4632223844528198) * gru_1_out_t2_28 + (0.010557741858065128) * gru_1_out_t2_29 + (-0.18592436611652374) * gru_1_out_t2_30 + (0.68488442897796631) * gru_1_out_t2_31 + (-0.1623423844575882) * gru_1_out_t2_32 + (-0.47610986232757568) * gru_1_out_t2_33 + (-0.049443043768405914) * gru_1_out_t2_34 + (-0.41719624400138855) * gru_1_out_t2_35 + (0.036111261695623398) * gru_1_out_t2_36 + (-0.22463695704936981) * gru_1_out_t2_37 + (0.021300075575709343) * gru_1_out_t2_38 + (1.1826920509338379) * gru_1_out_t2_39 + (0.45321673154830933) * gru_1_out_t2_40 + (0.41584926843643188) * gru_1_out_t2_41 + (-0.056581184267997742) * gru_1_out_t2_42 + (-0.11399336904287338) * gru_1_out_t2_43 + (0.27685099840164185) * gru_1_out_t2_44 + (-0.51332569122314453) * gru_1_out_t2_45 + (-0.97001087665557861) * gru_1_out_t2_46 + (-1.7526880502700806) * gru_1_out_t2_47 + (0.4702206552028656) * gru_1_out_t2_48 + (0.90080505609512329) * gru_1_out_t2_49 + (-0.4292273223400116) * gru_1_out_t2_50 + (0.2086092084646225) * gru_1_out_t2_51 + (-0.80718690156936646) * gru_1_out_t2_52 + (1.7491378784179688) * gru_1_out_t2_53 + (1.9926940202713013) * gru_1_out_t2_54 + (0.76168054342269897) * gru_1_out_t2_55 + (0.14590936899185181) * gru_1_out_t2_56 + (1.0457772016525269) * gru_1_out_t2_57 + (0.19074457883834839) * gru_1_out_t2_58 + (2.0056602954864502) * gru_1_out_t2_59 + (0.67170494794845581) * gru_1_out_t2_60 + (1.4005582332611084) * gru_1_out_t2_61 + (0.93852037191390991) * gru_1_out_t2_62 + (0.18454331159591675) * gru_1_out_t2_63 + gate_r * ((1.9924075603485107) + (-0.019029203802347183) * gru_2_rev_t3_h_0 + (0.058884453028440475) * gru_2_rev_t3_h_1 + (0.096497826278209686) * gru_2_rev_t3_h_2 + (0.084945462644100189) * gru_2_rev_t3_h_3 + (0.10174935311079025) * gru_2_rev_t3_h_4 + (0.1586567610502243) * gru_2_rev_t3_h_5 + (-0.13066892325878143) * gru_2_rev_t3_h_6 + (0.0087661845609545708) * gru_2_rev_t3_h_7 + (0.17358185350894928) * gru_2_rev_t3_h_8 + (-0.12295316904783249) * gru_2_rev_t3_h_9 + (-0.020603997632861137) * gru_2_rev_t3_h_10 + (0.083847939968109131) * gru_2_rev_t3_h_11 + (0.013880286365747452) * gru_2_rev_t3_h_12 + (0.043434798717498779) * gru_2_rev_t3_h_13 + (-0.046231649816036224) * gru_2_rev_t3_h_14 + (0.083957277238368988) * gru_2_rev_t3_h_15 + (0.1575276106595993) * gru_2_rev_t3_h_16 + (0.040270563215017319) * gru_2_rev_t3_h_17 + (-0.074294127523899078) * gru_2_rev_t3_h_18 + (0.30264267325401306) * gru_2_rev_t3_h_19 + (0.022171352058649063) * gru_2_rev_t3_h_20 + (0.21361994743347168) * gru_2_rev_t3_h_21 + (0.063595511019229889) * gru_2_rev_t3_h_22 + (-0.14672765135765076) * gru_2_rev_t3_h_23 + (-0.074754603207111359) * gru_2_rev_t3_h_24 + (-0.066321231424808502) * gru_2_rev_t3_h_25 + (0.0067581329494714737) * gru_2_rev_t3_h_26 + (0.01075421180576086) * gru_2_rev_t3_h_27 + (0.029076267033815384) * gru_2_rev_t3_h_28 + (-0.054471414536237717) * gru_2_rev_t3_h_29 + (0.055765580385923386) * gru_2_rev_t3_h_30 + (0.082916378974914551) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_22 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_22;
    // h=23
    gate_r = sigmoid((0.27645030617713928) + (0.05541669949889183) * gru_1_out_t2_0 + (-0.24639478325843811) * gru_1_out_t2_1 + (0.80836391448974609) * gru_1_out_t2_2 + (0.80512648820877075) * gru_1_out_t2_3 + (0.67483776807785034) * gru_1_out_t2_4 + (0.10021636635065079) * gru_1_out_t2_5 + (-3.6089546680450439) * gru_1_out_t2_6 + (-0.031414434313774109) * gru_1_out_t2_7 + (3.4617576599121094) * gru_1_out_t2_8 + (-0.35967028141021729) * gru_1_out_t2_9 + (0.16427679359912872) * gru_1_out_t2_10 + (2.3454380035400391) * gru_1_out_t2_11 + (-1.2699733972549438) * gru_1_out_t2_12 + (-1.392950177192688) * gru_1_out_t2_13 + (-2.6469020843505859) * gru_1_out_t2_14 + (-0.31886321306228638) * gru_1_out_t2_15 + (-0.41837140917778015) * gru_1_out_t2_16 + (-0.79891687631607056) * gru_1_out_t2_17 + (-0.62661451101303101) * gru_1_out_t2_18 + (-2.2676181793212891) * gru_1_out_t2_19 + (0.76325953006744385) * gru_1_out_t2_20 + (-2.2014718055725098) * gru_1_out_t2_21 + (-0.026312071830034256) * gru_1_out_t2_22 + (-1.2788064479827881) * gru_1_out_t2_23 + (-1.5267925262451172) * gru_1_out_t2_24 + (1.3332148790359497) * gru_1_out_t2_25 + (-1.2150669097900391) * gru_1_out_t2_26 + (1.3829759359359741) * gru_1_out_t2_27 + (-0.30864232778549194) * gru_1_out_t2_28 + (-0.071995168924331665) * gru_1_out_t2_29 + (-2.6299998760223389) * gru_1_out_t2_30 + (-0.54412448406219482) * gru_1_out_t2_31 + (-0.47256278991699219) * gru_1_out_t2_32 + (5.6464872360229492) * gru_1_out_t2_33 + (-1.8365575075149536) * gru_1_out_t2_34 + (0.30684772133827209) * gru_1_out_t2_35 + (0.89402395486831665) * gru_1_out_t2_36 + (-0.5008544921875) * gru_1_out_t2_37 + (-1.4245578050613403) * gru_1_out_t2_38 + (-1.2520873546600342) * gru_1_out_t2_39 + (-0.65202802419662476) * gru_1_out_t2_40 + (-0.05129680410027504) * gru_1_out_t2_41 + (-0.28643330931663513) * gru_1_out_t2_42 + (1.1932469606399536) * gru_1_out_t2_43 + (1.0156110525131226) * gru_1_out_t2_44 + (1.8645216226577759) * gru_1_out_t2_45 + (1.0856826305389404) * gru_1_out_t2_46 + (-0.39724487066268921) * gru_1_out_t2_47 + (0.13165357708930969) * gru_1_out_t2_48 + (2.5725307464599609) * gru_1_out_t2_49 + (-0.074314117431640625) * gru_1_out_t2_50 + (-0.072756044566631317) * gru_1_out_t2_51 + (-3.0854344367980957) * gru_1_out_t2_52 + (0.56854122877120972) * gru_1_out_t2_53 + (-0.44284456968307495) * gru_1_out_t2_54 + (0.42839747667312622) * gru_1_out_t2_55 + (1.3701709508895874) * gru_1_out_t2_56 + (0.53982776403427124) * gru_1_out_t2_57 + (-0.11166218668222427) * gru_1_out_t2_58 + (0.097592316567897797) * gru_1_out_t2_59 + (-0.53120589256286621) * gru_1_out_t2_60 + (-0.79787015914916992) * gru_1_out_t2_61 + (-1.0428711175918579) * gru_1_out_t2_62 + (1.272057056427002) * gru_1_out_t2_63 + (-0.079940266907215118) * gru_2_rev_t3_h_0 + (-0.045976694673299789) * gru_2_rev_t3_h_1 + (-0.030674614012241364) * gru_2_rev_t3_h_2 + (0.024252992123365402) * gru_2_rev_t3_h_3 + (-0.075126945972442627) * gru_2_rev_t3_h_4 + (0.008110356517136097) * gru_2_rev_t3_h_5 + (-0.11844772845506668) * gru_2_rev_t3_h_6 + (0.098365738987922668) * gru_2_rev_t3_h_7 + (0.044134106487035751) * gru_2_rev_t3_h_8 + (-0.021299054846167564) * gru_2_rev_t3_h_9 + (-0.14477124810218811) * gru_2_rev_t3_h_10 + (-0.1173105388879776) * gru_2_rev_t3_h_11 + (-0.26019671559333801) * gru_2_rev_t3_h_12 + (-0.0035835816524922848) * gru_2_rev_t3_h_13 + (-0.29067739844322205) * gru_2_rev_t3_h_14 + (-0.0076145157217979431) * gru_2_rev_t3_h_15 + (-0.15963837504386902) * gru_2_rev_t3_h_16 + (-0.084080375730991364) * gru_2_rev_t3_h_17 + (-0.071225672960281372) * gru_2_rev_t3_h_18 + (0.019980834797024727) * gru_2_rev_t3_h_19 + (-0.051071755588054657) * gru_2_rev_t3_h_20 + (0.13068678975105286) * gru_2_rev_t3_h_21 + (0.0019791594240814447) * gru_2_rev_t3_h_22 + (-0.12231658399105072) * gru_2_rev_t3_h_23 + (0.077054828405380249) * gru_2_rev_t3_h_24 + (-0.15529632568359375) * gru_2_rev_t3_h_25 + (-0.12694083154201508) * gru_2_rev_t3_h_26 + (0.019944597035646439) * gru_2_rev_t3_h_27 + (-0.017638832330703735) * gru_2_rev_t3_h_28 + (-0.17698711156845093) * gru_2_rev_t3_h_29 + (0.00023263202456291765) * gru_2_rev_t3_h_30 + (0.010983394458889961) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((-1.9517886638641357) + (-0.62111592292785645) * gru_1_out_t2_0 + (-0.2397119551897049) * gru_1_out_t2_1 + (0.14248000085353851) * gru_1_out_t2_2 + (0.13727927207946777) * gru_1_out_t2_3 + (-0.11508440971374512) * gru_1_out_t2_4 + (1.5160654783248901) * gru_1_out_t2_5 + (-0.51767635345458984) * gru_1_out_t2_6 + (-0.24995525181293488) * gru_1_out_t2_7 + (0.22293172776699066) * gru_1_out_t2_8 + (0.64284342527389526) * gru_1_out_t2_9 + (-1.8104147911071777) * gru_1_out_t2_10 + (-1.2285811901092529) * gru_1_out_t2_11 + (0.17119453847408295) * gru_1_out_t2_12 + (0.25349360704421997) * gru_1_out_t2_13 + (-0.1248612105846405) * gru_1_out_t2_14 + (0.32971224188804626) * gru_1_out_t2_15 + (0.89325761795043945) * gru_1_out_t2_16 + (-0.7234686017036438) * gru_1_out_t2_17 + (-0.49332514405250549) * gru_1_out_t2_18 + (0.89647924900054932) * gru_1_out_t2_19 + (0.086678363382816315) * gru_1_out_t2_20 + (0.78963941335678101) * gru_1_out_t2_21 + (1.1127142906188965) * gru_1_out_t2_22 + (1.1323275566101074) * gru_1_out_t2_23 + (-0.50157797336578369) * gru_1_out_t2_24 + (-2.2400436401367188) * gru_1_out_t2_25 + (-1.4165188074111938) * gru_1_out_t2_26 + (1.3915209770202637) * gru_1_out_t2_27 + (-0.0030457985121756792) * gru_1_out_t2_28 + (0.19305694103240967) * gru_1_out_t2_29 + (-1.575908899307251) * gru_1_out_t2_30 + (0.064360901713371277) * gru_1_out_t2_31 + (-0.77251458168029785) * gru_1_out_t2_32 + (-0.2749292254447937) * gru_1_out_t2_33 + (0.47638040781021118) * gru_1_out_t2_34 + (-0.080559238791465759) * gru_1_out_t2_35 + (-0.81985431909561157) * gru_1_out_t2_36 + (0.15221866965293884) * gru_1_out_t2_37 + (0.95597493648529053) * gru_1_out_t2_38 + (-0.41772514581680298) * gru_1_out_t2_39 + (0.72041916847229004) * gru_1_out_t2_40 + (-0.63159805536270142) * gru_1_out_t2_41 + (1.290913462638855) * gru_1_out_t2_42 + (0.82242333889007568) * gru_1_out_t2_43 + (0.21619778871536255) * gru_1_out_t2_44 + (-0.015581806190311909) * gru_1_out_t2_45 + (2.9078781604766846) * gru_1_out_t2_46 + (0.11575218290090561) * gru_1_out_t2_47 + (0.45479482412338257) * gru_1_out_t2_48 + (-0.34146711230278015) * gru_1_out_t2_49 + (1.4329607486724854) * gru_1_out_t2_50 + (-2.8490972518920898) * gru_1_out_t2_51 + (-0.69287705421447754) * gru_1_out_t2_52 + (-0.28730550408363342) * gru_1_out_t2_53 + (-1.0814130306243896) * gru_1_out_t2_54 + (-1.492344856262207) * gru_1_out_t2_55 + (1.1853790283203125) * gru_1_out_t2_56 + (-1.1638152599334717) * gru_1_out_t2_57 + (-0.5030672550201416) * gru_1_out_t2_58 + (1.2848310470581055) * gru_1_out_t2_59 + (0.12413274496793747) * gru_1_out_t2_60 + (-1.2748795747756958) * gru_1_out_t2_61 + (0.9557720422744751) * gru_1_out_t2_62 + (-0.74238145351409912) * gru_1_out_t2_63 + (0.022507160902023315) * gru_2_rev_t3_h_0 + (0.10737530887126923) * gru_2_rev_t3_h_1 + (-0.21307733654975891) * gru_2_rev_t3_h_2 + (-0.041410006582736969) * gru_2_rev_t3_h_3 + (0.032679703086614609) * gru_2_rev_t3_h_4 + (0.067384742200374603) * gru_2_rev_t3_h_5 + (-0.12287820130586624) * gru_2_rev_t3_h_6 + (-0.003308640094473958) * gru_2_rev_t3_h_7 + (0.030282462015748024) * gru_2_rev_t3_h_8 + (-0.046483155339956284) * gru_2_rev_t3_h_9 + (0.0064938226714730263) * gru_2_rev_t3_h_10 + (0.22314043343067169) * gru_2_rev_t3_h_11 + (0.10078909248113632) * gru_2_rev_t3_h_12 + (-0.12921077013015747) * gru_2_rev_t3_h_13 + (-0.020760849118232727) * gru_2_rev_t3_h_14 + (0.10421875864267349) * gru_2_rev_t3_h_15 + (-0.037430055439472198) * gru_2_rev_t3_h_16 + (0.027051080018281937) * gru_2_rev_t3_h_17 + (-0.079140283167362213) * gru_2_rev_t3_h_18 + (-0.15533620119094849) * gru_2_rev_t3_h_19 + (-0.12448567152023315) * gru_2_rev_t3_h_20 + (0.17782875895500183) * gru_2_rev_t3_h_21 + (-0.1228640004992485) * gru_2_rev_t3_h_22 + (-0.018852237612009048) * gru_2_rev_t3_h_23 + (-0.15186351537704468) * gru_2_rev_t3_h_24 + (0.06898806244134903) * gru_2_rev_t3_h_25 + (0.099727869033813477) * gru_2_rev_t3_h_26 + (0.12304060906171799) * gru_2_rev_t3_h_27 + (-0.020386872813105583) * gru_2_rev_t3_h_28 + (-0.11677566915750504) * gru_2_rev_t3_h_29 + (-0.096773684024810791) * gru_2_rev_t3_h_30 + (0.12297410517930984) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.51870477199554443) + (0.4508398175239563) * gru_1_out_t2_0 + (0.31989160180091858) * gru_1_out_t2_1 + (-0.034450020641088486) * gru_1_out_t2_2 + (0.3026486337184906) * gru_1_out_t2_3 + (-0.33738678693771362) * gru_1_out_t2_4 + (0.51588571071624756) * gru_1_out_t2_5 + (1.2983549833297729) * gru_1_out_t2_6 + (-0.0017117694951593876) * gru_1_out_t2_7 + (-0.035411935299634933) * gru_1_out_t2_8 + (-0.57168501615524292) * gru_1_out_t2_9 + (0.18520596623420715) * gru_1_out_t2_10 + (0.02517130970954895) * gru_1_out_t2_11 + (-0.12321754544973373) * gru_1_out_t2_12 + (0.13776908814907074) * gru_1_out_t2_13 + (-0.081855520606040955) * gru_1_out_t2_14 + (0.047739654779434204) * gru_1_out_t2_15 + (-0.50951898097991943) * gru_1_out_t2_16 + (-0.50636816024780273) * gru_1_out_t2_17 + (-0.21456387639045715) * gru_1_out_t2_18 + (-0.38051876425743103) * gru_1_out_t2_19 + (-0.21383382380008698) * gru_1_out_t2_20 + (0.14790259301662445) * gru_1_out_t2_21 + (-0.63617914915084839) * gru_1_out_t2_22 + (0.25775948166847229) * gru_1_out_t2_23 + (-0.62667781114578247) * gru_1_out_t2_24 + (0.090236172080039978) * gru_1_out_t2_25 + (0.75386160612106323) * gru_1_out_t2_26 + (-0.36319917440414429) * gru_1_out_t2_27 + (-0.32621011137962341) * gru_1_out_t2_28 + (-0.30268600583076477) * gru_1_out_t2_29 + (0.33753040432929993) * gru_1_out_t2_30 + (-0.34712719917297363) * gru_1_out_t2_31 + (2.1884942054748535) * gru_1_out_t2_32 + (0.71901768445968628) * gru_1_out_t2_33 + (0.33731970191001892) * gru_1_out_t2_34 + (-0.69846051931381226) * gru_1_out_t2_35 + (0.24282847344875336) * gru_1_out_t2_36 + (-0.14105795323848724) * gru_1_out_t2_37 + (-0.4209410548210144) * gru_1_out_t2_38 + (-0.82020014524459839) * gru_1_out_t2_39 + (0.41901561617851257) * gru_1_out_t2_40 + (0.21956099569797516) * gru_1_out_t2_41 + (-1.1792372465133667) * gru_1_out_t2_42 + (0.59354519844055176) * gru_1_out_t2_43 + (0.030107971280813217) * gru_1_out_t2_44 + (1.7151178121566772) * gru_1_out_t2_45 + (-0.77094739675521851) * gru_1_out_t2_46 + (-0.95944660902023315) * gru_1_out_t2_47 + (-0.0017444432014599442) * gru_1_out_t2_48 + (-1.2991788387298584) * gru_1_out_t2_49 + (-1.0898518562316895) * gru_1_out_t2_50 + (-0.59879004955291748) * gru_1_out_t2_51 + (-2.3062748908996582) * gru_1_out_t2_52 + (-0.28601160645484924) * gru_1_out_t2_53 + (-0.3723946213722229) * gru_1_out_t2_54 + (0.23197050392627716) * gru_1_out_t2_55 + (-0.067810088396072388) * gru_1_out_t2_56 + (0.50845819711685181) * gru_1_out_t2_57 + (0.42674091458320618) * gru_1_out_t2_58 + (-0.028506668284535408) * gru_1_out_t2_59 + (1.3660275936126709) * gru_1_out_t2_60 + (-0.47940412163734436) * gru_1_out_t2_61 + (-0.17142908275127411) * gru_1_out_t2_62 + (-1.2444473505020142) * gru_1_out_t2_63 + gate_r * ((2.8779900074005127) + (-0.0047510131262242794) * gru_2_rev_t3_h_0 + (-0.15434814989566803) * gru_2_rev_t3_h_1 + (0.12085920572280884) * gru_2_rev_t3_h_2 + (0.13415324687957764) * gru_2_rev_t3_h_3 + (-0.011316873133182526) * gru_2_rev_t3_h_4 + (-0.0019259749678894877) * gru_2_rev_t3_h_5 + (0.024986358359456062) * gru_2_rev_t3_h_6 + (-0.063551008701324463) * gru_2_rev_t3_h_7 + (0.03884003683924675) * gru_2_rev_t3_h_8 + (-0.1011757105588913) * gru_2_rev_t3_h_9 + (0.035233680158853531) * gru_2_rev_t3_h_10 + (0.00095053610857576132) * gru_2_rev_t3_h_11 + (-0.027361262589693069) * gru_2_rev_t3_h_12 + (-0.067673653364181519) * gru_2_rev_t3_h_13 + (-0.14197863638401031) * gru_2_rev_t3_h_14 + (-0.07138119637966156) * gru_2_rev_t3_h_15 + (-0.15260383486747742) * gru_2_rev_t3_h_16 + (-0.008707066997885704) * gru_2_rev_t3_h_17 + (-0.090052090585231781) * gru_2_rev_t3_h_18 + (0.018199564889073372) * gru_2_rev_t3_h_19 + (-0.036748472601175308) * gru_2_rev_t3_h_20 + (0.055391959846019745) * gru_2_rev_t3_h_21 + (-0.1121925562620163) * gru_2_rev_t3_h_22 + (0.10222776979207993) * gru_2_rev_t3_h_23 + (0.030244354158639908) * gru_2_rev_t3_h_24 + (-0.0058309054002165794) * gru_2_rev_t3_h_25 + (0.066562697291374207) * gru_2_rev_t3_h_26 + (0.055059570819139481) * gru_2_rev_t3_h_27 + (0.087171956896781921) * gru_2_rev_t3_h_28 + (-0.022131407633423805) * gru_2_rev_t3_h_29 + (-0.1532929390668869) * gru_2_rev_t3_h_30 + (0.053628150373697281) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_23 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_23;
    // h=24
    gate_r = sigmoid((-0.013902473263442516) + (-0.092945165932178497) * gru_1_out_t2_0 + (0.83469969034194946) * gru_1_out_t2_1 + (-1.1823204755783081) * gru_1_out_t2_2 + (-0.59028887748718262) * gru_1_out_t2_3 + (-0.34703919291496277) * gru_1_out_t2_4 + (0.53017717599868774) * gru_1_out_t2_5 + (1.5266755819320679) * gru_1_out_t2_6 + (-0.14098046720027924) * gru_1_out_t2_7 + (0.11271339654922485) * gru_1_out_t2_8 + (-0.09671909362077713) * gru_1_out_t2_9 + (1.5308277606964111) * gru_1_out_t2_10 + (0.92034071683883667) * gru_1_out_t2_11 + (-0.16469502449035645) * gru_1_out_t2_12 + (1.2369109392166138) * gru_1_out_t2_13 + (0.43964806199073792) * gru_1_out_t2_14 + (0.063987322151660919) * gru_1_out_t2_15 + (0.26329019665718079) * gru_1_out_t2_16 + (-0.705527663230896) * gru_1_out_t2_17 + (-0.36908423900604248) * gru_1_out_t2_18 + (-0.42128294706344604) * gru_1_out_t2_19 + (0.15727011859416962) * gru_1_out_t2_20 + (0.90123552083969116) * gru_1_out_t2_21 + (-1.6832246780395508) * gru_1_out_t2_22 + (-2.395188570022583) * gru_1_out_t2_23 + (-0.37107518315315247) * gru_1_out_t2_24 + (1.2455050945281982) * gru_1_out_t2_25 + (-0.69810128211975098) * gru_1_out_t2_26 + (-1.7028006315231323) * gru_1_out_t2_27 + (-0.51183384656906128) * gru_1_out_t2_28 + (0.011817348189651966) * gru_1_out_t2_29 + (-0.92314285039901733) * gru_1_out_t2_30 + (0.3283427357673645) * gru_1_out_t2_31 + (-0.45086938142776489) * gru_1_out_t2_32 + (0.51621866226196289) * gru_1_out_t2_33 + (1.5075088739395142) * gru_1_out_t2_34 + (-0.89093345403671265) * gru_1_out_t2_35 + (-0.21129295229911804) * gru_1_out_t2_36 + (0.91039562225341797) * gru_1_out_t2_37 + (0.25294309854507446) * gru_1_out_t2_38 + (-0.03780185803771019) * gru_1_out_t2_39 + (0.13758186995983124) * gru_1_out_t2_40 + (-0.067463807761669159) * gru_1_out_t2_41 + (2.4299221038818359) * gru_1_out_t2_42 + (-0.27260124683380127) * gru_1_out_t2_43 + (-0.098853260278701782) * gru_1_out_t2_44 + (0.36111298203468323) * gru_1_out_t2_45 + (2.0213046073913574) * gru_1_out_t2_46 + (0.83075326681137085) * gru_1_out_t2_47 + (0.28401634097099304) * gru_1_out_t2_48 + (1.2848356962203979) * gru_1_out_t2_49 + (0.19322378933429718) * gru_1_out_t2_50 + (-2.4806327819824219) * gru_1_out_t2_51 + (0.10789458453655243) * gru_1_out_t2_52 + (-0.14072120189666748) * gru_1_out_t2_53 + (0.82433402538299561) * gru_1_out_t2_54 + (-0.12936496734619141) * gru_1_out_t2_55 + (0.17874860763549805) * gru_1_out_t2_56 + (-0.1921132504940033) * gru_1_out_t2_57 + (-0.25140833854675293) * gru_1_out_t2_58 + (-0.91800767183303833) * gru_1_out_t2_59 + (0.12426622211933136) * gru_1_out_t2_60 + (-1.3950631618499756) * gru_1_out_t2_61 + (0.42113104462623596) * gru_1_out_t2_62 + (0.16428534686565399) * gru_1_out_t2_63 + (-0.015189919620752335) * gru_2_rev_t3_h_0 + (-0.058127854019403458) * gru_2_rev_t3_h_1 + (0.050157051533460617) * gru_2_rev_t3_h_2 + (0.0050263688899576664) * gru_2_rev_t3_h_3 + (-0.2178165465593338) * gru_2_rev_t3_h_4 + (-0.21647801995277405) * gru_2_rev_t3_h_5 + (-0.031731821596622467) * gru_2_rev_t3_h_6 + (-0.046565253287553787) * gru_2_rev_t3_h_7 + (-0.24468633532524109) * gru_2_rev_t3_h_8 + (0.011642523109912872) * gru_2_rev_t3_h_9 + (-0.14849293231964111) * gru_2_rev_t3_h_10 + (0.16072899103164673) * gru_2_rev_t3_h_11 + (0.0013464054791256785) * gru_2_rev_t3_h_12 + (-0.018072484061121941) * gru_2_rev_t3_h_13 + (-0.10894559323787689) * gru_2_rev_t3_h_14 + (0.073179528117179871) * gru_2_rev_t3_h_15 + (0.16366221010684967) * gru_2_rev_t3_h_16 + (-0.13559100031852722) * gru_2_rev_t3_h_17 + (0.068473495543003082) * gru_2_rev_t3_h_18 + (-0.15704713761806488) * gru_2_rev_t3_h_19 + (0.0039151986129581928) * gru_2_rev_t3_h_20 + (0.031705703586339951) * gru_2_rev_t3_h_21 + (-0.11828075349330902) * gru_2_rev_t3_h_22 + (-0.093367613852024078) * gru_2_rev_t3_h_23 + (0.01829657144844532) * gru_2_rev_t3_h_24 + (0.17131902277469635) * gru_2_rev_t3_h_25 + (0.081820599734783173) * gru_2_rev_t3_h_26 + (-0.036774169653654099) * gru_2_rev_t3_h_27 + (-0.20765967667102814) * gru_2_rev_t3_h_28 + (0.00048512226203456521) * gru_2_rev_t3_h_29 + (-0.00098675629124045372) * gru_2_rev_t3_h_30 + (-0.0062135779298841953) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((-0.40636718273162842) + (-0.17621037364006042) * gru_1_out_t2_0 + (0.023153664544224739) * gru_1_out_t2_1 + (0.75741177797317505) * gru_1_out_t2_2 + (0.74509811401367188) * gru_1_out_t2_3 + (0.26441410183906555) * gru_1_out_t2_4 + (-0.8899652361869812) * gru_1_out_t2_5 + (0.0242109764367342) * gru_1_out_t2_6 + (0.64969825744628906) * gru_1_out_t2_7 + (-0.11098360270261765) * gru_1_out_t2_8 + (0.27214384078979492) * gru_1_out_t2_9 + (-0.45699900388717651) * gru_1_out_t2_10 + (-0.78152006864547729) * gru_1_out_t2_11 + (-0.37939453125) * gru_1_out_t2_12 + (-0.091076076030731201) * gru_1_out_t2_13 + (-0.29992538690567017) * gru_1_out_t2_14 + (-0.071127347648143768) * gru_1_out_t2_15 + (0.05414779856801033) * gru_1_out_t2_16 + (-0.051605071872472763) * gru_1_out_t2_17 + (-0.12479060143232346) * gru_1_out_t2_18 + (0.19401934742927551) * gru_1_out_t2_19 + (-0.02478758804500103) * gru_1_out_t2_20 + (-0.052256930619478226) * gru_1_out_t2_21 + (0.76760154962539673) * gru_1_out_t2_22 + (0.0091199753805994987) * gru_1_out_t2_23 + (-0.024506920948624611) * gru_1_out_t2_24 + (-0.3998776376247406) * gru_1_out_t2_25 + (0.063380114734172821) * gru_1_out_t2_26 + (0.47752544283866882) * gru_1_out_t2_27 + (-0.10491988807916641) * gru_1_out_t2_28 + (-0.49543651938438416) * gru_1_out_t2_29 + (0.028339501470327377) * gru_1_out_t2_30 + (-0.83271926641464233) * gru_1_out_t2_31 + (-0.080267071723937988) * gru_1_out_t2_32 + (-0.17338801920413971) * gru_1_out_t2_33 + (-0.78327983617782593) * gru_1_out_t2_34 + (0.4985634982585907) * gru_1_out_t2_35 + (-0.290488600730896) * gru_1_out_t2_36 + (-0.43137794733047485) * gru_1_out_t2_37 + (0.29037836194038391) * gru_1_out_t2_38 + (-0.44949817657470703) * gru_1_out_t2_39 + (0.17592060565948486) * gru_1_out_t2_40 + (-0.18391767144203186) * gru_1_out_t2_41 + (0.0888809934258461) * gru_1_out_t2_42 + (0.24840198457241058) * gru_1_out_t2_43 + (0.77055197954177856) * gru_1_out_t2_44 + (-0.0073439097031950951) * gru_1_out_t2_45 + (-0.019116761162877083) * gru_1_out_t2_46 + (0.30091080069541931) * gru_1_out_t2_47 + (-0.22852352261543274) * gru_1_out_t2_48 + (-0.033737145364284515) * gru_1_out_t2_49 + (0.098782569169998169) * gru_1_out_t2_50 + (0.29501613974571228) * gru_1_out_t2_51 + (0.48825901746749878) * gru_1_out_t2_52 + (-0.18521320819854736) * gru_1_out_t2_53 + (-0.32770013809204102) * gru_1_out_t2_54 + (-0.054049365222454071) * gru_1_out_t2_55 + (0.00095885078189894557) * gru_1_out_t2_56 + (-0.24511474370956421) * gru_1_out_t2_57 + (-0.033177286386489868) * gru_1_out_t2_58 + (0.47180688381195068) * gru_1_out_t2_59 + (0.34181982278823853) * gru_1_out_t2_60 + (0.59801328182220459) * gru_1_out_t2_61 + (-0.6167256236076355) * gru_1_out_t2_62 + (-0.22156715393066406) * gru_1_out_t2_63 + (0.068393051624298096) * gru_2_rev_t3_h_0 + (0.069953091442584991) * gru_2_rev_t3_h_1 + (0.035096671432256699) * gru_2_rev_t3_h_2 + (0.082722187042236328) * gru_2_rev_t3_h_3 + (-0.1924210786819458) * gru_2_rev_t3_h_4 + (0.085681542754173279) * gru_2_rev_t3_h_5 + (0.095419079065322876) * gru_2_rev_t3_h_6 + (0.031075583770871162) * gru_2_rev_t3_h_7 + (-0.00365648721344769) * gru_2_rev_t3_h_8 + (0.079477697610855103) * gru_2_rev_t3_h_9 + (-0.064703546464443207) * gru_2_rev_t3_h_10 + (-0.14241749048233032) * gru_2_rev_t3_h_11 + (-0.22324299812316895) * gru_2_rev_t3_h_12 + (0.13914869725704193) * gru_2_rev_t3_h_13 + (0.050051793456077576) * gru_2_rev_t3_h_14 + (0.2244800329208374) * gru_2_rev_t3_h_15 + (0.025952937081456184) * gru_2_rev_t3_h_16 + (-0.092395991086959839) * gru_2_rev_t3_h_17 + (0.085255198180675507) * gru_2_rev_t3_h_18 + (0.26236945390701294) * gru_2_rev_t3_h_19 + (-0.069274522364139557) * gru_2_rev_t3_h_20 + (-0.092946179211139679) * gru_2_rev_t3_h_21 + (-0.064712069928646088) * gru_2_rev_t3_h_22 + (-0.18065768480300903) * gru_2_rev_t3_h_23 + (-0.051131889224052429) * gru_2_rev_t3_h_24 + (0.24045059084892273) * gru_2_rev_t3_h_25 + (0.16673912107944489) * gru_2_rev_t3_h_26 + (0.24703216552734375) * gru_2_rev_t3_h_27 + (0.25581914186477661) * gru_2_rev_t3_h_28 + (-0.19466383755207062) * gru_2_rev_t3_h_29 + (-0.065817609429359436) * gru_2_rev_t3_h_30 + (0.051922272890806198) * gru_2_rev_t3_h_31);
    gate_n = tanh((-0.23433879017829895) + (-0.10124967247247696) * gru_1_out_t2_0 + (0.20102611184120178) * gru_1_out_t2_1 + (0.67773890495300293) * gru_1_out_t2_2 + (0.4246688187122345) * gru_1_out_t2_3 + (0.093139447271823883) * gru_1_out_t2_4 + (-0.3895912766456604) * gru_1_out_t2_5 + (0.52449440956115723) * gru_1_out_t2_6 + (0.052925102412700653) * gru_1_out_t2_7 + (-0.088247932493686676) * gru_1_out_t2_8 + (0.39860793948173523) * gru_1_out_t2_9 + (-0.90857356786727905) * gru_1_out_t2_10 + (-1.1299010515213013) * gru_1_out_t2_11 + (0.10982614010572433) * gru_1_out_t2_12 + (-0.17790292203426361) * gru_1_out_t2_13 + (-0.29041281342506409) * gru_1_out_t2_14 + (0.38656669855117798) * gru_1_out_t2_15 + (0.1973365843296051) * gru_1_out_t2_16 + (0.096366405487060547) * gru_1_out_t2_17 + (0.35426583886146545) * gru_1_out_t2_18 + (0.36382371187210083) * gru_1_out_t2_19 + (-0.29397618770599365) * gru_1_out_t2_20 + (-0.18811661005020142) * gru_1_out_t2_21 + (2.0115587711334229) * gru_1_out_t2_22 + (-0.15404687821865082) * gru_1_out_t2_23 + (0.14313477277755737) * gru_1_out_t2_24 + (-0.30699464678764343) * gru_1_out_t2_25 + (0.19997638463973999) * gru_1_out_t2_26 + (0.82934492826461792) * gru_1_out_t2_27 + (0.068048328161239624) * gru_1_out_t2_28 + (-0.26296252012252808) * gru_1_out_t2_29 + (0.10895487666130066) * gru_1_out_t2_30 + (-0.40156874060630798) * gru_1_out_t2_31 + (0.38843569159507751) * gru_1_out_t2_32 + (-0.1789071261882782) * gru_1_out_t2_33 + (-0.49709519743919373) * gru_1_out_t2_34 + (0.46371442079544067) * gru_1_out_t2_35 + (-0.15982247889041901) * gru_1_out_t2_36 + (-0.31497317552566528) * gru_1_out_t2_37 + (-0.024818385019898415) * gru_1_out_t2_38 + (-0.37500721216201782) * gru_1_out_t2_39 + (0.25059029459953308) * gru_1_out_t2_40 + (-0.43203884363174438) * gru_1_out_t2_41 + (0.0039434232749044895) * gru_1_out_t2_42 + (0.67279046773910522) * gru_1_out_t2_43 + (0.29045742750167847) * gru_1_out_t2_44 + (-0.086488001048564911) * gru_1_out_t2_45 + (-0.13616067171096802) * gru_1_out_t2_46 + (0.0047586448490619659) * gru_1_out_t2_47 + (-0.20349077880382538) * gru_1_out_t2_48 + (-0.049285400658845901) * gru_1_out_t2_49 + (0.33093246817588806) * gru_1_out_t2_50 + (-0.069162465631961823) * gru_1_out_t2_51 + (-1.0491973161697388) * gru_1_out_t2_52 + (-0.21140387654304504) * gru_1_out_t2_53 + (-0.57745879888534546) * gru_1_out_t2_54 + (-0.091216646134853363) * gru_1_out_t2_55 + (-0.18960480391979218) * gru_1_out_t2_56 + (-0.23184579610824585) * gru_1_out_t2_57 + (-0.29322671890258789) * gru_1_out_t2_58 + (1.1996885538101196) * gru_1_out_t2_59 + (0.058400832116603851) * gru_1_out_t2_60 + (-0.034743852913379669) * gru_1_out_t2_61 + (-1.451213002204895) * gru_1_out_t2_62 + (-0.23366764187812805) * gru_1_out_t2_63 + gate_r * ((-0.48210108280181885) + (-0.11105290800333023) * gru_2_rev_t3_h_0 + (-0.00096319318981841207) * gru_2_rev_t3_h_1 + (-0.027010347694158554) * gru_2_rev_t3_h_2 + (0.062682360410690308) * gru_2_rev_t3_h_3 + (0.17643065750598907) * gru_2_rev_t3_h_4 + (0.030642999336123466) * gru_2_rev_t3_h_5 + (-0.0079289209097623825) * gru_2_rev_t3_h_6 + (0.22750912606716156) * gru_2_rev_t3_h_7 + (-0.052343789488077164) * gru_2_rev_t3_h_8 + (-0.037560805678367615) * gru_2_rev_t3_h_9 + (-0.08023563027381897) * gru_2_rev_t3_h_10 + (-0.068593442440032959) * gru_2_rev_t3_h_11 + (-0.12524931132793427) * gru_2_rev_t3_h_12 + (0.11417272686958313) * gru_2_rev_t3_h_13 + (-0.0091949040070176125) * gru_2_rev_t3_h_14 + (-0.16188089549541473) * gru_2_rev_t3_h_15 + (0.088769569993019104) * gru_2_rev_t3_h_16 + (0.0092733372002840042) * gru_2_rev_t3_h_17 + (0.053152352571487427) * gru_2_rev_t3_h_18 + (0.013054401613771915) * gru_2_rev_t3_h_19 + (-0.027501752600073814) * gru_2_rev_t3_h_20 + (-0.11227435618638992) * gru_2_rev_t3_h_21 + (-0.027092898264527321) * gru_2_rev_t3_h_22 + (0.0049796216189861298) * gru_2_rev_t3_h_23 + (0.021752264350652695) * gru_2_rev_t3_h_24 + (0.067010171711444855) * gru_2_rev_t3_h_25 + (0.04473588615655899) * gru_2_rev_t3_h_26 + (-0.059867803007364273) * gru_2_rev_t3_h_27 + (0.13489583134651184) * gru_2_rev_t3_h_28 + (-0.065426692366600037) * gru_2_rev_t3_h_29 + (-0.057205542922019958) * gru_2_rev_t3_h_30 + (-0.08329521119594574) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_24 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_24;
    // h=25
    gate_r = sigmoid((-0.69698935747146606) + (-0.27459535002708435) * gru_1_out_t2_0 + (0.44303780794143677) * gru_1_out_t2_1 + (0.089543953537940979) * gru_1_out_t2_2 + (0.23438096046447754) * gru_1_out_t2_3 + (-0.55704545974731445) * gru_1_out_t2_4 + (1.770663857460022) * gru_1_out_t2_5 + (5.7362051010131836) * gru_1_out_t2_6 + (0.34593537449836731) * gru_1_out_t2_7 + (-0.45127403736114502) * gru_1_out_t2_8 + (-0.0058366837911307812) * gru_1_out_t2_9 + (0.28442871570587158) * gru_1_out_t2_10 + (0.650032639503479) * gru_1_out_t2_11 + (-0.43836632370948792) * gru_1_out_t2_12 + (-0.050434619188308716) * gru_1_out_t2_13 + (-0.013629330322146416) * gru_1_out_t2_14 + (-0.17753857374191284) * gru_1_out_t2_15 + (0.58336377143859863) * gru_1_out_t2_16 + (-2.0455694198608398) * gru_1_out_t2_17 + (-1.1131342649459839) * gru_1_out_t2_18 + (0.0074762050062417984) * gru_1_out_t2_19 + (0.48342183232307434) * gru_1_out_t2_20 + (-1.0877058506011963) * gru_1_out_t2_21 + (-2.0820293426513672) * gru_1_out_t2_22 + (1.5119644403457642) * gru_1_out_t2_23 + (3.7834160327911377) * gru_1_out_t2_24 + (0.075075000524520874) * gru_1_out_t2_25 + (-2.2551546096801758) * gru_1_out_t2_26 + (0.45481228828430176) * gru_1_out_t2_27 + (1.7497603893280029) * gru_1_out_t2_28 + (-0.34249308705329895) * gru_1_out_t2_29 + (-4.0844087600708008) * gru_1_out_t2_30 + (0.4286314845085144) * gru_1_out_t2_31 + (-0.91180801391601562) * gru_1_out_t2_32 + (-0.27928972244262695) * gru_1_out_t2_33 + (-0.7662118673324585) * gru_1_out_t2_34 + (0.91206943988800049) * gru_1_out_t2_35 + (0.30550235509872437) * gru_1_out_t2_36 + (-0.64635682106018066) * gru_1_out_t2_37 + (-0.063689857721328735) * gru_1_out_t2_38 + (-0.41154539585113525) * gru_1_out_t2_39 + (0.46551519632339478) * gru_1_out_t2_40 + (-0.17710043489933014) * gru_1_out_t2_41 + (-2.2884812355041504) * gru_1_out_t2_42 + (0.53104490041732788) * gru_1_out_t2_43 + (-0.036249663680791855) * gru_1_out_t2_44 + (0.80208474397659302) * gru_1_out_t2_45 + (2.4488718509674072) * gru_1_out_t2_46 + (0.26469048857688904) * gru_1_out_t2_47 + (-0.026211943477392197) * gru_1_out_t2_48 + (-2.9604439735412598) * gru_1_out_t2_49 + (0.064520187675952911) * gru_1_out_t2_50 + (1.2278577089309692) * gru_1_out_t2_51 + (0.079059407114982605) * gru_1_out_t2_52 + (-0.31322729587554932) * gru_1_out_t2_53 + (1.1219086647033691) * gru_1_out_t2_54 + (2.2060184478759766) * gru_1_out_t2_55 + (-0.091363757848739624) * gru_1_out_t2_56 + (-0.11893711239099503) * gru_1_out_t2_57 + (-0.86810976266860962) * gru_1_out_t2_58 + (-0.33653056621551514) * gru_1_out_t2_59 + (-0.00042483094148337841) * gru_1_out_t2_60 + (-0.69881969690322876) * gru_1_out_t2_61 + (-0.060438927263021469) * gru_1_out_t2_62 + (-0.060003731399774551) * gru_1_out_t2_63 + (0.045616805553436279) * gru_2_rev_t3_h_0 + (0.016993308439850807) * gru_2_rev_t3_h_1 + (0.095238000154495239) * gru_2_rev_t3_h_2 + (-0.085992917418479919) * gru_2_rev_t3_h_3 + (0.070170864462852478) * gru_2_rev_t3_h_4 + (-0.07571692019701004) * gru_2_rev_t3_h_5 + (0.24476833641529083) * gru_2_rev_t3_h_6 + (-0.00028784814639948308) * gru_2_rev_t3_h_7 + (0.056931454688310623) * gru_2_rev_t3_h_8 + (-0.081983700394630432) * gru_2_rev_t3_h_9 + (0.097177363932132721) * gru_2_rev_t3_h_10 + (0.0018230419373139739) * gru_2_rev_t3_h_11 + (-0.0063478043302893639) * gru_2_rev_t3_h_12 + (0.087434291839599609) * gru_2_rev_t3_h_13 + (-0.051793381571769714) * gru_2_rev_t3_h_14 + (0.029634280130267143) * gru_2_rev_t3_h_15 + (-0.011423176154494286) * gru_2_rev_t3_h_16 + (0.16807347536087036) * gru_2_rev_t3_h_17 + (-0.006757727824151516) * gru_2_rev_t3_h_18 + (0.056002799421548843) * gru_2_rev_t3_h_19 + (-0.078311286866664886) * gru_2_rev_t3_h_20 + (-0.037977118045091629) * gru_2_rev_t3_h_21 + (-0.076812513172626495) * gru_2_rev_t3_h_22 + (0.083652682602405548) * gru_2_rev_t3_h_23 + (0.1344945877790451) * gru_2_rev_t3_h_24 + (0.10117524117231369) * gru_2_rev_t3_h_25 + (-0.032041754573583603) * gru_2_rev_t3_h_26 + (0.045005816966295242) * gru_2_rev_t3_h_27 + (-0.076106838881969452) * gru_2_rev_t3_h_28 + (0.051774244755506516) * gru_2_rev_t3_h_29 + (0.00074520503403618932) * gru_2_rev_t3_h_30 + (0.013471780344843864) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.17576257884502411) + (-0.088652618229389191) * gru_1_out_t2_0 + (-0.38263291120529175) * gru_1_out_t2_1 + (1.3311440944671631) * gru_1_out_t2_2 + (0.51297688484191895) * gru_1_out_t2_3 + (0.28499594330787659) * gru_1_out_t2_4 + (0.76315313577651978) * gru_1_out_t2_5 + (-0.57171249389648438) * gru_1_out_t2_6 + (0.42484664916992188) * gru_1_out_t2_7 + (-0.64570140838623047) * gru_1_out_t2_8 + (-0.52585494518280029) * gru_1_out_t2_9 + (-0.10763370245695114) * gru_1_out_t2_10 + (-0.43626439571380615) * gru_1_out_t2_11 + (-1.3408991098403931) * gru_1_out_t2_12 + (-0.61464577913284302) * gru_1_out_t2_13 + (-0.18928147852420807) * gru_1_out_t2_14 + (-0.50360816717147827) * gru_1_out_t2_15 + (0.28535807132720947) * gru_1_out_t2_16 + (0.82751923799514771) * gru_1_out_t2_17 + (0.65858381986618042) * gru_1_out_t2_18 + (-0.6556096076965332) * gru_1_out_t2_19 + (1.0745216608047485) * gru_1_out_t2_20 + (0.68015766143798828) * gru_1_out_t2_21 + (-0.27351602911949158) * gru_1_out_t2_22 + (0.54310482740402222) * gru_1_out_t2_23 + (-1.5038034915924072) * gru_1_out_t2_24 + (0.24537487328052521) * gru_1_out_t2_25 + (-0.0055296537466347218) * gru_1_out_t2_26 + (0.049993697553873062) * gru_1_out_t2_27 + (-0.038019757717847824) * gru_1_out_t2_28 + (0.24944710731506348) * gru_1_out_t2_29 + (0.1499965488910675) * gru_1_out_t2_30 + (-0.46542394161224365) * gru_1_out_t2_31 + (0.24074485898017883) * gru_1_out_t2_32 + (0.75499445199966431) * gru_1_out_t2_33 + (0.13679057359695435) * gru_1_out_t2_34 + (-0.17276313900947571) * gru_1_out_t2_35 + (0.13031044602394104) * gru_1_out_t2_36 + (-1.2052816152572632) * gru_1_out_t2_37 + (-0.32281601428985596) * gru_1_out_t2_38 + (-0.42538192868232727) * gru_1_out_t2_39 + (-0.17785623669624329) * gru_1_out_t2_40 + (0.2753908634185791) * gru_1_out_t2_41 + (-2.3129396438598633) * gru_1_out_t2_42 + (0.69151812791824341) * gru_1_out_t2_43 + (-0.29380249977111816) * gru_1_out_t2_44 + (0.67037522792816162) * gru_1_out_t2_45 + (-1.1434398889541626) * gru_1_out_t2_46 + (1.1482940912246704) * gru_1_out_t2_47 + (-1.4895474910736084) * gru_1_out_t2_48 + (-1.6495966911315918) * gru_1_out_t2_49 + (0.76524746417999268) * gru_1_out_t2_50 + (2.114915132522583) * gru_1_out_t2_51 + (-1.6647719144821167) * gru_1_out_t2_52 + (0.34291240572929382) * gru_1_out_t2_53 + (1.6249644756317139) * gru_1_out_t2_54 + (0.26043769717216492) * gru_1_out_t2_55 + (-0.024973617866635323) * gru_1_out_t2_56 + (0.41699305176734924) * gru_1_out_t2_57 + (0.73734837770462036) * gru_1_out_t2_58 + (0.20027895271778107) * gru_1_out_t2_59 + (-0.056795358657836914) * gru_1_out_t2_60 + (-0.95839649438858032) * gru_1_out_t2_61 + (0.61481356620788574) * gru_1_out_t2_62 + (0.078255206346511841) * gru_1_out_t2_63 + (-0.15899890661239624) * gru_2_rev_t3_h_0 + (-0.052402198314666748) * gru_2_rev_t3_h_1 + (0.066740341484546661) * gru_2_rev_t3_h_2 + (-0.017335962504148483) * gru_2_rev_t3_h_3 + (0.069280579686164856) * gru_2_rev_t3_h_4 + (-0.15967521071434021) * gru_2_rev_t3_h_5 + (-0.26623621582984924) * gru_2_rev_t3_h_6 + (-0.14419876039028168) * gru_2_rev_t3_h_7 + (0.0034105305094271898) * gru_2_rev_t3_h_8 + (-0.003583989106118679) * gru_2_rev_t3_h_9 + (0.15791495144367218) * gru_2_rev_t3_h_10 + (-0.0078479666262865067) * gru_2_rev_t3_h_11 + (-0.1315128356218338) * gru_2_rev_t3_h_12 + (-0.015027903951704502) * gru_2_rev_t3_h_13 + (0.17160545289516449) * gru_2_rev_t3_h_14 + (-0.056441180408000946) * gru_2_rev_t3_h_15 + (0.0055254492908716202) * gru_2_rev_t3_h_16 + (-0.097445212304592133) * gru_2_rev_t3_h_17 + (-0.06680481880903244) * gru_2_rev_t3_h_18 + (-0.031198855489492416) * gru_2_rev_t3_h_19 + (0.087474949657917023) * gru_2_rev_t3_h_20 + (0.0044837282039225101) * gru_2_rev_t3_h_21 + (0.12709970772266388) * gru_2_rev_t3_h_22 + (-0.038451086729764938) * gru_2_rev_t3_h_23 + (0.088733240962028503) * gru_2_rev_t3_h_24 + (0.085192546248435974) * gru_2_rev_t3_h_25 + (0.088513702154159546) * gru_2_rev_t3_h_26 + (-0.078322216868400574) * gru_2_rev_t3_h_27 + (0.0038740336894989014) * gru_2_rev_t3_h_28 + (-0.13142262399196625) * gru_2_rev_t3_h_29 + (-0.10570602118968964) * gru_2_rev_t3_h_30 + (0.19330461323261261) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.20960000157356262) + (0.26997476816177368) * gru_1_out_t2_0 + (-0.8154064416885376) * gru_1_out_t2_1 + (0.32378917932510376) * gru_1_out_t2_2 + (-1.0057529211044312) * gru_1_out_t2_3 + (-0.81230664253234863) * gru_1_out_t2_4 + (-0.8576924204826355) * gru_1_out_t2_5 + (4.3539090156555176) * gru_1_out_t2_6 + (-1.3698059320449829) * gru_1_out_t2_7 + (0.37139952182769775) * gru_1_out_t2_8 + (0.33968612551689148) * gru_1_out_t2_9 + (1.3796705007553101) * gru_1_out_t2_10 + (-0.28104096651077271) * gru_1_out_t2_11 + (0.092125654220581055) * gru_1_out_t2_12 + (0.72306078672409058) * gru_1_out_t2_13 + (-0.2116134911775589) * gru_1_out_t2_14 + (-0.11793416738510132) * gru_1_out_t2_15 + (-0.27814373373985291) * gru_1_out_t2_16 + (0.82920187711715698) * gru_1_out_t2_17 + (0.15063685178756714) * gru_1_out_t2_18 + (-0.061513066291809082) * gru_1_out_t2_19 + (-0.23839519917964935) * gru_1_out_t2_20 + (-3.1583852767944336) * gru_1_out_t2_21 + (-0.0096103837713599205) * gru_1_out_t2_22 + (-0.069360174238681793) * gru_1_out_t2_23 + (2.0507469177246094) * gru_1_out_t2_24 + (-0.049087513238191605) * gru_1_out_t2_25 + (-0.90105801820755005) * gru_1_out_t2_26 + (-0.49032458662986755) * gru_1_out_t2_27 + (-1.576876163482666) * gru_1_out_t2_28 + (-0.23681622743606567) * gru_1_out_t2_29 + (-0.47755476832389832) * gru_1_out_t2_30 + (1.3564156293869019) * gru_1_out_t2_31 + (-1.2203159332275391) * gru_1_out_t2_32 + (-0.046845298260450363) * gru_1_out_t2_33 + (-1.170842170715332) * gru_1_out_t2_34 + (0.41916632652282715) * gru_1_out_t2_35 + (0.22035001218318939) * gru_1_out_t2_36 + (1.14882493019104) * gru_1_out_t2_37 + (-0.079810291528701782) * gru_1_out_t2_38 + (1.6731762886047363) * gru_1_out_t2_39 + (0.24271050095558167) * gru_1_out_t2_40 + (0.036173582077026367) * gru_1_out_t2_41 + (-4.6068596839904785) * gru_1_out_t2_42 + (-0.35346263647079468) * gru_1_out_t2_43 + (-0.68730455636978149) * gru_1_out_t2_44 + (1.8337850570678711) * gru_1_out_t2_45 + (-2.7803225517272949) * gru_1_out_t2_46 + (-2.2567284107208252) * gru_1_out_t2_47 + (0.48069700598716736) * gru_1_out_t2_48 + (-2.6489639282226562) * gru_1_out_t2_49 + (0.089101724326610565) * gru_1_out_t2_50 + (2.8485615253448486) * gru_1_out_t2_51 + (0.53659981489181519) * gru_1_out_t2_52 + (-0.5644756555557251) * gru_1_out_t2_53 + (1.611701488494873) * gru_1_out_t2_54 + (-0.3644166886806488) * gru_1_out_t2_55 + (-3.6310238838195801) * gru_1_out_t2_56 + (-0.016129324212670326) * gru_1_out_t2_57 + (-1.1974332332611084) * gru_1_out_t2_58 + (-0.10834989696741104) * gru_1_out_t2_59 + (0.148614302277565) * gru_1_out_t2_60 + (0.72396677732467651) * gru_1_out_t2_61 + (0.099267944693565369) * gru_1_out_t2_62 + (-0.15559522807598114) * gru_1_out_t2_63 + gate_r * ((1.8137425184249878) + (0.084469713270664215) * gru_2_rev_t3_h_0 + (0.035477336496114731) * gru_2_rev_t3_h_1 + (0.015056969597935677) * gru_2_rev_t3_h_2 + (0.053837809711694717) * gru_2_rev_t3_h_3 + (-0.06668226420879364) * gru_2_rev_t3_h_4 + (-0.091365210711956024) * gru_2_rev_t3_h_5 + (-0.088320083916187286) * gru_2_rev_t3_h_6 + (0.060869302600622177) * gru_2_rev_t3_h_7 + (-0.068456500768661499) * gru_2_rev_t3_h_8 + (0.053492985665798187) * gru_2_rev_t3_h_9 + (0.30389043688774109) * gru_2_rev_t3_h_10 + (-0.091567151248455048) * gru_2_rev_t3_h_11 + (0.10424114018678665) * gru_2_rev_t3_h_12 + (-0.0075355516746640205) * gru_2_rev_t3_h_13 + (0.07659488171339035) * gru_2_rev_t3_h_14 + (0.047293972223997116) * gru_2_rev_t3_h_15 + (0.065026447176933289) * gru_2_rev_t3_h_16 + (0.0035369079560041428) * gru_2_rev_t3_h_17 + (0.018557107076048851) * gru_2_rev_t3_h_18 + (0.18616500496864319) * gru_2_rev_t3_h_19 + (-0.13751955330371857) * gru_2_rev_t3_h_20 + (0.10046134889125824) * gru_2_rev_t3_h_21 + (-0.11840479820966721) * gru_2_rev_t3_h_22 + (0.23308858275413513) * gru_2_rev_t3_h_23 + (0.029080947861075401) * gru_2_rev_t3_h_24 + (0.13535408675670624) * gru_2_rev_t3_h_25 + (0.055126640945672989) * gru_2_rev_t3_h_26 + (0.10198082774877548) * gru_2_rev_t3_h_27 + (-0.17821650207042694) * gru_2_rev_t3_h_28 + (-0.049211002886295319) * gru_2_rev_t3_h_29 + (0.034410674124956131) * gru_2_rev_t3_h_30 + (0.12893995642662048) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_25 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_25;
    // h=26
    gate_r = sigmoid((1.1760179996490479) + (0.5905759334564209) * gru_1_out_t2_0 + (0.049595728516578674) * gru_1_out_t2_1 + (0.67830026149749756) * gru_1_out_t2_2 + (-0.062319673597812653) * gru_1_out_t2_3 + (-1.1267377138137817) * gru_1_out_t2_4 + (-0.60137856006622314) * gru_1_out_t2_5 + (-0.85087990760803223) * gru_1_out_t2_6 + (-0.6419329047203064) * gru_1_out_t2_7 + (-0.15375103056430817) * gru_1_out_t2_8 + (-0.27053132653236389) * gru_1_out_t2_9 + (1.2913150787353516) * gru_1_out_t2_10 + (0.14807979762554169) * gru_1_out_t2_11 + (0.62565553188323975) * gru_1_out_t2_12 + (-0.28940978646278381) * gru_1_out_t2_13 + (-0.96705245971679688) * gru_1_out_t2_14 + (0.16384285688400269) * gru_1_out_t2_15 + (-0.86012077331542969) * gru_1_out_t2_16 + (0.038586575537919998) * gru_1_out_t2_17 + (0.13359390199184418) * gru_1_out_t2_18 + (-0.74161320924758911) * gru_1_out_t2_19 + (0.01492021232843399) * gru_1_out_t2_20 + (-0.46878138184547424) * gru_1_out_t2_21 + (0.13388463854789734) * gru_1_out_t2_22 + (1.1162559986114502) * gru_1_out_t2_23 + (0.064871497452259064) * gru_1_out_t2_24 + (0.64267086982727051) * gru_1_out_t2_25 + (-0.011685586534440517) * gru_1_out_t2_26 + (-0.89683479070663452) * gru_1_out_t2_27 + (-0.42107194662094116) * gru_1_out_t2_28 + (-1.3445785045623779) * gru_1_out_t2_29 + (1.2271778583526611) * gru_1_out_t2_30 + (-0.070496506989002228) * gru_1_out_t2_31 + (-0.40942582488059998) * gru_1_out_t2_32 + (0.3459542989730835) * gru_1_out_t2_33 + (0.052034046500921249) * gru_1_out_t2_34 + (-1.4366873502731323) * gru_1_out_t2_35 + (-0.076862260699272156) * gru_1_out_t2_36 + (0.056695248931646347) * gru_1_out_t2_37 + (-0.1733982264995575) * gru_1_out_t2_38 + (0.62332993745803833) * gru_1_out_t2_39 + (-0.56382709741592407) * gru_1_out_t2_40 + (0.3513549268245697) * gru_1_out_t2_41 + (-0.89763319492340088) * gru_1_out_t2_42 + (-0.5182117223739624) * gru_1_out_t2_43 + (0.19523070752620697) * gru_1_out_t2_44 + (-0.73243474960327148) * gru_1_out_t2_45 + (-0.42137345671653748) * gru_1_out_t2_46 + (-0.051012054085731506) * gru_1_out_t2_47 + (0.04065357893705368) * gru_1_out_t2_48 + (-0.068950913846492767) * gru_1_out_t2_49 + (-0.17044590413570404) * gru_1_out_t2_50 + (1.2446049451828003) * gru_1_out_t2_51 + (-0.12946432828903198) * gru_1_out_t2_52 + (0.27008935809135437) * gru_1_out_t2_53 + (1.6875053644180298) * gru_1_out_t2_54 + (0.54690092802047729) * gru_1_out_t2_55 + (0.30466350913047791) * gru_1_out_t2_56 + (-0.007818000391125679) * gru_1_out_t2_57 + (-0.082569494843482971) * gru_1_out_t2_58 + (-0.71522819995880127) * gru_1_out_t2_59 + (-0.080312803387641907) * gru_1_out_t2_60 + (0.54676192998886108) * gru_1_out_t2_61 + (0.49567770957946777) * gru_1_out_t2_62 + (0.21181294322013855) * gru_1_out_t2_63 + (0.13676361739635468) * gru_2_rev_t3_h_0 + (-0.026262532919645309) * gru_2_rev_t3_h_1 + (-0.028984151780605316) * gru_2_rev_t3_h_2 + (-0.10059020668268204) * gru_2_rev_t3_h_3 + (0.073125347495079041) * gru_2_rev_t3_h_4 + (-0.19397713243961334) * gru_2_rev_t3_h_5 + (0.13453662395477295) * gru_2_rev_t3_h_6 + (0.11303631961345673) * gru_2_rev_t3_h_7 + (0.041411556303501129) * gru_2_rev_t3_h_8 + (0.022913292050361633) * gru_2_rev_t3_h_9 + (0.0512896329164505) * gru_2_rev_t3_h_10 + (-0.048878919333219528) * gru_2_rev_t3_h_11 + (-0.081160828471183777) * gru_2_rev_t3_h_12 + (0.019248269498348236) * gru_2_rev_t3_h_13 + (0.013755104504525661) * gru_2_rev_t3_h_14 + (0.15510459244251251) * gru_2_rev_t3_h_15 + (-0.0044673341326415539) * gru_2_rev_t3_h_16 + (0.046975918114185333) * gru_2_rev_t3_h_17 + (-0.036419663578271866) * gru_2_rev_t3_h_18 + (-0.042708821594715118) * gru_2_rev_t3_h_19 + (0.043468520045280457) * gru_2_rev_t3_h_20 + (0.19553923606872559) * gru_2_rev_t3_h_21 + (0.11260420083999634) * gru_2_rev_t3_h_22 + (-0.0090391850098967552) * gru_2_rev_t3_h_23 + (-0.01715473085641861) * gru_2_rev_t3_h_24 + (0.12819007039070129) * gru_2_rev_t3_h_25 + (0.089655838906764984) * gru_2_rev_t3_h_26 + (-0.08688720315694809) * gru_2_rev_t3_h_27 + (0.088421352207660675) * gru_2_rev_t3_h_28 + (-0.1299663633108139) * gru_2_rev_t3_h_29 + (0.016842484474182129) * gru_2_rev_t3_h_30 + (0.050029825419187546) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((-0.050893776118755341) + (0.23226769268512726) * gru_1_out_t2_0 + (0.065114416182041168) * gru_1_out_t2_1 + (1.0851610898971558) * gru_1_out_t2_2 + (0.16506420075893402) * gru_1_out_t2_3 + (0.55716806650161743) * gru_1_out_t2_4 + (-0.097542285919189453) * gru_1_out_t2_5 + (0.25408774614334106) * gru_1_out_t2_6 + (0.16085487604141235) * gru_1_out_t2_7 + (-0.3440176248550415) * gru_1_out_t2_8 + (0.051513116806745529) * gru_1_out_t2_9 + (-0.39463701844215393) * gru_1_out_t2_10 + (-0.73035514354705811) * gru_1_out_t2_11 + (-0.26066479086875916) * gru_1_out_t2_12 + (0.059557359665632248) * gru_1_out_t2_13 + (-0.51638174057006836) * gru_1_out_t2_14 + (-0.011710420250892639) * gru_1_out_t2_15 + (-0.034543752670288086) * gru_1_out_t2_16 + (-0.022079918533563614) * gru_1_out_t2_17 + (-0.19903209805488586) * gru_1_out_t2_18 + (0.023371001705527306) * gru_1_out_t2_19 + (0.48802068829536438) * gru_1_out_t2_20 + (-0.10773850232362747) * gru_1_out_t2_21 + (-0.03970516100525856) * gru_1_out_t2_22 + (-0.27366137504577637) * gru_1_out_t2_23 + (0.066466256976127625) * gru_1_out_t2_24 + (-0.38437214493751526) * gru_1_out_t2_25 + (-0.10350251942873001) * gru_1_out_t2_26 + (-0.26347675919532776) * gru_1_out_t2_27 + (-0.011709727346897125) * gru_1_out_t2_28 + (-0.098604589700698853) * gru_1_out_t2_29 + (0.15558585524559021) * gru_1_out_t2_30 + (-0.20351491868495941) * gru_1_out_t2_31 + (0.2390061616897583) * gru_1_out_t2_32 + (-0.18918101489543915) * gru_1_out_t2_33 + (0.45542657375335693) * gru_1_out_t2_34 + (0.10309161245822906) * gru_1_out_t2_35 + (0.04157019779086113) * gru_1_out_t2_36 + (-0.09728609025478363) * gru_1_out_t2_37 + (-0.074288487434387207) * gru_1_out_t2_38 + (0.22796325385570526) * gru_1_out_t2_39 + (0.072928540408611298) * gru_1_out_t2_40 + (-0.10122032463550568) * gru_1_out_t2_41 + (0.10872352123260498) * gru_1_out_t2_42 + (-0.10075958073139191) * gru_1_out_t2_43 + (0.068661168217658997) * gru_1_out_t2_44 + (-0.0015729485312476754) * gru_1_out_t2_45 + (-0.30843350291252136) * gru_1_out_t2_46 + (0.053827647119760513) * gru_1_out_t2_47 + (-0.21144610643386841) * gru_1_out_t2_48 + (0.20334972441196442) * gru_1_out_t2_49 + (-0.019816236570477486) * gru_1_out_t2_50 + (-0.081547223031520844) * gru_1_out_t2_51 + (0.13692460954189301) * gru_1_out_t2_52 + (-0.016031801700592041) * gru_1_out_t2_53 + (-0.1359880119562149) * gru_1_out_t2_54 + (0.10863269865512848) * gru_1_out_t2_55 + (-0.51530236005783081) * gru_1_out_t2_56 + (0.01360203605145216) * gru_1_out_t2_57 + (0.22260324656963348) * gru_1_out_t2_58 + (0.078610479831695557) * gru_1_out_t2_59 + (-0.35313236713409424) * gru_1_out_t2_60 + (0.079085148870944977) * gru_1_out_t2_61 + (-0.38907149434089661) * gru_1_out_t2_62 + (0.073716491460800171) * gru_1_out_t2_63 + (-0.1993795782327652) * gru_2_rev_t3_h_0 + (-0.15743565559387207) * gru_2_rev_t3_h_1 + (0.095789067447185516) * gru_2_rev_t3_h_2 + (0.18233881890773773) * gru_2_rev_t3_h_3 + (-0.0018484527245163918) * gru_2_rev_t3_h_4 + (0.010453852824866772) * gru_2_rev_t3_h_5 + (0.09918280690908432) * gru_2_rev_t3_h_6 + (0.084020435810089111) * gru_2_rev_t3_h_7 + (0.10798494517803192) * gru_2_rev_t3_h_8 + (0.074561238288879395) * gru_2_rev_t3_h_9 + (0.035740312188863754) * gru_2_rev_t3_h_10 + (0.18012627959251404) * gru_2_rev_t3_h_11 + (-0.064620152115821838) * gru_2_rev_t3_h_12 + (-0.0045329402200877666) * gru_2_rev_t3_h_13 + (0.053962655365467072) * gru_2_rev_t3_h_14 + (0.043764561414718628) * gru_2_rev_t3_h_15 + (-0.025192823261022568) * gru_2_rev_t3_h_16 + (0.00059442204656079412) * gru_2_rev_t3_h_17 + (-0.054344270378351212) * gru_2_rev_t3_h_18 + (-0.006030903197824955) * gru_2_rev_t3_h_19 + (-0.078849606215953827) * gru_2_rev_t3_h_20 + (0.04748205840587616) * gru_2_rev_t3_h_21 + (-0.025289351120591164) * gru_2_rev_t3_h_22 + (0.040565047413110733) * gru_2_rev_t3_h_23 + (0.19062177836894989) * gru_2_rev_t3_h_24 + (-0.04516204446554184) * gru_2_rev_t3_h_25 + (-0.031690489500761032) * gru_2_rev_t3_h_26 + (-0.057566609233617783) * gru_2_rev_t3_h_27 + (0.30998554825782776) * gru_2_rev_t3_h_28 + (0.080796875059604645) * gru_2_rev_t3_h_29 + (0.048037394881248474) * gru_2_rev_t3_h_30 + (0.084077328443527222) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.87537604570388794) + (0.66484194993972778) * gru_1_out_t2_0 + (0.94366550445556641) * gru_1_out_t2_1 + (0.31335997581481934) * gru_1_out_t2_2 + (-0.12778922915458679) * gru_1_out_t2_3 + (-1.5544744729995728) * gru_1_out_t2_4 + (-0.091187216341495514) * gru_1_out_t2_5 + (-0.35394921898841858) * gru_1_out_t2_6 + (-0.089286036789417267) * gru_1_out_t2_7 + (-0.22398009896278381) * gru_1_out_t2_8 + (-0.18948854506015778) * gru_1_out_t2_9 + (0.93373250961303711) * gru_1_out_t2_10 + (1.2225686311721802) * gru_1_out_t2_11 + (0.28958478569984436) * gru_1_out_t2_12 + (0.048942591995000839) * gru_1_out_t2_13 + (-0.96573281288146973) * gru_1_out_t2_14 + (-0.12973740696907043) * gru_1_out_t2_15 + (-0.63729119300842285) * gru_1_out_t2_16 + (0.72797060012817383) * gru_1_out_t2_17 + (-0.29385840892791748) * gru_1_out_t2_18 + (-0.12759774923324585) * gru_1_out_t2_19 + (-0.025789501145482063) * gru_1_out_t2_20 + (-0.78122282028198242) * gru_1_out_t2_21 + (-0.50786435604095459) * gru_1_out_t2_22 + (1.5191543102264404) * gru_1_out_t2_23 + (0.98416101932525635) * gru_1_out_t2_24 + (0.10150592029094696) * gru_1_out_t2_25 + (0.95860612392425537) * gru_1_out_t2_26 + (-0.72864407300949097) * gru_1_out_t2_27 + (-0.0092050172388553619) * gru_1_out_t2_28 + (-0.77100086212158203) * gru_1_out_t2_29 + (1.992894172668457) * gru_1_out_t2_30 + (-0.22413884103298187) * gru_1_out_t2_31 + (-0.53447604179382324) * gru_1_out_t2_32 + (-0.66742944717407227) * gru_1_out_t2_33 + (0.25719103217124939) * gru_1_out_t2_34 + (-1.1061900854110718) * gru_1_out_t2_35 + (0.57494664192199707) * gru_1_out_t2_36 + (0.45942142605781555) * gru_1_out_t2_37 + (-0.41717308759689331) * gru_1_out_t2_38 + (0.47279945015907288) * gru_1_out_t2_39 + (-0.60271477699279785) * gru_1_out_t2_40 + (0.63382041454315186) * gru_1_out_t2_41 + (-1.4860683679580688) * gru_1_out_t2_42 + (-0.9014815092086792) * gru_1_out_t2_43 + (0.057874366641044617) * gru_1_out_t2_44 + (-0.87622791528701782) * gru_1_out_t2_45 + (-1.1145790815353394) * gru_1_out_t2_46 + (0.063554860651493073) * gru_1_out_t2_47 + (-0.46858125925064087) * gru_1_out_t2_48 + (-0.37056145071983337) * gru_1_out_t2_49 + (-0.97260779142379761) * gru_1_out_t2_50 + (2.201460599899292) * gru_1_out_t2_51 + (-0.37725082039833069) * gru_1_out_t2_52 + (0.28550827503204346) * gru_1_out_t2_53 + (1.6243127584457397) * gru_1_out_t2_54 + (1.2336790561676025) * gru_1_out_t2_55 + (-0.84539127349853516) * gru_1_out_t2_56 + (0.68748199939727783) * gru_1_out_t2_57 + (0.76575911045074463) * gru_1_out_t2_58 + (-1.6598458290100098) * gru_1_out_t2_59 + (0.0016854251734912395) * gru_1_out_t2_60 + (1.1765252351760864) * gru_1_out_t2_61 + (0.35808661580085754) * gru_1_out_t2_62 + (-0.51706713438034058) * gru_1_out_t2_63 + gate_r * ((1.1168237924575806) + (0.064914241433143616) * gru_2_rev_t3_h_0 + (0.10166405141353607) * gru_2_rev_t3_h_1 + (0.047173306345939636) * gru_2_rev_t3_h_2 + (0.070273719727993011) * gru_2_rev_t3_h_3 + (0.13219799101352692) * gru_2_rev_t3_h_4 + (-0.025050707161426544) * gru_2_rev_t3_h_5 + (0.15666767954826355) * gru_2_rev_t3_h_6 + (-0.043846681714057922) * gru_2_rev_t3_h_7 + (-0.038138613104820251) * gru_2_rev_t3_h_8 + (0.23455427587032318) * gru_2_rev_t3_h_9 + (-0.0013942021178081632) * gru_2_rev_t3_h_10 + (0.016619302332401276) * gru_2_rev_t3_h_11 + (-0.093391008675098419) * gru_2_rev_t3_h_12 + (0.047414977103471756) * gru_2_rev_t3_h_13 + (-0.0073132114484906197) * gru_2_rev_t3_h_14 + (-0.020600449293851852) * gru_2_rev_t3_h_15 + (-0.1158272996544838) * gru_2_rev_t3_h_16 + (0.0099036172032356262) * gru_2_rev_t3_h_17 + (-0.047497835010290146) * gru_2_rev_t3_h_18 + (-0.11626337468624115) * gru_2_rev_t3_h_19 + (0.20286357402801514) * gru_2_rev_t3_h_20 + (0.090741530060768127) * gru_2_rev_t3_h_21 + (-0.015943409875035286) * gru_2_rev_t3_h_22 + (-0.27417147159576416) * gru_2_rev_t3_h_23 + (-0.097201511263847351) * gru_2_rev_t3_h_24 + (0.029460234567523003) * gru_2_rev_t3_h_25 + (0.097680956125259399) * gru_2_rev_t3_h_26 + (0.14848126471042633) * gru_2_rev_t3_h_27 + (0.023678814992308617) * gru_2_rev_t3_h_28 + (0.1883743554353714) * gru_2_rev_t3_h_29 + (-0.096951320767402649) * gru_2_rev_t3_h_30 + (-0.032675251364707947) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_26 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_26;
    // h=27
    gate_r = sigmoid((-1.0518691539764404) + (-0.44333955645561218) * gru_1_out_t2_0 + (-0.69942033290863037) * gru_1_out_t2_1 + (0.28912544250488281) * gru_1_out_t2_2 + (0.16755123436450958) * gru_1_out_t2_3 + (0.57008582353591919) * gru_1_out_t2_4 + (-1.6492627859115601) * gru_1_out_t2_5 + (1.0854558944702148) * gru_1_out_t2_6 + (0.58646512031555176) * gru_1_out_t2_7 + (0.98911112546920776) * gru_1_out_t2_8 + (-0.3193323016166687) * gru_1_out_t2_9 + (-0.4814947247505188) * gru_1_out_t2_10 + (0.9021834135055542) * gru_1_out_t2_11 + (0.51566123962402344) * gru_1_out_t2_12 + (-3.1928524971008301) * gru_1_out_t2_13 + (0.058703456073999405) * gru_1_out_t2_14 + (0.20169432461261749) * gru_1_out_t2_15 + (0.072281122207641602) * gru_1_out_t2_16 + (0.47314721345901489) * gru_1_out_t2_17 + (-0.083532579243183136) * gru_1_out_t2_18 + (0.71719890832901001) * gru_1_out_t2_19 + (-0.25069805979728699) * gru_1_out_t2_20 + (-0.28194820880889893) * gru_1_out_t2_21 + (0.51460725069046021) * gru_1_out_t2_22 + (3.925184965133667) * gru_1_out_t2_23 + (0.81620925664901733) * gru_1_out_t2_24 + (1.3179134130477905) * gru_1_out_t2_25 + (-3.5767016410827637) * gru_1_out_t2_26 + (0.9379422664642334) * gru_1_out_t2_27 + (2.105534553527832) * gru_1_out_t2_28 + (-0.82316309213638306) * gru_1_out_t2_29 + (-0.40277239680290222) * gru_1_out_t2_30 + (-0.04238513857126236) * gru_1_out_t2_31 + (-0.94929689168930054) * gru_1_out_t2_32 + (-0.67202717065811157) * gru_1_out_t2_33 + (-0.058364499360322952) * gru_1_out_t2_34 + (0.22972416877746582) * gru_1_out_t2_35 + (1.8719184398651123) * gru_1_out_t2_36 + (-0.51753735542297363) * gru_1_out_t2_37 + (0.028976611793041229) * gru_1_out_t2_38 + (-0.27658537030220032) * gru_1_out_t2_39 + (1.3718112707138062) * gru_1_out_t2_40 + (0.25656303763389587) * gru_1_out_t2_41 + (0.83662033081054688) * gru_1_out_t2_42 + (0.38200464844703674) * gru_1_out_t2_43 + (-0.51606190204620361) * gru_1_out_t2_44 + (2.5274019241333008) * gru_1_out_t2_45 + (0.70710152387619019) * gru_1_out_t2_46 + (0.98730719089508057) * gru_1_out_t2_47 + (-0.19838292896747589) * gru_1_out_t2_48 + (0.20809823274612427) * gru_1_out_t2_49 + (-1.4523292779922485) * gru_1_out_t2_50 + (-1.0476188659667969) * gru_1_out_t2_51 + (-0.50742000341415405) * gru_1_out_t2_52 + (-1.1957348585128784) * gru_1_out_t2_53 + (0.025225065648555756) * gru_1_out_t2_54 + (-0.77760046720504761) * gru_1_out_t2_55 + (0.30410203337669373) * gru_1_out_t2_56 + (-0.53659731149673462) * gru_1_out_t2_57 + (-1.5718165636062622) * gru_1_out_t2_58 + (-0.46437320113182068) * gru_1_out_t2_59 + (0.89367216825485229) * gru_1_out_t2_60 + (0.56929153203964233) * gru_1_out_t2_61 + (0.41494271159172058) * gru_1_out_t2_62 + (2.338001012802124) * gru_1_out_t2_63 + (0.047423359006643295) * gru_2_rev_t3_h_0 + (-0.078604914247989655) * gru_2_rev_t3_h_1 + (-0.010788076557219028) * gru_2_rev_t3_h_2 + (-0.027461759746074677) * gru_2_rev_t3_h_3 + (0.017990041524171829) * gru_2_rev_t3_h_4 + (-0.036475129425525665) * gru_2_rev_t3_h_5 + (-0.11918468028306961) * gru_2_rev_t3_h_6 + (-0.11911355704069138) * gru_2_rev_t3_h_7 + (-0.061282128095626831) * gru_2_rev_t3_h_8 + (0.19175602495670319) * gru_2_rev_t3_h_9 + (-0.0032518883235752583) * gru_2_rev_t3_h_10 + (0.17896904051303864) * gru_2_rev_t3_h_11 + (-0.063056007027626038) * gru_2_rev_t3_h_12 + (0.11489137262105942) * gru_2_rev_t3_h_13 + (0.20570419728755951) * gru_2_rev_t3_h_14 + (0.044273994863033295) * gru_2_rev_t3_h_15 + (0.044799234718084335) * gru_2_rev_t3_h_16 + (0.028296163305640221) * gru_2_rev_t3_h_17 + (0.0061977524310350418) * gru_2_rev_t3_h_18 + (0.057629518210887909) * gru_2_rev_t3_h_19 + (0.065513245761394501) * gru_2_rev_t3_h_20 + (0.16655343770980835) * gru_2_rev_t3_h_21 + (0.013472599908709526) * gru_2_rev_t3_h_22 + (0.059866409748792648) * gru_2_rev_t3_h_23 + (0.10643915832042694) * gru_2_rev_t3_h_24 + (0.10289470106363297) * gru_2_rev_t3_h_25 + (-0.15859851241111755) * gru_2_rev_t3_h_26 + (-0.16184134781360626) * gru_2_rev_t3_h_27 + (0.17392966151237488) * gru_2_rev_t3_h_28 + (0.069537974894046783) * gru_2_rev_t3_h_29 + (-0.13836883008480072) * gru_2_rev_t3_h_30 + (-0.068229518830776215) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((1.9548653364181519) + (0.73764091730117798) * gru_1_out_t2_0 + (0.10392548888921738) * gru_1_out_t2_1 + (-0.50797867774963379) * gru_1_out_t2_2 + (-0.04367462545633316) * gru_1_out_t2_3 + (-0.26172322034835815) * gru_1_out_t2_4 + (-0.2422269731760025) * gru_1_out_t2_5 + (0.70501720905303955) * gru_1_out_t2_6 + (0.087257884442806244) * gru_1_out_t2_7 + (-0.10986524820327759) * gru_1_out_t2_8 + (0.084005832672119141) * gru_1_out_t2_9 + (0.56656068563461304) * gru_1_out_t2_10 + (0.62902182340621948) * gru_1_out_t2_11 + (-0.19899125397205353) * gru_1_out_t2_12 + (0.396291583776474) * gru_1_out_t2_13 + (2.36161208152771) * gru_1_out_t2_14 + (-0.269858717918396) * gru_1_out_t2_15 + (-0.85930925607681274) * gru_1_out_t2_16 + (-0.60488975048065186) * gru_1_out_t2_17 + (0.31383737921714783) * gru_1_out_t2_18 + (-0.1164325550198555) * gru_1_out_t2_19 + (0.19591890275478363) * gru_1_out_t2_20 + (-0.37080845236778259) * gru_1_out_t2_21 + (-0.3963412344455719) * gru_1_out_t2_22 + (0.19968482851982117) * gru_1_out_t2_23 + (0.0072462651878595352) * gru_1_out_t2_24 + (0.48910340666770935) * gru_1_out_t2_25 + (0.96197116374969482) * gru_1_out_t2_26 + (0.44946849346160889) * gru_1_out_t2_27 + (-2.4321756362915039) * gru_1_out_t2_28 + (0.21398083865642548) * gru_1_out_t2_29 + (0.82843059301376343) * gru_1_out_t2_30 + (-0.21549302339553833) * gru_1_out_t2_31 + (1.2864233255386353) * gru_1_out_t2_32 + (-0.086314618587493896) * gru_1_out_t2_33 + (-0.37860801815986633) * gru_1_out_t2_34 + (0.14895689487457275) * gru_1_out_t2_35 + (0.2123296856880188) * gru_1_out_t2_36 + (-0.19799627363681793) * gru_1_out_t2_37 + (-1.5371270179748535) * gru_1_out_t2_38 + (-0.39177417755126953) * gru_1_out_t2_39 + (-0.1261049211025238) * gru_1_out_t2_40 + (0.66096377372741699) * gru_1_out_t2_41 + (-1.0299489498138428) * gru_1_out_t2_42 + (0.27550351619720459) * gru_1_out_t2_43 + (-0.36111375689506531) * gru_1_out_t2_44 + (-0.0041634188964962959) * gru_1_out_t2_45 + (-0.88067615032196045) * gru_1_out_t2_46 + (-0.25523167848587036) * gru_1_out_t2_47 + (-0.054436825215816498) * gru_1_out_t2_48 + (0.28590124845504761) * gru_1_out_t2_49 + (-1.2728041410446167) * gru_1_out_t2_50 + (-0.88262659311294556) * gru_1_out_t2_51 + (-1.9601395130157471) * gru_1_out_t2_52 + (1.2450823783874512) * gru_1_out_t2_53 + (-1.7717599868774414) * gru_1_out_t2_54 + (-0.16980661451816559) * gru_1_out_t2_55 + (0.78441345691680908) * gru_1_out_t2_56 + (0.53271806240081787) * gru_1_out_t2_57 + (0.82162052392959595) * gru_1_out_t2_58 + (-0.059430383145809174) * gru_1_out_t2_59 + (-3.8463113307952881) * gru_1_out_t2_60 + (-0.17524075508117676) * gru_1_out_t2_61 + (0.9006887674331665) * gru_1_out_t2_62 + (-0.13187719881534576) * gru_1_out_t2_63 + (0.19888709485530853) * gru_2_rev_t3_h_0 + (-0.019915010780096054) * gru_2_rev_t3_h_1 + (0.096716456115245819) * gru_2_rev_t3_h_2 + (0.089164108037948608) * gru_2_rev_t3_h_3 + (0.037128645926713943) * gru_2_rev_t3_h_4 + (0.14787936210632324) * gru_2_rev_t3_h_5 + (-0.15206632018089294) * gru_2_rev_t3_h_6 + (0.27551236748695374) * gru_2_rev_t3_h_7 + (0.038444891571998596) * gru_2_rev_t3_h_8 + (0.075741313397884369) * gru_2_rev_t3_h_9 + (0.19345809519290924) * gru_2_rev_t3_h_10 + (0.094288036227226257) * gru_2_rev_t3_h_11 + (-0.17592744529247284) * gru_2_rev_t3_h_12 + (-0.070819221436977386) * gru_2_rev_t3_h_13 + (-0.044979419559240341) * gru_2_rev_t3_h_14 + (-0.098153732717037201) * gru_2_rev_t3_h_15 + (-0.029094452038407326) * gru_2_rev_t3_h_16 + (0.071558304131031036) * gru_2_rev_t3_h_17 + (-0.15308636426925659) * gru_2_rev_t3_h_18 + (-0.038897797465324402) * gru_2_rev_t3_h_19 + (-0.15402856469154358) * gru_2_rev_t3_h_20 + (-0.098471634089946747) * gru_2_rev_t3_h_21 + (0.17043893039226532) * gru_2_rev_t3_h_22 + (-0.021399365738034248) * gru_2_rev_t3_h_23 + (0.012963383458554745) * gru_2_rev_t3_h_24 + (0.1167081817984581) * gru_2_rev_t3_h_25 + (0.15374930202960968) * gru_2_rev_t3_h_26 + (-0.053572874516248703) * gru_2_rev_t3_h_27 + (-0.10529054701328278) * gru_2_rev_t3_h_28 + (-0.015223179012537003) * gru_2_rev_t3_h_29 + (-0.03887191042304039) * gru_2_rev_t3_h_30 + (0.096184432506561279) * gru_2_rev_t3_h_31);
    gate_n = tanh((-0.062036015093326569) + (-0.38780352473258972) * gru_1_out_t2_0 + (1.4110219478607178) * gru_1_out_t2_1 + (0.011864539235830307) * gru_1_out_t2_2 + (0.13351118564605713) * gru_1_out_t2_3 + (-0.42185306549072266) * gru_1_out_t2_4 + (0.024098055437207222) * gru_1_out_t2_5 + (0.027498800307512283) * gru_1_out_t2_6 + (-0.033495631068944931) * gru_1_out_t2_7 + (-0.090108193457126617) * gru_1_out_t2_8 + (0.020044766366481781) * gru_1_out_t2_9 + (-0.233772873878479) * gru_1_out_t2_10 + (0.061153586953878403) * gru_1_out_t2_11 + (-0.25522130727767944) * gru_1_out_t2_12 + (-0.44919443130493164) * gru_1_out_t2_13 + (0.3107159435749054) * gru_1_out_t2_14 + (-0.32492437958717346) * gru_1_out_t2_15 + (0.12024787068367004) * gru_1_out_t2_16 + (-0.29634284973144531) * gru_1_out_t2_17 + (0.98283267021179199) * gru_1_out_t2_18 + (0.29750704765319824) * gru_1_out_t2_19 + (-0.52533644437789917) * gru_1_out_t2_20 + (-0.32001447677612305) * gru_1_out_t2_21 + (-0.15064837038516998) * gru_1_out_t2_22 + (-0.63037580251693726) * gru_1_out_t2_23 + (-0.20837558805942535) * gru_1_out_t2_24 + (0.0038684078026562929) * gru_1_out_t2_25 + (-2.1101377010345459) * gru_1_out_t2_26 + (0.54774165153503418) * gru_1_out_t2_27 + (-0.28894674777984619) * gru_1_out_t2_28 + (0.60930699110031128) * gru_1_out_t2_29 + (0.33070138096809387) * gru_1_out_t2_30 + (-0.099656373262405396) * gru_1_out_t2_31 + (0.42689839005470276) * gru_1_out_t2_32 + (0.09615413099527359) * gru_1_out_t2_33 + (0.9548722505569458) * gru_1_out_t2_34 + (-0.06561773270368576) * gru_1_out_t2_35 + (-0.95758014917373657) * gru_1_out_t2_36 + (0.083822973072528839) * gru_1_out_t2_37 + (0.57980650663375854) * gru_1_out_t2_38 + (-0.45933049917221069) * gru_1_out_t2_39 + (0.14766156673431396) * gru_1_out_t2_40 + (-1.1401782035827637) * gru_1_out_t2_41 + (0.53502541780471802) * gru_1_out_t2_42 + (0.57631868124008179) * gru_1_out_t2_43 + (0.35844269394874573) * gru_1_out_t2_44 + (-0.15704573690891266) * gru_1_out_t2_45 + (0.85437226295471191) * gru_1_out_t2_46 + (-0.039592988789081573) * gru_1_out_t2_47 + (0.44901055097579956) * gru_1_out_t2_48 + (0.22018967568874359) * gru_1_out_t2_49 + (0.59834945201873779) * gru_1_out_t2_50 + (0.6331978440284729) * gru_1_out_t2_51 + (-0.53350383043289185) * gru_1_out_t2_52 + (-0.88507461547851562) * gru_1_out_t2_53 + (1.0072557926177979) * gru_1_out_t2_54 + (0.18442344665527344) * gru_1_out_t2_55 + (0.58986592292785645) * gru_1_out_t2_56 + (0.65712553262710571) * gru_1_out_t2_57 + (-1.1397949457168579) * gru_1_out_t2_58 + (1.1233315467834473) * gru_1_out_t2_59 + (0.74990546703338623) * gru_1_out_t2_60 + (-1.1575498580932617) * gru_1_out_t2_61 + (-0.37976157665252686) * gru_1_out_t2_62 + (-1.3193744421005249) * gru_1_out_t2_63 + gate_r * ((-1.9728058576583862) + (-0.10398215800523758) * gru_2_rev_t3_h_0 + (-0.24251583218574524) * gru_2_rev_t3_h_1 + (0.21975934505462646) * gru_2_rev_t3_h_2 + (-0.1609245091676712) * gru_2_rev_t3_h_3 + (-0.094349764287471771) * gru_2_rev_t3_h_4 + (-0.042695563286542892) * gru_2_rev_t3_h_5 + (0.065553337335586548) * gru_2_rev_t3_h_6 + (-0.027313394472002983) * gru_2_rev_t3_h_7 + (-0.013173317536711693) * gru_2_rev_t3_h_8 + (0.062375988811254501) * gru_2_rev_t3_h_9 + (0.018079349771142006) * gru_2_rev_t3_h_10 + (0.053938142955303192) * gru_2_rev_t3_h_11 + (0.081315614283084869) * gru_2_rev_t3_h_12 + (0.1700642853975296) * gru_2_rev_t3_h_13 + (-0.039956696331501007) * gru_2_rev_t3_h_14 + (-0.041120994836091995) * gru_2_rev_t3_h_15 + (-0.13579986989498138) * gru_2_rev_t3_h_16 + (-0.11849577724933624) * gru_2_rev_t3_h_17 + (-0.13928417861461639) * gru_2_rev_t3_h_18 + (-0.078675016760826111) * gru_2_rev_t3_h_19 + (0.14927211403846741) * gru_2_rev_t3_h_20 + (0.011251685209572315) * gru_2_rev_t3_h_21 + (-0.010363823734223843) * gru_2_rev_t3_h_22 + (-0.09973551332950592) * gru_2_rev_t3_h_23 + (-0.067138954997062683) * gru_2_rev_t3_h_24 + (0.12425795197486877) * gru_2_rev_t3_h_25 + (0.11907372623682022) * gru_2_rev_t3_h_26 + (0.0053307437337934971) * gru_2_rev_t3_h_27 + (-0.010262498632073402) * gru_2_rev_t3_h_28 + (0.02503969706594944) * gru_2_rev_t3_h_29 + (-0.058366198092699051) * gru_2_rev_t3_h_30 + (0.017163002863526344) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_27 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_27;
    // h=28
    gate_r = sigmoid((0.24181669950485229) + (0.14022313058376312) * gru_1_out_t2_0 + (-0.85340422391891479) * gru_1_out_t2_1 + (-0.58684980869293213) * gru_1_out_t2_2 + (-0.080141700804233551) * gru_1_out_t2_3 + (-0.44181719422340393) * gru_1_out_t2_4 + (0.1628851443529129) * gru_1_out_t2_5 + (0.021697044372558594) * gru_1_out_t2_6 + (-0.027795322239398956) * gru_1_out_t2_7 + (-0.39269638061523438) * gru_1_out_t2_8 + (-0.11535603553056717) * gru_1_out_t2_9 + (1.6575603485107422) * gru_1_out_t2_10 + (1.350703239440918) * gru_1_out_t2_11 + (-0.38218545913696289) * gru_1_out_t2_12 + (-0.86503994464874268) * gru_1_out_t2_13 + (0.67638152837753296) * gru_1_out_t2_14 + (-0.25088644027709961) * gru_1_out_t2_15 + (0.03453952819108963) * gru_1_out_t2_16 + (1.0252493619918823) * gru_1_out_t2_17 + (2.2147297859191895) * gru_1_out_t2_18 + (-0.37271210551261902) * gru_1_out_t2_19 + (0.61560666561126709) * gru_1_out_t2_20 + (2.2720656394958496) * gru_1_out_t2_21 + (-1.7405151128768921) * gru_1_out_t2_22 + (1.3804939985275269) * gru_1_out_t2_23 + (0.41152322292327881) * gru_1_out_t2_24 + (2.0751533508300781) * gru_1_out_t2_25 + (-1.7597042322158813) * gru_1_out_t2_26 + (-1.4937895536422729) * gru_1_out_t2_27 + (1.1851785182952881) * gru_1_out_t2_28 + (0.27004322409629822) * gru_1_out_t2_29 + (-0.042540311813354492) * gru_1_out_t2_30 + (-0.21907588839530945) * gru_1_out_t2_31 + (-0.77116626501083374) * gru_1_out_t2_32 + (-0.50500649213790894) * gru_1_out_t2_33 + (1.0712567567825317) * gru_1_out_t2_34 + (-1.2914140224456787) * gru_1_out_t2_35 + (0.41090339422225952) * gru_1_out_t2_36 + (0.66105669736862183) * gru_1_out_t2_37 + (-0.47158083319664001) * gru_1_out_t2_38 + (0.63702106475830078) * gru_1_out_t2_39 + (-0.15781451761722565) * gru_1_out_t2_40 + (0.036411147564649582) * gru_1_out_t2_41 + (0.13769105076789856) * gru_1_out_t2_42 + (-0.59743195772171021) * gru_1_out_t2_43 + (-0.1435379683971405) * gru_1_out_t2_44 + (-2.4842205047607422) * gru_1_out_t2_45 + (1.2808371782302856) * gru_1_out_t2_46 + (0.60675579309463501) * gru_1_out_t2_47 + (0.016117265447974205) * gru_1_out_t2_48 + (-0.31166711449623108) * gru_1_out_t2_49 + (-0.45120233297348022) * gru_1_out_t2_50 + (-0.50797867774963379) * gru_1_out_t2_51 + (0.69044822454452515) * gru_1_out_t2_52 + (0.1063050776720047) * gru_1_out_t2_53 + (0.050302892923355103) * gru_1_out_t2_54 + (-0.57058703899383545) * gru_1_out_t2_55 + (-1.5420458316802979) * gru_1_out_t2_56 + (0.053948037326335907) * gru_1_out_t2_57 + (-0.3048919141292572) * gru_1_out_t2_58 + (-2.4770851135253906) * gru_1_out_t2_59 + (-1.9681535959243774) * gru_1_out_t2_60 + (0.44040054082870483) * gru_1_out_t2_61 + (-0.35226309299468994) * gru_1_out_t2_62 + (-0.12645642459392548) * gru_1_out_t2_63 + (0.065366737544536591) * gru_2_rev_t3_h_0 + (0.1130189448595047) * gru_2_rev_t3_h_1 + (0.16449442505836487) * gru_2_rev_t3_h_2 + (-0.15236075222492218) * gru_2_rev_t3_h_3 + (0.010040587745606899) * gru_2_rev_t3_h_4 + (0.1316879540681839) * gru_2_rev_t3_h_5 + (0.040867038071155548) * gru_2_rev_t3_h_6 + (-0.10019047558307648) * gru_2_rev_t3_h_7 + (0.026248525828123093) * gru_2_rev_t3_h_8 + (-0.17338892817497253) * gru_2_rev_t3_h_9 + (-0.018957184627652168) * gru_2_rev_t3_h_10 + (0.026604076847434044) * gru_2_rev_t3_h_11 + (0.1017804816365242) * gru_2_rev_t3_h_12 + (0.028066394850611687) * gru_2_rev_t3_h_13 + (-0.11316636949777603) * gru_2_rev_t3_h_14 + (-0.087739840149879456) * gru_2_rev_t3_h_15 + (-0.074066787958145142) * gru_2_rev_t3_h_16 + (0.0027485617902129889) * gru_2_rev_t3_h_17 + (0.071000643074512482) * gru_2_rev_t3_h_18 + (0.12197494506835938) * gru_2_rev_t3_h_19 + (0.0095284935086965561) * gru_2_rev_t3_h_20 + (-0.16943831741809845) * gru_2_rev_t3_h_21 + (-0.027721928432583809) * gru_2_rev_t3_h_22 + (-0.013848744332790375) * gru_2_rev_t3_h_23 + (-0.072080798447132111) * gru_2_rev_t3_h_24 + (0.030974464491009712) * gru_2_rev_t3_h_25 + (-0.1096736416220665) * gru_2_rev_t3_h_26 + (0.12410379201173782) * gru_2_rev_t3_h_27 + (-0.0027732346206903458) * gru_2_rev_t3_h_28 + (-0.0087888371199369431) * gru_2_rev_t3_h_29 + (-0.12902264297008514) * gru_2_rev_t3_h_30 + (-0.12101282924413681) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.12402499467134476) + (0.1679929792881012) * gru_1_out_t2_0 + (-0.20272721350193024) * gru_1_out_t2_1 + (0.7001807689666748) * gru_1_out_t2_2 + (0.57407379150390625) * gru_1_out_t2_3 + (0.51748818159103394) * gru_1_out_t2_4 + (-0.12551659345626831) * gru_1_out_t2_5 + (0.27090004086494446) * gru_1_out_t2_6 + (0.39531522989273071) * gru_1_out_t2_7 + (-0.50498682260513306) * gru_1_out_t2_8 + (-0.55709892511367798) * gru_1_out_t2_9 + (0.26819911599159241) * gru_1_out_t2_10 + (-0.56121593713760376) * gru_1_out_t2_11 + (-0.3018392026424408) * gru_1_out_t2_12 + (-0.091727755963802338) * gru_1_out_t2_13 + (-0.16519120335578918) * gru_1_out_t2_14 + (-0.15771034359931946) * gru_1_out_t2_15 + (0.15696613490581512) * gru_1_out_t2_16 + (-0.015381886623799801) * gru_1_out_t2_17 + (0.24882516264915466) * gru_1_out_t2_18 + (-0.32448682188987732) * gru_1_out_t2_19 + (0.44205692410469055) * gru_1_out_t2_20 + (0.22633558511734009) * gru_1_out_t2_21 + (0.16564878821372986) * gru_1_out_t2_22 + (-0.30443742871284485) * gru_1_out_t2_23 + (0.21511119604110718) * gru_1_out_t2_24 + (-0.10911567509174347) * gru_1_out_t2_25 + (0.50568866729736328) * gru_1_out_t2_26 + (-0.24388903379440308) * gru_1_out_t2_27 + (-0.111131951212883) * gru_1_out_t2_28 + (-0.52609759569168091) * gru_1_out_t2_29 + (0.036466620862483978) * gru_1_out_t2_30 + (-0.13418735563755035) * gru_1_out_t2_31 + (-0.34467127919197083) * gru_1_out_t2_32 + (-0.33687466382980347) * gru_1_out_t2_33 + (0.33028843998908997) * gru_1_out_t2_34 + (-0.16221967339515686) * gru_1_out_t2_35 + (-0.0064113903790712357) * gru_1_out_t2_36 + (-0.35600623488426208) * gru_1_out_t2_37 + (0.25542360544204712) * gru_1_out_t2_38 + (-0.16381002962589264) * gru_1_out_t2_39 + (-0.21946083009243011) * gru_1_out_t2_40 + (-0.073011383414268494) * gru_1_out_t2_41 + (-0.021255273371934891) * gru_1_out_t2_42 + (0.1136198416352272) * gru_1_out_t2_43 + (-0.37254273891448975) * gru_1_out_t2_44 + (-0.27203488349914551) * gru_1_out_t2_45 + (-0.44954767823219299) * gru_1_out_t2_46 + (-0.021582040935754776) * gru_1_out_t2_47 + (-0.64578831195831299) * gru_1_out_t2_48 + (-0.025599291548132896) * gru_1_out_t2_49 + (-0.10523593425750732) * gru_1_out_t2_50 + (0.11438813805580139) * gru_1_out_t2_51 + (-0.19158296287059784) * gru_1_out_t2_52 + (0.38214215636253357) * gru_1_out_t2_53 + (-0.53248518705368042) * gru_1_out_t2_54 + (0.002647005720064044) * gru_1_out_t2_55 + (-0.37413987517356873) * gru_1_out_t2_56 + (0.020112855359911919) * gru_1_out_t2_57 + (0.16225942969322205) * gru_1_out_t2_58 + (0.17313733696937561) * gru_1_out_t2_59 + (-0.39555424451828003) * gru_1_out_t2_60 + (0.029571549966931343) * gru_1_out_t2_61 + (1.0448428392410278) * gru_1_out_t2_62 + (-0.00036360931699164212) * gru_1_out_t2_63 + (0.15657819807529449) * gru_2_rev_t3_h_0 + (-0.036342937499284744) * gru_2_rev_t3_h_1 + (0.19596357643604279) * gru_2_rev_t3_h_2 + (-0.035281404852867126) * gru_2_rev_t3_h_3 + (0.051929619163274765) * gru_2_rev_t3_h_4 + (-0.0095078647136688232) * gru_2_rev_t3_h_5 + (-0.0016502260696142912) * gru_2_rev_t3_h_6 + (0.08074980229139328) * gru_2_rev_t3_h_7 + (0.0088993757963180542) * gru_2_rev_t3_h_8 + (0.06111883744597435) * gru_2_rev_t3_h_9 + (0.068513952195644379) * gru_2_rev_t3_h_10 + (0.12317268550395966) * gru_2_rev_t3_h_11 + (0.011603333987295628) * gru_2_rev_t3_h_12 + (-0.15257300436496735) * gru_2_rev_t3_h_13 + (-0.10806088894605637) * gru_2_rev_t3_h_14 + (0.056985363364219666) * gru_2_rev_t3_h_15 + (0.0017123682191595435) * gru_2_rev_t3_h_16 + (0.020948775112628937) * gru_2_rev_t3_h_17 + (0.27074870467185974) * gru_2_rev_t3_h_18 + (0.074671819806098938) * gru_2_rev_t3_h_19 + (0.0021371629554778337) * gru_2_rev_t3_h_20 + (0.029544567689299583) * gru_2_rev_t3_h_21 + (0.13825409114360809) * gru_2_rev_t3_h_22 + (0.086803682148456573) * gru_2_rev_t3_h_23 + (-0.018607489764690399) * gru_2_rev_t3_h_24 + (0.1513596773147583) * gru_2_rev_t3_h_25 + (-0.052375461906194687) * gru_2_rev_t3_h_26 + (0.043912284076213837) * gru_2_rev_t3_h_27 + (-0.059858575463294983) * gru_2_rev_t3_h_28 + (0.037594176828861237) * gru_2_rev_t3_h_29 + (-0.034082897007465363) * gru_2_rev_t3_h_30 + (-0.040898006409406662) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.9580417275428772) + (0.73310261964797974) * gru_1_out_t2_0 + (0.44975882768630981) * gru_1_out_t2_1 + (0.49985745549201965) * gru_1_out_t2_2 + (-0.16651827096939087) * gru_1_out_t2_3 + (-0.65862351655960083) * gru_1_out_t2_4 + (0.95145928859710693) * gru_1_out_t2_5 + (-1.364611029624939) * gru_1_out_t2_6 + (-0.97973453998565674) * gru_1_out_t2_7 + (0.24841508269309998) * gru_1_out_t2_8 + (-0.1479937732219696) * gru_1_out_t2_9 + (1.0684843063354492) * gru_1_out_t2_10 + (1.9799529314041138) * gru_1_out_t2_11 + (0.49223491549491882) * gru_1_out_t2_12 + (0.4229634702205658) * gru_1_out_t2_13 + (-0.36795502901077271) * gru_1_out_t2_14 + (-0.085754789412021637) * gru_1_out_t2_15 + (-0.70163756608963013) * gru_1_out_t2_16 + (1.367084264755249) * gru_1_out_t2_17 + (0.013175444677472115) * gru_1_out_t2_18 + (-0.38546037673950195) * gru_1_out_t2_19 + (-0.26951873302459717) * gru_1_out_t2_20 + (-1.1338915824890137) * gru_1_out_t2_21 + (-1.3782892227172852) * gru_1_out_t2_22 + (0.10321039706468582) * gru_1_out_t2_23 + (0.25115483999252319) * gru_1_out_t2_24 + (-0.093299709260463715) * gru_1_out_t2_25 + (1.4595752954483032) * gru_1_out_t2_26 + (-0.98733240365982056) * gru_1_out_t2_27 + (0.94448792934417725) * gru_1_out_t2_28 + (0.89346927404403687) * gru_1_out_t2_29 + (0.86142796277999878) * gru_1_out_t2_30 + (-0.5760878324508667) * gru_1_out_t2_31 + (1.0837821960449219) * gru_1_out_t2_32 + (0.30079644918441772) * gru_1_out_t2_33 + (1.0295752286911011) * gru_1_out_t2_34 + (0.34080332517623901) * gru_1_out_t2_35 + (0.52949374914169312) * gru_1_out_t2_36 + (-0.0023290030658245087) * gru_1_out_t2_37 + (-0.54302489757537842) * gru_1_out_t2_38 + (0.68846374750137329) * gru_1_out_t2_39 + (-0.18959042429924011) * gru_1_out_t2_40 + (0.75482064485549927) * gru_1_out_t2_41 + (-1.0772769451141357) * gru_1_out_t2_42 + (-0.22898106276988983) * gru_1_out_t2_43 + (-0.056196600198745728) * gru_1_out_t2_44 + (0.32072979211807251) * gru_1_out_t2_45 + (-0.4089653491973877) * gru_1_out_t2_46 + (-0.2612491250038147) * gru_1_out_t2_47 + (-0.3879891037940979) * gru_1_out_t2_48 + (-0.66142153739929199) * gru_1_out_t2_49 + (-0.85748958587646484) * gru_1_out_t2_50 + (0.49446174502372742) * gru_1_out_t2_51 + (-1.0258655548095703) * gru_1_out_t2_52 + (0.42735320329666138) * gru_1_out_t2_53 + (0.55878162384033203) * gru_1_out_t2_54 + (0.72650635242462158) * gru_1_out_t2_55 + (-0.96628516912460327) * gru_1_out_t2_56 + (0.6257166862487793) * gru_1_out_t2_57 + (0.24701385200023651) * gru_1_out_t2_58 + (-0.29587128758430481) * gru_1_out_t2_59 + (0.14816069602966309) * gru_1_out_t2_60 + (0.74967294931411743) * gru_1_out_t2_61 + (0.82447123527526855) * gru_1_out_t2_62 + (0.33132371306419373) * gru_1_out_t2_63 + gate_r * ((0.88423258066177368) + (-0.015248372219502926) * gru_2_rev_t3_h_0 + (0.041325826197862625) * gru_2_rev_t3_h_1 + (0.048698142170906067) * gru_2_rev_t3_h_2 + (0.13160540163516998) * gru_2_rev_t3_h_3 + (-0.050030115991830826) * gru_2_rev_t3_h_4 + (0.016246302053332329) * gru_2_rev_t3_h_5 + (-0.10458724945783615) * gru_2_rev_t3_h_6 + (-0.23775947093963623) * gru_2_rev_t3_h_7 + (0.054179321974515915) * gru_2_rev_t3_h_8 + (0.057690490037202835) * gru_2_rev_t3_h_9 + (0.0014845579862594604) * gru_2_rev_t3_h_10 + (0.032202064990997314) * gru_2_rev_t3_h_11 + (0.10626457631587982) * gru_2_rev_t3_h_12 + (0.056813128292560577) * gru_2_rev_t3_h_13 + (-0.14411661028862) * gru_2_rev_t3_h_14 + (-0.008929811418056488) * gru_2_rev_t3_h_15 + (-0.03644382581114769) * gru_2_rev_t3_h_16 + (0.021896027028560638) * gru_2_rev_t3_h_17 + (-0.032861426472663879) * gru_2_rev_t3_h_18 + (0.055590100586414337) * gru_2_rev_t3_h_19 + (-0.13939002156257629) * gru_2_rev_t3_h_20 + (-0.08963746577501297) * gru_2_rev_t3_h_21 + (-0.012979236431419849) * gru_2_rev_t3_h_22 + (-0.090526960790157318) * gru_2_rev_t3_h_23 + (-0.23569534718990326) * gru_2_rev_t3_h_24 + (-0.0055427462793886662) * gru_2_rev_t3_h_25 + (0.14575423300266266) * gru_2_rev_t3_h_26 + (-0.071225844323635101) * gru_2_rev_t3_h_27 + (-0.073934882879257202) * gru_2_rev_t3_h_28 + (0.033832486718893051) * gru_2_rev_t3_h_29 + (-0.081851556897163391) * gru_2_rev_t3_h_30 + (0.059088461101055145) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_28 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_28;
    // h=29
    gate_r = sigmoid((1.0678094625473022) + (0.76326024532318115) * gru_1_out_t2_0 + (1.1089679002761841) * gru_1_out_t2_1 + (0.064178496599197388) * gru_1_out_t2_2 + (0.59004688262939453) * gru_1_out_t2_3 + (-0.44821205735206604) * gru_1_out_t2_4 + (-2.0877304077148438) * gru_1_out_t2_5 + (0.43216937780380249) * gru_1_out_t2_6 + (0.78227859735488892) * gru_1_out_t2_7 + (-1.3333045244216919) * gru_1_out_t2_8 + (0.78590786457061768) * gru_1_out_t2_9 + (0.52234125137329102) * gru_1_out_t2_10 + (-1.9902244806289673) * gru_1_out_t2_11 + (0.92607021331787109) * gru_1_out_t2_12 + (1.9398208856582642) * gru_1_out_t2_13 + (-0.96349602937698364) * gru_1_out_t2_14 + (0.24153269827365875) * gru_1_out_t2_15 + (-0.41404494643211365) * gru_1_out_t2_16 + (-0.69627535343170166) * gru_1_out_t2_17 + (-1.9428142309188843) * gru_1_out_t2_18 + (2.1793274879455566) * gru_1_out_t2_19 + (0.025320641696453094) * gru_1_out_t2_20 + (2.94386887550354) * gru_1_out_t2_21 + (1.4350183010101318) * gru_1_out_t2_22 + (0.57179415225982666) * gru_1_out_t2_23 + (4.1894898414611816) * gru_1_out_t2_24 + (-0.18531304597854614) * gru_1_out_t2_25 + (0.53526943922042847) * gru_1_out_t2_26 + (1.3718123435974121) * gru_1_out_t2_27 + (-3.4464225769042969) * gru_1_out_t2_28 + (-0.61265230178833008) * gru_1_out_t2_29 + (1.4590919017791748) * gru_1_out_t2_30 + (-0.30470287799835205) * gru_1_out_t2_31 + (3.5802903175354004) * gru_1_out_t2_32 + (0.67903900146484375) * gru_1_out_t2_33 + (-2.8423435688018799) * gru_1_out_t2_34 + (0.91544777154922485) * gru_1_out_t2_35 + (0.50430524349212646) * gru_1_out_t2_36 + (0.50200903415679932) * gru_1_out_t2_37 + (-1.8054081201553345) * gru_1_out_t2_38 + (2.3222908973693848) * gru_1_out_t2_39 + (-2.441608190536499) * gru_1_out_t2_40 + (1.34009850025177) * gru_1_out_t2_41 + (3.7388591766357422) * gru_1_out_t2_42 + (-1.8505825996398926) * gru_1_out_t2_43 + (-1.3083306550979614) * gru_1_out_t2_44 + (-3.8074371814727783) * gru_1_out_t2_45 + (0.3774087131023407) * gru_1_out_t2_46 + (0.36189085245132446) * gru_1_out_t2_47 + (-4.2919669151306152) * gru_1_out_t2_48 + (-1.0874899625778198) * gru_1_out_t2_49 + (-2.4791679382324219) * gru_1_out_t2_50 + (2.387345552444458) * gru_1_out_t2_51 + (1.7170889377593994) * gru_1_out_t2_52 + (1.527686595916748) * gru_1_out_t2_53 + (-3.2332043647766113) * gru_1_out_t2_54 + (-2.9455251693725586) * gru_1_out_t2_55 + (1.4794570207595825) * gru_1_out_t2_56 + (0.75733864307403564) * gru_1_out_t2_57 + (-2.1985011100769043) * gru_1_out_t2_58 + (-0.40663313865661621) * gru_1_out_t2_59 + (-2.0647249221801758) * gru_1_out_t2_60 + (-4.0366487503051758) * gru_1_out_t2_61 + (0.51578634977340698) * gru_1_out_t2_62 + (1.2760800123214722) * gru_1_out_t2_63 + (-0.030730536207556725) * gru_2_rev_t3_h_0 + (-0.020187266170978546) * gru_2_rev_t3_h_1 + (0.12197879701852798) * gru_2_rev_t3_h_2 + (-0.060429647564888) * gru_2_rev_t3_h_3 + (-0.16959346830844879) * gru_2_rev_t3_h_4 + (-0.0089558111503720284) * gru_2_rev_t3_h_5 + (-0.023051699623465538) * gru_2_rev_t3_h_6 + (0.027561573311686516) * gru_2_rev_t3_h_7 + (0.27717059850692749) * gru_2_rev_t3_h_8 + (0.001502396073192358) * gru_2_rev_t3_h_9 + (-0.027588298544287682) * gru_2_rev_t3_h_10 + (-0.015279197134077549) * gru_2_rev_t3_h_11 + (-0.089657396078109741) * gru_2_rev_t3_h_12 + (0.029479818418622017) * gru_2_rev_t3_h_13 + (0.16803376376628876) * gru_2_rev_t3_h_14 + (-0.083077743649482727) * gru_2_rev_t3_h_15 + (-0.069358654320240021) * gru_2_rev_t3_h_16 + (0.053569495677947998) * gru_2_rev_t3_h_17 + (-0.041992265731096268) * gru_2_rev_t3_h_18 + (0.055314444005489349) * gru_2_rev_t3_h_19 + (0.075983166694641113) * gru_2_rev_t3_h_20 + (0.05028107762336731) * gru_2_rev_t3_h_21 + (0.20775645971298218) * gru_2_rev_t3_h_22 + (0.12403734773397446) * gru_2_rev_t3_h_23 + (-0.10771315544843674) * gru_2_rev_t3_h_24 + (0.063627816736698151) * gru_2_rev_t3_h_25 + (0.0078034242615103722) * gru_2_rev_t3_h_26 + (-0.15437166392803192) * gru_2_rev_t3_h_27 + (-0.088685959577560425) * gru_2_rev_t3_h_28 + (-0.037932559847831726) * gru_2_rev_t3_h_29 + (0.026010677218437195) * gru_2_rev_t3_h_30 + (-0.01980462484061718) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.35107678174972534) + (0.096216082572937012) * gru_1_out_t2_0 + (-0.0025339196436107159) * gru_1_out_t2_1 + (-0.02801629900932312) * gru_1_out_t2_2 + (0.25603672862052917) * gru_1_out_t2_3 + (0.41801977157592773) * gru_1_out_t2_4 + (-0.00017786805983632803) * gru_1_out_t2_5 + (-0.023579910397529602) * gru_1_out_t2_6 + (0.4068886935710907) * gru_1_out_t2_7 + (-0.14016738533973694) * gru_1_out_t2_8 + (0.041670758277177811) * gru_1_out_t2_9 + (-0.37800362706184387) * gru_1_out_t2_10 + (0.043299064040184021) * gru_1_out_t2_11 + (0.030525699257850647) * gru_1_out_t2_12 + (0.023593021556735039) * gru_1_out_t2_13 + (0.32303428649902344) * gru_1_out_t2_14 + (-0.14817741513252258) * gru_1_out_t2_15 + (-0.31548205018043518) * gru_1_out_t2_16 + (-0.78662806749343872) * gru_1_out_t2_17 + (0.15873710811138153) * gru_1_out_t2_18 + (-0.0097508747130632401) * gru_1_out_t2_19 + (0.26127558946609497) * gru_1_out_t2_20 + (-0.065972670912742615) * gru_1_out_t2_21 + (-0.094570964574813843) * gru_1_out_t2_22 + (-0.02095523476600647) * gru_1_out_t2_23 + (0.065075486898422241) * gru_1_out_t2_24 + (0.15661445260047913) * gru_1_out_t2_25 + (0.19410166144371033) * gru_1_out_t2_26 + (0.47598138451576233) * gru_1_out_t2_27 + (-0.65323019027709961) * gru_1_out_t2_28 + (-0.010971700772643089) * gru_1_out_t2_29 + (-0.025442318990826607) * gru_1_out_t2_30 + (-0.17508232593536377) * gru_1_out_t2_31 + (0.87162518501281738) * gru_1_out_t2_32 + (-0.03420976921916008) * gru_1_out_t2_33 + (-0.033294171094894409) * gru_1_out_t2_34 + (0.091547600924968719) * gru_1_out_t2_35 + (0.14853084087371826) * gru_1_out_t2_36 + (-0.92064648866653442) * gru_1_out_t2_37 + (-0.28189781308174133) * gru_1_out_t2_38 + (-0.84976565837860107) * gru_1_out_t2_39 + (0.011298094876110554) * gru_1_out_t2_40 + (0.16653074324131012) * gru_1_out_t2_41 + (-0.13058727979660034) * gru_1_out_t2_42 + (1.0701690912246704) * gru_1_out_t2_43 + (-0.14549513161182404) * gru_1_out_t2_44 + (0.18423065543174744) * gru_1_out_t2_45 + (-0.84013926982879639) * gru_1_out_t2_46 + (-0.084445692598819733) * gru_1_out_t2_47 + (-0.02074170857667923) * gru_1_out_t2_48 + (0.14957956969738007) * gru_1_out_t2_49 + (-0.34172278642654419) * gru_1_out_t2_50 + (-0.1860271692276001) * gru_1_out_t2_51 + (-0.22614707052707672) * gru_1_out_t2_52 + (0.5783393383026123) * gru_1_out_t2_53 + (-0.10788815468549728) * gru_1_out_t2_54 + (0.14963085949420929) * gru_1_out_t2_55 + (0.4399508535861969) * gru_1_out_t2_56 + (0.37078556418418884) * gru_1_out_t2_57 + (0.39240798354148865) * gru_1_out_t2_58 + (-0.046546850353479385) * gru_1_out_t2_59 + (0.0030324372928589582) * gru_1_out_t2_60 + (0.25666600465774536) * gru_1_out_t2_61 + (0.11856870353221893) * gru_1_out_t2_62 + (0.21070794761180878) * gru_1_out_t2_63 + (-0.12570881843566895) * gru_2_rev_t3_h_0 + (-0.11488001793622971) * gru_2_rev_t3_h_1 + (-0.097457915544509888) * gru_2_rev_t3_h_2 + (0.28858229517936707) * gru_2_rev_t3_h_3 + (0.0751456618309021) * gru_2_rev_t3_h_4 + (-0.12661100924015045) * gru_2_rev_t3_h_5 + (0.067841321229934692) * gru_2_rev_t3_h_6 + (0.011659640818834305) * gru_2_rev_t3_h_7 + (0.11731956154108047) * gru_2_rev_t3_h_8 + (0.0076494351960718632) * gru_2_rev_t3_h_9 + (0.13681720197200775) * gru_2_rev_t3_h_10 + (0.13455697894096375) * gru_2_rev_t3_h_11 + (-0.027606425806879997) * gru_2_rev_t3_h_12 + (0.054222919046878815) * gru_2_rev_t3_h_13 + (-0.012670522555708885) * gru_2_rev_t3_h_14 + (-0.011785059235990047) * gru_2_rev_t3_h_15 + (-0.098800487816333771) * gru_2_rev_t3_h_16 + (-0.01472396869212389) * gru_2_rev_t3_h_17 + (0.11632861942052841) * gru_2_rev_t3_h_18 + (0.07238662987947464) * gru_2_rev_t3_h_19 + (0.11882238835096359) * gru_2_rev_t3_h_20 + (-0.10093185305595398) * gru_2_rev_t3_h_21 + (-0.081245839595794678) * gru_2_rev_t3_h_22 + (0.024031402543187141) * gru_2_rev_t3_h_23 + (0.014039858244359493) * gru_2_rev_t3_h_24 + (-0.052337680011987686) * gru_2_rev_t3_h_25 + (0.0094002438709139824) * gru_2_rev_t3_h_26 + (-0.014504073187708855) * gru_2_rev_t3_h_27 + (-0.032068002969026566) * gru_2_rev_t3_h_28 + (-0.054963059723377228) * gru_2_rev_t3_h_29 + (0.041715066879987717) * gru_2_rev_t3_h_30 + (-0.13659185171127319) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.35261452198028564) + (0.33798334002494812) * gru_1_out_t2_0 + (0.36473479866981506) * gru_1_out_t2_1 + (0.16357941925525665) * gru_1_out_t2_2 + (-0.23544250428676605) * gru_1_out_t2_3 + (-0.22529532015323639) * gru_1_out_t2_4 + (0.13058435916900635) * gru_1_out_t2_5 + (-0.27506303787231445) * gru_1_out_t2_6 + (-0.5539591908454895) * gru_1_out_t2_7 + (-0.067139767110347748) * gru_1_out_t2_8 + (-0.12950889766216278) * gru_1_out_t2_9 + (0.41682878136634827) * gru_1_out_t2_10 + (0.27256128191947937) * gru_1_out_t2_11 + (-0.25821977853775024) * gru_1_out_t2_12 + (-0.022165106609463692) * gru_1_out_t2_13 + (-1.5848747491836548) * gru_1_out_t2_14 + (-0.014747420325875282) * gru_1_out_t2_15 + (-0.14185070991516113) * gru_1_out_t2_16 + (-0.55500656366348267) * gru_1_out_t2_17 + (-0.2704632580280304) * gru_1_out_t2_18 + (-0.17353825271129608) * gru_1_out_t2_19 + (-0.078651763498783112) * gru_1_out_t2_20 + (-0.67745679616928101) * gru_1_out_t2_21 + (-0.51622569561004639) * gru_1_out_t2_22 + (-0.30120006203651428) * gru_1_out_t2_23 + (-0.99952524900436401) * gru_1_out_t2_24 + (0.1428183913230896) * gru_1_out_t2_25 + (0.77487105131149292) * gru_1_out_t2_26 + (-1.2449426651000977) * gru_1_out_t2_27 + (-0.24088215827941895) * gru_1_out_t2_28 + (-0.26880365610122681) * gru_1_out_t2_29 + (-0.1990344375371933) * gru_1_out_t2_30 + (-0.35935896635055542) * gru_1_out_t2_31 + (1.7169660329818726) * gru_1_out_t2_32 + (0.01114814355969429) * gru_1_out_t2_33 + (0.38370141386985779) * gru_1_out_t2_34 + (-0.0043903356418013573) * gru_1_out_t2_35 + (-0.019630074501037598) * gru_1_out_t2_36 + (0.10392176359891891) * gru_1_out_t2_37 + (-0.30334681272506714) * gru_1_out_t2_38 + (0.69407135248184204) * gru_1_out_t2_39 + (0.053337696939706802) * gru_1_out_t2_40 + (0.16025842726230621) * gru_1_out_t2_41 + (-0.45503479242324829) * gru_1_out_t2_42 + (-0.75426375865936279) * gru_1_out_t2_43 + (-0.045486658811569214) * gru_1_out_t2_44 + (0.51422888040542603) * gru_1_out_t2_45 + (-0.87408316135406494) * gru_1_out_t2_46 + (-1.3020255565643311) * gru_1_out_t2_47 + (-0.48713600635528564) * gru_1_out_t2_48 + (-0.57685881853103638) * gru_1_out_t2_49 + (-0.43333703279495239) * gru_1_out_t2_50 + (2.0071532726287842) * gru_1_out_t2_51 + (-1.9097284078598022) * gru_1_out_t2_52 + (-0.072031155228614807) * gru_1_out_t2_53 + (1.1493593454360962) * gru_1_out_t2_54 + (0.47758433222770691) * gru_1_out_t2_55 + (0.9113423228263855) * gru_1_out_t2_56 + (0.46720331907272339) * gru_1_out_t2_57 + (0.027803776785731316) * gru_1_out_t2_58 + (0.095389604568481445) * gru_1_out_t2_59 + (0.64494705200195312) * gru_1_out_t2_60 + (-0.29063200950622559) * gru_1_out_t2_61 + (-0.12726955115795135) * gru_1_out_t2_62 + (-0.024320591241121292) * gru_1_out_t2_63 + gate_r * ((0.66470801830291748) + (-0.10299459844827652) * gru_2_rev_t3_h_0 + (0.12581293284893036) * gru_2_rev_t3_h_1 + (0.014066262170672417) * gru_2_rev_t3_h_2 + (-0.085326105356216431) * gru_2_rev_t3_h_3 + (0.082222379744052887) * gru_2_rev_t3_h_4 + (0.036517295986413956) * gru_2_rev_t3_h_5 + (0.036134868860244751) * gru_2_rev_t3_h_6 + (0.039903312921524048) * gru_2_rev_t3_h_7 + (0.18959186971187592) * gru_2_rev_t3_h_8 + (-0.04386463388800621) * gru_2_rev_t3_h_9 + (-0.068311192095279694) * gru_2_rev_t3_h_10 + (-0.14558060467243195) * gru_2_rev_t3_h_11 + (-0.1122078150510788) * gru_2_rev_t3_h_12 + (-0.050751198083162308) * gru_2_rev_t3_h_13 + (0.13927048444747925) * gru_2_rev_t3_h_14 + (-0.12583842873573303) * gru_2_rev_t3_h_15 + (0.11789820343255997) * gru_2_rev_t3_h_16 + (-0.054257836192846298) * gru_2_rev_t3_h_17 + (0.18983381986618042) * gru_2_rev_t3_h_18 + (0.040552172809839249) * gru_2_rev_t3_h_19 + (0.021518155932426453) * gru_2_rev_t3_h_20 + (0.020739840343594551) * gru_2_rev_t3_h_21 + (-0.058971218764781952) * gru_2_rev_t3_h_22 + (0.033242214471101761) * gru_2_rev_t3_h_23 + (-0.057869508862495422) * gru_2_rev_t3_h_24 + (0.055641140788793564) * gru_2_rev_t3_h_25 + (-0.050956547260284424) * gru_2_rev_t3_h_26 + (-0.02243737131357193) * gru_2_rev_t3_h_27 + (-0.14678244292736053) * gru_2_rev_t3_h_28 + (0.071713000535964966) * gru_2_rev_t3_h_29 + (-0.0088389860466122627) * gru_2_rev_t3_h_30 + (0.025249132886528969) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_29 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_29;
    // h=30
    gate_r = sigmoid((-1.934731125831604) + (-0.91245740652084351) * gru_1_out_t2_0 + (-1.5595663785934448) * gru_1_out_t2_1 + (1.2816663980484009) * gru_1_out_t2_2 + (0.085828594863414764) * gru_1_out_t2_3 + (0.87199068069458008) * gru_1_out_t2_4 + (0.23951590061187744) * gru_1_out_t2_5 + (1.3989396095275879) * gru_1_out_t2_6 + (0.28177574276924133) * gru_1_out_t2_7 + (0.25877261161804199) * gru_1_out_t2_8 + (-1.0531520843505859) * gru_1_out_t2_9 + (-0.87811243534088135) * gru_1_out_t2_10 + (-0.61046427488327026) * gru_1_out_t2_11 + (-2.0884661674499512) * gru_1_out_t2_12 + (-1.7202895879745483) * gru_1_out_t2_13 + (-1.4699358940124512) * gru_1_out_t2_14 + (1.6061747074127197) * gru_1_out_t2_15 + (0.57000303268432617) * gru_1_out_t2_16 + (-1.831085205078125) * gru_1_out_t2_17 + (1.4030730724334717) * gru_1_out_t2_18 + (1.5421688556671143) * gru_1_out_t2_19 + (-0.63103288412094116) * gru_1_out_t2_20 + (3.8393332958221436) * gru_1_out_t2_21 + (0.71778172254562378) * gru_1_out_t2_22 + (-4.1322402954101562) * gru_1_out_t2_23 + (2.3892860412597656) * gru_1_out_t2_24 + (0.18247890472412109) * gru_1_out_t2_25 + (0.96305108070373535) * gru_1_out_t2_26 + (-0.66837751865386963) * gru_1_out_t2_27 + (1.3159173727035522) * gru_1_out_t2_28 + (-0.026208760216832161) * gru_1_out_t2_29 + (-1.7666041851043701) * gru_1_out_t2_30 + (-0.51424884796142578) * gru_1_out_t2_31 + (-0.88837325572967529) * gru_1_out_t2_32 + (0.24613980948925018) * gru_1_out_t2_33 + (-0.15525618195533752) * gru_1_out_t2_34 + (0.40328332781791687) * gru_1_out_t2_35 + (-0.27266427874565125) * gru_1_out_t2_36 + (1.0897842645645142) * gru_1_out_t2_37 + (-0.11870841681957245) * gru_1_out_t2_38 + (-2.7505931854248047) * gru_1_out_t2_39 + (3.3697147369384766) * gru_1_out_t2_40 + (-0.34176486730575562) * gru_1_out_t2_41 + (-2.3233928680419922) * gru_1_out_t2_42 + (1.8947372436523438) * gru_1_out_t2_43 + (-0.19168494641780853) * gru_1_out_t2_44 + (4.825955867767334) * gru_1_out_t2_45 + (-0.30648323893547058) * gru_1_out_t2_46 + (0.34732019901275635) * gru_1_out_t2_47 + (2.6827292442321777) * gru_1_out_t2_48 + (2.1632041931152344) * gru_1_out_t2_49 + (0.74210554361343384) * gru_1_out_t2_50 + (-1.5255805253982544) * gru_1_out_t2_51 + (2.6612296104431152) * gru_1_out_t2_52 + (-2.1982192993164062) * gru_1_out_t2_53 + (1.880192756652832) * gru_1_out_t2_54 + (0.40777027606964111) * gru_1_out_t2_55 + (0.78810513019561768) * gru_1_out_t2_56 + (0.10626824200153351) * gru_1_out_t2_57 + (-2.0172455310821533) * gru_1_out_t2_58 + (1.2224818468093872) * gru_1_out_t2_59 + (0.17658145725727081) * gru_1_out_t2_60 + (-4.8849201202392578) * gru_1_out_t2_61 + (3.3176043033599854) * gru_1_out_t2_62 + (1.5456959009170532) * gru_1_out_t2_63 + (-0.027298316359519958) * gru_2_rev_t3_h_0 + (-0.10015396028757095) * gru_2_rev_t3_h_1 + (0.04312436655163765) * gru_2_rev_t3_h_2 + (0.028939289972186089) * gru_2_rev_t3_h_3 + (0.2056281715631485) * gru_2_rev_t3_h_4 + (0.11640878021717072) * gru_2_rev_t3_h_5 + (-0.064611651003360748) * gru_2_rev_t3_h_6 + (0.064224295318126678) * gru_2_rev_t3_h_7 + (0.068992480635643005) * gru_2_rev_t3_h_8 + (0.097078047692775726) * gru_2_rev_t3_h_9 + (-0.084185183048248291) * gru_2_rev_t3_h_10 + (-0.026780493557453156) * gru_2_rev_t3_h_11 + (0.10265403240919113) * gru_2_rev_t3_h_12 + (0.051517795771360397) * gru_2_rev_t3_h_13 + (0.0084172440692782402) * gru_2_rev_t3_h_14 + (0.012762723490595818) * gru_2_rev_t3_h_15 + (-0.093716427683830261) * gru_2_rev_t3_h_16 + (0.0057400790974497795) * gru_2_rev_t3_h_17 + (-0.064188048243522644) * gru_2_rev_t3_h_18 + (0.10631542652845383) * gru_2_rev_t3_h_19 + (-0.00068994704633951187) * gru_2_rev_t3_h_20 + (0.052482668310403824) * gru_2_rev_t3_h_21 + (-0.14011453092098236) * gru_2_rev_t3_h_22 + (-0.14269883930683136) * gru_2_rev_t3_h_23 + (-0.1149974912405014) * gru_2_rev_t3_h_24 + (-0.1393485814332962) * gru_2_rev_t3_h_25 + (-0.082803711295127869) * gru_2_rev_t3_h_26 + (-0.14290401339530945) * gru_2_rev_t3_h_27 + (0.037910874933004379) * gru_2_rev_t3_h_28 + (0.038547035306692123) * gru_2_rev_t3_h_29 + (-0.070300407707691193) * gru_2_rev_t3_h_30 + (0.11156313121318817) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((1.2521442174911499) + (0.34168973565101624) * gru_1_out_t2_0 + (-0.042100369930267334) * gru_1_out_t2_1 + (-0.98251330852508545) * gru_1_out_t2_2 + (0.3845696747303009) * gru_1_out_t2_3 + (-0.10352212935686111) * gru_1_out_t2_4 + (-0.34171175956726074) * gru_1_out_t2_5 + (0.23454770445823669) * gru_1_out_t2_6 + (0.078328967094421387) * gru_1_out_t2_7 + (-0.15382981300354004) * gru_1_out_t2_8 + (0.056744560599327087) * gru_1_out_t2_9 + (0.17651601135730743) * gru_1_out_t2_10 + (0.33986824750900269) * gru_1_out_t2_11 + (-0.22831785678863525) * gru_1_out_t2_12 + (0.061941966414451599) * gru_1_out_t2_13 + (1.1454259157180786) * gru_1_out_t2_14 + (-0.23599414527416229) * gru_1_out_t2_15 + (-0.061336889863014221) * gru_1_out_t2_16 + (-0.35853511095046997) * gru_1_out_t2_17 + (0.41889744997024536) * gru_1_out_t2_18 + (0.098103739321231842) * gru_1_out_t2_19 + (0.17799963057041168) * gru_1_out_t2_20 + (-0.26570850610733032) * gru_1_out_t2_21 + (-0.081585824489593506) * gru_1_out_t2_22 + (-0.20880737900733948) * gru_1_out_t2_23 + (0.054716940969228745) * gru_1_out_t2_24 + (0.17363804578781128) * gru_1_out_t2_25 + (0.48300206661224365) * gru_1_out_t2_26 + (0.48810479044914246) * gru_1_out_t2_27 + (-1.7777073383331299) * gru_1_out_t2_28 + (-0.19304788112640381) * gru_1_out_t2_29 + (0.35614830255508423) * gru_1_out_t2_30 + (-0.43390002846717834) * gru_1_out_t2_31 + (1.1038459539413452) * gru_1_out_t2_32 + (-0.12787432968616486) * gru_1_out_t2_33 + (-0.20081628859043121) * gru_1_out_t2_34 + (0.076866410672664642) * gru_1_out_t2_35 + (0.15825353562831879) * gru_1_out_t2_36 + (-0.94026297330856323) * gru_1_out_t2_37 + (-0.85961627960205078) * gru_1_out_t2_38 + (-0.27196481823921204) * gru_1_out_t2_39 + (0.12150552123785019) * gru_1_out_t2_40 + (0.28835210204124451) * gru_1_out_t2_41 + (0.33045664429664612) * gru_1_out_t2_42 + (0.68873065710067749) * gru_1_out_t2_43 + (-0.26190900802612305) * gru_1_out_t2_44 + (0.37408879399299622) * gru_1_out_t2_45 + (-0.4466957151889801) * gru_1_out_t2_46 + (-0.077540524303913116) * gru_1_out_t2_47 + (-0.048960320651531219) * gru_1_out_t2_48 + (0.073072090744972229) * gru_1_out_t2_49 + (-0.86992818117141724) * gru_1_out_t2_50 + (-0.33942922949790955) * gru_1_out_t2_51 + (-1.717617392539978) * gru_1_out_t2_52 + (0.5374748706817627) * gru_1_out_t2_53 + (-0.24007411301136017) * gru_1_out_t2_54 + (-0.11799447983503342) * gru_1_out_t2_55 + (0.5603790283203125) * gru_1_out_t2_56 + (0.54259461164474487) * gru_1_out_t2_57 + (0.50692051649093628) * gru_1_out_t2_58 + (-0.067703403532505035) * gru_1_out_t2_59 + (-1.121614933013916) * gru_1_out_t2_60 + (0.83274012804031372) * gru_1_out_t2_61 + (0.1112619936466217) * gru_1_out_t2_62 + (0.63519740104675293) * gru_1_out_t2_63 + (-0.039589613676071167) * gru_2_rev_t3_h_0 + (-0.11054251343011856) * gru_2_rev_t3_h_1 + (-0.043860595673322678) * gru_2_rev_t3_h_2 + (-0.024696860462427139) * gru_2_rev_t3_h_3 + (0.030722757801413536) * gru_2_rev_t3_h_4 + (-0.10144452005624771) * gru_2_rev_t3_h_5 + (0.083525247871875763) * gru_2_rev_t3_h_6 + (-0.024903586134314537) * gru_2_rev_t3_h_7 + (-0.087160356342792511) * gru_2_rev_t3_h_8 + (0.01314363069832325) * gru_2_rev_t3_h_9 + (-0.13521626591682434) * gru_2_rev_t3_h_10 + (-0.02674572728574276) * gru_2_rev_t3_h_11 + (-0.0056753000244498253) * gru_2_rev_t3_h_12 + (-0.022250864654779434) * gru_2_rev_t3_h_13 + (-0.085962116718292236) * gru_2_rev_t3_h_14 + (-0.13937963545322418) * gru_2_rev_t3_h_15 + (0.035483155399560928) * gru_2_rev_t3_h_16 + (-0.20168854296207428) * gru_2_rev_t3_h_17 + (0.055501077324151993) * gru_2_rev_t3_h_18 + (0.051890969276428223) * gru_2_rev_t3_h_19 + (0.042056865990161896) * gru_2_rev_t3_h_20 + (0.2714657187461853) * gru_2_rev_t3_h_21 + (-0.12158451974391937) * gru_2_rev_t3_h_22 + (-0.014786336570978165) * gru_2_rev_t3_h_23 + (-0.025753786787390709) * gru_2_rev_t3_h_24 + (0.055948942899703979) * gru_2_rev_t3_h_25 + (0.11293153464794159) * gru_2_rev_t3_h_26 + (0.039767220616340637) * gru_2_rev_t3_h_27 + (0.0074900933541357517) * gru_2_rev_t3_h_28 + (-0.0066900947131216526) * gru_2_rev_t3_h_29 + (-0.11713942140340805) * gru_2_rev_t3_h_30 + (0.040790461003780365) * gru_2_rev_t3_h_31);
    gate_n = tanh((0.10977233946323395) + (-0.090040765702724457) * gru_1_out_t2_0 + (-0.064817130565643311) * gru_1_out_t2_1 + (-0.028330998495221138) * gru_1_out_t2_2 + (-0.5583760142326355) * gru_1_out_t2_3 + (-0.11130508780479431) * gru_1_out_t2_4 + (-0.13417379558086395) * gru_1_out_t2_5 + (-0.67697495222091675) * gru_1_out_t2_6 + (-0.19643375277519226) * gru_1_out_t2_7 + (-0.22132688760757446) * gru_1_out_t2_8 + (0.05295012891292572) * gru_1_out_t2_9 + (0.31457439064979553) * gru_1_out_t2_10 + (0.1191876083612442) * gru_1_out_t2_11 + (-0.38235312700271606) * gru_1_out_t2_12 + (-0.057151209563016891) * gru_1_out_t2_13 + (-0.86977934837341309) * gru_1_out_t2_14 + (0.094439305365085602) * gru_1_out_t2_15 + (-0.22828845679759979) * gru_1_out_t2_16 + (-0.58470773696899414) * gru_1_out_t2_17 + (-0.93880546092987061) * gru_1_out_t2_18 + (-0.06694524735212326) * gru_1_out_t2_19 + (-0.078498631715774536) * gru_1_out_t2_20 + (-0.32181358337402344) * gru_1_out_t2_21 + (-0.14024506509304047) * gru_1_out_t2_22 + (-0.49171391129493713) * gru_1_out_t2_23 + (-0.39566680788993835) * gru_1_out_t2_24 + (0.062276825308799744) * gru_1_out_t2_25 + (-0.5789521336555481) * gru_1_out_t2_26 + (-0.93231213092803955) * gru_1_out_t2_27 + (1.1842585802078247) * gru_1_out_t2_28 + (0.2727699875831604) * gru_1_out_t2_29 + (-0.29867875576019287) * gru_1_out_t2_30 + (0.12112204730510712) * gru_1_out_t2_31 + (0.57767903804779053) * gru_1_out_t2_32 + (0.55321550369262695) * gru_1_out_t2_33 + (0.012538861483335495) * gru_1_out_t2_34 + (-0.23032195866107941) * gru_1_out_t2_35 + (-0.068405613303184509) * gru_1_out_t2_36 + (1.2594296932220459) * gru_1_out_t2_37 + (-0.27687716484069824) * gru_1_out_t2_38 + (1.2684047222137451) * gru_1_out_t2_39 + (-0.3361838161945343) * gru_1_out_t2_40 + (0.14401954412460327) * gru_1_out_t2_41 + (0.039227712899446487) * gru_1_out_t2_42 + (0.28490158915519714) * gru_1_out_t2_43 + (-0.056540388613939285) * gru_1_out_t2_44 + (-0.29229316115379333) * gru_1_out_t2_45 + (1.3482666015625) * gru_1_out_t2_46 + (0.092125475406646729) * gru_1_out_t2_47 + (-0.6606566309928894) * gru_1_out_t2_48 + (-0.26720020174980164) * gru_1_out_t2_49 + (0.35031509399414062) * gru_1_out_t2_50 + (-0.50264018774032593) * gru_1_out_t2_51 + (0.51873254776000977) * gru_1_out_t2_52 + (0.10866664350032806) * gru_1_out_t2_53 + (2.4994442462921143) * gru_1_out_t2_54 + (-0.84784281253814697) * gru_1_out_t2_55 + (0.21983855962753296) * gru_1_out_t2_56 + (-0.13721822202205658) * gru_1_out_t2_57 + (0.08667369931936264) * gru_1_out_t2_58 + (0.27984875440597534) * gru_1_out_t2_59 + (0.72249752283096313) * gru_1_out_t2_60 + (0.071582980453968048) * gru_1_out_t2_61 + (-0.38113886117935181) * gru_1_out_t2_62 + (0.14769625663757324) * gru_1_out_t2_63 + gate_r * ((2.2501330375671387) + (0.012855499051511288) * gru_2_rev_t3_h_0 + (-0.18695764243602753) * gru_2_rev_t3_h_1 + (0.010087636299431324) * gru_2_rev_t3_h_2 + (-0.044879458844661713) * gru_2_rev_t3_h_3 + (-0.059084251523017883) * gru_2_rev_t3_h_4 + (0.18300005793571472) * gru_2_rev_t3_h_5 + (-0.0030824772547930479) * gru_2_rev_t3_h_6 + (0.13030941784381866) * gru_2_rev_t3_h_7 + (-0.11475493758916855) * gru_2_rev_t3_h_8 + (-0.008112405426800251) * gru_2_rev_t3_h_9 + (-0.057554803788661957) * gru_2_rev_t3_h_10 + (0.046319223940372467) * gru_2_rev_t3_h_11 + (-0.103856161236763) * gru_2_rev_t3_h_12 + (0.22389566898345947) * gru_2_rev_t3_h_13 + (0.13787734508514404) * gru_2_rev_t3_h_14 + (-0.00021995342103764415) * gru_2_rev_t3_h_15 + (-0.017428386956453323) * gru_2_rev_t3_h_16 + (0.023245958611369133) * gru_2_rev_t3_h_17 + (-0.060759902000427246) * gru_2_rev_t3_h_18 + (0.068286590278148651) * gru_2_rev_t3_h_19 + (-0.16800412535667419) * gru_2_rev_t3_h_20 + (-0.040820565074682236) * gru_2_rev_t3_h_21 + (0.05876251682639122) * gru_2_rev_t3_h_22 + (-0.030614778399467468) * gru_2_rev_t3_h_23 + (-0.02519635483622551) * gru_2_rev_t3_h_24 + (-0.15561169385910034) * gru_2_rev_t3_h_25 + (-0.063438877463340759) * gru_2_rev_t3_h_26 + (-0.065193817019462585) * gru_2_rev_t3_h_27 + (-0.16269691288471222) * gru_2_rev_t3_h_28 + (0.035735853016376495) * gru_2_rev_t3_h_29 + (0.16996234655380249) * gru_2_rev_t3_h_30 + (0.1398843377828598) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_30 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_30;
    // h=31
    gate_r = sigmoid((0.26813355088233948) + (0.25966152548789978) * gru_1_out_t2_0 + (-2.1302251815795898) * gru_1_out_t2_1 + (-1.0098283290863037) * gru_1_out_t2_2 + (-0.83940726518630981) * gru_1_out_t2_3 + (0.80054348707199097) * gru_1_out_t2_4 + (1.217708945274353) * gru_1_out_t2_5 + (2.5202429294586182) * gru_1_out_t2_6 + (-0.60067516565322876) * gru_1_out_t2_7 + (0.82925570011138916) * gru_1_out_t2_8 + (-0.54835599660873413) * gru_1_out_t2_9 + (-0.068575553596019745) * gru_1_out_t2_10 + (2.4288313388824463) * gru_1_out_t2_11 + (0.82589042186737061) * gru_1_out_t2_12 + (1.9605497121810913) * gru_1_out_t2_13 + (-0.73708754777908325) * gru_1_out_t2_14 + (-0.15766038000583649) * gru_1_out_t2_15 + (-0.16683472692966461) * gru_1_out_t2_16 + (0.053284443914890289) * gru_1_out_t2_17 + (0.60889965295791626) * gru_1_out_t2_18 + (-1.5565211772918701) * gru_1_out_t2_19 + (-0.37490385770797729) * gru_1_out_t2_20 + (0.97742873430252075) * gru_1_out_t2_21 + (-1.6427390575408936) * gru_1_out_t2_22 + (-0.29144841432571411) * gru_1_out_t2_23 + (2.0285713672637939) * gru_1_out_t2_24 + (0.97365665435791016) * gru_1_out_t2_25 + (-0.1907353550195694) * gru_1_out_t2_26 + (0.81452065706253052) * gru_1_out_t2_27 + (0.49790927767753601) * gru_1_out_t2_28 + (-0.64061272144317627) * gru_1_out_t2_29 + (-0.84952825307846069) * gru_1_out_t2_30 + (1.2904367446899414) * gru_1_out_t2_31 + (0.89473855495452881) * gru_1_out_t2_32 + (2.4409291744232178) * gru_1_out_t2_33 + (0.10187040269374847) * gru_1_out_t2_34 + (-1.2547811269760132) * gru_1_out_t2_35 + (-0.2644440233707428) * gru_1_out_t2_36 + (1.2764513492584229) * gru_1_out_t2_37 + (0.099281705915927887) * gru_1_out_t2_38 + (0.72308343648910522) * gru_1_out_t2_39 + (-0.38528463244438171) * gru_1_out_t2_40 + (-0.063841074705123901) * gru_1_out_t2_41 + (2.1525590419769287) * gru_1_out_t2_42 + (0.75212103128433228) * gru_1_out_t2_43 + (-0.79540002346038818) * gru_1_out_t2_44 + (-3.123878002166748) * gru_1_out_t2_45 + (3.9604427814483643) * gru_1_out_t2_46 + (-2.913799524307251) * gru_1_out_t2_47 + (-0.00093192444182932377) * gru_1_out_t2_48 + (1.3114556074142456) * gru_1_out_t2_49 + (-0.24565908312797546) * gru_1_out_t2_50 + (-1.1426212787628174) * gru_1_out_t2_51 + (-0.12152949720621109) * gru_1_out_t2_52 + (0.4575953483581543) * gru_1_out_t2_53 + (-0.076322577893733978) * gru_1_out_t2_54 + (-0.34638455510139465) * gru_1_out_t2_55 + (2.2946796417236328) * gru_1_out_t2_56 + (0.28573605418205261) * gru_1_out_t2_57 + (-0.029037304222583771) * gru_1_out_t2_58 + (0.049501292407512665) * gru_1_out_t2_59 + (-0.45490333437919617) * gru_1_out_t2_60 + (-1.0395622253417969) * gru_1_out_t2_61 + (-0.47043350338935852) * gru_1_out_t2_62 + (0.095262430608272552) * gru_1_out_t2_63 + (0.053980324417352676) * gru_2_rev_t3_h_0 + (-0.16121484339237213) * gru_2_rev_t3_h_1 + (-0.12874749302864075) * gru_2_rev_t3_h_2 + (-0.11233105510473251) * gru_2_rev_t3_h_3 + (-0.085714474320411682) * gru_2_rev_t3_h_4 + (0.18464402854442596) * gru_2_rev_t3_h_5 + (0.036725796759128571) * gru_2_rev_t3_h_6 + (-0.12725833058357239) * gru_2_rev_t3_h_7 + (-0.11285365372896194) * gru_2_rev_t3_h_8 + (-0.092784509062767029) * gru_2_rev_t3_h_9 + (0.048008888959884644) * gru_2_rev_t3_h_10 + (0.075172312557697296) * gru_2_rev_t3_h_11 + (0.10929957777261734) * gru_2_rev_t3_h_12 + (-0.030481113120913506) * gru_2_rev_t3_h_13 + (0.019305150955915451) * gru_2_rev_t3_h_14 + (0.11900065839290619) * gru_2_rev_t3_h_15 + (0.16424413025379181) * gru_2_rev_t3_h_16 + (0.0055439658463001251) * gru_2_rev_t3_h_17 + (0.054902475327253342) * gru_2_rev_t3_h_18 + (0.004228394478559494) * gru_2_rev_t3_h_19 + (0.077056862413883209) * gru_2_rev_t3_h_20 + (0.21581852436065674) * gru_2_rev_t3_h_21 + (0.092630684375762939) * gru_2_rev_t3_h_22 + (0.0068758963607251644) * gru_2_rev_t3_h_23 + (0.10379891842603683) * gru_2_rev_t3_h_24 + (-0.012566162273287773) * gru_2_rev_t3_h_25 + (0.13114577531814575) * gru_2_rev_t3_h_26 + (-0.090067759156227112) * gru_2_rev_t3_h_27 + (0.01850392110645771) * gru_2_rev_t3_h_28 + (-0.072789236903190613) * gru_2_rev_t3_h_29 + (0.14905431866645813) * gru_2_rev_t3_h_30 + (-0.097812667489051819) * gru_2_rev_t3_h_31);
    gate_z = sigmoid((0.24176619946956635) + (-0.13222278654575348) * gru_1_out_t2_0 + (-0.75276470184326172) * gru_1_out_t2_1 + (0.098734855651855469) * gru_1_out_t2_2 + (0.6956789493560791) * gru_1_out_t2_3 + (0.25494897365570068) * gru_1_out_t2_4 + (0.5014946460723877) * gru_1_out_t2_5 + (0.68738007545471191) * gru_1_out_t2_6 + (0.54501515626907349) * gru_1_out_t2_7 + (-0.68915355205535889) * gru_1_out_t2_8 + (-0.46506834030151367) * gru_1_out_t2_9 + (-0.29127654433250427) * gru_1_out_t2_10 + (-0.61135584115982056) * gru_1_out_t2_11 + (-0.7923349142074585) * gru_1_out_t2_12 + (-0.32712626457214355) * gru_1_out_t2_13 + (0.38902834057807922) * gru_1_out_t2_14 + (-0.82795661687850952) * gru_1_out_t2_15 + (-0.23836621642112732) * gru_1_out_t2_16 + (-0.1152333989739418) * gru_1_out_t2_17 + (0.4541211724281311) * gru_1_out_t2_18 + (-0.2228303998708725) * gru_1_out_t2_19 + (0.50834733247756958) * gru_1_out_t2_20 + (0.66001015901565552) * gru_1_out_t2_21 + (-0.51488113403320312) * gru_1_out_t2_22 + (0.89624708890914917) * gru_1_out_t2_23 + (-0.67202389240264893) * gru_1_out_t2_24 + (0.57900387048721313) * gru_1_out_t2_25 + (-0.43271756172180176) * gru_1_out_t2_26 + (-0.16129158437252045) * gru_1_out_t2_27 + (-0.077006332576274872) * gru_1_out_t2_28 + (-0.68556666374206543) * gru_1_out_t2_29 + (-0.068495042622089386) * gru_1_out_t2_30 + (-0.23216092586517334) * gru_1_out_t2_31 + (-0.0094079477712512016) * gru_1_out_t2_32 + (1.0373023748397827) * gru_1_out_t2_33 + (-0.53244775533676147) * gru_1_out_t2_34 + (-0.10150305926799774) * gru_1_out_t2_35 + (0.0020800924394279718) * gru_1_out_t2_36 + (0.053689964115619659) * gru_1_out_t2_37 + (-0.3003527820110321) * gru_1_out_t2_38 + (-0.77943170070648193) * gru_1_out_t2_39 + (0.24997697770595551) * gru_1_out_t2_40 + (-0.20523552596569061) * gru_1_out_t2_41 + (-0.28414332866668701) * gru_1_out_t2_42 + (0.57622784376144409) * gru_1_out_t2_43 + (0.0036530198995023966) * gru_1_out_t2_44 + (-0.15059287846088409) * gru_1_out_t2_45 + (0.42781922221183777) * gru_1_out_t2_46 + (0.15595036745071411) * gru_1_out_t2_47 + (0.039334729313850403) * gru_1_out_t2_48 + (0.42636793851852417) * gru_1_out_t2_49 + (-0.25698712468147278) * gru_1_out_t2_50 + (-0.20705358684062958) * gru_1_out_t2_51 + (0.17762792110443115) * gru_1_out_t2_52 + (0.067271001636981964) * gru_1_out_t2_53 + (-0.34913778305053711) * gru_1_out_t2_54 + (0.26211941242218018) * gru_1_out_t2_55 + (0.62295305728912354) * gru_1_out_t2_56 + (0.1952650249004364) * gru_1_out_t2_57 + (-0.087542906403541565) * gru_1_out_t2_58 + (-0.32258030772209167) * gru_1_out_t2_59 + (0.18340185284614563) * gru_1_out_t2_60 + (0.68138748407363892) * gru_1_out_t2_61 + (-0.41854476928710938) * gru_1_out_t2_62 + (0.57837849855422974) * gru_1_out_t2_63 + (-0.041036006063222885) * gru_2_rev_t3_h_0 + (0.018745927140116692) * gru_2_rev_t3_h_1 + (0.0041640433482825756) * gru_2_rev_t3_h_2 + (0.12247979640960693) * gru_2_rev_t3_h_3 + (-0.063994131982326508) * gru_2_rev_t3_h_4 + (0.056403223425149918) * gru_2_rev_t3_h_5 + (0.068014509975910187) * gru_2_rev_t3_h_6 + (0.090656407177448273) * gru_2_rev_t3_h_7 + (0.004923639353364706) * gru_2_rev_t3_h_8 + (-0.044792748987674713) * gru_2_rev_t3_h_9 + (0.011406668461859226) * gru_2_rev_t3_h_10 + (0.011562610045075417) * gru_2_rev_t3_h_11 + (0.030641056597232819) * gru_2_rev_t3_h_12 + (-0.17503149807453156) * gru_2_rev_t3_h_13 + (-0.13124640285968781) * gru_2_rev_t3_h_14 + (0.024931818246841431) * gru_2_rev_t3_h_15 + (-0.19087512791156769) * gru_2_rev_t3_h_16 + (-0.017528660595417023) * gru_2_rev_t3_h_17 + (-0.14419852197170258) * gru_2_rev_t3_h_18 + (-0.068694792687892914) * gru_2_rev_t3_h_19 + (0.04976385086774826) * gru_2_rev_t3_h_20 + (-0.072422660887241364) * gru_2_rev_t3_h_21 + (-0.12589733302593231) * gru_2_rev_t3_h_22 + (-0.016282098367810249) * gru_2_rev_t3_h_23 + (0.01569964736700058) * gru_2_rev_t3_h_24 + (0.049837838858366013) * gru_2_rev_t3_h_25 + (0.17111881077289581) * gru_2_rev_t3_h_26 + (0.022307561710476875) * gru_2_rev_t3_h_27 + (-0.038386218249797821) * gru_2_rev_t3_h_28 + (-0.017588403075933456) * gru_2_rev_t3_h_29 + (0.092002645134925842) * gru_2_rev_t3_h_30 + (0.077473968267440796) * gru_2_rev_t3_h_31);
    gate_n = tanh((-0.28322646021842957) + (-0.087723486125469208) * gru_1_out_t2_0 + (-0.11312280595302582) * gru_1_out_t2_1 + (0.8957141637802124) * gru_1_out_t2_2 + (0.87336492538452148) * gru_1_out_t2_3 + (-0.47964170575141907) * gru_1_out_t2_4 + (-0.4778655469417572) * gru_1_out_t2_5 + (2.9467711448669434) * gru_1_out_t2_6 + (0.10400845855474472) * gru_1_out_t2_7 + (-0.56618523597717285) * gru_1_out_t2_8 + (-0.11508575826883316) * gru_1_out_t2_9 + (-0.12246319651603699) * gru_1_out_t2_10 + (-1.5908595323562622) * gru_1_out_t2_11 + (0.011729325167834759) * gru_1_out_t2_12 + (-0.43385189771652222) * gru_1_out_t2_13 + (0.15385347604751587) * gru_1_out_t2_14 + (0.2160913348197937) * gru_1_out_t2_15 + (0.65641611814498901) * gru_1_out_t2_16 + (-0.8922688364982605) * gru_1_out_t2_17 + (-0.76143556833267212) * gru_1_out_t2_18 + (0.76047736406326294) * gru_1_out_t2_19 + (-0.12940672039985657) * gru_1_out_t2_20 + (-1.4685213565826416) * gru_1_out_t2_21 + (0.51254582405090332) * gru_1_out_t2_22 + (-2.5887806415557861) * gru_1_out_t2_23 + (0.29744416475296021) * gru_1_out_t2_24 + (-0.50989669561386108) * gru_1_out_t2_25 + (0.11948110163211823) * gru_1_out_t2_26 + (0.34450778365135193) * gru_1_out_t2_27 + (-1.1140835285186768) * gru_1_out_t2_28 + (-0.047414291650056839) * gru_1_out_t2_29 + (-0.32305997610092163) * gru_1_out_t2_30 + (-0.6934589147567749) * gru_1_out_t2_31 + (-0.83969807624816895) * gru_1_out_t2_32 + (-1.4471482038497925) * gru_1_out_t2_33 + (0.34082767367362976) * gru_1_out_t2_34 + (0.81397652626037598) * gru_1_out_t2_35 + (0.15429842472076416) * gru_1_out_t2_36 + (-1.1568177938461304) * gru_1_out_t2_37 + (0.17487539350986481) * gru_1_out_t2_38 + (-0.55350261926651001) * gru_1_out_t2_39 + (0.42122483253479004) * gru_1_out_t2_40 + (-0.10478889942169189) * gru_1_out_t2_41 + (-0.65787672996520996) * gru_1_out_t2_42 + (-1.504597544670105) * gru_1_out_t2_43 + (0.85133886337280273) * gru_1_out_t2_44 + (2.0936083793640137) * gru_1_out_t2_45 + (-1.7538620233535767) * gru_1_out_t2_46 + (0.6086466908454895) * gru_1_out_t2_47 + (-0.35322755575180054) * gru_1_out_t2_48 + (-1.5973385572433472) * gru_1_out_t2_49 + (0.11520844697952271) * gru_1_out_t2_50 + (0.63952004909515381) * gru_1_out_t2_51 + (0.17825601994991302) * gru_1_out_t2_52 + (-0.23335044085979462) * gru_1_out_t2_53 + (1.8795921802520752) * gru_1_out_t2_54 + (-0.12406695634126663) * gru_1_out_t2_55 + (-2.0065128803253174) * gru_1_out_t2_56 + (0.18649458885192871) * gru_1_out_t2_57 + (-0.30705636739730835) * gru_1_out_t2_58 + (-0.60636460781097412) * gru_1_out_t2_59 + (0.70498555898666382) * gru_1_out_t2_60 + (-0.090328812599182129) * gru_1_out_t2_61 + (0.10657226294279099) * gru_1_out_t2_62 + (-0.060634057968854904) * gru_1_out_t2_63 + gate_r * ((-1.2120252847671509) + (0.055304933339357376) * gru_2_rev_t3_h_0 + (-0.025981206446886063) * gru_2_rev_t3_h_1 + (0.060274407267570496) * gru_2_rev_t3_h_2 + (-0.081247150897979736) * gru_2_rev_t3_h_3 + (-0.041304118931293488) * gru_2_rev_t3_h_4 + (0.086047381162643433) * gru_2_rev_t3_h_5 + (-0.093313194811344147) * gru_2_rev_t3_h_6 + (-0.033794287592172623) * gru_2_rev_t3_h_7 + (0.23523744940757751) * gru_2_rev_t3_h_8 + (-0.012941473163664341) * gru_2_rev_t3_h_9 + (0.018095618113875389) * gru_2_rev_t3_h_10 + (-0.0033135849516838789) * gru_2_rev_t3_h_11 + (0.13320577144622803) * gru_2_rev_t3_h_12 + (0.19898419082164764) * gru_2_rev_t3_h_13 + (-0.027336196973919868) * gru_2_rev_t3_h_14 + (0.069672249257564545) * gru_2_rev_t3_h_15 + (-0.035223647952079773) * gru_2_rev_t3_h_16 + (-0.072004906833171844) * gru_2_rev_t3_h_17 + (0.08244381844997406) * gru_2_rev_t3_h_18 + (-0.067978531122207642) * gru_2_rev_t3_h_19 + (0.091952748596668243) * gru_2_rev_t3_h_20 + (-0.12715500593185425) * gru_2_rev_t3_h_21 + (0.034398756921291351) * gru_2_rev_t3_h_22 + (0.0026410387363284826) * gru_2_rev_t3_h_23 + (0.047354716807603836) * gru_2_rev_t3_h_24 + (0.051248569041490555) * gru_2_rev_t3_h_25 + (0.033891189843416214) * gru_2_rev_t3_h_26 + (0.049258146435022354) * gru_2_rev_t3_h_27 + (0.025265149772167206) * gru_2_rev_t3_h_28 + (0.021675713360309601) * gru_2_rev_t3_h_29 + (0.018117131665349007) * gru_2_rev_t3_h_30 + (-0.025885820388793945) * gru_2_rev_t3_h_31));
    gru_2_rev_t2_h_31 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t3_h_31;

    // RV step t=1
    // h=0
    gate_r = sigmoid((0.85594367980957031) + (0.19063784182071686) * gru_1_out_t1_0 + (0.40833914279937744) * gru_1_out_t1_1 + (0.099587418138980865) * gru_1_out_t1_2 + (0.53048956394195557) * gru_1_out_t1_3 + (0.054907824844121933) * gru_1_out_t1_4 + (-0.13566303253173828) * gru_1_out_t1_5 + (-0.39046892523765564) * gru_1_out_t1_6 + (0.083041653037071228) * gru_1_out_t1_7 + (-0.014237113296985626) * gru_1_out_t1_8 + (-0.4412478506565094) * gru_1_out_t1_9 + (0.70188301801681519) * gru_1_out_t1_10 + (0.89220064878463745) * gru_1_out_t1_11 + (-0.076577499508857727) * gru_1_out_t1_12 + (0.59953427314758301) * gru_1_out_t1_13 + (-0.16505110263824463) * gru_1_out_t1_14 + (-0.15051807463169098) * gru_1_out_t1_15 + (-0.33835408091545105) * gru_1_out_t1_16 + (0.057414378970861435) * gru_1_out_t1_17 + (0.015199053101241589) * gru_1_out_t1_18 + (-0.09961564838886261) * gru_1_out_t1_19 + (-0.19645173847675323) * gru_1_out_t1_20 + (-0.966450035572052) * gru_1_out_t1_21 + (-1.0676093101501465) * gru_1_out_t1_22 + (-0.14930357038974762) * gru_1_out_t1_23 + (-0.10879586637020111) * gru_1_out_t1_24 + (0.21218408644199371) * gru_1_out_t1_25 + (0.13776355981826782) * gru_1_out_t1_26 + (-0.7446589469909668) * gru_1_out_t1_27 + (0.012563435360789299) * gru_1_out_t1_28 + (-0.11505130678415298) * gru_1_out_t1_29 + (-0.4132002592086792) * gru_1_out_t1_30 + (-0.038513839244842529) * gru_1_out_t1_31 + (0.19250090420246124) * gru_1_out_t1_32 + (0.003691589692607522) * gru_1_out_t1_33 + (0.01416400633752346) * gru_1_out_t1_34 + (-0.023122232407331467) * gru_1_out_t1_35 + (0.46757680177688599) * gru_1_out_t1_36 + (0.26438876986503601) * gru_1_out_t1_37 + (-0.29630830883979797) * gru_1_out_t1_38 + (0.17613327503204346) * gru_1_out_t1_39 + (-0.47848695516586304) * gru_1_out_t1_40 + (0.25553932785987854) * gru_1_out_t1_41 + (-0.095339171588420868) * gru_1_out_t1_42 + (-0.5005536675453186) * gru_1_out_t1_43 + (0.04568839818239212) * gru_1_out_t1_44 + (-0.14408926665782928) * gru_1_out_t1_45 + (-0.25892436504364014) * gru_1_out_t1_46 + (-0.31659534573554993) * gru_1_out_t1_47 + (-0.28197717666625977) * gru_1_out_t1_48 + (-0.22800633311271667) * gru_1_out_t1_49 + (-0.060107801109552383) * gru_1_out_t1_50 + (0.53071242570877075) * gru_1_out_t1_51 + (0.022951638326048851) * gru_1_out_t1_52 + (0.49713540077209473) * gru_1_out_t1_53 + (-0.067836388945579529) * gru_1_out_t1_54 + (0.1441459059715271) * gru_1_out_t1_55 + (-0.29961711168289185) * gru_1_out_t1_56 + (0.27047809958457947) * gru_1_out_t1_57 + (0.34373384714126587) * gru_1_out_t1_58 + (-0.22454379498958588) * gru_1_out_t1_59 + (0.21046532690525055) * gru_1_out_t1_60 + (-0.12623761594295502) * gru_1_out_t1_61 + (-0.11237992346286774) * gru_1_out_t1_62 + (0.15872900187969208) * gru_1_out_t1_63 + (0.06585538387298584) * gru_2_rev_t2_h_0 + (-0.21263855695724487) * gru_2_rev_t2_h_1 + (0.062234785407781601) * gru_2_rev_t2_h_2 + (0.098807275295257568) * gru_2_rev_t2_h_3 + (0.090237736701965332) * gru_2_rev_t2_h_4 + (0.045356467366218567) * gru_2_rev_t2_h_5 + (-0.083613321185112) * gru_2_rev_t2_h_6 + (0.059361327439546585) * gru_2_rev_t2_h_7 + (-0.0066163288429379463) * gru_2_rev_t2_h_8 + (-0.09484158456325531) * gru_2_rev_t2_h_9 + (-0.012634100392460823) * gru_2_rev_t2_h_10 + (0.056857611984014511) * gru_2_rev_t2_h_11 + (0.026989905163645744) * gru_2_rev_t2_h_12 + (-0.024278335273265839) * gru_2_rev_t2_h_13 + (0.086821310222148895) * gru_2_rev_t2_h_14 + (-0.14916326105594635) * gru_2_rev_t2_h_15 + (0.14967982470989227) * gru_2_rev_t2_h_16 + (-0.10860808938741684) * gru_2_rev_t2_h_17 + (0.041316580027341843) * gru_2_rev_t2_h_18 + (-0.046468842774629593) * gru_2_rev_t2_h_19 + (0.048738617449998856) * gru_2_rev_t2_h_20 + (-0.10443969815969467) * gru_2_rev_t2_h_21 + (-0.021761341020464897) * gru_2_rev_t2_h_22 + (-0.03472345694899559) * gru_2_rev_t2_h_23 + (-0.031017456203699112) * gru_2_rev_t2_h_24 + (-0.048919092863798141) * gru_2_rev_t2_h_25 + (0.035284027457237244) * gru_2_rev_t2_h_26 + (0.15214991569519043) * gru_2_rev_t2_h_27 + (0.046012051403522491) * gru_2_rev_t2_h_28 + (-0.08867780864238739) * gru_2_rev_t2_h_29 + (-0.13330847024917603) * gru_2_rev_t2_h_30 + (0.12507927417755127) * gru_2_rev_t2_h_31);
    gate_z = sigmoid((-1.3921325206756592) + (-0.46470096707344055) * gru_1_out_t1_0 + (-2.1156003475189209) * gru_1_out_t1_1 + (0.060478080064058304) * gru_1_out_t1_2 + (-0.35111948847770691) * gru_1_out_t1_3 + (-0.095105811953544617) * gru_1_out_t1_4 + (1.0057213306427002) * gru_1_out_t1_5 + (-1.5084682703018188) * gru_1_out_t1_6 + (-0.13040368258953094) * gru_1_out_t1_7 + (0.39347079396247864) * gru_1_out_t1_8 + (0.75478160381317139) * gru_1_out_t1_9 + (-0.82380735874176025) * gru_1_out_t1_10 + (-1.1399995088577271) * gru_1_out_t1_11 + (-0.16595982015132904) * gru_1_out_t1_12 + (-0.67589902877807617) * gru_1_out_t1_13 + (-0.20026031136512756) * gru_1_out_t1_14 + (0.56006258726119995) * gru_1_out_t1_15 + (0.72086554765701294) * gru_1_out_t1_16 + (-0.18958888947963715) * gru_1_out_t1_17 + (-0.47306278347969055) * gru_1_out_t1_18 + (1.0188459157943726) * gru_1_out_t1_19 + (-0.29810440540313721) * gru_1_out_t1_20 + (0.22189198434352875) * gru_1_out_t1_21 + (0.55574345588684082) * gru_1_out_t1_22 + (-0.13205449283123016) * gru_1_out_t1_23 + (-0.35718655586242676) * gru_1_out_t1_24 + (-0.96330124139785767) * gru_1_out_t1_25 + (-0.75360596179962158) * gru_1_out_t1_26 + (0.54116439819335938) * gru_1_out_t1_27 + (-1.305051326751709) * gru_1_out_t1_28 + (0.42643880844116211) * gru_1_out_t1_29 + (-0.92045342922210693) * gru_1_out_t1_30 + (0.3979736864566803) * gru_1_out_t1_31 + (0.17125661671161652) * gru_1_out_t1_32 + (-1.042811393737793) * gru_1_out_t1_33 + (0.66535556316375732) * gru_1_out_t1_34 + (0.36175546050071716) * gru_1_out_t1_35 + (-0.4402947723865509) * gru_1_out_t1_36 + (0.61413741111755371) * gru_1_out_t1_37 + (0.61302840709686279) * gru_1_out_t1_38 + (0.3918837308883667) * gru_1_out_t1_39 + (0.25767457485198975) * gru_1_out_t1_40 + (-0.69124877452850342) * gru_1_out_t1_41 + (0.58335435390472412) * gru_1_out_t1_42 + (0.55161786079406738) * gru_1_out_t1_43 + (0.12522061169147491) * gru_1_out_t1_44 + (-0.11181087046861649) * gru_1_out_t1_45 + (2.159531831741333) * gru_1_out_t1_46 + (0.017564073204994202) * gru_1_out_t1_47 + (0.1454906165599823) * gru_1_out_t1_48 + (-0.56695204973220825) * gru_1_out_t1_49 + (1.5915021896362305) * gru_1_out_t1_50 + (-1.5736132860183716) * gru_1_out_t1_51 + (0.24534738063812256) * gru_1_out_t1_52 + (-0.30703070759773254) * gru_1_out_t1_53 + (0.36780580878257751) * gru_1_out_t1_54 + (-2.0540754795074463) * gru_1_out_t1_55 + (-0.13537156581878662) * gru_1_out_t1_56 + (-0.89596420526504517) * gru_1_out_t1_57 + (-0.64893847703933716) * gru_1_out_t1_58 + (0.47387993335723877) * gru_1_out_t1_59 + (-0.056359734386205673) * gru_1_out_t1_60 + (-0.99462097883224487) * gru_1_out_t1_61 + (0.45988431572914124) * gru_1_out_t1_62 + (-0.97053128480911255) * gru_1_out_t1_63 + (-0.11348219960927963) * gru_2_rev_t2_h_0 + (-0.034668043255805969) * gru_2_rev_t2_h_1 + (-0.065082356333732605) * gru_2_rev_t2_h_2 + (0.07624305784702301) * gru_2_rev_t2_h_3 + (0.030111780390143394) * gru_2_rev_t2_h_4 + (0.075298696756362915) * gru_2_rev_t2_h_5 + (0.0072362814098596573) * gru_2_rev_t2_h_6 + (0.027890009805560112) * gru_2_rev_t2_h_7 + (-0.23759549856185913) * gru_2_rev_t2_h_8 + (0.13622497022151947) * gru_2_rev_t2_h_9 + (0.10315735638141632) * gru_2_rev_t2_h_10 + (0.11271964758634567) * gru_2_rev_t2_h_11 + (0.018859652802348137) * gru_2_rev_t2_h_12 + (0.11739019304513931) * gru_2_rev_t2_h_13 + (-0.18711254000663757) * gru_2_rev_t2_h_14 + (-0.056472070515155792) * gru_2_rev_t2_h_15 + (0.088431417942047119) * gru_2_rev_t2_h_16 + (-0.060931190848350525) * gru_2_rev_t2_h_17 + (0.042161531746387482) * gru_2_rev_t2_h_18 + (0.13737089931964874) * gru_2_rev_t2_h_19 + (-0.08781876415014267) * gru_2_rev_t2_h_20 + (0.046648818999528885) * gru_2_rev_t2_h_21 + (-0.051431111991405487) * gru_2_rev_t2_h_22 + (0.14352579414844513) * gru_2_rev_t2_h_23 + (0.10322429984807968) * gru_2_rev_t2_h_24 + (-0.022386347874999046) * gru_2_rev_t2_h_25 + (-0.065196312963962555) * gru_2_rev_t2_h_26 + (0.14511337876319885) * gru_2_rev_t2_h_27 + (-0.053105633705854416) * gru_2_rev_t2_h_28 + (0.11722119152545929) * gru_2_rev_t2_h_29 + (-0.011492025107145309) * gru_2_rev_t2_h_30 + (-0.1086881086230278) * gru_2_rev_t2_h_31);
    gate_n = tanh((1.1684765815734863) + (1.2377455234527588) * gru_1_out_t1_0 + (0.50733327865600586) * gru_1_out_t1_1 + (-0.33478665351867676) * gru_1_out_t1_2 + (0.28292727470397949) * gru_1_out_t1_3 + (-0.09643930196762085) * gru_1_out_t1_4 + (-0.44746753573417664) * gru_1_out_t1_5 + (-0.83303982019424438) * gru_1_out_t1_6 + (-0.082652457058429718) * gru_1_out_t1_7 + (-0.61913812160491943) * gru_1_out_t1_8 + (-0.47819030284881592) * gru_1_out_t1_9 + (1.1612812280654907) * gru_1_out_t1_10 + (1.2244141101837158) * gru_1_out_t1_11 + (-0.12266942113637924) * gru_1_out_t1_12 + (1.2688999176025391) * gru_1_out_t1_13 + (-0.56391948461532593) * gru_1_out_t1_14 + (-0.31212633848190308) * gru_1_out_t1_15 + (-1.3423178195953369) * gru_1_out_t1_16 + (0.32007789611816406) * gru_1_out_t1_17 + (0.22307372093200684) * gru_1_out_t1_18 + (-0.18112547695636749) * gru_1_out_t1_19 + (-0.22403955459594727) * gru_1_out_t1_20 + (-1.4645984172821045) * gru_1_out_t1_21 + (-1.5797669887542725) * gru_1_out_t1_22 + (-0.0027466213796287775) * gru_1_out_t1_23 + (-0.33121103048324585) * gru_1_out_t1_24 + (0.60659617185592651) * gru_1_out_t1_25 + (0.87170422077178955) * gru_1_out_t1_26 + (-0.63913977146148682) * gru_1_out_t1_27 + (-0.13384413719177246) * gru_1_out_t1_28 + (0.0079132420942187309) * gru_1_out_t1_29 + (0.48802563548088074) * gru_1_out_t1_30 + (0.13155293464660645) * gru_1_out_t1_31 + (1.2055649757385254) * gru_1_out_t1_32 + (-0.0021215567830950022) * gru_1_out_t1_33 + (0.3706207275390625) * gru_1_out_t1_34 + (0.009538944810628891) * gru_1_out_t1_35 + (0.50592964887619019) * gru_1_out_t1_36 + (-0.22801586985588074) * gru_1_out_t1_37 + (-0.45687916874885559) * gru_1_out_t1_38 + (0.46728891134262085) * gru_1_out_t1_39 + (-0.51750838756561279) * gru_1_out_t1_40 + (0.82489621639251709) * gru_1_out_t1_41 + (-0.74061226844787598) * gru_1_out_t1_42 + (-0.35234114527702332) * gru_1_out_t1_43 + (-0.30583417415618896) * gru_1_out_t1_44 + (-0.29849964380264282) * gru_1_out_t1_45 + (-0.75306910276412964) * gru_1_out_t1_46 + (0.077699817717075348) * gru_1_out_t1_47 + (-0.24783900380134583) * gru_1_out_t1_48 + (0.1426175981760025) * gru_1_out_t1_49 + (-0.46229162812232971) * gru_1_out_t1_50 + (1.0247135162353516) * gru_1_out_t1_51 + (-0.16446982324123383) * gru_1_out_t1_52 + (0.7436555027961731) * gru_1_out_t1_53 + (0.68852472305297852) * gru_1_out_t1_54 + (0.68628937005996704) * gru_1_out_t1_55 + (-0.73677998781204224) * gru_1_out_t1_56 + (1.2082892656326294) * gru_1_out_t1_57 + (0.5530623197555542) * gru_1_out_t1_58 + (-0.52977859973907471) * gru_1_out_t1_59 + (0.0098874177783727646) * gru_1_out_t1_60 + (0.5398370623588562) * gru_1_out_t1_61 + (-0.20090523362159729) * gru_1_out_t1_62 + (0.42171388864517212) * gru_1_out_t1_63 + gate_r * ((1.1055328845977783) + (0.030431654304265976) * gru_2_rev_t2_h_0 + (-0.12106028944253922) * gru_2_rev_t2_h_1 + (0.12108079344034195) * gru_2_rev_t2_h_2 + (-0.12980499863624573) * gru_2_rev_t2_h_3 + (-0.06788305938243866) * gru_2_rev_t2_h_4 + (0.019855665042996407) * gru_2_rev_t2_h_5 + (0.048371415585279465) * gru_2_rev_t2_h_6 + (-0.061583425849676132) * gru_2_rev_t2_h_7 + (-0.073437266051769257) * gru_2_rev_t2_h_8 + (-0.085074983537197113) * gru_2_rev_t2_h_9 + (0.13582487404346466) * gru_2_rev_t2_h_10 + (-0.060779612511396408) * gru_2_rev_t2_h_11 + (-0.029164565727114677) * gru_2_rev_t2_h_12 + (-0.2332465648651123) * gru_2_rev_t2_h_13 + (0.11717985570430756) * gru_2_rev_t2_h_14 + (0.15151029825210571) * gru_2_rev_t2_h_15 + (-0.075514763593673706) * gru_2_rev_t2_h_16 + (0.025081455707550049) * gru_2_rev_t2_h_17 + (0.055312011390924454) * gru_2_rev_t2_h_18 + (-0.21438382565975189) * gru_2_rev_t2_h_19 + (-0.073139242827892303) * gru_2_rev_t2_h_20 + (-0.0581028051674366) * gru_2_rev_t2_h_21 + (-0.22342260181903839) * gru_2_rev_t2_h_22 + (-0.054335847496986389) * gru_2_rev_t2_h_23 + (-0.090474121272563934) * gru_2_rev_t2_h_24 + (-0.072413861751556396) * gru_2_rev_t2_h_25 + (-0.1000584214925766) * gru_2_rev_t2_h_26 + (-0.15322104096412659) * gru_2_rev_t2_h_27 + (0.14258332550525665) * gru_2_rev_t2_h_28 + (0.047664642333984375) * gru_2_rev_t2_h_29 + (0.1741226464509964) * gru_2_rev_t2_h_30 + (-0.0052778436802327633) * gru_2_rev_t2_h_31));
    gru_2_rev_t1_h_0 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t2_h_0;
    // h=1
    gate_r = sigmoid((0.40324199199676514) + (0.40218713879585266) * gru_1_out_t1_0 + (5.2115669250488281) * gru_1_out_t1_1 + (-0.70570802688598633) * gru_1_out_t1_2 + (0.30680185556411743) * gru_1_out_t1_3 + (1.7273051738739014) * gru_1_out_t1_4 + (0.8151240348815918) * gru_1_out_t1_5 + (-7.0190286636352539) * gru_1_out_t1_6 + (0.58135479688644409) * gru_1_out_t1_7 + (-1.8308714628219604) * gru_1_out_t1_8 + (-0.3579103946685791) * gru_1_out_t1_9 + (-1.3849482536315918) * gru_1_out_t1_10 + (-1.5870563983917236) * gru_1_out_t1_11 + (0.19850346446037292) * gru_1_out_t1_12 + (-4.5030040740966797) * gru_1_out_t1_13 + (1.2711187601089478) * gru_1_out_t1_14 + (-0.095055639743804932) * gru_1_out_t1_15 + (-0.44191166758537292) * gru_1_out_t1_16 + (-2.9218907356262207) * gru_1_out_t1_17 + (-1.0155858993530273) * gru_1_out_t1_18 + (-1.5717204809188843) * gru_1_out_t1_19 + (0.70350515842437744) * gru_1_out_t1_20 + (0.86513024568557739) * gru_1_out_t1_21 + (3.6216592788696289) * gru_1_out_t1_22 + (-0.30964350700378418) * gru_1_out_t1_23 + (-1.8175325393676758) * gru_1_out_t1_24 + (-0.61928403377532959) * gru_1_out_t1_25 + (-0.96123510599136353) * gru_1_out_t1_26 + (1.9340059757232666) * gru_1_out_t1_27 + (-1.4684387445449829) * gru_1_out_t1_28 + (1.1932697296142578) * gru_1_out_t1_29 + (2.0674240589141846) * gru_1_out_t1_30 + (0.45325496792793274) * gru_1_out_t1_31 + (2.2853612899780273) * gru_1_out_t1_32 + (1.8988642692565918) * gru_1_out_t1_33 + (-3.9292933940887451) * gru_1_out_t1_34 + (0.43228980898857117) * gru_1_out_t1_35 + (0.51681393384933472) * gru_1_out_t1_36 + (-1.5535457134246826) * gru_1_out_t1_37 + (-0.39237374067306519) * gru_1_out_t1_38 + (0.8425859808921814) * gru_1_out_t1_39 + (-0.99747633934020996) * gru_1_out_t1_40 + (0.14213645458221436) * gru_1_out_t1_41 + (-3.1373646259307861) * gru_1_out_t1_42 + (3.5879786014556885) * gru_1_out_t1_43 + (-0.35185083746910095) * gru_1_out_t1_44 + (0.25657889246940613) * gru_1_out_t1_45 + (1.053300142288208) * gru_1_out_t1_46 + (-0.33528706431388855) * gru_1_out_t1_47 + (0.69544368982315063) * gru_1_out_t1_48 + (-1.1668065786361694) * gru_1_out_t1_49 + (-1.8759716749191284) * gru_1_out_t1_50 + (-0.30689886212348938) * gru_1_out_t1_51 + (-1.0600677728652954) * gru_1_out_t1_52 + (2.6282129287719727) * gru_1_out_t1_53 + (6.3252387046813965) * gru_1_out_t1_54 + (-0.39752143621444702) * gru_1_out_t1_55 + (0.47132959961891174) * gru_1_out_t1_56 + (0.21888193488121033) * gru_1_out_t1_57 + (-0.73627537488937378) * gru_1_out_t1_58 + (-0.6785653829574585) * gru_1_out_t1_59 + (-1.5664225816726685) * gru_1_out_t1_60 + (-8.524165153503418) * gru_1_out_t1_61 + (-1.6637002229690552) * gru_1_out_t1_62 + (0.19450388848781586) * gru_1_out_t1_63 + (0.076560795307159424) * gru_2_rev_t2_h_0 + (0.12301125377416611) * gru_2_rev_t2_h_1 + (0.075263127684593201) * gru_2_rev_t2_h_2 + (-0.02510538324713707) * gru_2_rev_t2_h_3 + (0.28701475262641907) * gru_2_rev_t2_h_4 + (-0.030108749866485596) * gru_2_rev_t2_h_5 + (-0.033577907830476761) * gru_2_rev_t2_h_6 + (-0.16234783828258514) * gru_2_rev_t2_h_7 + (0.15398058295249939) * gru_2_rev_t2_h_8 + (-0.0099998330697417259) * gru_2_rev_t2_h_9 + (0.072998605668544769) * gru_2_rev_t2_h_10 + (0.092656657099723816) * gru_2_rev_t2_h_11 + (-0.26627624034881592) * gru_2_rev_t2_h_12 + (-0.21550674736499786) * gru_2_rev_t2_h_13 + (0.041150100529193878) * gru_2_rev_t2_h_14 + (0.11159764975309372) * gru_2_rev_t2_h_15 + (0.13338296115398407) * gru_2_rev_t2_h_16 + (-0.059432584792375565) * gru_2_rev_t2_h_17 + (0.071897923946380615) * gru_2_rev_t2_h_18 + (-0.10489677637815475) * gru_2_rev_t2_h_19 + (-0.029407460242509842) * gru_2_rev_t2_h_20 + (0.064393401145935059) * gru_2_rev_t2_h_21 + (-0.1555418074131012) * gru_2_rev_t2_h_22 + (-0.0087029961869120598) * gru_2_rev_t2_h_23 + (0.12089976668357849) * gru_2_rev_t2_h_24 + (0.029705408960580826) * gru_2_rev_t2_h_25 + (-0.13553057610988617) * gru_2_rev_t2_h_26 + (-0.054078299552202225) * gru_2_rev_t2_h_27 + (0.1082586869597435) * gru_2_rev_t2_h_28 + (0.19199822843074799) * gru_2_rev_t2_h_29 + (-0.0053758672438561916) * gru_2_rev_t2_h_30 + (0.11791533976793289) * gru_2_rev_t2_h_31);
    gate_z = sigmoid((1.3999652862548828) + (0.018097430467605591) * gru_1_out_t1_0 + (1.8321627378463745) * gru_1_out_t1_1 + (-0.81991982460021973) * gru_1_out_t1_2 + (-0.025493241846561432) * gru_1_out_t1_3 + (0.40076214075088501) * gru_1_out_t1_4 + (0.14022400975227356) * gru_1_out_t1_5 + (3.4800295829772949) * gru_1_out_t1_6 + (-0.28562042117118835) * gru_1_out_t1_7 + (0.25554677844047546) * gru_1_out_t1_8 + (-0.41741827130317688) * gru_1_out_t1_9 + (1.1523773670196533) * gru_1_out_t1_10 + (0.86747682094573975) * gru_1_out_t1_11 + (0.36717307567596436) * gru_1_out_t1_12 + (1.8306533098220825) * gru_1_out_t1_13 + (0.0040320991538465023) * gru_1_out_t1_14 + (0.12677678465843201) * gru_1_out_t1_15 + (-0.87672722339630127) * gru_1_out_t1_16 + (-0.78071379661560059) * gru_1_out_t1_17 + (0.64997923374176025) * gru_1_out_t1_18 + (0.545074462890625) * gru_1_out_t1_19 + (0.084302313625812531) * gru_1_out_t1_20 + (0.19162769615650177) * gru_1_out_t1_21 + (-1.6733652353286743) * gru_1_out_t1_22 + (-1.8038668632507324) * gru_1_out_t1_23 + (4.2510857582092285) * gru_1_out_t1_24 + (0.28173857927322388) * gru_1_out_t1_25 + (-0.21791158616542816) * gru_1_out_t1_26 + (0.13296425342559814) * gru_1_out_t1_27 + (0.48844817280769348) * gru_1_out_t1_28 + (0.22666299343109131) * gru_1_out_t1_29 + (0.096792563796043396) * gru_1_out_t1_30 + (0.46592763066291809) * gru_1_out_t1_31 + (2.4051029682159424) * gru_1_out_t1_32 + (1.5044683218002319) * gru_1_out_t1_33 + (-0.31116020679473877) * gru_1_out_t1_34 + (-0.82594650983810425) * gru_1_out_t1_35 + (0.28801658749580383) * gru_1_out_t1_36 + (0.36452829837799072) * gru_1_out_t1_37 + (-0.6232416033744812) * gru_1_out_t1_38 + (2.7905964851379395) * gru_1_out_t1_39 + (-0.29475635290145874) * gru_1_out_t1_40 + (0.8480602502822876) * gru_1_out_t1_41 + (-0.19405852258205414) * gru_1_out_t1_42 + (-1.9556084871292114) * gru_1_out_t1_43 + (-0.55930209159851074) * gru_1_out_t1_44 + (-0.95021498203277588) * gru_1_out_t1_45 + (-0.20935350656509399) * gru_1_out_t1_46 + (-0.36345192790031433) * gru_1_out_t1_47 + (-0.5816500186920166) * gru_1_out_t1_48 + (-1.000356912612915) * gru_1_out_t1_49 + (-0.51426297426223755) * gru_1_out_t1_50 + (-0.34150519967079163) * gru_1_out_t1_51 + (0.067490436136722565) * gru_1_out_t1_52 + (-0.35003450512886047) * gru_1_out_t1_53 + (1.5664207935333252) * gru_1_out_t1_54 + (-0.24337242543697357) * gru_1_out_t1_55 + (-0.24732290208339691) * gru_1_out_t1_56 + (0.40305551886558533) * gru_1_out_t1_57 + (0.21888306736946106) * gru_1_out_t1_58 + (-2.9140565395355225) * gru_1_out_t1_59 + (-2.0703482627868652) * gru_1_out_t1_60 + (0.43237611651420593) * gru_1_out_t1_61 + (2.327183723449707) * gru_1_out_t1_62 + (0.44206774234771729) * gru_1_out_t1_63 + (-0.045828070491552353) * gru_2_rev_t2_h_0 + (0.030080238357186317) * gru_2_rev_t2_h_1 + (0.030025888234376907) * gru_2_rev_t2_h_2 + (-0.02169809490442276) * gru_2_rev_t2_h_3 + (0.067256532609462738) * gru_2_rev_t2_h_4 + (-0.19249165058135986) * gru_2_rev_t2_h_5 + (-0.056731753051280975) * gru_2_rev_t2_h_6 + (0.1042134016752243) * gru_2_rev_t2_h_7 + (0.099740602076053619) * gru_2_rev_t2_h_8 + (-0.051003124564886093) * gru_2_rev_t2_h_9 + (-0.024245385080575943) * gru_2_rev_t2_h_10 + (0.16235671937465668) * gru_2_rev_t2_h_11 + (0.091050118207931519) * gru_2_rev_t2_h_12 + (-0.10850253701210022) * gru_2_rev_t2_h_13 + (-0.013819988816976547) * gru_2_rev_t2_h_14 + (-0.031347375363111496) * gru_2_rev_t2_h_15 + (0.17025190591812134) * gru_2_rev_t2_h_16 + (-0.046231012791395187) * gru_2_rev_t2_h_17 + (0.14066672325134277) * gru_2_rev_t2_h_18 + (0.0076002241112291813) * gru_2_rev_t2_h_19 + (-0.11934705078601837) * gru_2_rev_t2_h_20 + (-0.07979515939950943) * gru_2_rev_t2_h_21 + (0.13091672956943512) * gru_2_rev_t2_h_22 + (-0.16041195392608643) * gru_2_rev_t2_h_23 + (-0.069496840238571167) * gru_2_rev_t2_h_24 + (-0.073927029967308044) * gru_2_rev_t2_h_25 + (0.049814697355031967) * gru_2_rev_t2_h_26 + (0.049617964774370193) * gru_2_rev_t2_h_27 + (-0.014773665927350521) * gru_2_rev_t2_h_28 + (-0.017133943736553192) * gru_2_rev_t2_h_29 + (0.085632145404815674) * gru_2_rev_t2_h_30 + (-0.084208495914936066) * gru_2_rev_t2_h_31);
    gate_n = tanh((0.14778958261013031) + (-0.84879815578460693) * gru_1_out_t1_0 + (0.21775712072849274) * gru_1_out_t1_1 + (-0.83193045854568481) * gru_1_out_t1_2 + (-0.062793359160423279) * gru_1_out_t1_3 + (-0.87516450881958008) * gru_1_out_t1_4 + (1.7858936786651611) * gru_1_out_t1_5 + (-1.6785008907318115) * gru_1_out_t1_6 + (-0.068480461835861206) * gru_1_out_t1_7 + (0.28859004378318787) * gru_1_out_t1_8 + (-0.13369420170783997) * gru_1_out_t1_9 + (-0.38524651527404785) * gru_1_out_t1_10 + (0.25300323963165283) * gru_1_out_t1_11 + (-0.46257320046424866) * gru_1_out_t1_12 + (-2.1287674903869629) * gru_1_out_t1_13 + (0.51931852102279663) * gru_1_out_t1_14 + (-0.47371432185173035) * gru_1_out_t1_15 + (-0.095402605831623077) * gru_1_out_t1_16 + (0.12561261653900146) * gru_1_out_t1_17 + (0.037432890385389328) * gru_1_out_t1_18 + (0.31818607449531555) * gru_1_out_t1_19 + (-0.047760363668203354) * gru_1_out_t1_20 + (-0.931427001953125) * gru_1_out_t1_21 + (0.45836856961250305) * gru_1_out_t1_22 + (-0.33370819687843323) * gru_1_out_t1_23 + (1.4542109966278076) * gru_1_out_t1_24 + (0.60134059190750122) * gru_1_out_t1_25 + (0.2319013923406601) * gru_1_out_t1_26 + (0.15740090608596802) * gru_1_out_t1_27 + (-1.1114780902862549) * gru_1_out_t1_28 + (0.79923593997955322) * gru_1_out_t1_29 + (-0.56488144397735596) * gru_1_out_t1_30 + (-0.012367859482765198) * gru_1_out_t1_31 + (-4.6894345283508301) * gru_1_out_t1_32 + (-2.0846836566925049) * gru_1_out_t1_33 + (-1.3443083763122559) * gru_1_out_t1_34 + (-1.1210439205169678) * gru_1_out_t1_35 + (0.33449572324752808) * gru_1_out_t1_36 + (0.3731989860534668) * gru_1_out_t1_37 + (-0.35391384363174438) * gru_1_out_t1_38 + (0.93777745962142944) * gru_1_out_t1_39 + (-0.333263099193573) * gru_1_out_t1_40 + (0.16755309700965881) * gru_1_out_t1_41 + (1.0138695240020752) * gru_1_out_t1_42 + (0.19247926771640778) * gru_1_out_t1_43 + (-1.3082013130187988) * gru_1_out_t1_44 + (2.2201850414276123) * gru_1_out_t1_45 + (-0.8986821174621582) * gru_1_out_t1_46 + (-0.12701296806335449) * gru_1_out_t1_47 + (-0.85068041086196899) * gru_1_out_t1_48 + (-0.61266547441482544) * gru_1_out_t1_49 + (-0.071919761598110199) * gru_1_out_t1_50 + (0.90648549795150757) * gru_1_out_t1_51 + (0.41736942529678345) * gru_1_out_t1_52 + (-0.14345827698707581) * gru_1_out_t1_53 + (-3.259005069732666) * gru_1_out_t1_54 + (0.41526469588279724) * gru_1_out_t1_55 + (-1.0991966724395752) * gru_1_out_t1_56 + (-0.22304478287696838) * gru_1_out_t1_57 + (0.25713464617729187) * gru_1_out_t1_58 + (-0.64567661285400391) * gru_1_out_t1_59 + (-1.59873366355896) * gru_1_out_t1_60 + (-1.9797120094299316) * gru_1_out_t1_61 + (-1.3418761491775513) * gru_1_out_t1_62 + (0.60350030660629272) * gru_1_out_t1_63 + gate_r * ((-1.6442499160766602) + (0.092136755585670471) * gru_2_rev_t2_h_0 + (-0.080264352262020111) * gru_2_rev_t2_h_1 + (-0.098788894712924957) * gru_2_rev_t2_h_2 + (0.11525224894285202) * gru_2_rev_t2_h_3 + (-0.061831500381231308) * gru_2_rev_t2_h_4 + (-0.14284579455852509) * gru_2_rev_t2_h_5 + (-0.058358646929264069) * gru_2_rev_t2_h_6 + (-0.046611707657575607) * gru_2_rev_t2_h_7 + (0.048343021422624588) * gru_2_rev_t2_h_8 + (-0.05713416263461113) * gru_2_rev_t2_h_9 + (-0.11897437274456024) * gru_2_rev_t2_h_10 + (0.020850656554102898) * gru_2_rev_t2_h_11 + (0.034210465848445892) * gru_2_rev_t2_h_12 + (-0.14357583224773407) * gru_2_rev_t2_h_13 + (0.065098442137241364) * gru_2_rev_t2_h_14 + (-0.11526975035667419) * gru_2_rev_t2_h_15 + (0.025390466675162315) * gru_2_rev_t2_h_16 + (-0.050830859690904617) * gru_2_rev_t2_h_17 + (-0.052270963788032532) * gru_2_rev_t2_h_18 + (0.079667359590530396) * gru_2_rev_t2_h_19 + (0.11192000657320023) * gru_2_rev_t2_h_20 + (0.041839778423309326) * gru_2_rev_t2_h_21 + (-0.18368420004844666) * gru_2_rev_t2_h_22 + (-0.1465686708688736) * gru_2_rev_t2_h_23 + (-0.23816676437854767) * gru_2_rev_t2_h_24 + (0.083737500011920929) * gru_2_rev_t2_h_25 + (-0.21454684436321259) * gru_2_rev_t2_h_26 + (0.069612637162208557) * gru_2_rev_t2_h_27 + (0.1288607269525528) * gru_2_rev_t2_h_28 + (-0.010626503266394138) * gru_2_rev_t2_h_29 + (0.017025137320160866) * gru_2_rev_t2_h_30 + (0.062989778816699982) * gru_2_rev_t2_h_31));
    gru_2_rev_t1_h_1 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t2_h_1;
    // h=2
    gate_r = sigmoid((-0.87663215398788452) + (-0.43290671706199646) * gru_1_out_t1_0 + (-0.37159848213195801) * gru_1_out_t1_1 + (0.066734969615936279) * gru_1_out_t1_2 + (0.70254260301589966) * gru_1_out_t1_3 + (0.67383986711502075) * gru_1_out_t1_4 + (0.13154175877571106) * gru_1_out_t1_5 + (-0.78778344392776489) * gru_1_out_t1_6 + (0.5931929349899292) * gru_1_out_t1_7 + (1.1162482500076294) * gru_1_out_t1_8 + (-0.40366208553314209) * gru_1_out_t1_9 + (-0.13312716782093048) * gru_1_out_t1_10 + (-0.52457773685455322) * gru_1_out_t1_11 + (-0.837482750415802) * gru_1_out_t1_12 + (-4.2968454360961914) * gru_1_out_t1_13 + (0.34230160713195801) * gru_1_out_t1_14 + (0.33264735341072083) * gru_1_out_t1_15 + (0.61678123474121094) * gru_1_out_t1_16 + (-1.5318697690963745) * gru_1_out_t1_17 + (0.58053457736968994) * gru_1_out_t1_18 + (-2.0133047103881836) * gru_1_out_t1_19 + (0.48919248580932617) * gru_1_out_t1_20 + (-1.0173903703689575) * gru_1_out_t1_21 + (0.64181405305862427) * gru_1_out_t1_22 + (1.4770562648773193) * gru_1_out_t1_23 + (-3.2719776630401611) * gru_1_out_t1_24 + (1.4028137922286987) * gru_1_out_t1_25 + (-0.31524422764778137) * gru_1_out_t1_26 + (1.4483044147491455) * gru_1_out_t1_27 + (-1.1325132846832275) * gru_1_out_t1_28 + (0.01917867548763752) * gru_1_out_t1_29 + (0.64395433664321899) * gru_1_out_t1_30 + (-0.26304703950881958) * gru_1_out_t1_31 + (-0.22695474326610565) * gru_1_out_t1_32 + (0.83482956886291504) * gru_1_out_t1_33 + (-1.4011886119842529) * gru_1_out_t1_34 + (1.7859117984771729) * gru_1_out_t1_35 + (0.71755886077880859) * gru_1_out_t1_36 + (-0.62422209978103638) * gru_1_out_t1_37 + (0.072583071887493134) * gru_1_out_t1_38 + (-1.3875012397766113) * gru_1_out_t1_39 + (0.71221953630447388) * gru_1_out_t1_40 + (0.28215909004211426) * gru_1_out_t1_41 + (-1.7307727336883545) * gru_1_out_t1_42 + (0.53417837619781494) * gru_1_out_t1_43 + (0.66773229837417603) * gru_1_out_t1_44 + (3.8776226043701172) * gru_1_out_t1_45 + (0.99221277236938477) * gru_1_out_t1_46 + (0.33239570260047913) * gru_1_out_t1_47 + (-0.30107364058494568) * gru_1_out_t1_48 + (-0.11625137180089951) * gru_1_out_t1_49 + (-0.79322808980941772) * gru_1_out_t1_50 + (-0.096322983503341675) * gru_1_out_t1_51 + (-1.6167439222335815) * gru_1_out_t1_52 + (-2.1548392772674561) * gru_1_out_t1_53 + (-0.18232846260070801) * gru_1_out_t1_54 + (0.056101113557815552) * gru_1_out_t1_55 + (-0.10542170703411102) * gru_1_out_t1_56 + (-0.075356252491474152) * gru_1_out_t1_57 + (-1.5225090980529785) * gru_1_out_t1_58 + (-0.3948168158531189) * gru_1_out_t1_59 + (-1.1637367010116577) * gru_1_out_t1_60 + (0.78459388017654419) * gru_1_out_t1_61 + (-1.1643588542938232) * gru_1_out_t1_62 + (-1.109355092048645) * gru_1_out_t1_63 + (0.016105441376566887) * gru_2_rev_t2_h_0 + (-0.13975894451141357) * gru_2_rev_t2_h_1 + (0.018100906163454056) * gru_2_rev_t2_h_2 + (0.042917266488075256) * gru_2_rev_t2_h_3 + (0.22165702283382416) * gru_2_rev_t2_h_4 + (0.10262973606586456) * gru_2_rev_t2_h_5 + (0.21511448919773102) * gru_2_rev_t2_h_6 + (-0.062452327460050583) * gru_2_rev_t2_h_7 + (-0.17368735373020172) * gru_2_rev_t2_h_8 + (0.069950900971889496) * gru_2_rev_t2_h_9 + (-0.12925541400909424) * gru_2_rev_t2_h_10 + (0.13091151416301727) * gru_2_rev_t2_h_11 + (0.07951730489730835) * gru_2_rev_t2_h_12 + (-0.041110508143901825) * gru_2_rev_t2_h_13 + (-0.026207340881228447) * gru_2_rev_t2_h_14 + (0.036849401891231537) * gru_2_rev_t2_h_15 + (0.08464706689119339) * gru_2_rev_t2_h_16 + (0.054092183709144592) * gru_2_rev_t2_h_17 + (-0.13166733086109161) * gru_2_rev_t2_h_18 + (-0.047418057918548584) * gru_2_rev_t2_h_19 + (-0.040743321180343628) * gru_2_rev_t2_h_20 + (-0.0097445948049426079) * gru_2_rev_t2_h_21 + (0.14114251732826233) * gru_2_rev_t2_h_22 + (0.14814217388629913) * gru_2_rev_t2_h_23 + (-0.13380751013755798) * gru_2_rev_t2_h_24 + (0.034522749483585358) * gru_2_rev_t2_h_25 + (0.044992711395025253) * gru_2_rev_t2_h_26 + (-0.0005133054219186306) * gru_2_rev_t2_h_27 + (-0.040130231529474258) * gru_2_rev_t2_h_28 + (-0.21751700341701508) * gru_2_rev_t2_h_29 + (0.023673592135310173) * gru_2_rev_t2_h_30 + (-0.016596212983131409) * gru_2_rev_t2_h_31);
    gate_z = sigmoid((0.53210854530334473) + (0.25790563225746155) * gru_1_out_t1_0 + (0.037837691605091095) * gru_1_out_t1_1 + (0.62299072742462158) * gru_1_out_t1_2 + (0.32528731226921082) * gru_1_out_t1_3 + (-0.21904878318309784) * gru_1_out_t1_4 + (0.13750500977039337) * gru_1_out_t1_5 + (1.1905393600463867) * gru_1_out_t1_6 + (-0.15628995001316071) * gru_1_out_t1_7 + (0.60344201326370239) * gru_1_out_t1_8 + (-0.79426091909408569) * gru_1_out_t1_9 + (0.036067549139261246) * gru_1_out_t1_10 + (-0.28452682495117188) * gru_1_out_t1_11 + (0.28202760219573975) * gru_1_out_t1_12 + (-0.40662521123886108) * gru_1_out_t1_13 + (1.0533654689788818) * gru_1_out_t1_14 + (-0.66187673807144165) * gru_1_out_t1_15 + (-0.036246128380298615) * gru_1_out_t1_16 + (0.044397104531526566) * gru_1_out_t1_17 + (0.41182208061218262) * gru_1_out_t1_18 + (0.93084365129470825) * gru_1_out_t1_19 + (0.74250674247741699) * gru_1_out_t1_20 + (1.108551025390625) * gru_1_out_t1_21 + (0.053581651300191879) * gru_1_out_t1_22 + (2.0355503559112549) * gru_1_out_t1_23 + (-0.82474929094314575) * gru_1_out_t1_24 + (1.1082543134689331) * gru_1_out_t1_25 + (-0.8894926905632019) * gru_1_out_t1_26 + (-0.64190965890884399) * gru_1_out_t1_27 + (1.5894565582275391) * gru_1_out_t1_28 + (0.14679057896137238) * gru_1_out_t1_29 + (0.80881989002227783) * gru_1_out_t1_30 + (-0.24983207881450653) * gru_1_out_t1_31 + (-1.4763590097427368) * gru_1_out_t1_32 + (0.32510071992874146) * gru_1_out_t1_33 + (-0.84862339496612549) * gru_1_out_t1_34 + (-0.63561612367630005) * gru_1_out_t1_35 + (2.2236695289611816) * gru_1_out_t1_36 + (-0.14978724718093872) * gru_1_out_t1_37 + (-1.8496595621109009) * gru_1_out_t1_38 + (1.3935931921005249) * gru_1_out_t1_39 + (-1.0657377243041992) * gru_1_out_t1_40 + (1.4313197135925293) * gru_1_out_t1_41 + (-1.7470688819885254) * gru_1_out_t1_42 + (-1.1925764083862305) * gru_1_out_t1_43 + (0.23793159425258636) * gru_1_out_t1_44 + (-1.9579236507415771) * gru_1_out_t1_45 + (-0.13880884647369385) * gru_1_out_t1_46 + (0.51279544830322266) * gru_1_out_t1_47 + (-1.2743618488311768) * gru_1_out_t1_48 + (-0.93052816390991211) * gru_1_out_t1_49 + (-2.1408622264862061) * gru_1_out_t1_50 + (-0.89114683866500854) * gru_1_out_t1_51 + (1.1195292472839355) * gru_1_out_t1_52 + (1.6933690309524536) * gru_1_out_t1_53 + (-0.35413035750389099) * gru_1_out_t1_54 + (0.29228517413139343) * gru_1_out_t1_55 + (1.0418961048126221) * gru_1_out_t1_56 + (0.36952418088912964) * gru_1_out_t1_57 + (1.0984258651733398) * gru_1_out_t1_58 + (0.14420531690120697) * gru_1_out_t1_59 + (-2.68251633644104) * gru_1_out_t1_60 + (0.92842292785644531) * gru_1_out_t1_61 + (-1.2042216062545776) * gru_1_out_t1_62 + (0.8191872239112854) * gru_1_out_t1_63 + (0.02206464484333992) * gru_2_rev_t2_h_0 + (-0.031511552631855011) * gru_2_rev_t2_h_1 + (-0.068501576781272888) * gru_2_rev_t2_h_2 + (0.070489130914211273) * gru_2_rev_t2_h_3 + (-0.12679854035377502) * gru_2_rev_t2_h_4 + (0.051602613180875778) * gru_2_rev_t2_h_5 + (-0.027262110263109207) * gru_2_rev_t2_h_6 + (0.12319481372833252) * gru_2_rev_t2_h_7 + (0.06026647612452507) * gru_2_rev_t2_h_8 + (0.022861266508698463) * gru_2_rev_t2_h_9 + (-0.055479485541582108) * gru_2_rev_t2_h_10 + (-0.051489897072315216) * gru_2_rev_t2_h_11 + (-0.084513269364833832) * gru_2_rev_t2_h_12 + (-0.067214928567409515) * gru_2_rev_t2_h_13 + (-0.072003640234470367) * gru_2_rev_t2_h_14 + (-0.16471190750598907) * gru_2_rev_t2_h_15 + (0.16038064658641815) * gru_2_rev_t2_h_16 + (0.12691937386989594) * gru_2_rev_t2_h_17 + (-0.21381346881389618) * gru_2_rev_t2_h_18 + (0.033603981137275696) * gru_2_rev_t2_h_19 + (0.154815673828125) * gru_2_rev_t2_h_20 + (0.074791647493839264) * gru_2_rev_t2_h_21 + (-0.0801195427775383) * gru_2_rev_t2_h_22 + (-0.1198994517326355) * gru_2_rev_t2_h_23 + (0.038981989026069641) * gru_2_rev_t2_h_24 + (0.085973426699638367) * gru_2_rev_t2_h_25 + (-0.18400537967681885) * gru_2_rev_t2_h_26 + (-0.036580167710781097) * gru_2_rev_t2_h_27 + (-0.043450482189655304) * gru_2_rev_t2_h_28 + (0.25423654913902283) * gru_2_rev_t2_h_29 + (0.027980966493487358) * gru_2_rev_t2_h_30 + (-0.0033618472516536713) * gru_2_rev_t2_h_31);
    gate_n = tanh((0.26977014541625977) + (0.14536136388778687) * gru_1_out_t1_0 + (0.64221030473709106) * gru_1_out_t1_1 + (-0.38113078474998474) * gru_1_out_t1_2 + (-0.51085561513900757) * gru_1_out_t1_3 + (-0.17018377780914307) * gru_1_out_t1_4 + (-0.34443825483322144) * gru_1_out_t1_5 + (0.085300639271736145) * gru_1_out_t1_6 + (-0.21806220710277557) * gru_1_out_t1_7 + (-1.907280445098877) * gru_1_out_t1_8 + (-0.54759633541107178) * gru_1_out_t1_9 + (0.2858336865901947) * gru_1_out_t1_10 + (-0.72326749563217163) * gru_1_out_t1_11 + (-0.30244180560112) * gru_1_out_t1_12 + (3.5567548274993896) * gru_1_out_t1_13 + (-0.662833571434021) * gru_1_out_t1_14 + (-0.19308660924434662) * gru_1_out_t1_15 + (-0.35196158289909363) * gru_1_out_t1_16 + (-0.22341875731945038) * gru_1_out_t1_17 + (1.0848381519317627) * gru_1_out_t1_18 + (-0.023234190419316292) * gru_1_out_t1_19 + (0.34024783968925476) * gru_1_out_t1_20 + (1.443638801574707) * gru_1_out_t1_21 + (-0.35222136974334717) * gru_1_out_t1_22 + (-0.063109681010246277) * gru_1_out_t1_23 + (2.7059621810913086) * gru_1_out_t1_24 + (-1.5548141002655029) * gru_1_out_t1_25 + (0.15242920815944672) * gru_1_out_t1_26 + (0.17113777995109558) * gru_1_out_t1_27 + (-1.5963977575302124) * gru_1_out_t1_28 + (-0.66722995042800903) * gru_1_out_t1_29 + (-0.081094399094581604) * gru_1_out_t1_30 + (0.40646669268608093) * gru_1_out_t1_31 + (0.60694831609725952) * gru_1_out_t1_32 + (0.37382760643959045) * gru_1_out_t1_33 + (0.34520292282104492) * gru_1_out_t1_34 + (-0.75388967990875244) * gru_1_out_t1_35 + (-2.0804729461669922) * gru_1_out_t1_36 + (0.2479570209980011) * gru_1_out_t1_37 + (0.72240757942199707) * gru_1_out_t1_38 + (-0.038849271833896637) * gru_1_out_t1_39 + (-1.0809643268585205) * gru_1_out_t1_40 + (-0.80836039781570435) * gru_1_out_t1_41 + (1.8011984825134277) * gru_1_out_t1_42 + (0.49946928024291992) * gru_1_out_t1_43 + (-0.48007556796073914) * gru_1_out_t1_44 + (-1.1845120191574097) * gru_1_out_t1_45 + (0.50091749429702759) * gru_1_out_t1_46 + (-0.57718026638031006) * gru_1_out_t1_47 + (0.40696650743484497) * gru_1_out_t1_48 + (0.24324879050254822) * gru_1_out_t1_49 + (0.7256360650062561) * gru_1_out_t1_50 + (-0.99883776903152466) * gru_1_out_t1_51 + (-0.20970696210861206) * gru_1_out_t1_52 + (1.3452894687652588) * gru_1_out_t1_53 + (-0.1834561675786972) * gru_1_out_t1_54 + (-0.01399184949696064) * gru_1_out_t1_55 + (0.3557070791721344) * gru_1_out_t1_56 + (0.22042089700698853) * gru_1_out_t1_57 + (0.95215332508087158) * gru_1_out_t1_58 + (0.903797447681427) * gru_1_out_t1_59 + (-0.020250625908374786) * gru_1_out_t1_60 + (-0.35030144453048706) * gru_1_out_t1_61 + (0.5838320255279541) * gru_1_out_t1_62 + (0.84571957588195801) * gru_1_out_t1_63 + gate_r * ((-2.0385770797729492) + (0.033780563622713089) * gru_2_rev_t2_h_0 + (-0.097563207149505615) * gru_2_rev_t2_h_1 + (-0.03721083328127861) * gru_2_rev_t2_h_2 + (-0.0009638092597015202) * gru_2_rev_t2_h_3 + (0.14503426849842072) * gru_2_rev_t2_h_4 + (-0.15015855431556702) * gru_2_rev_t2_h_5 + (0.07951316237449646) * gru_2_rev_t2_h_6 + (0.12700748443603516) * gru_2_rev_t2_h_7 + (0.0016554155154153705) * gru_2_rev_t2_h_8 + (0.067043036222457886) * gru_2_rev_t2_h_9 + (0.098475508391857147) * gru_2_rev_t2_h_10 + (0.01463609840720892) * gru_2_rev_t2_h_11 + (0.103101946413517) * gru_2_rev_t2_h_12 + (0.13995757699012756) * gru_2_rev_t2_h_13 + (0.21793106198310852) * gru_2_rev_t2_h_14 + (0.0068625332787632942) * gru_2_rev_t2_h_15 + (-0.11276119947433472) * gru_2_rev_t2_h_16 + (-0.18708853423595428) * gru_2_rev_t2_h_17 + (0.046654991805553436) * gru_2_rev_t2_h_18 + (-0.054011799395084381) * gru_2_rev_t2_h_19 + (-0.048074811697006226) * gru_2_rev_t2_h_20 + (0.015621181577444077) * gru_2_rev_t2_h_21 + (-0.080127790570259094) * gru_2_rev_t2_h_22 + (0.018334239721298218) * gru_2_rev_t2_h_23 + (-0.17079053819179535) * gru_2_rev_t2_h_24 + (-0.17468948662281036) * gru_2_rev_t2_h_25 + (0.065977849066257477) * gru_2_rev_t2_h_26 + (0.10157819837331772) * gru_2_rev_t2_h_27 + (-0.12709240615367889) * gru_2_rev_t2_h_28 + (0.032964956015348434) * gru_2_rev_t2_h_29 + (0.053976457566022873) * gru_2_rev_t2_h_30 + (0.076456718146800995) * gru_2_rev_t2_h_31));
    gru_2_rev_t1_h_2 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t2_h_2;
    // h=3
    gate_r = sigmoid((-1.7578297853469849) + (-0.90580469369888306) * gru_1_out_t1_0 + (-0.80345630645751953) * gru_1_out_t1_1 + (0.31070175766944885) * gru_1_out_t1_2 + (-0.35923647880554199) * gru_1_out_t1_3 + (0.28847119212150574) * gru_1_out_t1_4 + (-1.8737151622772217) * gru_1_out_t1_5 + (-1.4111815690994263) * gru_1_out_t1_6 + (-0.056352991610765457) * gru_1_out_t1_7 + (-0.36384481191635132) * gru_1_out_t1_8 + (0.15151207149028778) * gru_1_out_t1_9 + (-0.76664215326309204) * gru_1_out_t1_10 + (-1.6297086477279663) * gru_1_out_t1_11 + (0.23689888417720795) * gru_1_out_t1_12 + (-0.3095565140247345) * gru_1_out_t1_13 + (2.9350872039794922) * gru_1_out_t1_14 + (0.16921530663967133) * gru_1_out_t1_15 + (0.28152653574943542) * gru_1_out_t1_16 + (0.58152914047241211) * gru_1_out_t1_17 + (-2.2212653160095215) * gru_1_out_t1_18 + (1.6670029163360596) * gru_1_out_t1_19 + (0.65206778049468994) * gru_1_out_t1_20 + (-0.32548603415489197) * gru_1_out_t1_21 + (-0.11671009659767151) * gru_1_out_t1_22 + (-0.78685605525970459) * gru_1_out_t1_23 + (-3.1981830596923828) * gru_1_out_t1_24 + (0.6110374927520752) * gru_1_out_t1_25 + (0.16854435205459595) * gru_1_out_t1_26 + (0.018740875646471977) * gru_1_out_t1_27 + (-1.6798760890960693) * gru_1_out_t1_28 + (-0.19408042728900909) * gru_1_out_t1_29 + (-3.3449053764343262) * gru_1_out_t1_30 + (0.01899290457367897) * gru_1_out_t1_31 + (-0.652599036693573) * gru_1_out_t1_32 + (-0.94114339351654053) * gru_1_out_t1_33 + (1.8847635984420776) * gru_1_out_t1_34 + (-0.89242249727249146) * gru_1_out_t1_35 + (-0.1877804696559906) * gru_1_out_t1_36 + (0.60840916633605957) * gru_1_out_t1_37 + (5.0094037055969238) * gru_1_out_t1_38 + (1.2667703628540039) * gru_1_out_t1_39 + (0.34472331404685974) * gru_1_out_t1_40 + (-0.4896550178527832) * gru_1_out_t1_41 + (-1.0061689615249634) * gru_1_out_t1_42 + (-0.89175176620483398) * gru_1_out_t1_43 + (-0.78723442554473877) * gru_1_out_t1_44 + (-1.418545126914978) * gru_1_out_t1_45 + (0.15449368953704834) * gru_1_out_t1_46 + (2.1896100044250488) * gru_1_out_t1_47 + (-0.7905648946762085) * gru_1_out_t1_48 + (-5.3881158828735352) * gru_1_out_t1_49 + (1.5669307708740234) * gru_1_out_t1_50 + (-1.3419448137283325) * gru_1_out_t1_51 + (2.0257275104522705) * gru_1_out_t1_52 + (-0.71551603078842163) * gru_1_out_t1_53 + (-0.81023013591766357) * gru_1_out_t1_54 + (-0.81441211700439453) * gru_1_out_t1_55 + (1.0073696374893188) * gru_1_out_t1_56 + (0.20804733037948608) * gru_1_out_t1_57 + (-0.77131378650665283) * gru_1_out_t1_58 + (0.33232021331787109) * gru_1_out_t1_59 + (-1.4865158796310425) * gru_1_out_t1_60 + (1.1940749883651733) * gru_1_out_t1_61 + (0.73951047658920288) * gru_1_out_t1_62 + (0.81293636560440063) * gru_1_out_t1_63 + (-0.013587650842964649) * gru_2_rev_t2_h_0 + (0.0010850088438019156) * gru_2_rev_t2_h_1 + (0.026990273967385292) * gru_2_rev_t2_h_2 + (-0.18534709513187408) * gru_2_rev_t2_h_3 + (-0.09017479419708252) * gru_2_rev_t2_h_4 + (-0.10384733229875565) * gru_2_rev_t2_h_5 + (-0.01335931196808815) * gru_2_rev_t2_h_6 + (0.21830959618091583) * gru_2_rev_t2_h_7 + (-0.030936773866415024) * gru_2_rev_t2_h_8 + (-0.081356659531593323) * gru_2_rev_t2_h_9 + (-0.10864164680242538) * gru_2_rev_t2_h_10 + (0.020953062921762466) * gru_2_rev_t2_h_11 + (-0.013220766559243202) * gru_2_rev_t2_h_12 + (-0.12331946194171906) * gru_2_rev_t2_h_13 + (-0.051031295210123062) * gru_2_rev_t2_h_14 + (0.14010941982269287) * gru_2_rev_t2_h_15 + (0.036763731390237808) * gru_2_rev_t2_h_16 + (-0.055448494851589203) * gru_2_rev_t2_h_17 + (-0.017414774745702744) * gru_2_rev_t2_h_18 + (0.057109732180833817) * gru_2_rev_t2_h_19 + (0.070722870528697968) * gru_2_rev_t2_h_20 + (-0.32335278391838074) * gru_2_rev_t2_h_21 + (-0.085174977779388428) * gru_2_rev_t2_h_22 + (0.067485041916370392) * gru_2_rev_t2_h_23 + (-0.073033906519412994) * gru_2_rev_t2_h_24 + (0.049133259803056717) * gru_2_rev_t2_h_25 + (-0.017172807827591896) * gru_2_rev_t2_h_26 + (-0.22285811603069305) * gru_2_rev_t2_h_27 + (0.053037591278553009) * gru_2_rev_t2_h_28 + (-0.02743062935769558) * gru_2_rev_t2_h_29 + (0.010070820339024067) * gru_2_rev_t2_h_30 + (-0.1053585410118103) * gru_2_rev_t2_h_31);
    gate_z = sigmoid((-0.32178577780723572) + (-0.039736181497573853) * gru_1_out_t1_0 + (-0.13857121765613556) * gru_1_out_t1_1 + (0.18911334872245789) * gru_1_out_t1_2 + (0.018177377060055733) * gru_1_out_t1_3 + (-0.045020885765552521) * gru_1_out_t1_4 + (0.15855218470096588) * gru_1_out_t1_5 + (0.0030539471190422773) * gru_1_out_t1_6 + (0.070335119962692261) * gru_1_out_t1_7 + (0.03618462011218071) * gru_1_out_t1_8 + (0.044255882501602173) * gru_1_out_t1_9 + (-0.016090186312794685) * gru_1_out_t1_10 + (0.078262440860271454) * gru_1_out_t1_11 + (0.035217173397541046) * gru_1_out_t1_12 + (-0.1010533943772316) * gru_1_out_t1_13 + (-0.46797269582748413) * gru_1_out_t1_14 + (0.08141152560710907) * gru_1_out_t1_15 + (0.15895560383796692) * gru_1_out_t1_16 + (0.20975214242935181) * gru_1_out_t1_17 + (-0.012959523126482964) * gru_1_out_t1_18 + (0.087815254926681519) * gru_1_out_t1_19 + (0.15262985229492188) * gru_1_out_t1_20 + (0.069540604948997498) * gru_1_out_t1_21 + (0.12811021506786346) * gru_1_out_t1_22 + (-0.11243245005607605) * gru_1_out_t1_23 + (0.15179675817489624) * gru_1_out_t1_24 + (0.0036900832783430815) * gru_1_out_t1_25 + (0.036756940186023712) * gru_1_out_t1_26 + (-0.35421586036682129) * gru_1_out_t1_27 + (2.1266882419586182) * gru_1_out_t1_28 + (-0.06473337858915329) * gru_1_out_t1_29 + (-0.091981574892997742) * gru_1_out_t1_30 + (0.088566392660140991) * gru_1_out_t1_31 + (-0.61358237266540527) * gru_1_out_t1_32 + (-0.095317266881465912) * gru_1_out_t1_33 + (-0.0027198668103665113) * gru_1_out_t1_34 + (0.050586484372615814) * gru_1_out_t1_35 + (0.027310211211442947) * gru_1_out_t1_36 + (0.8476567268371582) * gru_1_out_t1_37 + (0.53851312398910522) * gru_1_out_t1_38 + (0.70957100391387939) * gru_1_out_t1_39 + (-0.018395427614450455) * gru_1_out_t1_40 + (-0.085393764078617096) * gru_1_out_t1_41 + (0.16069237887859344) * gru_1_out_t1_42 + (-1.3965948820114136) * gru_1_out_t1_43 + (-0.064104326069355011) * gru_1_out_t1_44 + (-0.085750304162502289) * gru_1_out_t1_45 + (1.7835706472396851) * gru_1_out_t1_46 + (0.11185483634471893) * gru_1_out_t1_47 + (0.11067016422748566) * gru_1_out_t1_48 + (-0.1415741890668869) * gru_1_out_t1_49 + (-0.2293989360332489) * gru_1_out_t1_50 + (-0.12725409865379333) * gru_1_out_t1_51 + (1.5322196483612061) * gru_1_out_t1_52 + (-0.097363047301769257) * gru_1_out_t1_53 + (0.31443494558334351) * gru_1_out_t1_54 + (-0.027958504855632782) * gru_1_out_t1_55 + (-0.27793586254119873) * gru_1_out_t1_56 + (0.039264470338821411) * gru_1_out_t1_57 + (0.059432823210954666) * gru_1_out_t1_58 + (-0.16068263351917267) * gru_1_out_t1_59 + (-1.1458491086959839) * gru_1_out_t1_60 + (0.20239852368831635) * gru_1_out_t1_61 + (-0.0077701001428067684) * gru_1_out_t1_62 + (0.053583152592182159) * gru_1_out_t1_63 + (-0.11747822910547256) * gru_2_rev_t2_h_0 + (-0.21593302488327026) * gru_2_rev_t2_h_1 + (0.053858101367950439) * gru_2_rev_t2_h_2 + (-0.002835472347214818) * gru_2_rev_t2_h_3 + (-0.0065728039480745792) * gru_2_rev_t2_h_4 + (0.046680018305778503) * gru_2_rev_t2_h_5 + (0.20176546275615692) * gru_2_rev_t2_h_6 + (-0.088451668620109558) * gru_2_rev_t2_h_7 + (0.06243617832660675) * gru_2_rev_t2_h_8 + (-0.057440195232629776) * gru_2_rev_t2_h_9 + (-0.077706873416900635) * gru_2_rev_t2_h_10 + (-0.032062709331512451) * gru_2_rev_t2_h_11 + (-0.051666188985109329) * gru_2_rev_t2_h_12 + (-0.13110020756721497) * gru_2_rev_t2_h_13 + (-0.023755248636007309) * gru_2_rev_t2_h_14 + (0.27361339330673218) * gru_2_rev_t2_h_15 + (0.041364181786775589) * gru_2_rev_t2_h_16 + (-0.14236578345298767) * gru_2_rev_t2_h_17 + (0.072313025593757629) * gru_2_rev_t2_h_18 + (0.2224404364824295) * gru_2_rev_t2_h_19 + (0.080468259751796722) * gru_2_rev_t2_h_20 + (-0.13773152232170105) * gru_2_rev_t2_h_21 + (0.12696433067321777) * gru_2_rev_t2_h_22 + (-0.0061754626221954823) * gru_2_rev_t2_h_23 + (0.1546514630317688) * gru_2_rev_t2_h_24 + (0.056290693581104279) * gru_2_rev_t2_h_25 + (-0.063631288707256317) * gru_2_rev_t2_h_26 + (0.071723505854606628) * gru_2_rev_t2_h_27 + (-0.14639748632907867) * gru_2_rev_t2_h_28 + (0.11686559766530991) * gru_2_rev_t2_h_29 + (0.11149641871452332) * gru_2_rev_t2_h_30 + (0.33167129755020142) * gru_2_rev_t2_h_31);
    gate_n = tanh((0.83433890342712402) + (0.36005681753158569) * gru_1_out_t1_0 + (0.37514010071754456) * gru_1_out_t1_1 + (-0.48771917819976807) * gru_1_out_t1_2 + (0.13618727028369904) * gru_1_out_t1_3 + (0.1470230370759964) * gru_1_out_t1_4 + (-0.31684476137161255) * gru_1_out_t1_5 + (0.62368452548980713) * gru_1_out_t1_6 + (0.015206962823867798) * gru_1_out_t1_7 + (0.34096944332122803) * gru_1_out_t1_8 + (-0.14731547236442566) * gru_1_out_t1_9 + (0.21103683114051819) * gru_1_out_t1_10 + (-0.20923379063606262) * gru_1_out_t1_11 + (0.12690487504005432) * gru_1_out_t1_12 + (-0.11688424646854401) * gru_1_out_t1_13 + (1.121232271194458) * gru_1_out_t1_14 + (-0.14361895620822906) * gru_1_out_t1_15 + (-0.27491894364356995) * gru_1_out_t1_16 + (0.45920932292938232) * gru_1_out_t1_17 + (-0.11076805740594864) * gru_1_out_t1_18 + (0.16731920838356018) * gru_1_out_t1_19 + (-0.069756053388118744) * gru_1_out_t1_20 + (0.0091336313635110855) * gru_1_out_t1_21 + (-0.15883909165859222) * gru_1_out_t1_22 + (-0.44768688082695007) * gru_1_out_t1_23 + (0.059004988521337509) * gru_1_out_t1_24 + (-0.10139409452676773) * gru_1_out_t1_25 + (-0.22670619189739227) * gru_1_out_t1_26 + (0.1738278865814209) * gru_1_out_t1_27 + (-0.47721213102340698) * gru_1_out_t1_28 + (-0.097359292209148407) * gru_1_out_t1_29 + (0.13781942427158356) * gru_1_out_t1_30 + (0.048306357115507126) * gru_1_out_t1_31 + (-0.61435562372207642) * gru_1_out_t1_32 + (0.21892726421356201) * gru_1_out_t1_33 + (1.0281623601913452) * gru_1_out_t1_34 + (0.14748021960258484) * gru_1_out_t1_35 + (0.10430669039487839) * gru_1_out_t1_36 + (-0.51989227533340454) * gru_1_out_t1_37 + (-0.84911417961120605) * gru_1_out_t1_38 + (-1.1949442625045776) * gru_1_out_t1_39 + (0.11636781692504883) * gru_1_out_t1_40 + (0.59430992603302002) * gru_1_out_t1_41 + (-2.0894045829772949) * gru_1_out_t1_42 + (1.6383824348449707) * gru_1_out_t1_43 + (0.19644279778003693) * gru_1_out_t1_44 + (0.10912048816680908) * gru_1_out_t1_45 + (-6.3502230644226074) * gru_1_out_t1_46 + (-1.261427640914917) * gru_1_out_t1_47 + (0.63024377822875977) * gru_1_out_t1_48 + (1.6505794525146484) * gru_1_out_t1_49 + (-0.22566677629947662) * gru_1_out_t1_50 + (0.52590095996856689) * gru_1_out_t1_51 + (0.11414453387260437) * gru_1_out_t1_52 + (0.13540592789649963) * gru_1_out_t1_53 + (1.6038908958435059) * gru_1_out_t1_54 + (0.37304219603538513) * gru_1_out_t1_55 + (0.35593008995056152) * gru_1_out_t1_56 + (-0.009183814749121666) * gru_1_out_t1_57 + (0.57595670223236084) * gru_1_out_t1_58 + (0.12334113568067551) * gru_1_out_t1_59 + (2.4847180843353271) * gru_1_out_t1_60 + (-1.0094752311706543) * gru_1_out_t1_61 + (0.10094968974590302) * gru_1_out_t1_62 + (-0.12983867526054382) * gru_1_out_t1_63 + gate_r * ((-0.92866998910903931) + (-0.28383034467697144) * gru_2_rev_t2_h_0 + (0.14671280980110168) * gru_2_rev_t2_h_1 + (0.050068031996488571) * gru_2_rev_t2_h_2 + (-0.12282923609018326) * gru_2_rev_t2_h_3 + (-0.054361738264560699) * gru_2_rev_t2_h_4 + (-0.19556780159473419) * gru_2_rev_t2_h_5 + (-0.12261097878217697) * gru_2_rev_t2_h_6 + (-0.012559212744235992) * gru_2_rev_t2_h_7 + (0.0056566433049738407) * gru_2_rev_t2_h_8 + (-0.030129952356219292) * gru_2_rev_t2_h_9 + (0.017156295478343964) * gru_2_rev_t2_h_10 + (0.067516185343265533) * gru_2_rev_t2_h_11 + (-0.066232472658157349) * gru_2_rev_t2_h_12 + (0.040862567722797394) * gru_2_rev_t2_h_13 + (-0.063288092613220215) * gru_2_rev_t2_h_14 + (-0.024200141429901123) * gru_2_rev_t2_h_15 + (-0.18909236788749695) * gru_2_rev_t2_h_16 + (-0.025991516187787056) * gru_2_rev_t2_h_17 + (-0.13388907909393311) * gru_2_rev_t2_h_18 + (0.030242150649428368) * gru_2_rev_t2_h_19 + (-0.13705654442310333) * gru_2_rev_t2_h_20 + (0.077363252639770508) * gru_2_rev_t2_h_21 + (0.014091143384575844) * gru_2_rev_t2_h_22 + (0.18943943083286285) * gru_2_rev_t2_h_23 + (-0.0052285552956163883) * gru_2_rev_t2_h_24 + (-0.046994592994451523) * gru_2_rev_t2_h_25 + (0.015441391617059708) * gru_2_rev_t2_h_26 + (0.12384446710348129) * gru_2_rev_t2_h_27 + (0.13885298371315002) * gru_2_rev_t2_h_28 + (0.023839507251977921) * gru_2_rev_t2_h_29 + (0.057608481496572495) * gru_2_rev_t2_h_30 + (-0.0195207130163908) * gru_2_rev_t2_h_31));
    gru_2_rev_t1_h_3 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t2_h_3;
    // h=4
    gate_r = sigmoid((-0.072476036846637726) + (0.092038363218307495) * gru_1_out_t1_0 + (0.14468652009963989) * gru_1_out_t1_1 + (0.68585103750228882) * gru_1_out_t1_2 + (-0.15887098014354706) * gru_1_out_t1_3 + (0.53959566354751587) * gru_1_out_t1_4 + (-0.86899977922439575) * gru_1_out_t1_5 + (1.270720362663269) * gru_1_out_t1_6 + (0.67621511220932007) * gru_1_out_t1_7 + (-0.38098201155662537) * gru_1_out_t1_8 + (0.42592689394950867) * gru_1_out_t1_9 + (0.53354454040527344) * gru_1_out_t1_10 + (0.48150855302810669) * gru_1_out_t1_11 + (0.081659406423568726) * gru_1_out_t1_12 + (1.1638485193252563) * gru_1_out_t1_13 + (-0.59629040956497192) * gru_1_out_t1_14 + (0.248850017786026) * gru_1_out_t1_15 + (0.30753284692764282) * gru_1_out_t1_16 + (-4.191075325012207) * gru_1_out_t1_17 + (0.66709470748901367) * gru_1_out_t1_18 + (-0.34120997786521912) * gru_1_out_t1_19 + (-0.66845661401748657) * gru_1_out_t1_20 + (-1.0343948602676392) * gru_1_out_t1_21 + (-0.9785459041595459) * gru_1_out_t1_22 + (1.1872216463088989) * gru_1_out_t1_23 + (-0.54966080188751221) * gru_1_out_t1_24 + (0.040817532688379288) * gru_1_out_t1_25 + (0.82032972574234009) * gru_1_out_t1_26 + (-0.84302008152008057) * gru_1_out_t1_27 + (1.1259356737136841) * gru_1_out_t1_28 + (-1.082358717918396) * gru_1_out_t1_29 + (-0.76320028305053711) * gru_1_out_t1_30 + (-0.80155324935913086) * gru_1_out_t1_31 + (3.1871416568756104) * gru_1_out_t1_32 + (1.8499870300292969) * gru_1_out_t1_33 + (-0.20419588685035706) * gru_1_out_t1_34 + (2.8353812694549561) * gru_1_out_t1_35 + (-0.22154815495014191) * gru_1_out_t1_36 + (-0.43629145622253418) * gru_1_out_t1_37 + (-0.064111381769180298) * gru_1_out_t1_38 + (-0.59882903099060059) * gru_1_out_t1_39 + (0.75308686494827271) * gru_1_out_t1_40 + (-0.29871004819869995) * gru_1_out_t1_41 + (-0.97607231140136719) * gru_1_out_t1_42 + (0.81906032562255859) * gru_1_out_t1_43 + (-0.035271260887384415) * gru_1_out_t1_44 + (1.030086874961853) * gru_1_out_t1_45 + (-2.2958505153656006) * gru_1_out_t1_46 + (0.94757336378097534) * gru_1_out_t1_47 + (1.1578766107559204) * gru_1_out_t1_48 + (-1.3808815479278564) * gru_1_out_t1_49 + (0.1321711540222168) * gru_1_out_t1_50 + (-0.41227388381958008) * gru_1_out_t1_51 + (0.064979240298271179) * gru_1_out_t1_52 + (-0.44184541702270508) * gru_1_out_t1_53 + (2.1630566120147705) * gru_1_out_t1_54 + (1.2701668739318848) * gru_1_out_t1_55 + (-1.6848068237304688) * gru_1_out_t1_56 + (-0.19666214287281036) * gru_1_out_t1_57 + (-0.56893646717071533) * gru_1_out_t1_58 + (1.6839776039123535) * gru_1_out_t1_59 + (-0.36052945256233215) * gru_1_out_t1_60 + (-0.2337537556886673) * gru_1_out_t1_61 + (2.7299809455871582) * gru_1_out_t1_62 + (0.073677659034729004) * gru_1_out_t1_63 + (-0.15687721967697144) * gru_2_rev_t2_h_0 + (-0.0082652894780039787) * gru_2_rev_t2_h_1 + (-0.042191214859485626) * gru_2_rev_t2_h_2 + (-0.11852924525737762) * gru_2_rev_t2_h_3 + (0.016654746606945992) * gru_2_rev_t2_h_4 + (-0.0021330660674721003) * gru_2_rev_t2_h_5 + (0.075278297066688538) * gru_2_rev_t2_h_6 + (0.051147598773241043) * gru_2_rev_t2_h_7 + (0.19372151792049408) * gru_2_rev_t2_h_8 + (0.15533694624900818) * gru_2_rev_t2_h_9 + (0.080850429832935333) * gru_2_rev_t2_h_10 + (0.098965398967266083) * gru_2_rev_t2_h_11 + (-0.0089811356738209724) * gru_2_rev_t2_h_12 + (-0.13088752329349518) * gru_2_rev_t2_h_13 + (0.020751927047967911) * gru_2_rev_t2_h_14 + (-0.11407210677862167) * gru_2_rev_t2_h_15 + (0.078189797699451447) * gru_2_rev_t2_h_16 + (0.070551641285419464) * gru_2_rev_t2_h_17 + (-0.010310379788279533) * gru_2_rev_t2_h_18 + (0.049148183315992355) * gru_2_rev_t2_h_19 + (-0.037689782679080963) * gru_2_rev_t2_h_20 + (-0.019270241260528564) * gru_2_rev_t2_h_21 + (-0.19151566922664642) * gru_2_rev_t2_h_22 + (0.19007514417171478) * gru_2_rev_t2_h_23 + (-0.068281590938568115) * gru_2_rev_t2_h_24 + (0.081231392920017242) * gru_2_rev_t2_h_25 + (-0.051851667463779449) * gru_2_rev_t2_h_26 + (-0.028181666508316994) * gru_2_rev_t2_h_27 + (0.021717216819524765) * gru_2_rev_t2_h_28 + (-0.086100287735462189) * gru_2_rev_t2_h_29 + (0.019096292555332184) * gru_2_rev_t2_h_30 + (-0.070487067103385925) * gru_2_rev_t2_h_31);
    gate_z = sigmoid((1.3592343330383301) + (0.75337475538253784) * gru_1_out_t1_0 + (-0.85984945297241211) * gru_1_out_t1_1 + (-0.9307590126991272) * gru_1_out_t1_2 + (0.52130448818206787) * gru_1_out_t1_3 + (0.31489700078964233) * gru_1_out_t1_4 + (-0.29398387670516968) * gru_1_out_t1_5 + (0.44311082363128662) * gru_1_out_t1_6 + (-0.53742700815200806) * gru_1_out_t1_7 + (-0.52048617601394653) * gru_1_out_t1_8 + (-0.1365126371383667) * gru_1_out_t1_9 + (0.32422971725463867) * gru_1_out_t1_10 + (-0.11818990111351013) * gru_1_out_t1_11 + (-0.039020303636789322) * gru_1_out_t1_12 + (1.073451042175293) * gru_1_out_t1_13 + (1.094611644744873) * gru_1_out_t1_14 + (0.071761280298233032) * gru_1_out_t1_15 + (-0.34139290452003479) * gru_1_out_t1_16 + (-0.50256764888763428) * gru_1_out_t1_17 + (1.1601928472518921) * gru_1_out_t1_18 + (-0.040121473371982574) * gru_1_out_t1_19 + (0.077437758445739746) * gru_1_out_t1_20 + (-0.44515201449394226) * gru_1_out_t1_21 + (-0.080804251134395599) * gru_1_out_t1_22 + (-1.0806460380554199) * gru_1_out_t1_23 + (0.23308476805686951) * gru_1_out_t1_24 + (0.38257408142089844) * gru_1_out_t1_25 + (0.49892160296440125) * gru_1_out_t1_26 + (0.5103638768196106) * gru_1_out_t1_27 + (-2.2313737869262695) * gru_1_out_t1_28 + (-0.020415041595697403) * gru_1_out_t1_29 + (0.21667678654193878) * gru_1_out_t1_30 + (-0.079316489398479462) * gru_1_out_t1_31 + (0.37636381387710571) * gru_1_out_t1_32 + (-0.24861103296279907) * gru_1_out_t1_33 + (0.24266619980335236) * gru_1_out_t1_34 + (0.031908486038446426) * gru_1_out_t1_35 + (0.49909093976020813) * gru_1_out_t1_36 + (-0.5459362268447876) * gru_1_out_t1_37 + (-1.3916653394699097) * gru_1_out_t1_38 + (0.12990891933441162) * gru_1_out_t1_39 + (-0.93206548690795898) * gru_1_out_t1_40 + (0.96416574716567993) * gru_1_out_t1_41 + (-2.1839351654052734) * gru_1_out_t1_42 + (-0.59524226188659668) * gru_1_out_t1_43 + (-0.2205653190612793) * gru_1_out_t1_44 + (-0.92509299516677856) * gru_1_out_t1_45 + (-1.1585630178451538) * gru_1_out_t1_46 + (-0.3101331889629364) * gru_1_out_t1_47 + (-0.39102718234062195) * gru_1_out_t1_48 + (0.34283921122550964) * gru_1_out_t1_49 + (-0.78991419076919556) * gru_1_out_t1_50 + (0.4411531388759613) * gru_1_out_t1_51 + (-1.4031146764755249) * gru_1_out_t1_52 + (1.0090485811233521) * gru_1_out_t1_53 + (-1.5610982179641724) * gru_1_out_t1_54 + (-0.38765758275985718) * gru_1_out_t1_55 + (0.32600691914558411) * gru_1_out_t1_56 + (0.54648882150650024) * gru_1_out_t1_57 + (0.83220666646957397) * gru_1_out_t1_58 + (-0.72152143716812134) * gru_1_out_t1_59 + (-2.0062825679779053) * gru_1_out_t1_60 + (2.0330445766448975) * gru_1_out_t1_61 + (-0.56166630983352661) * gru_1_out_t1_62 + (0.65056121349334717) * gru_1_out_t1_63 + (-0.062649346888065338) * gru_2_rev_t2_h_0 + (0.05993984267115593) * gru_2_rev_t2_h_1 + (-0.060369614511728287) * gru_2_rev_t2_h_2 + (0.012712635099887848) * gru_2_rev_t2_h_3 + (0.24980434775352478) * gru_2_rev_t2_h_4 + (-0.14114724099636078) * gru_2_rev_t2_h_5 + (-0.071750551462173462) * gru_2_rev_t2_h_6 + (-0.12500596046447754) * gru_2_rev_t2_h_7 + (-0.11264324933290482) * gru_2_rev_t2_h_8 + (0.023541489616036415) * gru_2_rev_t2_h_9 + (-0.042140346020460129) * gru_2_rev_t2_h_10 + (-0.13256317377090454) * gru_2_rev_t2_h_11 + (-0.064733654260635376) * gru_2_rev_t2_h_12 + (0.19253280758857727) * gru_2_rev_t2_h_13 + (-0.026298059150576591) * gru_2_rev_t2_h_14 + (0.038028374314308167) * gru_2_rev_t2_h_15 + (-0.056288708001375198) * gru_2_rev_t2_h_16 + (-0.069073013961315155) * gru_2_rev_t2_h_17 + (0.081560418009757996) * gru_2_rev_t2_h_18 + (-0.052644483745098114) * gru_2_rev_t2_h_19 + (-0.05427110567688942) * gru_2_rev_t2_h_20 + (-0.12274263054132462) * gru_2_rev_t2_h_21 + (0.09030517190694809) * gru_2_rev_t2_h_22 + (0.06412825733423233) * gru_2_rev_t2_h_23 + (0.017344066873192787) * gru_2_rev_t2_h_24 + (0.040071345865726471) * gru_2_rev_t2_h_25 + (-0.05948982760310173) * gru_2_rev_t2_h_26 + (-0.1006428599357605) * gru_2_rev_t2_h_27 + (-0.12517823278903961) * gru_2_rev_t2_h_28 + (-0.045994102954864502) * gru_2_rev_t2_h_29 + (-0.12816457450389862) * gru_2_rev_t2_h_30 + (-0.060620423406362534) * gru_2_rev_t2_h_31);
    gate_n = tanh((0.065595917403697968) + (-0.10271923243999481) * gru_1_out_t1_0 + (0.67930567264556885) * gru_1_out_t1_1 + (-3.6882527183479397e-06) * gru_1_out_t1_2 + (-0.26747885346412659) * gru_1_out_t1_3 + (0.061427727341651917) * gru_1_out_t1_4 + (0.27607196569442749) * gru_1_out_t1_5 + (-1.0585664510726929) * gru_1_out_t1_6 + (-0.092826656997203827) * gru_1_out_t1_7 + (0.19367276132106781) * gru_1_out_t1_8 + (-0.33118447661399841) * gru_1_out_t1_9 + (0.63141125440597534) * gru_1_out_t1_10 + (0.98780059814453125) * gru_1_out_t1_11 + (0.055274732410907745) * gru_1_out_t1_12 + (-0.58292746543884277) * gru_1_out_t1_13 + (-0.67365521192550659) * gru_1_out_t1_14 + (-0.22049440443515778) * gru_1_out_t1_15 + (-0.11311403661966324) * gru_1_out_t1_16 + (-1.5413438081741333) * gru_1_out_t1_17 + (0.31106135249137878) * gru_1_out_t1_18 + (0.43646630644798279) * gru_1_out_t1_19 + (-0.11906387656927109) * gru_1_out_t1_20 + (-1.1253082752227783) * gru_1_out_t1_21 + (-0.24301464855670929) * gru_1_out_t1_22 + (-1.7939242124557495) * gru_1_out_t1_23 + (-0.68186706304550171) * gru_1_out_t1_24 + (0.060710683465003967) * gru_1_out_t1_25 + (1.2448029518127441) * gru_1_out_t1_26 + (-0.99292874336242676) * gru_1_out_t1_27 + (0.48326399922370911) * gru_1_out_t1_28 + (0.034033708274364471) * gru_1_out_t1_29 + (1.7464594841003418) * gru_1_out_t1_30 + (0.21141305565834045) * gru_1_out_t1_31 + (4.2816958427429199) * gru_1_out_t1_32 + (1.1728062629699707) * gru_1_out_t1_33 + (0.13033163547515869) * gru_1_out_t1_34 + (-0.43078058958053589) * gru_1_out_t1_35 + (0.45487013459205627) * gru_1_out_t1_36 + (0.48092645406723022) * gru_1_out_t1_37 + (0.39893114566802979) * gru_1_out_t1_38 + (0.1286454051733017) * gru_1_out_t1_39 + (0.27172970771789551) * gru_1_out_t1_40 + (-0.16724732518196106) * gru_1_out_t1_41 + (-1.1625580787658691) * gru_1_out_t1_42 + (0.10794240981340408) * gru_1_out_t1_43 + (-0.61309373378753662) * gru_1_out_t1_44 + (-0.50594872236251831) * gru_1_out_t1_45 + (-1.3696705102920532) * gru_1_out_t1_46 + (-0.43497511744499207) * gru_1_out_t1_47 + (0.78735017776489258) * gru_1_out_t1_48 + (-0.8040621280670166) * gru_1_out_t1_49 + (0.64708346128463745) * gru_1_out_t1_50 + (-0.30397751927375793) * gru_1_out_t1_51 + (-0.58480280637741089) * gru_1_out_t1_52 + (-0.20248450338840485) * gru_1_out_t1_53 + (0.15417513251304626) * gru_1_out_t1_54 + (-0.064498923718929291) * gru_1_out_t1_55 + (-1.4523447751998901) * gru_1_out_t1_56 + (0.0074963546358048916) * gru_1_out_t1_57 + (-0.084139555692672729) * gru_1_out_t1_58 + (0.39438343048095703) * gru_1_out_t1_59 + (-0.081742048263549805) * gru_1_out_t1_60 + (-0.7526475191116333) * gru_1_out_t1_61 + (-1.0253816843032837) * gru_1_out_t1_62 + (-0.53909468650817871) * gru_1_out_t1_63 + gate_r * ((2.3596947193145752) + (-0.055604644119739532) * gru_2_rev_t2_h_0 + (-0.04057282954454422) * gru_2_rev_t2_h_1 + (0.071076966822147369) * gru_2_rev_t2_h_2 + (-0.16062535345554352) * gru_2_rev_t2_h_3 + (0.040019582957029343) * gru_2_rev_t2_h_4 + (-0.012600960209965706) * gru_2_rev_t2_h_5 + (-0.063291005790233612) * gru_2_rev_t2_h_6 + (0.032678406685590744) * gru_2_rev_t2_h_7 + (-0.11493462324142456) * gru_2_rev_t2_h_8 + (-0.022143915295600891) * gru_2_rev_t2_h_9 + (0.02621142566204071) * gru_2_rev_t2_h_10 + (0.058887936174869537) * gru_2_rev_t2_h_11 + (-0.11928746849298477) * gru_2_rev_t2_h_12 + (0.21304245293140411) * gru_2_rev_t2_h_13 + (0.060287322849035263) * gru_2_rev_t2_h_14 + (-0.10586266964673996) * gru_2_rev_t2_h_15 + (0.17743328213691711) * gru_2_rev_t2_h_16 + (-0.0030491030775010586) * gru_2_rev_t2_h_17 + (0.035754680633544922) * gru_2_rev_t2_h_18 + (-0.040775924921035767) * gru_2_rev_t2_h_19 + (0.055216390639543533) * gru_2_rev_t2_h_20 + (-0.10470712929964066) * gru_2_rev_t2_h_21 + (-0.025669673457741737) * gru_2_rev_t2_h_22 + (-0.030253596603870392) * gru_2_rev_t2_h_23 + (0.041845303028821945) * gru_2_rev_t2_h_24 + (-0.10586366057395935) * gru_2_rev_t2_h_25 + (-0.040189169347286224) * gru_2_rev_t2_h_26 + (0.092874743044376373) * gru_2_rev_t2_h_27 + (0.068460449576377869) * gru_2_rev_t2_h_28 + (0.02825859934091568) * gru_2_rev_t2_h_29 + (0.050392057746648788) * gru_2_rev_t2_h_30 + (0.13711036741733551) * gru_2_rev_t2_h_31));
    gru_2_rev_t1_h_4 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t2_h_4;
    // h=5
    gate_r = sigmoid((1.1325153112411499) + (0.56752574443817139) * gru_1_out_t1_0 + (-3.7138223648071289) * gru_1_out_t1_1 + (0.0476682148873806) * gru_1_out_t1_2 + (1.2641781568527222) * gru_1_out_t1_3 + (0.14233826100826263) * gru_1_out_t1_4 + (-3.4789726734161377) * gru_1_out_t1_5 + (-0.93116301298141479) * gru_1_out_t1_6 + (-0.038633976131677628) * gru_1_out_t1_7 + (-1.7943291664123535) * gru_1_out_t1_8 + (0.40925711393356323) * gru_1_out_t1_9 + (0.37051874399185181) * gru_1_out_t1_10 + (0.82066315412521362) * gru_1_out_t1_11 + (-0.059107381850481033) * gru_1_out_t1_12 + (2.2266876697540283) * gru_1_out_t1_13 + (-0.40629518032073975) * gru_1_out_t1_14 + (0.33279135823249817) * gru_1_out_t1_15 + (-0.64117300510406494) * gru_1_out_t1_16 + (1.0771183967590332) * gru_1_out_t1_17 + (1.9289125204086304) * gru_1_out_t1_18 + (-0.10362941771745682) * gru_1_out_t1_19 + (2.1127557754516602) * gru_1_out_t1_20 + (0.18330541253089905) * gru_1_out_t1_21 + (-1.7079858779907227) * gru_1_out_t1_22 + (-0.019125748425722122) * gru_1_out_t1_23 + (1.9183886051177979) * gru_1_out_t1_24 + (-0.019509918987751007) * gru_1_out_t1_25 + (0.40626642107963562) * gru_1_out_t1_26 + (-0.044239792972803116) * gru_1_out_t1_27 + (0.044814877212047577) * gru_1_out_t1_28 + (-0.94921624660491943) * gru_1_out_t1_29 + (0.70083600282669067) * gru_1_out_t1_30 + (-0.28333404660224915) * gru_1_out_t1_31 + (-5.4781103134155273) * gru_1_out_t1_32 + (-0.18814948201179504) * gru_1_out_t1_33 + (-1.449116587638855) * gru_1_out_t1_34 + (-1.2598936557769775) * gru_1_out_t1_35 + (-1.0170716047286987) * gru_1_out_t1_36 + (-0.6116107702255249) * gru_1_out_t1_37 + (-1.1409859657287598) * gru_1_out_t1_38 + (-2.6551260948181152) * gru_1_out_t1_39 + (-0.092353060841560364) * gru_1_out_t1_40 + (0.02273988351225853) * gru_1_out_t1_41 + (1.3746975660324097) * gru_1_out_t1_42 + (-1.5990197658538818) * gru_1_out_t1_43 + (-0.91402339935302734) * gru_1_out_t1_44 + (-0.92478430271148682) * gru_1_out_t1_45 + (-0.9635123610496521) * gru_1_out_t1_46 + (-2.298405647277832) * gru_1_out_t1_47 + (2.0051145553588867) * gru_1_out_t1_48 + (2.277454137802124) * gru_1_out_t1_49 + (0.22194311022758484) * gru_1_out_t1_50 + (1.4431134462356567) * gru_1_out_t1_51 + (1.6999003887176514) * gru_1_out_t1_52 + (0.92861425876617432) * gru_1_out_t1_53 + (-3.6958925724029541) * gru_1_out_t1_54 + (-1.4320344924926758) * gru_1_out_t1_55 + (0.66894513368606567) * gru_1_out_t1_56 + (0.20077149569988251) * gru_1_out_t1_57 + (0.79676830768585205) * gru_1_out_t1_58 + (0.17452025413513184) * gru_1_out_t1_59 + (-0.44618907570838928) * gru_1_out_t1_60 + (0.21298311650753021) * gru_1_out_t1_61 + (2.2400314807891846) * gru_1_out_t1_62 + (-0.57354950904846191) * gru_1_out_t1_63 + (-0.24015635251998901) * gru_2_rev_t2_h_0 + (0.063089646399021149) * gru_2_rev_t2_h_1 + (0.028578504920005798) * gru_2_rev_t2_h_2 + (-0.11938351392745972) * gru_2_rev_t2_h_3 + (0.14446227252483368) * gru_2_rev_t2_h_4 + (0.040763773024082184) * gru_2_rev_t2_h_5 + (0.047423724085092545) * gru_2_rev_t2_h_6 + (-0.16314223408699036) * gru_2_rev_t2_h_7 + (-0.03530869260430336) * gru_2_rev_t2_h_8 + (0.059185042977333069) * gru_2_rev_t2_h_9 + (0.14000929892063141) * gru_2_rev_t2_h_10 + (0.098273254930973053) * gru_2_rev_t2_h_11 + (0.17038004100322723) * gru_2_rev_t2_h_12 + (-0.22375179827213287) * gru_2_rev_t2_h_13 + (-0.044477462768554688) * gru_2_rev_t2_h_14 + (-0.1379765123128891) * gru_2_rev_t2_h_15 + (-0.031054513528943062) * gru_2_rev_t2_h_16 + (0.085830606520175934) * gru_2_rev_t2_h_17 + (0.08830057829618454) * gru_2_rev_t2_h_18 + (0.17822819948196411) * gru_2_rev_t2_h_19 + (-0.041853364557027817) * gru_2_rev_t2_h_20 + (0.035289149731397629) * gru_2_rev_t2_h_21 + (0.098042652010917664) * gru_2_rev_t2_h_22 + (-0.13180331885814667) * gru_2_rev_t2_h_23 + (0.026345301419496536) * gru_2_rev_t2_h_24 + (0.045481715351343155) * gru_2_rev_t2_h_25 + (0.039897900074720383) * gru_2_rev_t2_h_26 + (-0.038152437657117844) * gru_2_rev_t2_h_27 + (0.10410068184137344) * gru_2_rev_t2_h_28 + (-0.22250686585903168) * gru_2_rev_t2_h_29 + (0.065846666693687439) * gru_2_rev_t2_h_30 + (0.091626681387424469) * gru_2_rev_t2_h_31);
    gate_z = sigmoid((-0.060794264078140259) + (-0.16986469924449921) * gru_1_out_t1_0 + (0.00069776317104697227) * gru_1_out_t1_1 + (0.54250311851501465) * gru_1_out_t1_2 + (0.77713692188262939) * gru_1_out_t1_3 + (0.34814891219139099) * gru_1_out_t1_4 + (0.34144952893257141) * gru_1_out_t1_5 + (0.10615181177854538) * gru_1_out_t1_6 + (-0.008228302001953125) * gru_1_out_t1_7 + (-0.19668856263160706) * gru_1_out_t1_8 + (-0.49532002210617065) * gru_1_out_t1_9 + (-0.11007145047187805) * gru_1_out_t1_10 + (-0.36523821949958801) * gru_1_out_t1_11 + (-0.010461464524269104) * gru_1_out_t1_12 + (-0.21235010027885437) * gru_1_out_t1_13 + (-0.021720362827181816) * gru_1_out_t1_14 + (-0.0055106077343225479) * gru_1_out_t1_15 + (0.039249852299690247) * gru_1_out_t1_16 + (0.023778904229402542) * gru_1_out_t1_17 + (0.20340266823768616) * gru_1_out_t1_18 + (0.03414655476808548) * gru_1_out_t1_19 + (-0.025805061683058739) * gru_1_out_t1_20 + (-0.11774206161499023) * gru_1_out_t1_21 + (0.14591220021247864) * gru_1_out_t1_22 + (0.15126910805702209) * gru_1_out_t1_23 + (0.11908254772424698) * gru_1_out_t1_24 + (-0.45299175381660461) * gru_1_out_t1_25 + (0.021610371768474579) * gru_1_out_t1_26 + (0.40872746706008911) * gru_1_out_t1_27 + (0.13340677320957184) * gru_1_out_t1_28 + (-0.42361786961555481) * gru_1_out_t1_29 + (0.059207618236541748) * gru_1_out_t1_30 + (-0.3776853084564209) * gru_1_out_t1_31 + (-0.04964848980307579) * gru_1_out_t1_32 + (-0.36842882633209229) * gru_1_out_t1_33 + (-0.33987858891487122) * gru_1_out_t1_34 + (0.44615203142166138) * gru_1_out_t1_35 + (0.077569328248500824) * gru_1_out_t1_36 + (-0.21889637410640717) * gru_1_out_t1_37 + (-0.15700578689575195) * gru_1_out_t1_38 + (-0.20187978446483612) * gru_1_out_t1_39 + (-0.0075660035945475101) * gru_1_out_t1_40 + (-0.021951872855424881) * gru_1_out_t1_41 + (-0.4478478729724884) * gru_1_out_t1_42 + (0.52989339828491211) * gru_1_out_t1_43 + (0.21908874809741974) * gru_1_out_t1_44 + (0.12182820588350296) * gru_1_out_t1_45 + (-0.28732356429100037) * gru_1_out_t1_46 + (-0.12041131407022476) * gru_1_out_t1_47 + (0.14267516136169434) * gru_1_out_t1_48 + (-0.7738107442855835) * gru_1_out_t1_49 + (0.023390581831336021) * gru_1_out_t1_50 + (0.71256566047668457) * gru_1_out_t1_51 + (-0.68376439809799194) * gru_1_out_t1_52 + (-0.24443291127681732) * gru_1_out_t1_53 + (0.27107787132263184) * gru_1_out_t1_54 + (-0.0036380805540829897) * gru_1_out_t1_55 + (0.064497753977775574) * gru_1_out_t1_56 + (0.044110026210546494) * gru_1_out_t1_57 + (0.47879555821418762) * gru_1_out_t1_58 + (0.39168038964271545) * gru_1_out_t1_59 + (0.054273262619972229) * gru_1_out_t1_60 + (0.84590655565261841) * gru_1_out_t1_61 + (0.11952214688062668) * gru_1_out_t1_62 + (-0.25777351856231689) * gru_1_out_t1_63 + (-0.039792619645595551) * gru_2_rev_t2_h_0 + (0.093713149428367615) * gru_2_rev_t2_h_1 + (-0.22191563248634338) * gru_2_rev_t2_h_2 + (-0.15208333730697632) * gru_2_rev_t2_h_3 + (0.02509024553000927) * gru_2_rev_t2_h_4 + (0.11095323413610458) * gru_2_rev_t2_h_5 + (-0.034886695444583893) * gru_2_rev_t2_h_6 + (-0.12797185778617859) * gru_2_rev_t2_h_7 + (0.023475436493754387) * gru_2_rev_t2_h_8 + (-0.11181193590164185) * gru_2_rev_t2_h_9 + (0.03409285843372345) * gru_2_rev_t2_h_10 + (0.0065337643027305603) * gru_2_rev_t2_h_11 + (-0.077074408531188965) * gru_2_rev_t2_h_12 + (0.07679593563079834) * gru_2_rev_t2_h_13 + (-0.10574289411306381) * gru_2_rev_t2_h_14 + (-0.016077829524874687) * gru_2_rev_t2_h_15 + (-0.023005800321698189) * gru_2_rev_t2_h_16 + (-0.20854116976261139) * gru_2_rev_t2_h_17 + (-0.059607651084661484) * gru_2_rev_t2_h_18 + (-0.012521650642156601) * gru_2_rev_t2_h_19 + (-0.01517438143491745) * gru_2_rev_t2_h_20 + (-0.056427795439958572) * gru_2_rev_t2_h_21 + (-0.11355010420084) * gru_2_rev_t2_h_22 + (0.072175800800323486) * gru_2_rev_t2_h_23 + (-0.077918440103530884) * gru_2_rev_t2_h_24 + (0.21052666008472443) * gru_2_rev_t2_h_25 + (0.05747976154088974) * gru_2_rev_t2_h_26 + (0.017390625551342964) * gru_2_rev_t2_h_27 + (0.064279764890670776) * gru_2_rev_t2_h_28 + (0.023641509935259819) * gru_2_rev_t2_h_29 + (-0.0055550816468894482) * gru_2_rev_t2_h_30 + (0.17602840065956116) * gru_2_rev_t2_h_31);
    gate_n = tanh((0.42859762907028198) + (0.34992972016334534) * gru_1_out_t1_0 + (-0.23156140744686127) * gru_1_out_t1_1 + (0.58980280160903931) * gru_1_out_t1_2 + (0.25162959098815918) * gru_1_out_t1_3 + (-0.2587285041809082) * gru_1_out_t1_4 + (-0.050596673041582108) * gru_1_out_t1_5 + (-0.95566850900650024) * gru_1_out_t1_6 + (-0.23893840610980988) * gru_1_out_t1_7 + (0.086635135114192963) * gru_1_out_t1_8 + (-0.45928505063056946) * gru_1_out_t1_9 + (0.46376082301139832) * gru_1_out_t1_10 + (0.15218661725521088) * gru_1_out_t1_11 + (-0.27244457602500916) * gru_1_out_t1_12 + (0.83779573440551758) * gru_1_out_t1_13 + (-0.44178715348243713) * gru_1_out_t1_14 + (-0.28775960206985474) * gru_1_out_t1_15 + (-0.71863782405853271) * gru_1_out_t1_16 + (0.74135738611221313) * gru_1_out_t1_17 + (0.85252135992050171) * gru_1_out_t1_18 + (-0.26096445322036743) * gru_1_out_t1_19 + (0.132708340883255) * gru_1_out_t1_20 + (0.42424815893173218) * gru_1_out_t1_21 + (-0.64336919784545898) * gru_1_out_t1_22 + (-0.51934319734573364) * gru_1_out_t1_23 + (-0.82170718908309937) * gru_1_out_t1_24 + (0.09386608749628067) * gru_1_out_t1_25 + (0.84984469413757324) * gru_1_out_t1_26 + (-0.045547313988208771) * gru_1_out_t1_27 + (-0.65452796220779419) * gru_1_out_t1_28 + (0.43659275770187378) * gru_1_out_t1_29 + (0.80873268842697144) * gru_1_out_t1_30 + (0.34664145112037659) * gru_1_out_t1_31 + (2.0013737678527832) * gru_1_out_t1_32 + (-0.074308007955551147) * gru_1_out_t1_33 + (-0.0093693286180496216) * gru_1_out_t1_34 + (-0.43745630979537964) * gru_1_out_t1_35 + (0.1024075448513031) * gru_1_out_t1_36 + (-0.16692958772182465) * gru_1_out_t1_37 + (0.071497932076454163) * gru_1_out_t1_38 + (0.21587347984313965) * gru_1_out_t1_39 + (-0.32906043529510498) * gru_1_out_t1_40 + (0.31747385859489441) * gru_1_out_t1_41 + (0.78687864542007446) * gru_1_out_t1_42 + (-0.6097678542137146) * gru_1_out_t1_43 + (-0.61178940534591675) * gru_1_out_t1_44 + (-0.67048972845077515) * gru_1_out_t1_45 + (-1.6151697635650635) * gru_1_out_t1_46 + (-0.10506920516490936) * gru_1_out_t1_47 + (0.16603071987628937) * gru_1_out_t1_48 + (-0.59170389175415039) * gru_1_out_t1_49 + (-0.066808588802814484) * gru_1_out_t1_50 + (1.0979326963424683) * gru_1_out_t1_51 + (1.4857169389724731) * gru_1_out_t1_52 + (-0.050270374864339828) * gru_1_out_t1_53 + (1.6844896078109741) * gru_1_out_t1_54 + (0.036261741071939468) * gru_1_out_t1_55 + (-0.92346698045730591) * gru_1_out_t1_56 + (0.55900907516479492) * gru_1_out_t1_57 + (-0.081463754177093506) * gru_1_out_t1_58 + (-0.307655930519104) * gru_1_out_t1_59 + (-0.35776269435882568) * gru_1_out_t1_60 + (-5.1905584335327148) * gru_1_out_t1_61 + (1.0883333683013916) * gru_1_out_t1_62 + (0.56266885995864868) * gru_1_out_t1_63 + gate_r * ((0.55942350625991821) + (0.11870159953832626) * gru_2_rev_t2_h_0 + (-0.052155960351228714) * gru_2_rev_t2_h_1 + (-0.062738560140132904) * gru_2_rev_t2_h_2 + (-0.053439322859048843) * gru_2_rev_t2_h_3 + (0.12049376964569092) * gru_2_rev_t2_h_4 + (-0.0084662344306707382) * gru_2_rev_t2_h_5 + (0.076851561665534973) * gru_2_rev_t2_h_6 + (-0.0153867332264781) * gru_2_rev_t2_h_7 + (-0.057278379797935486) * gru_2_rev_t2_h_8 + (-0.067177928984165192) * gru_2_rev_t2_h_9 + (0.16840334236621857) * gru_2_rev_t2_h_10 + (-0.051803518086671829) * gru_2_rev_t2_h_11 + (-0.11441671103239059) * gru_2_rev_t2_h_12 + (0.11442975699901581) * gru_2_rev_t2_h_13 + (-0.2711300253868103) * gru_2_rev_t2_h_14 + (0.024553690105676651) * gru_2_rev_t2_h_15 + (0.30330842733383179) * gru_2_rev_t2_h_16 + (-0.046663798391819) * gru_2_rev_t2_h_17 + (-0.073381446301937103) * gru_2_rev_t2_h_18 + (0.11804530769586563) * gru_2_rev_t2_h_19 + (0.0020181324798613787) * gru_2_rev_t2_h_20 + (-0.062094219028949738) * gru_2_rev_t2_h_21 + (0.040898453444242477) * gru_2_rev_t2_h_22 + (0.013227513991296291) * gru_2_rev_t2_h_23 + (-0.19510877132415771) * gru_2_rev_t2_h_24 + (-0.061583086848258972) * gru_2_rev_t2_h_25 + (-0.16340629756450653) * gru_2_rev_t2_h_26 + (-0.094755686819553375) * gru_2_rev_t2_h_27 + (0.096040636301040649) * gru_2_rev_t2_h_28 + (0.036413576453924179) * gru_2_rev_t2_h_29 + (-0.18399545550346375) * gru_2_rev_t2_h_30 + (0.0038974867202341557) * gru_2_rev_t2_h_31));
    gru_2_rev_t1_h_5 = (1.0 - gate_z) * gate_n + gate_z * gru_2_rev_t2_h_5;
    // h=6
