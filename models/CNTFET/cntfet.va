    gate_r = sigmoid((1.1197860240936279) + (0.82189655303955078) * emb_t4_0 + (0.84979915618896484) * emb_t4_1 + (0.63162010908126831) * emb_t4_2 + (0.59661942720413208) * emb_t4_3 + (-0.26328656077384949) * emb_t4_4 + (-0.74788320064544678) * emb_t4_5 + (0.042410414665937424) * emb_t4_6 + (-0.86037814617156982) * emb_t4_7 + (0.69385504722595215) * emb_t4_8 + (-1.1680564880371094) * emb_t4_9 + (-0.36268532276153564) * emb_t4_10 + (0.5741237998008728) * emb_t4_11 + (0.80066180229187012) * emb_t4_12 + (0.3629651665687561) * emb_t4_13 + (-0.48242610692977905) * emb_t4_14 + (0.36558768153190613) * emb_t4_15 + (1.2318867444992065) * emb_t4_16 + (-0.26140722632408142) * emb_t4_17 + (-1.0478253364562988) * emb_t4_18 + (1.1572840213775635) * emb_t4_19 + (0.58639121055603027) * emb_t4_20 + (-0.42898482084274292) * emb_t4_21 + (-0.49490630626678467) * emb_t4_22 + (-0.025686496868729591) * emb_t4_23 + (-0.032259661704301834) * emb_t4_24 + (-0.58412003517150879) * emb_t4_25 + (0.042390689253807068) * emb_t4_26 + (-0.014617961831390858) * emb_t4_27 + (-0.45873472094535828) * emb_t4_28 + (0.76545733213424683) * emb_t4_29 + (-0.11830274760723114) * emb_t4_30 + (-0.82707095146179199) * emb_t4_31 + (-0.11377521604299545) * gru_0_fwd_t3_h_0 + (0.49484780430793762) * gru_0_fwd_t3_h_1 + (0.14865636825561523) * gru_0_fwd_t3_h_2 + (1.0188875198364258) * gru_0_fwd_t3_h_3 + (0.79360133409500122) * gru_0_fwd_t3_h_4 + (0.88067495822906494) * gru_0_fwd_t3_h_5 + (-3.5741405487060547) * gru_0_fwd_t3_h_6 + (-0.080673180520534515) * gru_0_fwd_t3_h_7 + (0.3026549220085144) * gru_0_fwd_t3_h_8 + (1.10136878490448) * gru_0_fwd_t3_h_9 + (0.030721839517354965) * gru_0_fwd_t3_h_10 + (0.24231904745101929) * gru_0_fwd_t3_h_11 + (-0.25698202848434448) * gru_0_fwd_t3_h_12 + (-0.79313129186630249) * gru_0_fwd_t3_h_13 + (0.38349774479866028) * gru_0_fwd_t3_h_14 + (0.88436049222946167) * gru_0_fwd_t3_h_15 + (0.047915004193782806) * gru_0_fwd_t3_h_16 + (0.10697253048419952) * gru_0_fwd_t3_h_17 + (1.5925276279449463) * gru_0_fwd_t3_h_18 + (0.94665277004241943) * gru_0_fwd_t3_h_19 + (2.1543376445770264) * gru_0_fwd_t3_h_20 + (0.22832992672920227) * gru_0_fwd_t3_h_21 + (0.074176594614982605) * gru_0_fwd_t3_h_22 + (-0.4923250675201416) * gru_0_fwd_t3_h_23 + (1.8622615337371826) * gru_0_fwd_t3_h_24 + (0.26764729619026184) * gru_0_fwd_t3_h_25 + (1.0227169990539551) * gru_0_fwd_t3_h_26 + (0.71264427900314331) * gru_0_fwd_t3_h_27 + (-0.56702607870101929) * gru_0_fwd_t3_h_28 + (1.5039618015289307) * gru_0_fwd_t3_h_29 + (0.42466428875923157) * gru_0_fwd_t3_h_30 + (-2.046318531036377) * gru_0_fwd_t3_h_31);
    gate_z = sigmoid((0.93570268154144287) + (0.027945071458816528) * emb_t4_0 + (-0.29999658465385437) * emb_t4_1 + (0.37092065811157227) * emb_t4_2 + (0.11785808950662613) * emb_t4_3 + (-0.42889499664306641) * emb_t4_4 + (0.025375081226229668) * emb_t4_5 + (-0.013721304945647717) * emb_t4_6 + (-0.28716537356376648) * emb_t4_7 + (0.52241778373718262) * emb_t4_8 + (0.20057013630867004) * emb_t4_9 + (0.043395094573497772) * emb_t4_10 + (0.33710560202598572) * emb_t4_11 + (0.53270399570465088) * emb_t4_12 + (-0.6542210578918457) * emb_t4_13 + (0.28734761476516724) * emb_t4_14 + (0.11672159284353256) * emb_t4_15 + (0.20078630745410919) * emb_t4_16 + (-0.63615882396697998) * emb_t4_17 + (0.022169522941112518) * emb_t4_18 + (0.61556482315063477) * emb_t4_19 + (0.56159460544586182) * emb_t4_20 + (0.2355131208896637) * emb_t4_21 + (-0.58501154184341431) * emb_t4_22 + (-0.23210981488227844) * emb_t4_23 + (0.043808095157146454) * emb_t4_24 + (-0.00083580572390928864) * emb_t4_25 + (0.48075786232948303) * emb_t4_26 + (0.1017712876200676) * emb_t4_27 + (0.35832160711288452) * emb_t4_28 + (-0.19724997878074646) * emb_t4_29 + (1.0564422607421875) * emb_t4_30 + (-0.51558518409729004) * emb_t4_31 + (-0.052631378173828125) * gru_0_fwd_t3_h_0 + (0.12540276348590851) * gru_0_fwd_t3_h_1 + (-0.40728402137756348) * gru_0_fwd_t3_h_2 + (0.45038846135139465) * gru_0_fwd_t3_h_3 + (0.0069151311181485653) * gru_0_fwd_t3_h_4 + (0.043897204101085663) * gru_0_fwd_t3_h_5 + (-0.51441150903701782) * gru_0_fwd_t3_h_6 + (0.54450982809066772) * gru_0_fwd_t3_h_7 + (0.93323218822479248) * gru_0_fwd_t3_h_8 + (-0.20096880197525024) * gru_0_fwd_t3_h_9 + (0.41260793805122375) * gru_0_fwd_t3_h_10 + (0.21722094714641571) * gru_0_fwd_t3_h_11 + (-0.21869494020938873) * gru_0_fwd_t3_h_12 + (-0.59330326318740845) * gru_0_fwd_t3_h_13 + (0.28238683938980103) * gru_0_fwd_t3_h_14 + (0.31732171773910522) * gru_0_fwd_t3_h_15 + (0.0050415699370205402) * gru_0_fwd_t3_h_16 + (-0.53080970048904419) * gru_0_fwd_t3_h_17 + (0.40165555477142334) * gru_0_fwd_t3_h_18 + (0.37447160482406616) * gru_0_fwd_t3_h_19 + (-0.41426545381546021) * gru_0_fwd_t3_h_20 + (-0.95179545879364014) * gru_0_fwd_t3_h_21 + (0.78936189413070679) * gru_0_fwd_t3_h_22 + (-1.1169302463531494) * gru_0_fwd_t3_h_23 + (-1.5654652118682861) * gru_0_fwd_t3_h_24 + (-0.13280864059925079) * gru_0_fwd_t3_h_25 + (-3.115680456161499) * gru_0_fwd_t3_h_26 + (0.34119254350662231) * gru_0_fwd_t3_h_27 + (-0.64078515768051147) * gru_0_fwd_t3_h_28 + (-0.21707659959793091) * gru_0_fwd_t3_h_29 + (0.17915607988834381) * gru_0_fwd_t3_h_30 + (0.49229168891906738) * gru_0_fwd_t3_h_31);
    gate_n = tanh((0.059556685388088226) + (0.0093570752069354057) * emb_t4_0 + (-0.14118006825447083) * emb_t4_1 + (0.27748677134513855) * emb_t4_2 + (0.13478186726570129) * emb_t4_3 + (-0.096241101622581482) * emb_t4_4 + (0.028125690296292305) * emb_t4_5 + (-0.21943745017051697) * emb_t4_6 + (-0.040820885449647903) * emb_t4_7 + (0.015611233189702034) * emb_t4_8 + (-0.026535511016845703) * emb_t4_9 + (0.11295320093631744) * emb_t4_10 + (0.1657504141330719) * emb_t4_11 + (0.30802986025810242) * emb_t4_12 + (-0.19599159061908722) * emb_t4_13 + (0.051283437758684158) * emb_t4_14 + (0.01581161841750145) * emb_t4_15 + (0.16965529322624207) * emb_t4_16 + (0.17486566305160522) * emb_t4_17 + (-0.3228529691696167) * emb_t4_18 + (0.04059198871254921) * emb_t4_19 + (0.10199558734893799) * emb_t4_20 + (0.044503945857286453) * emb_t4_21 + (-0.3532220721244812) * emb_t4_22 + (0.072760716080665588) * emb_t4_23 + (-0.031821347773075104) * emb_t4_24 + (-0.00347660924308002) * emb_t4_25 + (-0.068912975490093231) * emb_t4_26 + (0.12479005008935928) * emb_t4_27 + (0.0084166890010237694) * emb_t4_28 + (-0.074207529425621033) * emb_t4_29 + (-0.19051642715930939) * emb_t4_30 + (-0.29854661226272583) * emb_t4_31 + gate_r * ((0.093639783561229706) + (-0.26055413484573364) * gru_0_fwd_t3_h_0 + (-0.095837920904159546) * gru_0_fwd_t3_h_1 + (0.038966912776231766) * gru_0_fwd_t3_h_2 + (0.014310726895928383) * gru_0_fwd_t3_h_3 + (-0.049272693693637848) * gru_0_fwd_t3_h_4 + (0.22457613050937653) * gru_0_fwd_t3_h_5 + (1.4724425077438354) * gru_0_fwd_t3_h_6 + (-0.077588565647602081) * gru_0_fwd_t3_h_7 + (0.097471266984939575) * gru_0_fwd_t3_h_8 + (-0.55311673879623413) * gru_0_fwd_t3_h_9 + (-0.13370458781719208) * gru_0_fwd_t3_h_10 + (-0.25395268201828003) * gru_0_fwd_t3_h_11 + (0.4308381974697113) * gru_0_fwd_t3_h_12 + (0.25299379229545593) * gru_0_fwd_t3_h_13 + (-0.29430118203163147) * gru_0_fwd_t3_h_14 + (-0.014947656542062759) * gru_0_fwd_t3_h_15 + (0.022595809772610664) * gru_0_fwd_t3_h_16 + (0.54277259111404419) * gru_0_fwd_t3_h_17 + (-0.35988220572471619) * gru_0_fwd_t3_h_18 + (1.1189311742782593) * gru_0_fwd_t3_h_19 + (0.42105749249458313) * gru_0_fwd_t3_h_20 + (0.31713798642158508) * gru_0_fwd_t3_h_21 + (-0.59697574377059937) * gru_0_fwd_t3_h_22 + (0.041749343276023865) * gru_0_fwd_t3_h_23 + (-0.99520927667617798) * gru_0_fwd_t3_h_24 + (0.28341895341873169) * gru_0_fwd_t3_h_25 + (2.939974308013916) * gru_0_fwd_t3_h_26 + (0.26471617817878723) * gru_0_fwd_t3_h_27 + (-0.81368362903594971) * gru_0_fwd_t3_h_28 + (-0.32824662327766418) * gru_0_fwd_t3_h_29 + (-0.31704512238502502) * gru_0_fwd_t3_h_30 + (1.2399663925170898) * gru_0_fwd_t3_h_31));
    gru_0_fwd_t4_h_31 = (1.0 - gate_z) * gate_n + gate_z * gru_0_fwd_t3_h_31;

    // Reverse sequence
    // RV step t=4
    // h=0
    gate_r = sigmoid((-2.9835760593414307) + (-0.2894538938999176) * emb_t4_0 + (-1.0065344572067261) * emb_t4_1 + (-0.2484540194272995) * emb_t4_2 + (-1.6565470695495605) * emb_t4_3 + (1.4283560514450073) * emb_t4_4 + (1.1049230098724365) * emb_t4_5 + (1.5637035369873047) * emb_t4_6 + (0.61245578527450562) * emb_t4_7 + (-0.76217371225357056) * emb_t4_8 + (1.0227657556533813) * emb_t4_9 + (1.000507116317749) * emb_t4_10 + (-1.6554383039474487) * emb_t4_11 + (-1.7877154350280762) * emb_t4_12 + (0.15166507661342621) * emb_t4_13 + (0.86731231212615967) * emb_t4_14 + (0.49553677439689636) * emb_t4_15 + (-1.1724370718002319) * emb_t4_16 + (1.6185518503189087) * emb_t4_17 + (0.97716200351715088) * emb_t4_18 + (-1.3622130155563354) * emb_t4_19 + (-1.409847617149353) * emb_t4_20 + (0.5451006293296814) * emb_t4_21 + (1.1372634172439575) * emb_t4_22 + (0.68434017896652222) * emb_t4_23 + (0.8193785548210144) * emb_t4_24 + (0.2640354335308075) * emb_t4_25 + (-1.8077752590179443) * emb_t4_26 + (-1.2768290042877197) * emb_t4_27 + (0.52384662628173828) * emb_t4_28 + (-0.40466684103012085) * emb_t4_29 + (-1.1958518028259277) * emb_t4_30 + (0.97426825761795044) * emb_t4_31);
    gate_z = sigmoid((-0.23713213205337524) + (-0.094452530145645142) * emb_t4_0 + (0.21141506731510162) * emb_t4_1 + (-0.028694683685898781) * emb_t4_2 + (0.09788871556520462) * emb_t4_3 + (-0.30816355347633362) * emb_t4_4 + (0.01998172327876091) * emb_t4_5 + (0.055055197328329086) * emb_t4_6 + (0.0012398603139445186) * emb_t4_7 + (-0.3471817672252655) * emb_t4_8 + (-0.015082758851349354) * emb_t4_9 + (-0.0455658920109272) * emb_t4_10 + (-0.38441550731658936) * emb_t4_11 + (-0.11193738877773285) * emb_t4_12 + (-0.52671444416046143) * emb_t4_13 + (0.021289674565196037) * emb_t4_14 + (-0.04076920822262764) * emb_t4_15 + (0.0047816503793001175) * emb_t4_16 + (0.22122785449028015) * emb_t4_17 + (0.4573395848274231) * emb_t4_18 + (-0.61744415760040283) * emb_t4_19 + (-0.14113922417163849) * emb_t4_20 + (0.027857039123773575) * emb_t4_21 + (-0.027806330472230911) * emb_t4_22 + (0.076793096959590912) * emb_t4_23 + (-0.022407537326216698) * emb_t4_24 + (-0.030158311128616333) * emb_t4_25 + (0.44543731212615967) * emb_t4_26 + (0.0095486780628561974) * emb_t4_27 + (0.53045326471328735) * emb_t4_28 + (-0.9014277458190918) * emb_t4_29 + (0.33636349439620972) * emb_t4_30 + (0.13960909843444824) * emb_t4_31);
    gate_n = tanh((0.31142440438270569) + (-0.019339106976985931) * emb_t4_0 + (-1.083100438117981) * emb_t4_1 + (0.034396085888147354) * emb_t4_2 + (-0.13810527324676514) * emb_t4_3 + (-1.248698353767395) * emb_t4_4 + (0.040851529687643051) * emb_t4_5 + (-1.6545813083648682) * emb_t4_6 + (-0.011575773358345032) * emb_t4_7 + (0.090101957321166992) * emb_t4_8 + (0.40074479579925537) * emb_t4_9 + (0.16766327619552612) * emb_t4_10 + (0.29562315344810486) * emb_t4_11 + (0.097509466111660004) * emb_t4_12 + (-1.1618857383728027) * emb_t4_13 + (-0.023454835638403893) * emb_t4_14 + (0.0025133476592600346) * emb_t4_15 + (0.011139494366943836) * emb_t4_16 + (-0.64154452085494995) * emb_t4_17 + (0.12155960500240326) * emb_t4_18 + (0.24741975963115692) * emb_t4_19 + (0.48124334216117859) * emb_t4_20 + (-0.053347807377576828) * emb_t4_21 + (0.22831031680107117) * emb_t4_22 + (0.0040268870070576668) * emb_t4_23 + (-0.045491855591535568) * emb_t4_24 + (0.032861612737178802) * emb_t4_25 + (0.82190942764282227) * emb_t4_26 + (-0.028285810723900795) * emb_t4_27 + (0.96199721097946167) * emb_t4_28 + (-1.1373158693313599) * emb_t4_29 + (1.228196382522583) * emb_t4_30 + (-0.13546010851860046) * emb_t4_31 + gate_r * (-0.075502410531044006));
    gru_0_rev_t4_h_0 = (1.0 - gate_z) * gate_n;
    // h=1
    gate_r = sigmoid((0.4216620922088623) + (0.040358386933803558) * emb_t4_0 + (0.79457920789718628) * emb_t4_1 + (0.073323294520378113) * emb_t4_2 + (0.11622408032417297) * emb_t4_3 + (-0.33492177724838257) * emb_t4_4 + (0.015712980180978775) * emb_t4_5 + (-0.27669963240623474) * emb_t4_6 + (-0.028263602405786514) * emb_t4_7 + (0.63715058565139771) * emb_t4_8 + (-5.6999020576477051) * emb_t4_9 + (-3.4735171794891357) * emb_t4_10 + (0.53878825902938843) * emb_t4_11 + (0.41282382607460022) * emb_t4_12 + (0.52130669355392456) * emb_t4_13 + (0.032681141048669815) * emb_t4_14 + (0.0037251824978739023) * emb_t4_15 + (0.10511696338653564) * emb_t4_16 + (0.096871748566627502) * emb_t4_17 + (-1.4801664352416992) * emb_t4_18 + (0.89164203405380249) * emb_t4_19 + (0.37726473808288574) * emb_t4_20 + (-0.0081274267286062241) * emb_t4_21 + (-0.98772859573364258) * emb_t4_22 + (-0.021713085472583771) * emb_t4_23 + (0.05414251983165741) * emb_t4_24 + (-0.10559131950139999) * emb_t4_25 + (0.3659203052520752) * emb_t4_26 + (0.0032646018080413342) * emb_t4_27 + (-0.88622325658798218) * emb_t4_28 + (0.68386071920394897) * emb_t4_29 + (-0.57752048969268799) * emb_t4_30 + (-0.11037802696228027) * emb_t4_31);
    gate_z = sigmoid((-0.46039289236068726) + (0.060518428683280945) * emb_t4_0 + (1.1332238912582397) * emb_t4_1 + (0.038747049868106842) * emb_t4_2 + (-0.4428306519985199) * emb_t4_3 + (1.1608535051345825) * emb_t4_4 + (0.13420116901397705) * emb_t4_5 + (1.0308222770690918) * emb_t4_6 + (0.0410185307264328) * emb_t4_7 + (0.16079102456569672) * emb_t4_8 + (0.14993944764137268) * emb_t4_9 + (-0.35022842884063721) * emb_t4_10 + (-0.31914260983467102) * emb_t4_11 + (0.43606829643249512) * emb_t4_12 + (1.1248135566711426) * emb_t4_13 + (0.021003365516662598) * emb_t4_14 + (0.0059432140551507473) * emb_t4_15 + (-0.10131619870662689) * emb_t4_16 + (0.92381668090820312) * emb_t4_17 + (-0.13260744512081146) * emb_t4_18 + (0.18333296477794647) * emb_t4_19 + (-0.0073598409071564674) * emb_t4_20 + (0.0083366269245743752) * emb_t4_21 + (0.39938196539878845) * emb_t4_22 + (-0.23865433037281036) * emb_t4_23 + (0.2018158882856369) * emb_t4_24 + (-0.085929840803146362) * emb_t4_25 + (-0.91146039962768555) * emb_t4_26 + (0.016306772828102112) * emb_t4_27 + (-0.42052999138832092) * emb_t4_28 + (0.7816932201385498) * emb_t4_29 + (-0.84993302822113037) * emb_t4_30 + (0.026607520878314972) * emb_t4_31);
    gate_n = tanh((0.0017191440565511584) + (0.034440875053405762) * emb_t4_0 + (-0.66524612903594971) * emb_t4_1 + (0.065156638622283936) * emb_t4_2 + (-0.0072310366667807102) * emb_t4_3 + (-0.11210089921951294) * emb_t4_4 + (-0.019568353891372681) * emb_t4_5 + (0.044101700186729431) * emb_t4_6 + (-0.0176859050989151) * emb_t4_7 + (0.40532231330871582) * emb_t4_8 + (1.5651329755783081) * emb_t4_9 + (1.3349515199661255) * emb_t4_10 + (-0.28234502673149109) * emb_t4_11 + (-0.18285919725894928) * emb_t4_12 + (-0.69954246282577515) * emb_t4_13 + (-0.0063655716367065907) * emb_t4_14 + (-0.0084611810743808746) * emb_t4_15 + (0.03270857036113739) * emb_t4_16 + (-0.088633738458156586) * emb_t4_17 + (0.39253699779510498) * emb_t4_18 + (-0.799480140209198) * emb_t4_19 + (0.16929744184017181) * emb_t4_20 + (-0.0080615635961294174) * emb_t4_21 + (-0.018845891579985619) * emb_t4_22 + (0.0087021738290786743) * emb_t4_23 + (0.0067608607932925224) * emb_t4_24 + (-0.014747118577361107) * emb_t4_25 + (0.2206137478351593) * emb_t4_26 + (0.00846844632178545) * emb_t4_27 + (0.85196274518966675) * emb_t4_28 + (-1.0941895246505737) * emb_t4_29 + (0.46526119112968445) * emb_t4_30 + (0.18320520222187042) * emb_t4_31 + gate_r * (-0.033734701573848724));
    gru_0_rev_t4_h_1 = (1.0 - gate_z) * gate_n;
    // h=2
    gate_r = sigmoid((0.74615961313247681) + (-0.08885645866394043) * emb_t4_0 + (1.0937559604644775) * emb_t4_1 + (0.11653187125921249) * emb_t4_2 + (0.73037058115005493) * emb_t4_3 + (0.32688421010971069) * emb_t4_4 + (-1.1882870197296143) * emb_t4_5 + (-0.064901135861873627) * emb_t4_6 + (-0.41705429553985596) * emb_t4_7 + (0.56586074829101562) * emb_t4_8 + (-3.226313591003418) * emb_t4_9 + (-1.6568456888198853) * emb_t4_10 + (-0.39169976115226746) * emb_t4_11 + (0.61035889387130737) * emb_t4_12 + (0.35834527015686035) * emb_t4_13 + (-1.1571964025497437) * emb_t4_14 + (-0.33319815993309021) * emb_t4_15 + (0.75961244106292725) * emb_t4_16 + (-0.1129801943898201) * emb_t4_17 + (-1.5690505504608154) * emb_t4_18 + (1.4574296474456787) * emb_t4_19 + (0.54301714897155762) * emb_t4_20 + (-0.59782576560974121) * emb_t4_21 + (-1.8494070768356323) * emb_t4_22 + (-0.57249343395233154) * emb_t4_23 + (0.45289716124534607) * emb_t4_24 + (0.27596387267112732) * emb_t4_25 + (0.032521408051252365) * emb_t4_26 + (-0.24957029521465302) * emb_t4_27 + (-0.23151740431785583) * emb_t4_28 + (0.65897327661514282) * emb_t4_29 + (0.087767727673053741) * emb_t4_30 + (-0.68677932024002075) * emb_t4_31);
    gate_z = sigmoid((1.4295028448104858) + (0.0030123933684080839) * emb_t4_0 + (0.34719598293304443) * emb_t4_1 + (-0.010751851834356785) * emb_t4_2 + (0.2233523428440094) * emb_t4_3 + (0.051800966262817383) * emb_t4_4 + (0.0036630355753004551) * emb_t4_5 + (0.074413977563381195) * emb_t4_6 + (0.0042781578376889229) * emb_t4_7 + (0.53331613540649414) * emb_t4_8 + (0.00049478036817163229) * emb_t4_9 + (-0.38463446497917175) * emb_t4_10 + (0.66199463605880737) * emb_t4_11 + (0.19998748600482941) * emb_t4_12 + (-0.18887631595134735) * emb_t4_13 + (-0.0023455999325960875) * emb_t4_14 + (0.0091478358954191208) * emb_t4_15 + (-0.0051097404211759567) * emb_t4_16 + (-0.25639131665229797) * emb_t4_17 + (-0.33122223615646362) * emb_t4_18 + (0.051683567464351654) * emb_t4_19 + (0.39044225215911865) * emb_t4_20 + (0.00028479064349085093) * emb_t4_21 + (0.27298229932785034) * emb_t4_22 + (-0.010792865417897701) * emb_t4_23 + (-0.0038974529597908258) * emb_t4_24 + (-0.011434595100581646) * emb_t4_25 + (0.24560485780239105) * emb_t4_26 + (-0.0067862076684832573) * emb_t4_27 + (0.18143868446350098) * emb_t4_28 + (0.11124227941036224) * emb_t4_29 + (-0.16090299189090729) * emb_t4_30 + (-1.1402376890182495) * emb_t4_31);
    gate_n = tanh((-0.054261401295661926) + (-0.0029363944195210934) * emb_t4_0 + (-0.020234154537320137) * emb_t4_1 + (-0.035539023578166962) * emb_t4_2 + (0.087563574314117432) * emb_t4_3 + (-0.31429487466812134) * emb_t4_4 + (-0.30938434600830078) * emb_t4_5 + (-0.29067340493202209) * emb_t4_6 + (0.11690608412027359) * emb_t4_7 + (-0.021563621237874031) * emb_t4_8 + (0.82431697845458984) * emb_t4_9 + (0.11660616844892502) * emb_t4_10 + (-0.020250139757990837) * emb_t4_11 + (-0.056436717510223389) * emb_t4_12 + (-0.19005453586578369) * emb_t4_13 + (0.068130187690258026) * emb_t4_14 + (0.0094068422913551331) * emb_t4_15 + (-0.087542258203029633) * emb_t4_16 + (-0.27825480699539185) * emb_t4_17 + (0.34196183085441589) * emb_t4_18 + (-0.75081723928451538) * emb_t4_19 + (0.15506298840045929) * emb_t4_20 + (0.075114354491233826) * emb_t4_21 + (0.11321459710597992) * emb_t4_22 + (0.12183143198490143) * emb_t4_23 + (0.41414940357208252) * emb_t4_24 + (0.14087295532226562) * emb_t4_25 + (-0.2452787458896637) * emb_t4_26 + (-0.061310745775699615) * emb_t4_27 + (-0.33511528372764587) * emb_t4_28 + (-0.53857207298278809) * emb_t4_29 + (-0.01773926243185997) * emb_t4_30 + (0.18156217038631439) * emb_t4_31 + gate_r * (-0.073369190096855164));
    gru_0_rev_t4_h_2 = (1.0 - gate_z) * gate_n;
    // h=3
    gate_r = sigmoid((-1.2693327665328979) + (-0.18729329109191895) * emb_t4_0 + (0.89130485057830811) * emb_t4_1 + (0.37625452876091003) * emb_t4_2 + (-0.77646291255950928) * emb_t4_3 + (0.28546142578125) * emb_t4_4 + (0.1039729043841362) * emb_t4_5 + (0.58586239814758301) * emb_t4_6 + (-0.81807762384414673) * emb_t4_7 + (-0.48910436034202576) * emb_t4_8 + (0.076232723891735077) * emb_t4_9 + (0.0089441603049635887) * emb_t4_10 + (-0.92309528589248657) * emb_t4_11 + (-0.55719113349914551) * emb_t4_12 + (0.46199291944503784) * emb_t4_13 + (0.47896400094032288) * emb_t4_14 + (1.1286525726318359) * emb_t4_15 + (0.097555242478847504) * emb_t4_16 + (0.72513651847839355) * emb_t4_17 + (0.46851438283920288) * emb_t4_18 + (-0.59397679567337036) * emb_t4_19 + (-0.74950617551803589) * emb_t4_20 + (0.577414870262146) * emb_t4_21 + (0.7755962610244751) * emb_t4_22 + (0.1846974790096283) * emb_t4_23 + (0.081343889236450195) * emb_t4_24 + (1.7035981416702271) * emb_t4_25 + (-0.61382204294204712) * emb_t4_26 + (-0.70568162202835083) * emb_t4_27 + (-0.4217681884765625) * emb_t4_28 + (1.0495849847793579) * emb_t4_29 + (-0.52108216285705566) * emb_t4_30 + (0.454201340675354) * emb_t4_31);
    gate_z = sigmoid((1.6078463792800903) + (-0.001726062735542655) * emb_t4_0 + (0.077014490962028503) * emb_t4_1 + (-0.0044821808114647865) * emb_t4_2 + (0.10917814075946808) * emb_t4_3 + (0.37941429018974304) * emb_t4_4 + (0.0041542504914104939) * emb_t4_5 + (0.25740176439285278) * emb_t4_6 + (-0.0036479898262768984) * emb_t4_7 + (-0.059008967131376266) * emb_t4_8 + (0.12668302655220032) * emb_t4_9 + (0.082020103931427002) * emb_t4_10 + (0.2527521550655365) * emb_t4_11 + (0.070899859070777893) * emb_t4_12 + (0.47202906012535095) * emb_t4_13 + (0.00078425806714221835) * emb_t4_14 + (-0.0017647622153162956) * emb_t4_15 + (-0.001397377229295671) * emb_t4_16 + (-0.076351754367351532) * emb_t4_17 + (0.14220768213272095) * emb_t4_18 + (-0.21766521036624908) * emb_t4_19 + (0.2430431991815567) * emb_t4_20 + (-0.0016410897951573133) * emb_t4_21 + (-0.35762676596641541) * emb_t4_22 + (-0.00052992359269410372) * emb_t4_23 + (-0.0022541859652847052) * emb_t4_24 + (0.0086500328034162521) * emb_t4_25 + (0.12148726731538773) * emb_t4_26 + (-0.0031367745250463486) * emb_t4_27 + (0.019585469737648964) * emb_t4_28 + (0.3592568039894104) * emb_t4_29 + (0.049357231706380844) * emb_t4_30 + (0.34058290719985962) * emb_t4_31);
    gate_n = tanh((0.4309772253036499) + (-0.026210254058241844) * emb_t4_0 + (0.23744942247867584) * emb_t4_1 + (-0.061120368540287018) * emb_t4_2 + (0.57514357566833496) * emb_t4_3 + (-0.16420482099056244) * emb_t4_4 + (-0.15247580409049988) * emb_t4_5 + (-0.025387577712535858) * emb_t4_6 + (-0.063496649265289307) * emb_t4_7 + (0.76471704244613647) * emb_t4_8 + (-0.86447417736053467) * emb_t4_9 + (-0.58499574661254883) * emb_t4_10 + (0.30235102772712708) * emb_t4_11 + (0.34290716052055359) * emb_t4_12 + (0.31330606341362) * emb_t4_13 + (-0.039406627416610718) * emb_t4_14 + (0.059008199721574783) * emb_t4_15 + (0.071378849446773529) * emb_t4_16 + (-0.27085781097412109) * emb_t4_17 + (-1.2381625175476074) * emb_t4_18 + (0.80788356065750122) * emb_t4_19 + (0.4392111599445343) * emb_t4_20 + (0.063526660203933716) * emb_t4_21 + (-1.7766882181167603) * emb_t4_22 + (0.044288210570812225) * emb_t4_23 + (0.029589410871267319) * emb_t4_24 + (-0.075754851102828979) * emb_t4_25 + (0.53334522247314453) * emb_t4_26 + (0.054795470088720322) * emb_t4_27 + (-0.4979516863822937) * emb_t4_28 + (0.11023539304733276) * emb_t4_29 + (-0.12318271398544312) * emb_t4_30 + (-0.99751871824264526) * emb_t4_31 + gate_r * (-0.10919719189405441));
    gru_0_rev_t4_h_3 = (1.0 - gate_z) * gate_n;
    // h=4
    gate_r = sigmoid((-1.3685516119003296) + (0.2236257940530777) * emb_t4_0 + (0.2315046638250351) * emb_t4_1 + (-0.0069134663790464401) * emb_t4_2 + (-1.3870807886123657) * emb_t4_3 + (-0.10641256719827652) * emb_t4_4 + (-0.53056198358535767) * emb_t4_5 + (-0.11012519896030426) * emb_t4_6 + (-0.10570209473371506) * emb_t4_7 + (-0.66879916191101074) * emb_t4_8 + (0.23310942947864532) * emb_t4_9 + (0.59494161605834961) * emb_t4_10 + (-1.0102554559707642) * emb_t4_11 + (-0.85333633422851562) * emb_t4_12 + (0.24490706622600555) * emb_t4_13 + (-0.5255168080329895) * emb_t4_14 + (0.31045553088188171) * emb_t4_15 + (-0.26299077272415161) * emb_t4_16 + (0.8356509804725647) * emb_t4_17 + (0.0081240134313702583) * emb_t4_18 + (-0.20643709599971771) * emb_t4_19 + (-0.74964088201522827) * emb_t4_20 + (-0.4777131974697113) * emb_t4_21 + (0.11391793936491013) * emb_t4_22 + (0.72878921031951904) * emb_t4_23 + (-0.38144084811210632) * emb_t4_24 + (0.33510813117027283) * emb_t4_25 + (-1.3575292825698853) * emb_t4_26 + (-0.18604283034801483) * emb_t4_27 + (-0.43928316235542297) * emb_t4_28 + (-0.24148491024971008) * emb_t4_29 + (-0.30673620104789734) * emb_t4_30 + (1.8704019784927368) * emb_t4_31);
    gate_z = sigmoid((2.4346427917480469) + (0.076031491160392761) * emb_t4_0 + (-0.07498527318239212) * emb_t4_1 + (-0.12274941056966782) * emb_t4_2 + (1.3836251497268677) * emb_t4_3 + (-0.38983270525932312) * emb_t4_4 + (-0.34554648399353027) * emb_t4_5 + (-0.27028623223304749) * emb_t4_6 + (0.30968695878982544) * emb_t4_7 + (1.8473078012466431) * emb_t4_8 + (-0.43921613693237305) * emb_t4_9 + (-0.56298470497131348) * emb_t4_10 + (1.5358134508132935) * emb_t4_11 + (1.5420798063278198) * emb_t4_12 + (-0.065896123647689819) * emb_t4_13 + (-0.10415127873420715) * emb_t4_14 + (0.080940008163452148) * emb_t4_15 + (-0.26589882373809814) * emb_t4_16 + (-0.45362770557403564) * emb_t4_17 + (-0.62490648031234741) * emb_t4_18 + (0.78356188535690308) * emb_t4_19 + (1.0456368923187256) * emb_t4_20 + (-0.0038928152061998844) * emb_t4_21 + (-0.5675768256187439) * emb_t4_22 + (0.049756228923797607) * emb_t4_23 + (-0.14089852571487427) * emb_t4_24 + (0.065446317195892334) * emb_t4_25 + (0.33768534660339355) * emb_t4_26 + (0.0066933473572134972) * emb_t4_27 + (-0.19684574007987976) * emb_t4_28 + (0.13190034031867981) * emb_t4_29 + (-0.26188069581985474) * emb_t4_30 + (-2.0341219902038574) * emb_t4_31);
    gate_n = tanh((-0.016163228079676628) + (-0.027884617447853088) * emb_t4_0 + (-0.080985419452190399) * emb_t4_1 + (-0.035114459693431854) * emb_t4_2 + (0.16090622544288635) * emb_t4_3 + (-0.43337962031364441) * emb_t4_4 + (0.059590533375740051) * emb_t4_5 + (-0.17441758513450623) * emb_t4_6 + (-0.122524693608284) * emb_t4_7 + (-0.21187984943389893) * emb_t4_8 + (-0.44347575306892395) * emb_t4_9 + (0.18624871969223022) * emb_t4_10 + (-0.23481367528438568) * emb_t4_11 + (0.091380417346954346) * emb_t4_12 + (0.32930436730384827) * emb_t4_13 + (-0.0055515216663479805) * emb_t4_14 + (0.005958891473710537) * emb_t4_15 + (-0.019560828804969788) * emb_t4_16 + (0.16434705257415771) * emb_t4_17 + (-0.32695618271827698) * emb_t4_18 + (-0.22283002734184265) * emb_t4_19 + (-0.12126600742340088) * emb_t4_20 + (-0.021952878683805466) * emb_t4_21 + (-0.062434587627649307) * emb_t4_22 + (0.056233879178762436) * emb_t4_23 + (-0.053126074373722076) * emb_t4_24 + (0.071384981274604797) * emb_t4_25 + (-0.20940221846103668) * emb_t4_26 + (-0.03841070830821991) * emb_t4_27 + (0.072856955230236053) * emb_t4_28 + (-0.30034703016281128) * emb_t4_29 + (-0.0074970419518649578) * emb_t4_30 + (-0.014893620274960995) * emb_t4_31 + gate_r * (-0.0051035168580710888));
    gru_0_rev_t4_h_4 = (1.0 - gate_z) * gate_n;
    // h=5
    gate_r = sigmoid((-1.5634896755218506) + (-0.62903255224227905) * emb_t4_0 + (0.36245304346084595) * emb_t4_1 + (-1.5545089244842529) * emb_t4_2 + (-1.2221488952636719) * emb_t4_3 + (0.65975433588027954) * emb_t4_4 + (2.0174753665924072) * emb_t4_5 + (0.62188005447387695) * emb_t4_6 + (0.56032282114028931) * emb_t4_7 + (-1.1194415092468262) * emb_t4_8 + (0.67931801080703735) * emb_t4_9 + (0.99105501174926758) * emb_t4_10 + (-0.79531687498092651) * emb_t4_11 + (-0.61260032653808594) * emb_t4_12 + (0.48130452632904053) * emb_t4_13 + (0.67230534553527832) * emb_t4_14 + (-0.74714452028274536) * emb_t4_15 + (-0.75569170713424683) * emb_t4_16 + (0.44226035475730896) * emb_t4_17 + (0.8893393874168396) * emb_t4_18 + (-0.861533522605896) * emb_t4_19 + (-0.84034454822540283) * emb_t4_20 + (-0.22506797313690186) * emb_t4_21 + (0.74993497133255005) * emb_t4_22 + (1.0221257209777832) * emb_t4_23 + (0.57013022899627686) * emb_t4_24 + (0.77331399917602539) * emb_t4_25 + (-0.71970087289810181) * emb_t4_26 + (1.2238805294036865) * emb_t4_27 + (-0.45674803853034973) * emb_t4_28 + (0.46003538370132446) * emb_t4_29 + (-0.019631205126643181) * emb_t4_30 + (0.46944329142570496) * emb_t4_31);
    gate_z = sigmoid((1.4312663078308105) + (-0.16836337745189667) * emb_t4_0 + (0.44441503286361694) * emb_t4_1 + (0.16264483332633972) * emb_t4_2 + (1.0687229633331299) * emb_t4_3 + (-0.57740002870559692) * emb_t4_4 + (0.24474041163921356) * emb_t4_5 + (-0.72791266441345215) * emb_t4_6 + (-0.090155191719532013) * emb_t4_7 + (0.52850556373596191) * emb_t4_8 + (-0.095212966203689575) * emb_t4_9 + (-0.75963431596755981) * emb_t4_10 + (0.29542917013168335) * emb_t4_11 + (0.52279412746429443) * emb_t4_12 + (0.2410600334405899) * emb_t4_13 + (-0.10806937515735626) * emb_t4_14 + (-0.29624739289283752) * emb_t4_15 + (0.1450391411781311) * emb_t4_16 + (-0.64505428075790405) * emb_t4_17 + (-0.70188021659851074) * emb_t4_18 + (0.37090384960174561) * emb_t4_19 + (0.72022032737731934) * emb_t4_20 + (-0.4697345495223999) * emb_t4_21 + (-1.1323502063751221) * emb_t4_22 + (0.8552585244178772) * emb_t4_23 + (-0.4344315230846405) * emb_t4_24 + (0.35562679171562195) * emb_t4_25 + (1.0576106309890747) * emb_t4_26 + (0.1960688978433609) * emb_t4_27 + (-0.066304668784141541) * emb_t4_28 + (0.4063924252986908) * emb_t4_29 + (0.48414763808250427) * emb_t4_30 + (-0.76584368944168091) * emb_t4_31);
    gate_n = tanh((-0.095938041806221008) + (0.019716093316674232) * emb_t4_0 + (-0.10058939456939697) * emb_t4_1 + (0.042951811105012894) * emb_t4_2 + (-0.24419373273849487) * emb_t4_3 + (0.19518949091434479) * emb_t4_4 + (0.031617607921361923) * emb_t4_5 + (-0.091009944677352905) * emb_t4_6 + (-0.12042555958032608) * emb_t4_7 + (0.024757981300354004) * emb_t4_8 + (0.084511339664459229) * emb_t4_9 + (0.0086361942812800407) * emb_t4_10 + (-0.04753856360912323) * emb_t4_11 + (-0.091400280594825745) * emb_t4_12 + (-0.13011062145233154) * emb_t4_13 + (0.041920062154531479) * emb_t4_14 + (-0.018763028085231781) * emb_t4_15 + (0.064093425869941711) * emb_t4_16 + (-0.20723046362400055) * emb_t4_17 + (0.41586199402809143) * emb_t4_18 + (-0.29028573632240295) * emb_t4_19 + (-0.40064457058906555) * emb_t4_20 + (-0.022126013413071632) * emb_t4_21 + (-0.0042889942415058613) * emb_t4_22 + (-0.065435081720352173) * emb_t4_23 + (0.02503061480820179) * emb_t4_24 + (0.017134957015514374) * emb_t4_25 + (0.19566901028156281) * emb_t4_26 + (-0.005349836777895689) * emb_t4_27 + (0.24285364151000977) * emb_t4_28 + (-0.4245639443397522) * emb_t4_29 + (-0.36877095699310303) * emb_t4_30 + (0.13548864424228668) * emb_t4_31 + gate_r * (0.30367663502693176));
    gru_0_rev_t4_h_5 = (1.0 - gate_z) * gate_n;
    // h=6
    gate_r = sigmoid((-0.16276088356971741) + (0.20025475323200226) * emb_t4_0 + (0.17347058653831482) * emb_t4_1 + (0.35707581043243408) * emb_t4_2 + (0.46974825859069824) * emb_t4_3 + (0.22605399787425995) * emb_t4_4 + (-0.32701298594474792) * emb_t4_5 + (0.16208638250827789) * emb_t4_6 + (0.052859973162412643) * emb_t4_7 + (-0.19004581868648529) * emb_t4_8 + (-0.77393364906311035) * emb_t4_9 + (-0.43571323156356812) * emb_t4_10 + (0.16889031231403351) * emb_t4_11 + (0.090000458061695099) * emb_t4_12 + (0.39088490605354309) * emb_t4_13 + (-0.22382055222988129) * emb_t4_14 + (0.053270865231752396) * emb_t4_15 + (-0.044224943965673447) * emb_t4_16 + (0.27830639481544495) * emb_t4_17 + (-0.60966300964355469) * emb_t4_18 + (0.19745741784572601) * emb_t4_19 + (-0.1724993884563446) * emb_t4_20 + (0.15035286545753479) * emb_t4_21 + (0.082759574055671692) * emb_t4_22 + (0.41038119792938232) * emb_t4_23 + (0.065190263092517853) * emb_t4_24 + (0.06509023904800415) * emb_t4_25 + (0.29210397601127625) * emb_t4_26 + (-0.041783846914768219) * emb_t4_27 + (-0.28990316390991211) * emb_t4_28 + (0.36020195484161377) * emb_t4_29 + (0.42040523886680603) * emb_t4_30 + (0.37163341045379639) * emb_t4_31);
    gate_z = sigmoid((0.43828460574150085) + (-0.11457296460866928) * emb_t4_0 + (0.95512300729751587) * emb_t4_1 + (-0.1657164990901947) * emb_t4_2 + (0.082567401230335236) * emb_t4_3 + (0.038362599909305573) * emb_t4_4 + (-0.21106328070163727) * emb_t4_5 + (-0.10894918441772461) * emb_t4_6 + (0.04673212394118309) * emb_t4_7 + (0.14320369064807892) * emb_t4_8 + (-1.4584397077560425) * emb_t4_9 + (-0.94442278146743774) * emb_t4_10 + (0.28447550535202026) * emb_t4_11 + (0.33804842829704285) * emb_t4_12 + (0.73368620872497559) * emb_t4_13 + (0.031311057507991791) * emb_t4_14 + (0.04951082170009613) * emb_t4_15 + (0.012886076234281063) * emb_t4_16 + (-0.029510708525776863) * emb_t4_17 + (-0.8211861252784729) * emb_t4_18 + (0.97318583726882935) * emb_t4_19 + (0.065554253756999969) * emb_t4_20 + (0.21369661390781403) * emb_t4_21 + (-0.60520964860916138) * emb_t4_22 + (-0.10672582685947418) * emb_t4_23 + (-0.083651915192604065) * emb_t4_24 + (-0.12971997261047363) * emb_t4_25 + (-0.15323644876480103) * emb_t4_26 + (0.092682525515556335) * emb_t4_27 + (-0.73803234100341797) * emb_t4_28 + (0.36626550555229187) * emb_t4_29 + (-0.61820012331008911) * emb_t4_30 + (-0.57488489151000977) * emb_t4_31);
    gate_n = tanh((-0.045015387237071991) + (0.017269458621740341) * emb_t4_0 + (0.37110093235969543) * emb_t4_1 + (-0.0012924645561724901) * emb_t4_2 + (-0.20327292382717133) * emb_t4_3 + (-0.22391784191131592) * emb_t4_4 + (-0.0038543003611266613) * emb_t4_5 + (-0.082848511636257172) * emb_t4_6 + (-0.055194873362779617) * emb_t4_7 + (-0.095518298447132111) * emb_t4_8 + (-0.92083251476287842) * emb_t4_9 + (-0.44550743699073792) * emb_t4_10 + (0.060151893645524979) * emb_t4_11 + (0.18334275484085083) * emb_t4_12 + (0.48310336470603943) * emb_t4_13 + (0.0055563142523169518) * emb_t4_14 + (0.023337433114647865) * emb_t4_15 + (-0.028754057362675667) * emb_t4_16 + (0.41201657056808472) * emb_t4_17 + (-0.9497947096824646) * emb_t4_18 + (0.66103571653366089) * emb_t4_19 + (0.014644306153059006) * emb_t4_20 + (0.0090339388698339462) * emb_t4_21 + (-0.37559798359870911) * emb_t4_22 + (0.0049393344670534134) * emb_t4_23 + (0.023944161832332611) * emb_t4_24 + (-0.01578749343752861) * emb_t4_25 + (-0.28385165333747864) * emb_t4_26 + (0.0053995572961866856) * emb_t4_27 + (-0.5838969349861145) * emb_t4_28 + (0.5506671667098999) * emb_t4_29 + (-0.062937475740909576) * emb_t4_30 + (0.48956561088562012) * emb_t4_31 + gate_r * (-0.11357367038726807));
    gru_0_rev_t4_h_6 = (1.0 - gate_z) * gate_n;
    // h=7
    gate_r = sigmoid((1.9255975484848022) + (0.55523896217346191) * emb_t4_0 + (0.89170128107070923) * emb_t4_1 + (0.2156120091676712) * emb_t4_2 + (1.1129550933837891) * emb_t4_3 + (-0.53035211563110352) * emb_t4_4 + (-0.25143095850944519) * emb_t4_5 + (-0.50795894861221313) * emb_t4_6 + (0.866973876953125) * emb_t4_7 + (2.0420713424682617) * emb_t4_8 + (-1.1865967512130737) * emb_t4_9 + (-0.8294302225112915) * emb_t4_10 + (1.4127449989318848) * emb_t4_11 + (8.7584238052368164) * emb_t4_12 + (0.27749598026275635) * emb_t4_13 + (-0.32566460967063904) * emb_t4_14 + (0.3347194492816925) * emb_t4_15 + (0.18621660768985748) * emb_t4_16 + (-0.52024084329605103) * emb_t4_17 + (-1.1663960218429565) * emb_t4_18 + (1.1315882205963135) * emb_t4_19 + (0.93168950080871582) * emb_t4_20 + (-0.81291139125823975) * emb_t4_21 + (-1.8350151777267456) * emb_t4_22 + (-0.10416764765977859) * emb_t4_23 + (-0.34112545847892761) * emb_t4_24 + (-0.97905004024505615) * emb_t4_25 + (0.89600902795791626) * emb_t4_26 + (0.00066087965387851) * emb_t4_27 + (-0.92635774612426758) * emb_t4_28 + (0.47958353161811829) * emb_t4_29 + (0.7244299054145813) * emb_t4_30 + (-3.2421584129333496) * emb_t4_31);
    gate_z = sigmoid((1.012992262840271) + (-0.047066505998373032) * emb_t4_0 + (-0.73198771476745605) * emb_t4_1 + (-0.042197540402412415) * emb_t4_2 + (0.72793388366699219) * emb_t4_3 + (-0.4706551730632782) * emb_t4_4 + (0.062597908079624176) * emb_t4_5 + (-0.78531628847122192) * emb_t4_6 + (0.13587543368339539) * emb_t4_7 + (0.19500631093978882) * emb_t4_8 + (0.78638374805450439) * emb_t4_9 + (0.42679259181022644) * emb_t4_10 + (0.21645635366439819) * emb_t4_11 + (0.42666754126548767) * emb_t4_12 + (-0.20513574779033661) * emb_t4_13 + (-0.064165227115154266) * emb_t4_14 + (-0.015597824938595295) * emb_t4_15 + (-0.0016061861533671618) * emb_t4_16 + (-0.573924720287323) * emb_t4_17 + (0.059122134000062943) * emb_t4_18 + (0.083723932504653931) * emb_t4_19 + (0.60947668552398682) * emb_t4_20 + (0.036745931953191757) * emb_t4_21 + (0.16261662542819977) * emb_t4_22 + (-0.012009855359792709) * emb_t4_23 + (0.047605734318494797) * emb_t4_24 + (0.042569983750581741) * emb_t4_25 + (0.58801406621932983) * emb_t4_26 + (-0.049603130668401718) * emb_t4_27 + (0.46339148283004761) * emb_t4_28 + (-0.76598042249679565) * emb_t4_29 + (0.37158751487731934) * emb_t4_30 + (-0.30164533853530884) * emb_t4_31);
    gate_n = tanh((-0.070102639496326447) + (-0.0083256987854838371) * emb_t4_0 + (0.48970863223075867) * emb_t4_1 + (-0.015992360189557076) * emb_t4_2 + (-0.019377069547772408) * emb_t4_3 + (0.51630574464797974) * emb_t4_4 + (-0.10033709555864334) * emb_t4_5 + (-0.031198322772979736) * emb_t4_6 + (-0.025811705738306046) * emb_t4_7 + (0.15150557458400726) * emb_t4_8 + (0.025755628943443298) * emb_t4_9 + (0.28951391577720642) * emb_t4_10 + (0.13297167420387268) * emb_t4_11 + (-0.16793139278888702) * emb_t4_12 + (0.42544922232627869) * emb_t4_13 + (0.013488370925188065) * emb_t4_14 + (0.094314821064472198) * emb_t4_15 + (-0.049746453762054443) * emb_t4_16 + (-0.41539847850799561) * emb_t4_17 + (-0.54253751039505005) * emb_t4_18 + (0.19768832623958588) * emb_t4_19 + (-0.24333646893501282) * emb_t4_20 + (0.12760193645954132) * emb_t4_21 + (-0.019673768430948257) * emb_t4_22 + (0.12006796896457672) * emb_t4_23 + (0.059151895344257355) * emb_t4_24 + (-0.035049080848693848) * emb_t4_25 + (-0.20564790070056915) * emb_t4_26 + (-0.02051263116300106) * emb_t4_27 + (-0.5644868016242981) * emb_t4_28 + (0.25314801931381226) * emb_t4_29 + (-0.29811897873878479) * emb_t4_30 + (-0.21613103151321411) * emb_t4_31 + gate_r * (-0.074222423136234283));
    gru_0_rev_t4_h_7 = (1.0 - gate_z) * gate_n;
    // h=8
    gate_r = sigmoid((-0.088317222893238068) + (-0.29859715700149536) * emb_t4_0 + (0.59277522563934326) * emb_t4_1 + (-0.4380335807800293) * emb_t4_2 + (-0.35593768954277039) * emb_t4_3 + (0.26711726188659668) * emb_t4_4 + (-0.067696087062358856) * emb_t4_5 + (-0.09071805328130722) * emb_t4_6 + (0.085169240832328796) * emb_t4_7 + (0.37693926692008972) * emb_t4_8 + (-0.45889070630073547) * emb_t4_9 + (-0.59728115797042847) * emb_t4_10 + (0.070683427155017853) * emb_t4_11 + (0.6882970929145813) * emb_t4_12 + (0.7901725172996521) * emb_t4_13 + (-0.63566619157791138) * emb_t4_14 + (0.295259028673172) * emb_t4_15 + (-0.11202562600374222) * emb_t4_16 + (0.10295461118221283) * emb_t4_17 + (-0.43338054418563843) * emb_t4_18 + (0.82146245241165161) * emb_t4_19 + (-0.51971602439880371) * emb_t4_20 + (0.018043039366602898) * emb_t4_21 + (-1.2643245458602905) * emb_t4_22 + (-0.088630355894565582) * emb_t4_23 + (-0.6161695122718811) * emb_t4_24 + (-0.53258198499679565) * emb_t4_25 + (-0.12352132052183151) * emb_t4_26 + (0.53737556934356689) * emb_t4_27 + (-0.31555074453353882) * emb_t4_28 + (0.64074826240539551) * emb_t4_29 + (-0.18776631355285645) * emb_t4_30 + (-0.63243919610977173) * emb_t4_31);
    gate_z = sigmoid((1.7676719427108765) + (-0.00023765943478792906) * emb_t4_0 + (-0.67883878946304321) * emb_t4_1 + (0.019546473398804665) * emb_t4_2 + (0.57504260540008545) * emb_t4_3 + (-0.56773644685745239) * emb_t4_4 + (-0.038961723446846008) * emb_t4_5 + (-0.59113162755966187) * emb_t4_6 + (-0.053194526582956314) * emb_t4_7 + (0.73442691564559937) * emb_t4_8 + (-0.065437562763690948) * emb_t4_9 + (-0.70704537630081177) * emb_t4_10 + (1.3342037200927734) * emb_t4_11 + (0.54119563102722168) * emb_t4_12 + (-0.26398104429244995) * emb_t4_13 + (-0.044033762067556381) * emb_t4_14 + (0.0056064622476696968) * emb_t4_15 + (-0.024803906679153442) * emb_t4_16 + (-0.90262460708618164) * emb_t4_17 + (-0.18564625084400177) * emb_t4_18 + (0.4561082124710083) * emb_t4_19 + (0.85451072454452515) * emb_t4_20 + (-0.053171802312135696) * emb_t4_21 + (-0.83141034841537476) * emb_t4_22 + (0.027176834642887115) * emb_t4_23 + (-0.063192494213581085) * emb_t4_24 + (0.055789001286029816) * emb_t4_25 + (0.82528162002563477) * emb_t4_26 + (0.0019977150950580835) * emb_t4_27 + (0.062262360006570816) * emb_t4_28 + (-0.41623932123184204) * emb_t4_29 + (0.8691137433052063) * emb_t4_30 + (-0.74443256855010986) * emb_t4_31);
    gate_n = tanh((0.11516551673412323) + (-0.30722233653068542) * emb_t4_0 + (0.21935297548770905) * emb_t4_1 + (-0.10048635303974152) * emb_t4_2 + (0.60413885116577148) * emb_t4_3 + (-0.00069453363539651036) * emb_t4_4 + (-0.060450449585914612) * emb_t4_5 + (0.4743863046169281) * emb_t4_6 + (0.35428830981254578) * emb_t4_7 + (0.89534968137741089) * emb_t4_8 + (-1.1169939041137695) * emb_t4_9 + (-0.90294241905212402) * emb_t4_10 + (0.3525691032409668) * emb_t4_11 + (0.91655135154724121) * emb_t4_12 + (0.38453042507171631) * emb_t4_13 + (0.27479523420333862) * emb_t4_14 + (-0.021351942792534828) * emb_t4_15 + (-0.36118367314338684) * emb_t4_16 + (0.3721655011177063) * emb_t4_17 + (-1.381151556968689) * emb_t4_18 + (1.558931827545166) * emb_t4_19 + (0.24192021787166595) * emb_t4_20 + (0.19281555712223053) * emb_t4_21 + (-2.0417885780334473) * emb_t4_22 + (0.18458203971385956) * emb_t4_23 + (0.38974288105964661) * emb_t4_24 + (0.071693979203701019) * emb_t4_25 + (0.37011626362800598) * emb_t4_26 + (-0.72757446765899658) * emb_t4_27 + (-0.70288264751434326) * emb_t4_28 + (-0.043969228863716125) * emb_t4_29 + (-0.49711495637893677) * emb_t4_30 + (-0.20480358600616455) * emb_t4_31 + gate_r * (-0.068669766187667847));
    gru_0_rev_t4_h_8 = (1.0 - gate_z) * gate_n;
    // h=9
    gate_r = sigmoid((0.9948272705078125) + (-0.15560701489448547) * emb_t4_0 + (0.93296557664871216) * emb_t4_1 + (-0.29702147841453552) * emb_t4_2 + (0.0034452064428478479) * emb_t4_3 + (0.37517359852790833) * emb_t4_4 + (0.62616831064224243) * emb_t4_5 + (0.54468649625778198) * emb_t4_6 + (-2.6662132740020752) * emb_t4_7 + (3.7957842350006104) * emb_t4_8 + (-1.1920335292816162) * emb_t4_9 + (-1.2930651903152466) * emb_t4_10 + (0.77808529138565063) * emb_t4_11 + (7.5570454597473145) * emb_t4_12 + (0.56379145383834839) * emb_t4_13 + (-0.25856849551200867) * emb_t4_14 + (0.26747101545333862) * emb_t4_15 + (-0.49149933457374573) * emb_t4_16 + (0.32623070478439331) * emb_t4_17 + (-1.2964415550231934) * emb_t4_18 + (1.7554880380630493) * emb_t4_19 + (-0.023007405921816826) * emb_t4_20 + (0.77137076854705811) * emb_t4_21 + (-4.7274293899536133) * emb_t4_22 + (-0.35579517483711243) * emb_t4_23 + (-0.098790682852268219) * emb_t4_24 + (-0.97251492738723755) * emb_t4_25 + (-0.14317280054092407) * emb_t4_26 + (-0.80601811408996582) * emb_t4_27 + (-0.23854458332061768) * emb_t4_28 + (0.3480689525604248) * emb_t4_29 + (-0.079403534531593323) * emb_t4_30 + (-2.862332820892334) * emb_t4_31);
    gate_z = sigmoid((0.37533152103424072) + (-0.030614938586950302) * emb_t4_0 + (1.6962347030639648) * emb_t4_1 + (0.15319781005382538) * emb_t4_2 + (0.27374917268753052) * emb_t4_3 + (0.72963517904281616) * emb_t4_4 + (-0.11105795204639435) * emb_t4_5 + (0.23851336538791656) * emb_t4_6 + (-0.067529633641242981) * emb_t4_7 + (0.30174866318702698) * emb_t4_8 + (-2.0908222198486328) * emb_t4_9 + (-1.0966730117797852) * emb_t4_10 + (0.60387927293777466) * emb_t4_11 + (0.29930877685546875) * emb_t4_12 + (0.98631161451339722) * emb_t4_13 + (0.0058492203243076801) * emb_t4_14 + (-0.049653958529233932) * emb_t4_15 + (0.13023962080478668) * emb_t4_16 + (0.07884661853313446) * emb_t4_17 + (-0.42228594422340393) * emb_t4_18 + (1.0615423917770386) * emb_t4_19 + (-0.13277958333492279) * emb_t4_20 + (0.010803588666021824) * emb_t4_21 + (-0.48536893725395203) * emb_t4_22 + (0.055356647819280624) * emb_t4_23 + (-0.063386350870132446) * emb_t4_24 + (-0.25398683547973633) * emb_t4_25 + (-0.22189944982528687) * emb_t4_26 + (0.048635315150022507) * emb_t4_27 + (-0.90204781293869019) * emb_t4_28 + (1.1696432828903198) * emb_t4_29 + (-0.25330430269241333) * emb_t4_30 + (0.17070676386356354) * emb_t4_31);
    gate_n = tanh((0.23018018901348114) + (0.040882468223571777) * emb_t4_0 + (0.017970947548747063) * emb_t4_1 + (-0.059332888573408127) * emb_t4_2 + (-0.55593621730804443) * emb_t4_3 + (-0.28659060597419739) * emb_t4_4 + (0.073795787990093231) * emb_t4_5 + (-0.15439136326313019) * emb_t4_6 + (0.40341395139694214) * emb_t4_7 + (1.1105508804321289) * emb_t4_8 + (-0.0077962786890566349) * emb_t4_9 + (-0.59185028076171875) * emb_t4_10 + (0.29747265577316284) * emb_t4_11 + (0.81642383337020874) * emb_t4_12 + (-0.388226717710495) * emb_t4_13 + (-0.094587624073028564) * emb_t4_14 + (-0.055437855422496796) * emb_t4_15 + (-0.36119735240936279) * emb_t4_16 + (-0.055192776024341583) * emb_t4_17 + (-0.8903014063835144) * emb_t4_18 + (0.59483474493026733) * emb_t4_19 + (0.041678100824356079) * emb_t4_20 + (0.008398003876209259) * emb_t4_21 + (-0.68829488754272461) * emb_t4_22 + (0.36530813574790955) * emb_t4_23 + (0.17174878716468811) * emb_t4_24 + (0.17922626435756683) * emb_t4_25 + (0.15266311168670654) * emb_t4_26 + (-0.17142131924629211) * emb_t4_27 + (-0.35156989097595215) * emb_t4_28 + (0.22318530082702637) * emb_t4_29 + (0.48994293808937073) * emb_t4_30 + (-0.92399001121520996) * emb_t4_31 + gate_r * (0.96686816215515137));
    gru_0_rev_t4_h_9 = (1.0 - gate_z) * gate_n;
    // h=10
    gate_r = sigmoid((0.88041150569915771) + (-0.33314657211303711) * emb_t4_0 + (-0.061852548271417618) * emb_t4_1 + (0.15153881907463074) * emb_t4_2 + (0.73445171117782593) * emb_t4_3 + (-1.0025272369384766) * emb_t4_4 + (0.013858617283403873) * emb_t4_5 + (-0.65061432123184204) * emb_t4_6 + (0.1410490870475769) * emb_t4_7 + (0.62026971578598022) * emb_t4_8 + (0.11467281728982925) * emb_t4_9 + (0.28752008080482483) * emb_t4_10 + (0.80265837907791138) * emb_t4_11 + (1.5358299016952515) * emb_t4_12 + (-1.0008670091629028) * emb_t4_13 + (-0.91726851463317871) * emb_t4_14 + (0.20866914093494415) * emb_t4_15 + (-0.65957295894622803) * emb_t4_16 + (-0.40234485268592834) * emb_t4_17 + (-0.49843314290046692) * emb_t4_18 + (0.29021480679512024) * emb_t4_19 + (0.49456650018692017) * emb_t4_20 + (0.17322084307670593) * emb_t4_21 + (-0.30176076292991638) * emb_t4_22 + (-0.17468239367008209) * emb_t4_23 + (-0.15749503672122955) * emb_t4_24 + (0.41441875696182251) * emb_t4_25 + (0.78653347492218018) * emb_t4_26 + (-0.81280392408370972) * emb_t4_27 + (0.50572609901428223) * emb_t4_28 + (-0.55641835927963257) * emb_t4_29 + (1.1146214008331299) * emb_t4_30 + (-0.57240164279937744) * emb_t4_31);
    gate_z = sigmoid((0.94025146961212158) + (-0.055128280073404312) * emb_t4_0 + (-0.38388177752494812) * emb_t4_1 + (-0.0075555485673248768) * emb_t4_2 + (0.45786809921264648) * emb_t4_3 + (-0.768807053565979) * emb_t4_4 + (0.048790626227855682) * emb_t4_5 + (-0.82025003433227539) * emb_t4_6 + (0.054189302027225494) * emb_t4_7 + (0.21040645241737366) * emb_t4_8 + (-0.17354248464107513) * emb_t4_9 + (-0.39329808950424194) * emb_t4_10 + (0.88528746366500854) * emb_t4_11 + (0.37616336345672607) * emb_t4_12 + (-0.16758330166339874) * emb_t4_13 + (0.0810728520154953) * emb_t4_14 + (-0.067571081221103668) * emb_t4_15 + (-0.034666981548070908) * emb_t4_16 + (-0.81840217113494873) * emb_t4_17 + (-0.56302231550216675) * emb_t4_18 + (-0.20403428375720978) * emb_t4_19 + (0.40622910857200623) * emb_t4_20 + (-0.0047821858897805214) * emb_t4_21 + (-0.38002270460128784) * emb_t4_22 + (-0.041609831154346466) * emb_t4_23 + (0.0048080887645483017) * emb_t4_24 + (0.11000420898199081) * emb_t4_25 + (0.61589086055755615) * emb_t4_26 + (0.030096324160695076) * emb_t4_27 + (0.23305623233318329) * emb_t4_28 + (-0.50568485260009766) * emb_t4_29 + (0.86426627635955811) * emb_t4_30 + (-0.34773877263069153) * emb_t4_31);
    gate_n = tanh((-0.050970137119293213) + (-0.0084421355277299881) * emb_t4_0 + (0.25063276290893555) * emb_t4_1 + (0.004513672087341547) * emb_t4_2 + (-0.1969171017408371) * emb_t4_3 + (0.33182415366172791) * emb_t4_4 + (0.052020303905010223) * emb_t4_5 + (0.076562628149986267) * emb_t4_6 + (0.12660343945026398) * emb_t4_7 + (0.14278951287269592) * emb_t4_8 + (-0.047504980117082596) * emb_t4_9 + (0.12127996981143951) * emb_t4_10 + (-0.045387797057628632) * emb_t4_11 + (0.19630531966686249) * emb_t4_12 + (0.27372300624847412) * emb_t4_13 + (-0.048866834491491318) * emb_t4_14 + (-0.053699858486652374) * emb_t4_15 + (0.0095550818368792534) * emb_t4_16 + (0.14115393161773682) * emb_t4_17 + (0.45962423086166382) * emb_t4_18 + (-0.20257261395454407) * emb_t4_19 + (-0.1729653924703598) * emb_t4_20 + (-0.088452346622943878) * emb_t4_21 + (-0.010871979407966137) * emb_t4_22 + (0.050594594329595566) * emb_t4_23 + (-0.030299292877316475) * emb_t4_24 + (0.10581396520137787) * emb_t4_25 + (0.051439329981803894) * emb_t4_26 + (-0.010545365512371063) * emb_t4_27 + (-0.25608080625534058) * emb_t4_28 + (0.19220797717571259) * emb_t4_29 + (-0.053969398140907288) * emb_t4_30 + (0.19188903272151947) * emb_t4_31 + gate_r * (-0.063596904277801514));
    gru_0_rev_t4_h_10 = (1.0 - gate_z) * gate_n;
    // h=11
    gate_r = sigmoid((-0.088519908487796783) + (-0.42864495515823364) * emb_t4_0 + (0.7868722677230835) * emb_t4_1 + (-0.34357810020446777) * emb_t4_2 + (0.073531664907932281) * emb_t4_3 + (0.11682534962892532) * emb_t4_4 + (0.1238856241106987) * emb_t4_5 + (0.18413998186588287) * emb_t4_6 + (-1.8615565299987793) * emb_t4_7 + (0.93350785970687866) * emb_t4_8 + (0.19804410636425018) * emb_t4_9 + (0.33198854327201843) * emb_t4_10 + (0.046571392565965652) * emb_t4_11 + (1.0062586069107056) * emb_t4_12 + (-0.054774396121501923) * emb_t4_13 + (-0.21212901175022125) * emb_t4_14 + (-0.43435359001159668) * emb_t4_15 + (-0.06130300834774971) * emb_t4_16 + (0.41468393802642822) * emb_t4_17 + (-0.10650640726089478) * emb_t4_18 + (-0.25482472777366638) * emb_t4_19 + (-0.60928440093994141) * emb_t4_20 + (0.58590090274810791) * emb_t4_21 + (-1.3707834482192993) * emb_t4_22 + (0.13742563128471375) * emb_t4_23 + (0.35796582698822021) * emb_t4_24 + (0.42272579669952393) * emb_t4_25 + (0.12809407711029053) * emb_t4_26 + (-0.1792895644903183) * emb_t4_27 + (0.15057668089866638) * emb_t4_28 + (0.56269282102584839) * emb_t4_29 + (-0.28416174650192261) * emb_t4_30 + (-0.18545739352703094) * emb_t4_31);
    gate_z = sigmoid((1.7369898557662964) + (-0.012829374521970749) * emb_t4_0 + (-0.3034624457359314) * emb_t4_1 + (-0.018585545942187309) * emb_t4_2 + (0.40256702899932861) * emb_t4_3 + (-0.34696996212005615) * emb_t4_4 + (0.019062630832195282) * emb_t4_5 + (0.026088079437613487) * emb_t4_6 + (0.00062856113072484732) * emb_t4_7 + (1.0484764575958252) * emb_t4_8 + (-0.2815234363079071) * emb_t4_9 + (-0.54315048456192017) * emb_t4_10 + (0.43050926923751831) * emb_t4_11 + (0.41857770085334778) * emb_t4_12 + (0.19282424449920654) * emb_t4_13 + (0.0088970763608813286) * emb_t4_14 + (-0.01559915579855442) * emb_t4_15 + (0.0017699571326375008) * emb_t4_16 + (0.1569383442401886) * emb_t4_17 + (-0.083910614252090454) * emb_t4_18 + (0.14798794686794281) * emb_t4_19 + (0.5737144947052002) * emb_t4_20 + (-0.015245171263813972) * emb_t4_21 + (-0.18728677928447723) * emb_t4_22 + (0.019998202100396156) * emb_t4_23 + (0.0017829691059887409) * emb_t4_24 + (0.0033025036100298166) * emb_t4_25 + (0.037912268191576004) * emb_t4_26 + (-0.0052588833495974541) * emb_t4_27 + (-0.19140951335430145) * emb_t4_28 + (0.073352336883544922) * emb_t4_29 + (-0.29260814189910889) * emb_t4_30 + (-0.37189415097236633) * emb_t4_31);
    gate_n = tanh((0.025761548429727554) + (0.069977223873138428) * emb_t4_0 + (0.20830993354320526) * emb_t4_1 + (0.14105051755905151) * emb_t4_2 + (-0.50288283824920654) * emb_t4_3 + (0.38622820377349854) * emb_t4_4 + (-0.057550672441720963) * emb_t4_5 + (0.48497274518013) * emb_t4_6 + (0.084617651998996735) * emb_t4_7 + (0.38710039854049683) * emb_t4_8 + (-0.64426285028457642) * emb_t4_9 + (-0.82916635274887085) * emb_t4_10 + (0.35207411646842957) * emb_t4_11 + (0.1262006014585495) * emb_t4_12 + (0.90183573961257935) * emb_t4_13 + (0.1929076611995697) * emb_t4_14 + (-0.18534901738166809) * emb_t4_15 + (-0.1705472469329834) * emb_t4_16 + (0.10561834275722504) * emb_t4_17 + (-0.75537437200546265) * emb_t4_18 + (0.57868236303329468) * emb_t4_19 + (-0.10405415296554565) * emb_t4_20 + (-0.010821156203746796) * emb_t4_21 + (-0.23685908317565918) * emb_t4_22 + (-0.039659082889556885) * emb_t4_23 + (0.10234694927930832) * emb_t4_24 + (-0.30255493521690369) * emb_t4_25 + (-0.33071556687355042) * emb_t4_26 + (-0.021039482206106186) * emb_t4_27 + (-0.34970936179161072) * emb_t4_28 + (1.241974949836731) * emb_t4_29 + (-0.97688531875610352) * emb_t4_30 + (-0.37848377227783203) * emb_t4_31 + gate_r * (0.049158003181219101));
    gru_0_rev_t4_h_11 = (1.0 - gate_z) * gate_n;
    // h=12
    gate_r = sigmoid((0.19926956295967102) + (-0.067331664264202118) * emb_t4_0 + (-0.74870485067367554) * emb_t4_1 + (0.87782996892929077) * emb_t4_2 + (0.31495362520217896) * emb_t4_3 + (-0.46559882164001465) * emb_t4_4 + (-0.10391244292259216) * emb_t4_5 + (-0.35722678899765015) * emb_t4_6 + (0.11593266576528549) * emb_t4_7 + (-0.61379820108413696) * emb_t4_8 + (0.68002063035964966) * emb_t4_9 + (0.903969407081604) * emb_t4_10 + (0.090398751199245453) * emb_t4_11 + (-1.0834028720855713) * emb_t4_12 + (-0.29198557138442993) * emb_t4_13 + (0.12228428572416306) * emb_t4_14 + (-0.053074423223733902) * emb_t4_15 + (0.56703066825866699) * emb_t4_16 + (-0.50466364622116089) * emb_t4_17 + (0.59465503692626953) * emb_t4_18 + (-0.84894925355911255) * emb_t4_19 + (0.16116119921207428) * emb_t4_20 + (0.081396572291851044) * emb_t4_21 + (1.1139926910400391) * emb_t4_22 + (-0.36552879214286804) * emb_t4_23 + (-0.31935560703277588) * emb_t4_24 + (0.69322383403778076) * emb_t4_25 + (0.12548811733722687) * emb_t4_26 + (0.37135154008865356) * emb_t4_27 + (0.26834577322006226) * emb_t4_28 + (-0.7400164008140564) * emb_t4_29 + (0.6406102180480957) * emb_t4_30 + (0.8193548321723938) * emb_t4_31);
    gate_z = sigmoid((0.37525436282157898) + (0.02873268723487854) * emb_t4_0 + (0.46333634853363037) * emb_t4_1 + (0.054666042327880859) * emb_t4_2 + (-0.15520849823951721) * emb_t4_3 + (-0.059237387031316757) * emb_t4_4 + (0.19809821248054504) * emb_t4_5 + (-0.059524267911911011) * emb_t4_6 + (0.00017535801453050226) * emb_t4_7 + (-0.24859246611595154) * emb_t4_8 + (-0.14470908045768738) * emb_t4_9 + (-0.27431604266166687) * emb_t4_10 + (0.27241688966751099) * emb_t4_11 + (0.021912628784775734) * emb_t4_12 + (0.1983388364315033) * emb_t4_13 + (0.04460076242685318) * emb_t4_14 + (-0.11417511105537415) * emb_t4_15 + (0.042615737766027451) * emb_t4_16 + (-0.15254925191402435) * emb_t4_17 + (-0.40131354331970215) * emb_t4_18 + (0.24146825075149536) * emb_t4_19 + (0.049813337624073029) * emb_t4_20 + (-0.084806904196739197) * emb_t4_21 + (-0.56833231449127197) * emb_t4_22 + (-0.080430969595909119) * emb_t4_23 + (0.11878390610218048) * emb_t4_24 + (-0.10057906061410904) * emb_t4_25 + (-0.1895512193441391) * emb_t4_26 + (-0.037268240004777908) * emb_t4_27 + (0.0044636367820203304) * emb_t4_28 + (0.18313175439834595) * emb_t4_29 + (0.0052720755338668823) * emb_t4_30 + (-0.40464058518409729) * emb_t4_31);
    gate_n = tanh((1.3918232917785645) + (0.0099478065967559814) * emb_t4_0 + (0.60018932819366455) * emb_t4_1 + (0.028263276442885399) * emb_t4_2 + (1.4671456813812256) * emb_t4_3 + (-0.22006136178970337) * emb_t4_4 + (-0.014997608028352261) * emb_t4_5 + (-0.42907947301864624) * emb_t4_6 + (0.015719899907708168) * emb_t4_7 + (2.4035546779632568) * emb_t4_8 + (-0.33133906126022339) * emb_t4_9 + (-0.87221884727478027) * emb_t4_10 + (0.9308820366859436) * emb_t4_11 + (1.2722036838531494) * emb_t4_12 + (-0.0019454191206023097) * emb_t4_13 + (-0.0041214493103325367) * emb_t4_14 + (0.0023075088392943144) * emb_t4_15 + (0.010803038254380226) * emb_t4_16 + (-0.52183854579925537) * emb_t4_17 + (-0.45135071873664856) * emb_t4_18 + (0.20699004828929901) * emb_t4_19 + (0.58852016925811768) * emb_t4_20 + (-0.026288965716958046) * emb_t4_21 + (-1.0162254571914673) * emb_t4_22 + (0.0084366220980882645) * emb_t4_23 + (-0.027270687744021416) * emb_t4_24 + (-0.013432336039841175) * emb_t4_25 + (0.55314731597900391) * emb_t4_26 + (0.041914753615856171) * emb_t4_27 + (-0.20794588327407837) * emb_t4_28 + (0.16753177344799042) * emb_t4_29 + (0.22720544040203094) * emb_t4_30 + (-2.2309696674346924) * emb_t4_31 + gate_r * (1.3616474866867065));
    gru_0_rev_t4_h_12 = (1.0 - gate_z) * gate_n;
    // h=13
    gate_r = sigmoid((-0.8471907377243042) + (0.55413860082626343) * emb_t4_0 + (-0.61571353673934937) * emb_t4_1 + (-0.40594193339347839) * emb_t4_2 + (0.081596903502941132) * emb_t4_3 + (-0.52892470359802246) * emb_t4_4 + (0.67255669832229614) * emb_t4_5 + (-0.27922585606575012) * emb_t4_6 + (1.9742788076400757) * emb_t4_7 + (-7.3871927261352539) * emb_t4_8 + (0.71850454807281494) * emb_t4_9 + (1.0384657382965088) * emb_t4_10 + (-0.42498612403869629) * emb_t4_11 + (-2.058356761932373) * emb_t4_12 + (-0.35568952560424805) * emb_t4_13 + (0.24166402220726013) * emb_t4_14 + (-0.33188208937644958) * emb_t4_15 + (-0.80781394243240356) * emb_t4_16 + (-0.32437142729759216) * emb_t4_17 + (0.81620621681213379) * emb_t4_18 + (-1.0332520008087158) * emb_t4_19 + (0.15213945508003235) * emb_t4_20 + (0.31029251217842102) * emb_t4_21 + (1.6249688863754272) * emb_t4_22 + (0.095902420580387115) * emb_t4_23 + (-0.59736859798431396) * emb_t4_24 + (0.35210147500038147) * emb_t4_25 + (0.43775841593742371) * emb_t4_26 + (0.055683411657810211) * emb_t4_27 + (0.61002242565155029) * emb_t4_28 + (-0.5278933048248291) * emb_t4_29 + (0.88334602117538452) * emb_t4_30 + (7.2100882530212402) * emb_t4_31);
    gate_z = sigmoid((0.6680489182472229) + (0.0025599468499422073) * emb_t4_0 + (0.2076709121465683) * emb_t4_1 + (0.00098374695517122746) * emb_t4_2 + (0.20989960432052612) * emb_t4_3 + (0.21669933199882507) * emb_t4_4 + (-0.011526999063789845) * emb_t4_5 + (-0.32647332549095154) * emb_t4_6 + (0.016910377889871597) * emb_t4_7 + (0.12821713089942932) * emb_t4_8 + (-0.024750072509050369) * emb_t4_9 + (-0.17117558419704437) * emb_t4_10 + (0.28039613366127014) * emb_t4_11 + (0.19344037771224976) * emb_t4_12 + (-0.051016397774219513) * emb_t4_13 + (-0.010580402798950672) * emb_t4_14 + (0.0066116815432906151) * emb_t4_15 + (-0.018739279359579086) * emb_t4_16 + (0.091853834688663483) * emb_t4_17 + (-0.36166143417358398) * emb_t4_18 + (-0.13729137182235718) * emb_t4_19 + (-0.21852181851863861) * emb_t4_20 + (-0.000277818733593449) * emb_t4_21 + (-0.24793429672718048) * emb_t4_22 + (0.0026213398668915033) * emb_t4_23 + (-0.014627248048782349) * emb_t4_24 + (0.0023010277654975653) * emb_t4_25 + (-0.40856611728668213) * emb_t4_26 + (0.007384889293462038) * emb_t4_27 + (-0.44331687688827515) * emb_t4_28 + (0.33899307250976562) * emb_t4_29 + (0.30118456482887268) * emb_t4_30 + (0.030001640319824219) * emb_t4_31);
    gate_n = tanh((1.4192674160003662) + (-0.0024527641944587231) * emb_t4_0 + (0.013600567355751991) * emb_t4_1 + (0.021397409960627556) * emb_t4_2 + (0.98087441921234131) * emb_t4_3 + (0.017589518800377846) * emb_t4_4 + (-0.020491674542427063) * emb_t4_5 + (-0.37787339091300964) * emb_t4_6 + (-0.0058721285313367844) * emb_t4_7 + (0.60607171058654785) * emb_t4_8 + (-0.67578792572021484) * emb_t4_9 + (-0.017862968146800995) * emb_t4_10 + (1.1348549127578735) * emb_t4_11 + (1.12957763671875) * emb_t4_12 + (0.17881251871585846) * emb_t4_13 + (0.029307989403605461) * emb_t4_14 + (0.0087201977148652077) * emb_t4_15 + (0.013434852473437786) * emb_t4_16 + (-0.37021809816360474) * emb_t4_17 + (-0.30552935600280762) * emb_t4_18 + (0.28159856796264648) * emb_t4_19 + (1.4146416187286377) * emb_t4_20 + (0.013037398457527161) * emb_t4_21 + (-0.11863017827272415) * emb_t4_22 + (0.00060954084619879723) * emb_t4_23 + (0.045046281069517136) * emb_t4_24 + (-0.049778178334236145) * emb_t4_25 + (0.45883461833000183) * emb_t4_26 + (0.0030700014904141426) * emb_t4_27 + (0.28979590535163879) * emb_t4_28 + (0.44459515810012817) * emb_t4_29 + (0.18634524941444397) * emb_t4_30 + (-0.9519842267036438) * emb_t4_31 + gate_r * (1.7175730466842651));
    gru_0_rev_t4_h_13 = (1.0 - gate_z) * gate_n;
    // h=14
    gate_r = sigmoid((0.4441811740398407) + (0.36075064539909363) * emb_t4_0 + (1.3077433109283447) * emb_t4_1 + (0.10506085306406021) * emb_t4_2 + (0.30991849303245544) * emb_t4_3 + (0.34923911094665527) * emb_t4_4 + (-0.2855791449546814) * emb_t4_5 + (0.77927654981613159) * emb_t4_6 + (0.11512690037488937) * emb_t4_7 + (0.12239233404397964) * emb_t4_8 + (-0.91336655616760254) * emb_t4_9 + (-0.36862480640411377) * emb_t4_10 + (0.5283663272857666) * emb_t4_11 + (0.32265979051589966) * emb_t4_12 + (0.75916504859924316) * emb_t4_13 + (-0.45579206943511963) * emb_t4_14 + (0.13288974761962891) * emb_t4_15 + (-0.011488001793622971) * emb_t4_16 + (0.26103127002716064) * emb_t4_17 + (-0.68207436800003052) * emb_t4_18 + (0.56140989065170288) * emb_t4_19 + (-0.09335692971944809) * emb_t4_20 + (0.17620952427387238) * emb_t4_21 + (-0.41434291005134583) * emb_t4_22 + (0.15505670011043549) * emb_t4_23 + (0.074162617325782776) * emb_t4_24 + (0.15997406840324402) * emb_t4_25 + (-0.24888993799686432) * emb_t4_26 + (0.046698622405529022) * emb_t4_27 + (-0.66703903675079346) * emb_t4_28 + (0.83388769626617432) * emb_t4_29 + (-0.1665327250957489) * emb_t4_30 + (-0.14907297492027283) * emb_t4_31);
    gate_z = sigmoid((0.22907911241054535) + (-0.053022883832454681) * emb_t4_0 + (-2.0112128257751465) * emb_t4_1 + (-0.17153991758823395) * emb_t4_2 + (0.33761188387870789) * emb_t4_3 + (-1.4350898265838623) * emb_t4_4 + (-0.032737910747528076) * emb_t4_5 + (-0.70515894889831543) * emb_t4_6 + (0.061784304678440094) * emb_t4_7 + (-0.37807756662368774) * emb_t4_8 + (0.84044498205184937) * emb_t4_9 + (0.64871752262115479) * emb_t4_10 + (-0.18615145981311798) * emb_t4_11 + (-0.48771470785140991) * emb_t4_12 + (-2.0230305194854736) * emb_t4_13 + (-0.050683092325925827) * emb_t4_14 + (0.17341475188732147) * emb_t4_15 + (0.019496751949191093) * emb_t4_16 + (-0.91630542278289795) * emb_t4_17 + (0.54210352897644043) * emb_t4_18 + (-0.57203561067581177) * emb_t4_19 + (0.28487011790275574) * emb_t4_20 + (0.16342206299304962) * emb_t4_21 + (0.59586191177368164) * emb_t4_22 + (0.22398652136325836) * emb_t4_23 + (0.053156107664108276) * emb_t4_24 + (-0.0074884542264044285) * emb_t4_25 + (0.99484026432037354) * emb_t4_26 + (-0.041708830744028091) * emb_t4_27 + (1.833073616027832) * emb_t4_28 + (-2.54404616355896) * emb_t4_29 + (1.1508170366287231) * emb_t4_30 + (0.63742166757583618) * emb_t4_31);
    gate_n = tanh((-0.0047882925719022751) + (0.0072417380288243294) * emb_t4_0 + (-1.1025224924087524) * emb_t4_1 + (0.040932387113571167) * emb_t4_2 + (0.28991508483886719) * emb_t4_3 + (-0.74824637174606323) * emb_t4_4 + (0.023332331329584122) * emb_t4_5 + (-0.1807473748922348) * emb_t4_6 + (-0.0094903288409113884) * emb_t4_7 + (0.303212970495224) * emb_t4_8 + (0.19635353982448578) * emb_t4_9 + (-0.21143828332424164) * emb_t4_10 + (0.19519101083278656) * emb_t4_11 + (-0.36399301886558533) * emb_t4_12 + (-1.0259802341461182) * emb_t4_13 + (-0.0026821310166269541) * emb_t4_14 + (-0.03891880065202713) * emb_t4_15 + (0.017421802505850792) * emb_t4_16 + (-0.17275097966194153) * emb_t4_17 + (0.57019633054733276) * emb_t4_18 + (-0.061267741024494171) * emb_t4_19 + (-0.30537161231040955) * emb_t4_20 + (-0.037297904491424561) * emb_t4_21 + (0.12500278651714325) * emb_t4_22 + (0.0059627131558954716) * emb_t4_23 + (-0.010628154501318932) * emb_t4_24 + (0.012551397085189819) * emb_t4_25 + (0.08045678585767746) * emb_t4_26 + (0.034582793712615967) * emb_t4_27 + (0.37388166785240173) * emb_t4_28 + (-0.94272834062576294) * emb_t4_29 + (-0.037900727242231369) * emb_t4_30 + (0.21891963481903076) * emb_t4_31 + gate_r * (-0.34946075081825256));
    gru_0_rev_t4_h_14 = (1.0 - gate_z) * gate_n;
    // h=15
    gate_r = sigmoid((-2.5485363006591797) + (-1.0981466770172119) * emb_t4_0 + (0.17039939761161804) * emb_t4_1 + (-1.1289713382720947) * emb_t4_2 + (-1.5023065805435181) * emb_t4_3 + (0.91546201705932617) * emb_t4_4 + (0.8393784761428833) * emb_t4_5 + (1.4448281526565552) * emb_t4_6 + (1.1443384885787964) * emb_t4_7 + (-0.94598031044006348) * emb_t4_8 + (1.2868512868881226) * emb_t4_9 + (1.0692732334136963) * emb_t4_10 + (-1.866188645362854) * emb_t4_11 + (-1.2244753837585449) * emb_t4_12 + (0.69439452886581421) * emb_t4_13 + (0.20707008242607117) * emb_t4_14 + (0.9440767765045166) * emb_t4_15 + (-1.0659303665161133) * emb_t4_16 + (1.251213550567627) * emb_t4_17 + (1.2705866098403931) * emb_t4_18 + (-0.84995198249816895) * emb_t4_19 + (-1.6389269828796387) * emb_t4_20 + (0.64584022760391235) * emb_t4_21 + (1.0417753458023071) * emb_t4_22 + (-0.12841182947158813) * emb_t4_23 + (0.14785376191139221) * emb_t4_24 + (-0.26613712310791016) * emb_t4_25 + (-1.4654747247695923) * emb_t4_26 + (-0.96218967437744141) * emb_t4_27 + (-0.065828926861286163) * emb_t4_28 + (0.54787540435791016) * emb_t4_29 + (-1.3537800312042236) * emb_t4_30 + (1.1862084865570068) * emb_t4_31);
    gate_z = sigmoid((-0.7214432954788208) + (0.059250675141811371) * emb_t4_0 + (-0.66896331310272217) * emb_t4_1 + (-0.19164617359638214) * emb_t4_2 + (-0.092587999999523163) * emb_t4_3 + (-0.10477571934461594) * emb_t4_4 + (0.10209141671657562) * emb_t4_5 + (-0.30720424652099609) * emb_t4_6 + (0.14000840485095978) * emb_t4_7 + (-0.25854814052581787) * emb_t4_8 + (0.25518879294395447) * emb_t4_9 + (0.1545366495847702) * emb_t4_10 + (-0.24109284579753876) * emb_t4_11 + (-0.79885894060134888) * emb_t4_12 + (-0.7995913028717041) * emb_t4_13 + (0.029181808233261108) * emb_t4_14 + (0.31742268800735474) * emb_t4_15 + (-0.23846352100372314) * emb_t4_16 + (0.10590140521526337) * emb_t4_17 + (0.4637124240398407) * emb_t4_18 + (-0.52289789915084839) * emb_t4_19 + (-0.52198821306228638) * emb_t4_20 + (0.30753082036972046) * emb_t4_21 + (0.48222053050994873) * emb_t4_22 + (-0.32363796234130859) * emb_t4_23 + (0.33859178423881531) * emb_t4_24 + (0.099730536341667175) * emb_t4_25 + (-0.25171643495559692) * emb_t4_26 + (-0.16489721834659576) * emb_t4_27 + (0.69695961475372314) * emb_t4_28 + (-0.19398064911365509) * emb_t4_29 + (0.24372236430644989) * emb_t4_30 + (0.66748279333114624) * emb_t4_31);
    gate_n = tanh((-0.11509934067726135) + (0.0086536100134253502) * emb_t4_0 + (0.53708797693252563) * emb_t4_1 + (-0.014071125537157059) * emb_t4_2 + (-0.23890426754951477) * emb_t4_3 + (0.46016910672187805) * emb_t4_4 + (0.00610391516238451) * emb_t4_5 + (0.23954620957374573) * emb_t4_6 + (-0.032185286283493042) * emb_t4_7 + (-0.75479906797409058) * emb_t4_8 + (0.028451530262827873) * emb_t4_9 + (-0.36921647191047668) * emb_t4_10 + (0.12913116812705994) * emb_t4_11 + (0.42067602276802063) * emb_t4_12 + (0.31604626774787903) * emb_t4_13 + (-0.011742912232875824) * emb_t4_14 + (0.028448460623621941) * emb_t4_15 + (-0.011185531504452229) * emb_t4_16 + (0.36221572756767273) * emb_t4_17 + (-0.26043137907981873) * emb_t4_18 + (0.42170342803001404) * emb_t4_19 + (-0.10561381280422211) * emb_t4_20 + (0.0082730865105986595) * emb_t4_21 + (-0.18132719397544861) * emb_t4_22 + (-0.018829261884093285) * emb_t4_23 + (-0.0086690681055188179) * emb_t4_24 + (0.021084075793623924) * emb_t4_25 + (-0.14471642673015594) * emb_t4_26 + (-0.017638092860579491) * emb_t4_27 + (-0.24931818246841431) * emb_t4_28 + (0.85941141843795776) * emb_t4_29 + (-0.81741935014724731) * emb_t4_30 + (0.43749606609344482) * emb_t4_31 + gate_r * (-0.027562964707612991));
    gru_0_rev_t4_h_15 = (1.0 - gate_z) * gate_n;
    // h=16
    gate_r = sigmoid((-3.6276388168334961) + (-0.55399399995803833) * emb_t4_0 + (1.1829593181610107) * emb_t4_1 + (-0.90462017059326172) * emb_t4_2 + (-1.6816167831420898) * emb_t4_3 + (1.5920102596282959) * emb_t4_4 + (1.3378474712371826) * emb_t4_5 + (0.99278193712234497) * emb_t4_6 + (1.3013887405395508) * emb_t4_7 + (-1.4189082384109497) * emb_t4_8 + (0.78257745504379272) * emb_t4_9 + (1.0267593860626221) * emb_t4_10 + (-1.8772982358932495) * emb_t4_11 + (-1.7390748262405396) * emb_t4_12 + (1.4438059329986572) * emb_t4_13 + (-0.31045487523078918) * emb_t4_14 + (0.88484835624694824) * emb_t4_15 + (-1.3324580192565918) * emb_t4_16 + (1.3524980545043945) * emb_t4_17 + (0.93577629327774048) * emb_t4_18 + (-1.3887078762054443) * emb_t4_19 + (-1.9425407648086548) * emb_t4_20 + (0.55787521600723267) * emb_t4_21 + (1.706667423248291) * emb_t4_22 + (-0.73649758100509644) * emb_t4_23 + (0.83116143941879272) * emb_t4_24 + (-1.2745752334594727) * emb_t4_25 + (-1.4535328149795532) * emb_t4_26 + (-1.6293405294418335) * emb_t4_27 + (-1.1243579387664795) * emb_t4_28 + (1.5127159357070923) * emb_t4_29 + (-1.9072438478469849) * emb_t4_30 + (1.3102514743804932) * emb_t4_31);
    gate_z = sigmoid((-3.0341415405273438) + (-0.24392977356910706) * emb_t4_0 + (-0.19663697481155396) * emb_t4_1 + (-0.45847463607788086) * emb_t4_2 + (-0.95124411582946777) * emb_t4_3 + (0.052034236490726471) * emb_t4_4 + (0.09866497665643692) * emb_t4_5 + (0.40371975302696228) * emb_t4_6 + (-0.14609228074550629) * emb_t4_7 + (-2.148754358291626) * emb_t4_8 + (2.3644254207611084) * emb_t4_9 + (2.224658727645874) * emb_t4_10 + (-1.3206096887588501) * emb_t4_11 + (-1.7818115949630737) * emb_t4_12 + (0.095168635249137878) * emb_t4_13 + (0.015438671223819256) * emb_t4_14 + (1.0705443620681763) * emb_t4_15 + (-0.39765426516532898) * emb_t4_16 + (0.98318248987197876) * emb_t4_17 + (1.4402689933776855) * emb_t4_18 + (-1.8661266565322876) * emb_t4_19 + (-1.0157074928283691) * emb_t4_20 + (0.27175894379615784) * emb_t4_21 + (2.0576980113983154) * emb_t4_22 + (0.76965421438217163) * emb_t4_23 + (0.22717304527759552) * emb_t4_24 + (0.36869752407073975) * emb_t4_25 + (-0.88211947679519653) * emb_t4_26 + (-0.17457166314125061) * emb_t4_27 + (0.075170420110225677) * emb_t4_28 + (-0.13373211026191711) * emb_t4_29 + (-0.96754521131515503) * emb_t4_30 + (1.6378720998764038) * emb_t4_31);
    gate_n = tanh((-0.00054617202840745449) + (0.0045771966688334942) * emb_t4_0 + (0.17028774321079254) * emb_t4_1 + (-0.0083374436944723129) * emb_t4_2 + (0.115583635866642) * emb_t4_3 + (0.43597325682640076) * emb_t4_4 + (-0.022567637264728546) * emb_t4_5 + (0.11851710826158524) * emb_t4_6 + (-0.0018321617972105742) * emb_t4_7 + (0.2643856406211853) * emb_t4_8 + (-1.4264582395553589) * emb_t4_9 + (-0.79762095212936401) * emb_t4_10 + (0.097066275775432587) * emb_t4_11 + (-0.10985676199197769) * emb_t4_12 + (0.32709237933158875) * emb_t4_13 + (0.0044286008924245834) * emb_t4_14 + (0.013022799976170063) * emb_t4_15 + (0.0037355748936533928) * emb_t4_16 + (-0.077571108937263489) * emb_t4_17 + (-0.19987742602825165) * emb_t4_18 + (0.56083059310913086) * emb_t4_19 + (-0.33396464586257935) * emb_t4_20 + (0.031821254640817642) * emb_t4_21 + (0.010200436227023602) * emb_t4_22 + (-0.010865524411201477) * emb_t4_23 + (0.028364550322294235) * emb_t4_24 + (-0.011354763060808182) * emb_t4_25 + (0.023156503215432167) * emb_t4_26 + (-0.0046282000839710236) * emb_t4_27 + (-0.24959765374660492) * emb_t4_28 + (1.0619994401931763) * emb_t4_29 + (-0.012424244545400143) * emb_t4_30 + (-0.15213806927204132) * emb_t4_31 + gate_r * (-0.1024572029709816));
    gru_0_rev_t4_h_16 = (1.0 - gate_z) * gate_n;
    // h=17
    gate_r = sigmoid((-3.1107819080352783) + (-0.96565186977386475) * emb_t4_0 + (0.54152154922485352) * emb_t4_1 + (-1.1846390962600708) * emb_t4_2 + (-1.195543646812439) * emb_t4_3 + (1.0474015474319458) * emb_t4_4 + (0.7267029881477356) * emb_t4_5 + (0.70588850975036621) * emb_t4_6 + (0.81107205152511597) * emb_t4_7 + (-0.99850946664810181) * emb_t4_8 + (0.98403728008270264) * emb_t4_9 + (0.89941275119781494) * emb_t4_10 + (-1.1420797109603882) * emb_t4_11 + (-1.3212742805480957) * emb_t4_12 + (0.61673367023468018) * emb_t4_13 + (0.72625023126602173) * emb_t4_14 + (1.0770673751831055) * emb_t4_15 + (-1.2579820156097412) * emb_t4_16 + (1.4941186904907227) * emb_t4_17 + (0.80668115615844727) * emb_t4_18 + (-1.2636659145355225) * emb_t4_19 + (-1.6255443096160889) * emb_t4_20 + (0.72453922033309937) * emb_t4_21 + (0.77528786659240723) * emb_t4_22 + (-0.14455495774745941) * emb_t4_23 + (1.0300053358078003) * emb_t4_24 + (-0.16098590195178986) * emb_t4_25 + (-0.74074292182922363) * emb_t4_26 + (-0.30634444952011108) * emb_t4_27 + (-0.48927971720695496) * emb_t4_28 + (1.0149382352828979) * emb_t4_29 + (-0.6032065749168396) * emb_t4_30 + (1.2659003734588623) * emb_t4_31);
    gate_z = sigmoid((-2.0034410953521729) + (0.5234794020652771) * emb_t4_0 + (0.016087613999843597) * emb_t4_1 + (0.6930534839630127) * emb_t4_2 + (-0.73686337471008301) * emb_t4_3 + (0.580849289894104) * emb_t4_4 + (-0.003114079125225544) * emb_t4_5 + (0.83411157131195068) * emb_t4_6 + (0.42322385311126709) * emb_t4_7 + (-1.4112616777420044) * emb_t4_8 + (2.4097495079040527) * emb_t4_9 + (1.8141844272613525) * emb_t4_10 + (-0.9813302755355835) * emb_t4_11 + (-1.1346726417541504) * emb_t4_12 + (0.62405312061309814) * emb_t4_13 + (0.82887643575668335) * emb_t4_14 + (0.27686628699302673) * emb_t4_15 + (-0.1316993236541748) * emb_t4_16 + (0.94877243041992188) * emb_t4_17 + (1.8238505125045776) * emb_t4_18 + (-1.1620571613311768) * emb_t4_19 + (-0.24408441781997681) * emb_t4_20 + (-0.21168693900108337) * emb_t4_21 + (1.3034882545471191) * emb_t4_22 + (-0.23716039955615997) * emb_t4_23 + (-0.14831389486789703) * emb_t4_24 + (-0.054054338485002518) * emb_t4_25 + (-0.4632478654384613) * emb_t4_26 + (-0.17461040616035461) * emb_t4_27 + (-0.050040788948535919) * emb_t4_28 + (0.15523026883602142) * emb_t4_29 + (-0.65608829259872437) * emb_t4_30 + (1.0230476856231689) * emb_t4_31);
    gate_n = tanh((-0.022157993167638779) + (-0.015913363546133041) * emb_t4_0 + (-0.61482137441635132) * emb_t4_1 + (0.0076300408691167831) * emb_t4_2 + (-0.021139446645975113) * emb_t4_3 + (-0.28343075513839722) * emb_t4_4 + (-0.017258845269680023) * emb_t4_5 + (-0.41530627012252808) * emb_t4_6 + (0.037708468735218048) * emb_t4_7 + (-0.17013177275657654) * emb_t4_8 + (0.85230022668838501) * emb_t4_9 + (0.16671329736709595) * emb_t4_10 + (0.0058722039684653282) * emb_t4_11 + (-0.56553143262863159) * emb_t4_12 + (-0.60855954885482788) * emb_t4_13 + (0.030933454632759094) * emb_t4_14 + (-0.0046227886341512203) * emb_t4_15 + (0.0071983765810728073) * emb_t4_16 + (-0.21838642656803131) * emb_t4_17 + (0.25267964601516724) * emb_t4_18 + (-0.42689117789268494) * emb_t4_19 + (0.0053769955411553383) * emb_t4_20 + (0.064662173390388489) * emb_t4_21 + (0.26178878545761108) * emb_t4_22 + (-0.043964389711618423) * emb_t4_23 + (0.11218304932117462) * emb_t4_24 + (-0.035765327513217926) * emb_t4_25 + (0.25849226117134094) * emb_t4_26 + (-0.016273008659482002) * emb_t4_27 + (0.32490220665931702) * emb_t4_28 + (-0.017818063497543335) * emb_t4_29 + (0.27783492207527161) * emb_t4_30 + (0.003300385782495141) * emb_t4_31 + gate_r * (-0.28120747208595276));
    gru_0_rev_t4_h_17 = (1.0 - gate_z) * gate_n;
    // h=18
    gate_r = sigmoid((-0.036454733461141586) + (-0.065201081335544586) * emb_t4_0 + (0.53062635660171509) * emb_t4_1 + (0.011271261610090733) * emb_t4_2 + (-0.24644921720027924) * emb_t4_3 + (0.16306582093238831) * emb_t4_4 + (-0.031682509928941727) * emb_t4_5 + (0.19659058749675751) * emb_t4_6 + (-0.022091209888458252) * emb_t4_7 + (0.16437581181526184) * emb_t4_8 + (-0.62140697240829468) * emb_t4_9 + (-0.0472455695271492) * emb_t4_10 + (-0.040558211505413055) * emb_t4_11 + (-0.34304314851760864) * emb_t4_12 + (0.85213363170623779) * emb_t4_13 + (-0.036205735057592392) * emb_t4_14 + (-0.15391191840171814) * emb_t4_15 + (0.16102422773838043) * emb_t4_16 + (-0.10120628774166107) * emb_t4_17 + (-0.41253086924552917) * emb_t4_18 + (0.53241938352584839) * emb_t4_19 + (0.27077949047088623) * emb_t4_20 + (-0.067844681441783905) * emb_t4_21 + (-0.09389805793762207) * emb_t4_22 + (0.18802960216999054) * emb_t4_23 + (-0.16243058443069458) * emb_t4_24 + (0.13230270147323608) * emb_t4_25 + (-0.28899893164634705) * emb_t4_26 + (0.04551282525062561) * emb_t4_27 + (-0.85732436180114746) * emb_t4_28 + (0.97620159387588501) * emb_t4_29 + (-0.46704152226448059) * emb_t4_30 + (0.43740251660346985) * emb_t4_31);
    gate_z = sigmoid((-1.4978121519088745) + (-0.43860715627670288) * emb_t4_0 + (-0.85169357061386108) * emb_t4_1 + (-0.35603117942810059) * emb_t4_2 + (-0.74947535991668701) * emb_t4_3 + (0.43814629316329956) * emb_t4_4 + (1.2335069179534912) * emb_t4_5 + (0.11379426717758179) * emb_t4_6 + (0.3493688702583313) * emb_t4_7 + (-0.78740262985229492) * emb_t4_8 + (1.4865201711654663) * emb_t4_9 + (1.6285649538040161) * emb_t4_10 + (-0.83910524845123291) * emb_t4_11 + (-0.50544434785842896) * emb_t4_12 + (-0.6168939471244812) * emb_t4_13 + (0.071439191699028015) * emb_t4_14 + (0.57882249355316162) * emb_t4_15 + (0.25527212023735046) * emb_t4_16 + (0.15450169146060944) * emb_t4_17 + (1.3401434421539307) * emb_t4_18 + (-0.59255146980285645) * emb_t4_19 + (-0.83472800254821777) * emb_t4_20 + (0.97425329685211182) * emb_t4_21 + (1.2894057035446167) * emb_t4_22 + (-0.6093219518661499) * emb_t4_23 + (0.11822836101055145) * emb_t4_24 + (0.62713336944580078) * emb_t4_25 + (0.049175392836332321) * emb_t4_26 + (-0.28905946016311646) * emb_t4_27 + (0.93095046281814575) * emb_t4_28 + (-0.13380184769630432) * emb_t4_29 + (-0.40445157885551453) * emb_t4_30 + (1.008270263671875) * emb_t4_31);
    gate_n = tanh((0.046371109783649445) + (-0.0048591182567179203) * emb_t4_0 + (-0.45264828205108643) * emb_t4_1 + (-0.0063616624101996422) * emb_t4_2 + (0.053491745144128799) * emb_t4_3 + (-0.058726012706756592) * emb_t4_4 + (-0.0034763820003718138) * emb_t4_5 + (0.010522292926907539) * emb_t4_6 + (-0.0053152083419263363) * emb_t4_7 + (0.048255186527967453) * emb_t4_8 + (0.23834626376628876) * emb_t4_9 + (-0.067361995577812195) * emb_t4_10 + (0.1652316153049469) * emb_t4_11 + (-0.27158817648887634) * emb_t4_12 + (-0.094877012073993683) * emb_t4_13 + (-0.018849676474928856) * emb_t4_14 + (-0.0021181304473429918) * emb_t4_15 + (-0.012360644526779652) * emb_t4_16 + (-0.52830427885055542) * emb_t4_17 + (0.073907561600208282) * emb_t4_18 + (-0.1474204957485199) * emb_t4_19 + (0.12769855558872223) * emb_t4_20 + (0.0068980911746621132) * emb_t4_21 + (0.24603369832038879) * emb_t4_22 + (0.0046543306671082973) * emb_t4_23 + (-0.0067050261422991753) * emb_t4_24 + (0.013961959630250931) * emb_t4_25 + (-0.060271337628364563) * emb_t4_26 + (-0.0037825689651072025) * emb_t4_27 + (0.12672163546085358) * emb_t4_28 + (0.26538461446762085) * emb_t4_29 + (-0.22168616950511932) * emb_t4_30 + (-0.0025916832964867353) * emb_t4_31 + gate_r * (-0.2609228789806366));
    gru_0_rev_t4_h_18 = (1.0 - gate_z) * gate_n;
    // h=19
    gate_r = sigmoid((0.60123640298843384) + (-0.090696848928928375) * emb_t4_0 + (0.63431203365325928) * emb_t4_1 + (0.057218778878450394) * emb_t4_2 + (-0.23073315620422363) * emb_t4_3 + (0.340861976146698) * emb_t4_4 + (0.25616341829299927) * emb_t4_5 + (-0.096920974552631378) * emb_t4_6 + (-0.30860334634780884) * emb_t4_7 + (1.917966365814209) * emb_t4_8 + (-2.1318411827087402) * emb_t4_9 + (-1.2897759675979614) * emb_t4_10 + (0.3156813383102417) * emb_t4_11 + (3.2653563022613525) * emb_t4_12 + (0.6604047417640686) * emb_t4_13 + (-0.20446567237377167) * emb_t4_14 + (0.099141389131546021) * emb_t4_15 + (-0.065083891153335571) * emb_t4_16 + (0.097014501690864563) * emb_t4_17 + (-1.0433775186538696) * emb_t4_18 + (1.4585690498352051) * emb_t4_19 + (-0.16509515047073364) * emb_t4_20 + (0.40098559856414795) * emb_t4_21 + (-2.3982560634613037) * emb_t4_22 + (0.24840317666530609) * emb_t4_23 + (-0.050794906914234161) * emb_t4_24 + (-0.081716492772102356) * emb_t4_25 + (-0.31634053587913513) * emb_t4_26 + (0.080328591167926788) * emb_t4_27 + (-1.2798395156860352) * emb_t4_28 + (0.54768049716949463) * emb_t4_29 + (-0.87233614921569824) * emb_t4_30 + (-1.960204005241394) * emb_t4_31);
    gate_z = sigmoid((2.4300346374511719) + (-0.0051412573084235191) * emb_t4_0 + (-0.3225063681602478) * emb_t4_1 + (-0.02895328588783741) * emb_t4_2 + (0.3751218318939209) * emb_t4_3 + (-0.071810543537139893) * emb_t4_4 + (-0.0087339403107762337) * emb_t4_5 + (0.0056174639612436295) * emb_t4_6 + (-0.014164562337100506) * emb_t4_7 + (0.37523475289344788) * emb_t4_8 + (0.24843846261501312) * emb_t4_9 + (0.11024381965398788) * emb_t4_10 + (0.31875023245811462) * emb_t4_11 + (0.49581238627433777) * emb_t4_12 + (0.093487769365310669) * emb_t4_13 + (-0.012458187527954578) * emb_t4_14 + (0.03368275985121727) * emb_t4_15 + (-0.018859509378671646) * emb_t4_16 + (0.30735662579536438) * emb_t4_17 + (0.05697900801897049) * emb_t4_18 + (0.50854825973510742) * emb_t4_19 + (0.41150546073913574) * emb_t4_20 + (0.03356890007853508) * emb_t4_21 + (-0.24917949736118317) * emb_t4_22 + (0.018723750486969948) * emb_t4_23 + (0.02020379900932312) * emb_t4_24 + (0.027616111561655998) * emb_t4_25 + (0.10162147879600525) * emb_t4_26 + (-0.04969797283411026) * emb_t4_27 + (-0.35087665915489197) * emb_t4_28 + (0.48617285490036011) * emb_t4_29 + (-0.23653492331504822) * emb_t4_30 + (-0.40728408098220825) * emb_t4_31);
    gate_n = tanh((0.41683101654052734) + (0.15079621970653534) * emb_t4_0 + (0.75203430652618408) * emb_t4_1 + (0.15180236101150513) * emb_t4_2 + (0.56286221742630005) * emb_t4_3 + (-0.12597629427909851) * emb_t4_4 + (-0.26728802919387817) * emb_t4_5 + (-0.0061264797113835812) * emb_t4_6 + (0.09531867504119873) * emb_t4_7 + (0.70012187957763672) * emb_t4_8 + (-0.29852434992790222) * emb_t4_9 + (-0.47693061828613281) * emb_t4_10 + (0.10405405610799789) * emb_t4_11 + (1.3601082563400269) * emb_t4_12 + (0.12594461441040039) * emb_t4_13 + (0.18855847418308258) * emb_t4_14 + (0.091632500290870667) * emb_t4_15 + (0.049250539392232895) * emb_t4_16 + (-0.28092131018638611) * emb_t4_17 + (-0.30399131774902344) * emb_t4_18 + (0.9413483738899231) * emb_t4_19 + (0.47450956702232361) * emb_t4_20 + (-0.038550343364477158) * emb_t4_21 + (-0.85411477088928223) * emb_t4_22 + (-0.22600859403610229) * emb_t4_23 + (0.16237011551856995) * emb_t4_24 + (-0.38356611132621765) * emb_t4_25 + (-0.049156934022903442) * emb_t4_26 + (0.13897094130516052) * emb_t4_27 + (-0.11754735559225082) * emb_t4_28 + (0.00051393453031778336) * emb_t4_29 + (-0.77287799119949341) * emb_t4_30 + (-0.81934696435928345) * emb_t4_31 + gate_r * (0.49530044198036194));
    gru_0_rev_t4_h_19 = (1.0 - gate_z) * gate_n;
    // h=20
    gate_r = sigmoid((0.30574136972427368) + (-0.096371293067932129) * emb_t4_0 + (0.78394633531570435) * emb_t4_1 + (-0.19684949517250061) * emb_t4_2 + (0.015630219131708145) * emb_t4_3 + (0.66065418720245361) * emb_t4_4 + (-0.031988333910703659) * emb_t4_5 + (0.12387829273939133) * emb_t4_6 + (0.016236612573266029) * emb_t4_7 + (0.60808330774307251) * emb_t4_8 + (-1.2002642154693604) * emb_t4_9 + (-1.0488544702529907) * emb_t4_10 + (0.1953919529914856) * emb_t4_11 + (0.49646413326263428) * emb_t4_12 + (0.83269304037094116) * emb_t4_13 + (0.057752717286348343) * emb_t4_14 + (0.027285249903798103) * emb_t4_15 + (-0.10062924027442932) * emb_t4_16 + (0.36470234394073486) * emb_t4_17 + (-1.4042959213256836) * emb_t4_18 + (0.47666895389556885) * emb_t4_19 + (-0.045229211449623108) * emb_t4_20 + (-0.029340252280235291) * emb_t4_21 + (-0.012155872769653797) * emb_t4_22 + (0.28922238945960999) * emb_t4_23 + (-0.012967183254659176) * emb_t4_24 + (-0.24206057190895081) * emb_t4_25 + (0.18798315525054932) * emb_t4_26 + (0.031028348952531815) * emb_t4_27 + (-1.1486427783966064) * emb_t4_28 + (1.0719989538192749) * emb_t4_29 + (-0.23517680168151855) * emb_t4_30 + (-0.76001191139221191) * emb_t4_31);
    gate_z = sigmoid((-0.013074534013867378) + (-0.078633993864059448) * emb_t4_0 + (1.5888527631759644) * emb_t4_1 + (-0.31464824080467224) * emb_t4_2 + (-0.0094735957682132721) * emb_t4_3 + (1.0337593555450439) * emb_t4_4 + (0.13330365717411041) * emb_t4_5 + (0.8087729811668396) * emb_t4_6 + (0.040261942893266678) * emb_t4_7 + (0.021398577839136124) * emb_t4_8 + (-0.47170218825340271) * emb_t4_9 + (-0.52772510051727295) * emb_t4_10 + (-0.10679770261049271) * emb_t4_11 + (0.17782081663608551) * emb_t4_12 + (1.8314095735549927) * emb_t4_13 + (0.043360203504562378) * emb_t4_14 + (0.33600574731826782) * emb_t4_15 + (-0.14760537445545197) * emb_t4_16 + (0.10373607277870178) * emb_t4_17 + (-0.6005403995513916) * emb_t4_18 + (0.53539389371871948) * emb_t4_19 + (-0.46471387147903442) * emb_t4_20 + (0.089228086173534393) * emb_t4_21 + (-0.15671248733997345) * emb_t4_22 + (-0.29380211234092712) * emb_t4_23 + (0.027899496257305145) * emb_t4_24 + (-0.15816964209079742) * emb_t4_25 + (-1.030306339263916) * emb_t4_26 + (-0.060929596424102783) * emb_t4_27 + (-1.3685263395309448) * emb_t4_28 + (1.3131042718887329) * emb_t4_29 + (-1.2264167070388794) * emb_t4_30 + (-0.24501195549964905) * emb_t4_31);
    gate_n = tanh((0.22971293330192566) + (0.029820721596479416) * emb_t4_0 + (0.80022686719894409) * emb_t4_1 + (0.046054650098085403) * emb_t4_2 + (-0.15211004018783569) * emb_t4_3 + (0.46707683801651001) * emb_t4_4 + (0.042870365083217621) * emb_t4_5 + (0.57972168922424316) * emb_t4_6 + (-0.014915795065462589) * emb_t4_7 + (0.41252151131629944) * emb_t4_8 + (-2.7285985946655273) * emb_t4_9 + (-1.6888195276260376) * emb_t4_10 + (-0.16130271553993225) * emb_t4_11 + (0.33149287104606628) * emb_t4_12 + (0.70486479997634888) * emb_t4_13 + (-0.007321289274841547) * emb_t4_14 + (0.0081356512382626534) * emb_t4_15 + (0.040817584842443466) * emb_t4_16 + (0.11674167215824127) * emb_t4_17 + (-0.89962577819824219) * emb_t4_18 + (0.66304612159729004) * emb_t4_19 + (0.22929759323596954) * emb_t4_20 + (0.018466096371412277) * emb_t4_21 + (-0.6468697190284729) * emb_t4_22 + (-0.076123885810375214) * emb_t4_23 + (0.018611298874020576) * emb_t4_24 + (0.042857419699430466) * emb_t4_25 + (0.11565127968788147) * emb_t4_26 + (-0.015362804755568504) * emb_t4_27 + (-0.1429801732301712) * emb_t4_28 + (0.426605224609375) * emb_t4_29 + (-0.17170427739620209) * emb_t4_30 + (-0.24655194580554962) * emb_t4_31 + gate_r * (0.30836334824562073));
    gru_0_rev_t4_h_20 = (1.0 - gate_z) * gate_n;
    // h=21
    gate_r = sigmoid((-0.81632357835769653) + (-0.15533007681369781) * emb_t4_0 + (0.25004518032073975) * emb_t4_1 + (-0.59654700756072998) * emb_t4_2 + (-0.45024439692497253) * emb_t4_3 + (0.22536042332649231) * emb_t4_4 + (0.68719732761383057) * emb_t4_5 + (0.29456955194473267) * emb_t4_6 + (0.20197322964668274) * emb_t4_7 + (-0.68620979785919189) * emb_t4_8 + (0.77394843101501465) * emb_t4_9 + (0.35862115025520325) * emb_t4_10 + (-0.45027703046798706) * emb_t4_11 + (-0.39216193556785583) * emb_t4_12 + (-0.10403089970350266) * emb_t4_13 + (0.1512303352355957) * emb_t4_14 + (0.20774814486503601) * emb_t4_15 + (-0.34698522090911865) * emb_t4_16 + (0.11772714555263519) * emb_t4_17 + (0.74905049800872803) * emb_t4_18 + (-1.4287266731262207) * emb_t4_19 + (-0.19436617195606232) * emb_t4_20 + (-0.047971762716770172) * emb_t4_21 + (0.63111799955368042) * emb_t4_22 + (-0.73483830690383911) * emb_t4_23 + (-1.1406437158584595) * emb_t4_24 + (0.32612848281860352) * emb_t4_25 + (-0.16619542241096497) * emb_t4_26 + (-0.64201676845550537) * emb_t4_27 + (0.25412452220916748) * emb_t4_28 + (-0.034536037594079971) * emb_t4_29 + (-0.6244158148765564) * emb_t4_30 + (0.56147545576095581) * emb_t4_31);
    gate_z = sigmoid((-0.74580198526382446) + (0.41014713048934937) * emb_t4_0 + (0.23182281851768494) * emb_t4_1 + (0.13059556484222412) * emb_t4_2 + (-0.094242304563522339) * emb_t4_3 + (0.94689780473709106) * emb_t4_4 + (0.34524530172348022) * emb_t4_5 + (0.89168083667755127) * emb_t4_6 + (-0.36694890260696411) * emb_t4_7 + (-0.17787168920040131) * emb_t4_8 + (0.62961816787719727) * emb_t4_9 + (0.48802617192268372) * emb_t4_10 + (-0.26804685592651367) * emb_t4_11 + (-0.34741714596748352) * emb_t4_12 + (0.21053895354270935) * emb_t4_13 + (0.056148260831832886) * emb_t4_14 + (-0.19469892978668213) * emb_t4_15 + (-0.1933322548866272) * emb_t4_16 + (0.47850921750068665) * emb_t4_17 + (-0.17392952740192413) * emb_t4_18 + (-0.45702219009399414) * emb_t4_19 + (-0.58957219123840332) * emb_t4_20 + (-0.43115532398223877) * emb_t4_21 + (0.49823564291000366) * emb_t4_22 + (-0.7252575159072876) * emb_t4_23 + (-0.26195994019508362) * emb_t4_24 + (0.012542654760181904) * emb_t4_25 + (-0.79435580968856812) * emb_t4_26 + (-0.15644161403179169) * emb_t4_27 + (-0.28429168462753296) * emb_t4_28 + (0.75150197744369507) * emb_t4_29 + (-0.55153673887252808) * emb_t4_30 + (0.40481123328208923) * emb_t4_31);
    gate_n = tanh((-0.064671911299228668) + (-0.0145057188346982) * emb_t4_0 + (-0.45209154486656189) * emb_t4_1 + (-0.016878098249435425) * emb_t4_2 + (-0.43513000011444092) * emb_t4_3 + (-0.10596102476119995) * emb_t4_4 + (0.024203134700655937) * emb_t4_5 + (-0.28881499171257019) * emb_t4_6 + (-0.0098277358338236809) * emb_t4_7 + (0.13458746671676636) * emb_t4_8 + (0.8168601393699646) * emb_t4_9 + (0.54673868417739868) * emb_t4_10 + (-0.013148934580385685) * emb_t4_11 + (0.17140950262546539) * emb_t4_12 + (-0.75303566455841064) * emb_t4_13 + (-0.0048305625095963478) * emb_t4_14 + (0.0017919479869306087) * emb_t4_15 + (-0.01953292079269886) * emb_t4_16 + (-0.34601119160652161) * emb_t4_17 + (0.34857809543609619) * emb_t4_18 + (-0.13400174677371979) * emb_t4_19 + (0.30393022298812866) * emb_t4_20 + (0.016960266977548599) * emb_t4_21 + (0.079755917191505432) * emb_t4_22 + (-0.014274687506258488) * emb_t4_23 + (-0.010848176665604115) * emb_t4_24 + (0.014527259394526482) * emb_t4_25 + (-0.10188835859298706) * emb_t4_26 + (-0.017021981999278069) * emb_t4_27 + (0.4810810387134552) * emb_t4_28 + (-0.74018782377243042) * emb_t4_29 + (0.27836692333221436) * emb_t4_30 + (-0.20410780608654022) * emb_t4_31 + gate_r * (-0.03882262110710144));
    gru_0_rev_t4_h_21 = (1.0 - gate_z) * gate_n;
    // h=22
    gate_r = sigmoid((0.32870063185691833) + (-0.077598646283149719) * emb_t4_0 + (-0.12727274000644684) * emb_t4_1 + (-0.32023012638092041) * emb_t4_2 + (0.10055723041296005) * emb_t4_3 + (-0.62927377223968506) * emb_t4_4 + (0.14438393712043762) * emb_t4_5 + (-0.44472554326057434) * emb_t4_6 + (-0.16689799726009369) * emb_t4_7 + (-0.0067595671862363815) * emb_t4_8 + (-0.17882181704044342) * emb_t4_9 + (0.56066477298736572) * emb_t4_10 + (-0.071845710277557373) * emb_t4_11 + (-0.63292938470840454) * emb_t4_12 + (-0.061934899538755417) * emb_t4_13 + (0.0032900529913604259) * emb_t4_14 + (-0.16320358216762543) * emb_t4_15 + (0.46593967080116272) * emb_t4_16 + (-0.40324035286903381) * emb_t4_17 + (0.27885061502456665) * emb_t4_18 + (-0.74125570058822632) * emb_t4_19 + (0.37897410988807678) * emb_t4_20 + (-0.080790154635906219) * emb_t4_21 + (0.019687112420797348) * emb_t4_22 + (-0.43844661116600037) * emb_t4_23 + (0.014504094608128071) * emb_t4_24 + (-0.44512251019477844) * emb_t4_25 + (0.17529314756393433) * emb_t4_26 + (-0.25938299298286438) * emb_t4_27 + (0.20370449125766754) * emb_t4_28 + (-0.42857608199119568) * emb_t4_29 + (0.76999980211257935) * emb_t4_30 + (0.13001042604446411) * emb_t4_31);
    gate_z = sigmoid((0.39693024754524231) + (0.010230946354568005) * emb_t4_0 + (-0.47218921780586243) * emb_t4_1 + (0.097433693706989288) * emb_t4_2 + (0.32850766181945801) * emb_t4_3 + (-0.31571677327156067) * emb_t4_4 + (0.10928338021039963) * emb_t4_5 + (-0.071918308734893799) * emb_t4_6 + (0.0096652237698435783) * emb_t4_7 + (0.42622661590576172) * emb_t4_8 + (-0.6314467191696167) * emb_t4_9 + (-0.5540047287940979) * emb_t4_10 + (0.58308660984039307) * emb_t4_11 + (0.41726681590080261) * emb_t4_12 + (-0.30103424191474915) * emb_t4_13 + (-0.078893117606639862) * emb_t4_14 + (0.085925668478012085) * emb_t4_15 + (0.05362258106470108) * emb_t4_16 + (0.023656098172068596) * emb_t4_17 + (-0.40956547856330872) * emb_t4_18 + (0.24052409827709198) * emb_t4_19 + (0.16636624932289124) * emb_t4_20 + (-0.053386863321065903) * emb_t4_21 + (0.0068326340988278389) * emb_t4_22 + (0.031989037990570068) * emb_t4_23 + (-0.2554301917552948) * emb_t4_24 + (0.12300414592027664) * emb_t4_25 + (-0.081419952213764191) * emb_t4_26 + (0.081370718777179718) * emb_t4_27 + (0.52485525608062744) * emb_t4_28 + (-0.25920924544334412) * emb_t4_29 + (0.050281360745429993) * emb_t4_30 + (-0.26076352596282959) * emb_t4_31);
    gate_n = tanh((-3.4135909080505371) + (0.002728540450334549) * emb_t4_0 + (-0.27497506141662598) * emb_t4_1 + (0.0029159768018871546) * emb_t4_2 + (-0.13194204866886139) * emb_t4_3 + (-0.056994132697582245) * emb_t4_4 + (0.0006965980282984674) * emb_t4_5 + (0.44180935621261597) * emb_t4_6 + (0.00088222773047164083) * emb_t4_7 + (0.0082344608381390572) * emb_t4_8 + (-0.033774677664041519) * emb_t4_9 + (0.53089648485183716) * emb_t4_10 + (-0.16563704609870911) * emb_t4_11 + (0.020524762570858002) * emb_t4_12 + (0.28117311000823975) * emb_t4_13 + (-0.0043445685878396034) * emb_t4_14 + (0.0034962492063641548) * emb_t4_15 + (-0.00084853387670591474) * emb_t4_16 + (0.040554888546466827) * emb_t4_17 + (0.35078164935112) * emb_t4_18 + (-0.3072967529296875) * emb_t4_19 + (-0.11760462075471878) * emb_t4_20 + (-0.0014168376801535487) * emb_t4_21 + (-0.037649985402822495) * emb_t4_22 + (-0.0021140382159501314) * emb_t4_23 + (-0.0032717080321162939) * emb_t4_24 + (0.0039416556246578693) * emb_t4_25 + (-0.038618061691522598) * emb_t4_26 + (0.00077581842197105289) * emb_t4_27 + (0.065976612269878387) * emb_t4_28 + (0.21243771910667419) * emb_t4_29 + (0.34293198585510254) * emb_t4_30 + (0.37474724650382996) * emb_t4_31 + gate_r * (-3.4165711402893066));
    gru_0_rev_t4_h_22 = (1.0 - gate_z) * gate_n;
    // h=23
    gate_r = sigmoid((0.6727975606918335) + (0.15331923961639404) * emb_t4_0 + (0.19076457619667053) * emb_t4_1 + (0.041639707982540131) * emb_t4_2 + (0.086788080632686615) * emb_t4_3 + (0.40731707215309143) * emb_t4_4 + (0.046675305813550949) * emb_t4_5 + (0.53039056062698364) * emb_t4_6 + (-0.26320245862007141) * emb_t4_7 + (3.864422082901001) * emb_t4_8 + (-0.3848341703414917) * emb_t4_9 + (-0.096491813659667969) * emb_t4_10 + (0.11183642596006393) * emb_t4_11 + (6.1263818740844727) * emb_t4_12 + (0.82057327032089233) * emb_t4_13 + (-0.33826020359992981) * emb_t4_14 + (-1.0511786937713623) * emb_t4_15 + (-0.77991348505020142) * emb_t4_16 + (0.15794000029563904) * emb_t4_17 + (-0.34941175580024719) * emb_t4_18 + (0.74547916650772095) * emb_t4_19 + (0.18030849099159241) * emb_t4_20 + (0.61507946252822876) * emb_t4_21 + (-1.170180082321167) * emb_t4_22 + (0.42506828904151917) * emb_t4_23 + (0.10956092923879623) * emb_t4_24 + (0.27264097332954407) * emb_t4_25 + (-0.78987628221511841) * emb_t4_26 + (-0.38116616010665894) * emb_t4_27 + (-0.78061223030090332) * emb_t4_28 + (0.38897690176963806) * emb_t4_29 + (-0.72332066297531128) * emb_t4_30 + (-6.2226972579956055) * emb_t4_31);
    gate_z = sigmoid((-0.81445848941802979) + (0.00043014364200644195) * emb_t4_0 + (-0.2161974161863327) * emb_t4_1 + (-0.0027795892674475908) * emb_t4_2 + (-0.0603770911693573) * emb_t4_3 + (0.1652170717716217) * emb_t4_4 + (0.00091139733558520675) * emb_t4_5 + (-0.14932477474212646) * emb_t4_6 + (0.00092351622879505157) * emb_t4_7 + (0.03801090270280838) * emb_t4_8 + (-0.059916872531175613) * emb_t4_9 + (-0.28817501664161682) * emb_t4_10 + (-0.066594876348972321) * emb_t4_11 + (-0.46100166440010071) * emb_t4_12 + (0.36268642544746399) * emb_t4_13 + (-6.2344491880139685e-07) * emb_t4_14 + (-0.0016302572330459952) * emb_t4_15 + (-0.0021349424496293068) * emb_t4_16 + (0.47143852710723877) * emb_t4_17 + (0.39460316300392151) * emb_t4_18 + (-0.46239304542541504) * emb_t4_19 + (-0.12200218439102173) * emb_t4_20 + (-8.3172235463280231e-05) * emb_t4_21 + (0.1636136919260025) * emb_t4_22 + (0.00035267483326606452) * emb_t4_23 + (-0.00015512465324718505) * emb_t4_24 + (0.0024075089022517204) * emb_t4_25 + (-0.018496673554182053) * emb_t4_26 + (-0.0006459130672737956) * emb_t4_27 + (-0.34508103132247925) * emb_t4_28 + (-0.33571326732635498) * emb_t4_29 + (-0.25194844603538513) * emb_t4_30 + (0.023423835635185242) * emb_t4_31);
    gate_n = tanh((0.81481647491455078) + (0.38457006216049194) * emb_t4_0 + (0.49048694968223572) * emb_t4_1 + (0.96388512849807739) * emb_t4_2 + (0.54865503311157227) * emb_t4_3 + (-0.056372877210378647) * emb_t4_4 + (0.41909492015838623) * emb_t4_5 + (0.15156026184558868) * emb_t4_6 + (-1.1325676441192627) * emb_t4_7 + (3.7597672939300537) * emb_t4_8 + (-0.6779559850692749) * emb_t4_9 + (-0.8543325662612915) * emb_t4_10 + (0.72184109687805176) * emb_t4_11 + (3.5904181003570557) * emb_t4_12 + (0.09551035612821579) * emb_t4_13 + (0.025600003078579903) * emb_t4_14 + (-0.3581484854221344) * emb_t4_15 + (-0.17473210394382477) * emb_t4_16 + (-0.10362590849399567) * emb_t4_17 + (-0.95575052499771118) * emb_t4_18 + (1.0804091691970825) * emb_t4_19 + (1.1961759328842163) * emb_t4_20 + (-0.43121173977851868) * emb_t4_21 + (-1.5881068706512451) * emb_t4_22 + (-0.53644019365310669) * emb_t4_23 + (-0.42774546146392822) * emb_t4_24 + (-1.1619769334793091) * emb_t4_25 + (0.41951170563697815) * emb_t4_26 + (-0.46760568022727966) * emb_t4_27 + (-0.46871235966682434) * emb_t4_28 + (0.20510822534561157) * emb_t4_29 + (0.071247518062591553) * emb_t4_30 + (-3.4489779472351074) * emb_t4_31 + gate_r * (0.72348600625991821));
    gru_0_rev_t4_h_23 = (1.0 - gate_z) * gate_n;
    // h=24
    gate_r = sigmoid((0.67366540431976318) + (0.41744104027748108) * emb_t4_0 + (-0.058972612023353577) * emb_t4_1 + (-0.40895506739616394) * emb_t4_2 + (-0.24018912017345428) * emb_t4_3 + (-0.24757079780101776) * emb_t4_4 + (-0.13943079113960266) * emb_t4_5 + (0.052713871002197266) * emb_t4_6 + (0.21726503968238831) * emb_t4_7 + (0.5896485447883606) * emb_t4_8 + (-0.1245899572968483) * emb_t4_9 + (-0.5707390308380127) * emb_t4_10 + (0.16533045470714569) * emb_t4_11 + (0.34912854433059692) * emb_t4_12 + (0.50022178888320923) * emb_t4_13 + (-0.55664843320846558) * emb_t4_14 + (0.1970478743314743) * emb_t4_15 + (-0.059312544763088226) * emb_t4_16 + (-0.15058945119380951) * emb_t4_17 + (-0.37469914555549622) * emb_t4_18 + (0.024496898055076599) * emb_t4_19 + (0.52491331100463867) * emb_t4_20 + (-0.39102199673652649) * emb_t4_21 + (-0.7402040958404541) * emb_t4_22 + (0.50304657220840454) * emb_t4_23 + (-0.33863544464111328) * emb_t4_24 + (0.49096950888633728) * emb_t4_25 + (0.026264974847435951) * emb_t4_26 + (-0.09327089786529541) * emb_t4_27 + (-0.3275819718837738) * emb_t4_28 + (0.23906369507312775) * emb_t4_29 + (0.50904238224029541) * emb_t4_30 + (-0.56786048412322998) * emb_t4_31);
    gate_z = sigmoid((-0.089968547224998474) + (0.0035437550395727158) * emb_t4_0 + (-0.41170632839202881) * emb_t4_1 + (-0.0065493029542267323) * emb_t4_2 + (0.30897712707519531) * emb_t4_3 + (-0.40353056788444519) * emb_t4_4 + (0.039284799247980118) * emb_t4_5 + (-0.35245269536972046) * emb_t4_6 + (0.32541763782501221) * emb_t4_7 + (-0.53564023971557617) * emb_t4_8 + (0.91905266046524048) * emb_t4_9 + (0.6215406060218811) * emb_t4_10 + (-0.60992449522018433) * emb_t4_11 + (-0.66984701156616211) * emb_t4_12 + (-0.71973097324371338) * emb_t4_13 + (-0.24336706101894379) * emb_t4_14 + (0.19901297986507416) * emb_t4_15 + (-0.086203522980213165) * emb_t4_16 + (-0.083043746650218964) * emb_t4_17 + (0.73421323299407959) * emb_t4_18 + (-0.65435928106307983) * emb_t4_19 + (0.020578369498252869) * emb_t4_20 + (0.0076341279782354832) * emb_t4_21 + (0.62878262996673584) * emb_t4_22 + (0.33913680911064148) * emb_t4_23 + (0.10401933640241623) * emb_t4_24 + (0.13025492429733276) * emb_t4_25 + (0.33629330992698669) * emb_t4_26 + (-0.15593381226062775) * emb_t4_27 + (0.31515595316886902) * emb_t4_28 + (-1.214504599571228) * emb_t4_29 + (-0.031459454447031021) * emb_t4_30 + (0.21881510317325592) * emb_t4_31);
    gate_n = tanh((-0.04569472000002861) + (-0.0074193072505295277) * emb_t4_0 + (-0.041296377778053284) * emb_t4_1 + (0.016267554834485054) * emb_t4_2 + (-0.25593018531799316) * emb_t4_3 + (0.19248059391975403) * emb_t4_4 + (0.002783370204269886) * emb_t4_5 + (0.2984984815120697) * emb_t4_6 + (0.030059311538934708) * emb_t4_7 + (0.17830801010131836) * emb_t4_8 + (-0.1281745433807373) * emb_t4_9 + (-0.015046579763293266) * emb_t4_10 + (0.081237882375717163) * emb_t4_11 + (-0.0057075684890151024) * emb_t4_12 + (0.099380098283290863) * emb_t4_13 + (-0.035550795495510101) * emb_t4_14 + (-0.027449626475572586) * emb_t4_15 + (0.039211396127939224) * emb_t4_16 + (-0.040178477764129639) * emb_t4_17 + (-0.015397191978991032) * emb_t4_18 + (0.460518479347229) * emb_t4_19 + (0.10052689909934998) * emb_t4_20 + (0.0034078720491379499) * emb_t4_21 + (-0.28633278608322144) * emb_t4_22 + (0.053041413426399231) * emb_t4_23 + (-0.0020833560265600681) * emb_t4_24 + (0.026963373646140099) * emb_t4_25 + (-0.32211649417877197) * emb_t4_26 + (-0.014405340887606144) * emb_t4_27 + (-0.2402542382478714) * emb_t4_28 + (-0.09135621041059494) * emb_t4_29 + (-0.22630250453948975) * emb_t4_30 + (0.039756480604410172) * emb_t4_31 + gate_r * (-0.22250570356845856));
    gru_0_rev_t4_h_24 = (1.0 - gate_z) * gate_n;
    // h=25
    gate_r = sigmoid((-2.1282727718353271) + (0.25715795159339905) * emb_t4_0 + (0.039369940757751465) * emb_t4_1 + (-0.69823688268661499) * emb_t4_2 + (-0.54066795110702515) * emb_t4_3 + (0.13336622714996338) * emb_t4_4 + (-0.76071882247924805) * emb_t4_5 + (0.83323013782501221) * emb_t4_6 + (0.24302217364311218) * emb_t4_7 + (-1.4435840845108032) * emb_t4_8 + (0.99740076065063477) * emb_t4_9 + (1.7969180345535278) * emb_t4_10 + (-1.2062828540802002) * emb_t4_11 + (-2.2306809425354004) * emb_t4_12 + (0.23912440240383148) * emb_t4_13 + (0.22273263335227966) * emb_t4_14 + (0.66886323690414429) * emb_t4_15 + (-0.35155683755874634) * emb_t4_16 + (0.5605512261390686) * emb_t4_17 + (2.6281325817108154) * emb_t4_18 + (-2.4750547409057617) * emb_t4_19 + (-0.48113414645195007) * emb_t4_20 + (0.87681955099105835) * emb_t4_21 + (2.0862770080566406) * emb_t4_22 + (-0.28890585899353027) * emb_t4_23 + (0.71180576086044312) * emb_t4_24 + (-0.043380346149206161) * emb_t4_25 + (-0.72959303855895996) * emb_t4_26 + (-1.0318795442581177) * emb_t4_27 + (0.10062818974256516) * emb_t4_28 + (0.033288445323705673) * emb_t4_29 + (-0.68417483568191528) * emb_t4_30 + (1.0320874452590942) * emb_t4_31);
    gate_z = sigmoid((-1.0343008041381836) + (-0.11894117295742035) * emb_t4_0 + (0.33630552887916565) * emb_t4_1 + (-0.43691104650497437) * emb_t4_2 + (-0.33420899510383606) * emb_t4_3 + (0.18126337230205536) * emb_t4_4 + (-0.024748319759964943) * emb_t4_5 + (0.048608753830194473) * emb_t4_6 + (0.014354699291288853) * emb_t4_7 + (-0.80990129709243774) * emb_t4_8 + (-0.10408443957567215) * emb_t4_9 + (0.30223920941352844) * emb_t4_10 + (-0.43656617403030396) * emb_t4_11 + (-0.97778981924057007) * emb_t4_12 + (-0.4272264838218689) * emb_t4_13 + (-0.016624113544821739) * emb_t4_14 + (-0.030560998246073723) * emb_t4_15 + (-0.33663696050643921) * emb_t4_16 + (-0.039525032043457031) * emb_t4_17 + (0.66717666387557983) * emb_t4_18 + (-1.0760421752929688) * emb_t4_19 + (-0.022832207381725311) * emb_t4_20 + (0.23127028346061707) * emb_t4_21 + (0.3310091495513916) * emb_t4_22 + (-0.030763942748308182) * emb_t4_23 + (0.40938636660575867) * emb_t4_24 + (0.11012759059667587) * emb_t4_25 + (-0.59098529815673828) * emb_t4_26 + (-0.28985694050788879) * emb_t4_27 + (-0.033977396786212921) * emb_t4_28 + (-0.3845120370388031) * emb_t4_29 + (-0.098012767732143402) * emb_t4_30 + (0.79540520906448364) * emb_t4_31);
    gate_n = tanh((-0.030487675219774246) + (0.021830381825566292) * emb_t4_0 + (-0.40206196904182434) * emb_t4_1 + (-0.034422937780618668) * emb_t4_2 + (0.42191627621650696) * emb_t4_3 + (-0.21854633092880249) * emb_t4_4 + (-0.0052112117409706116) * emb_t4_5 + (-0.079658888280391693) * emb_t4_6 + (-0.030271556228399277) * emb_t4_7 + (-0.27175208926200867) * emb_t4_8 + (0.36174112558364868) * emb_t4_9 + (0.2726496160030365) * emb_t4_10 + (-0.30267807841300964) * emb_t4_11 + (-0.38848069310188293) * emb_t4_12 + (-0.8245423436164856) * emb_t4_13 + (-0.014803031459450722) * emb_t4_14 + (0.035825669765472412) * emb_t4_15 + (-0.010822847485542297) * emb_t4_16 + (-0.06533648818731308) * emb_t4_17 + (0.44106262922286987) * emb_t4_18 + (-0.42275154590606689) * emb_t4_19 + (-0.089276671409606934) * emb_t4_20 + (0.012546977028250694) * emb_t4_21 + (0.29032301902770996) * emb_t4_22 + (0.00018747766443993896) * emb_t4_23 + (-0.035291362553834915) * emb_t4_24 + (0.0084596937522292137) * emb_t4_25 + (0.25339648127555847) * emb_t4_26 + (-0.0075440709479153156) * emb_t4_27 + (0.16011030972003937) * emb_t4_28 + (-0.92615741491317749) * emb_t4_29 + (-0.32100898027420044) * emb_t4_30 + (0.14961324632167816) * emb_t4_31 + gate_r * (0.17084111273288727));
    gru_0_rev_t4_h_25 = (1.0 - gate_z) * gate_n;
    // h=26
    gate_r = sigmoid((0.75765615701675415) + (0.046318113803863525) * emb_t4_0 + (-0.66292101144790649) * emb_t4_1 + (-0.55082404613494873) * emb_t4_2 + (0.1813732236623764) * emb_t4_3 + (-0.46879014372825623) * emb_t4_4 + (-0.13508045673370361) * emb_t4_5 + (-0.86223125457763672) * emb_t4_6 + (0.68482619524002075) * emb_t4_7 + (0.43473109602928162) * emb_t4_8 + (0.76691830158233643) * emb_t4_9 + (0.52833789587020874) * emb_t4_10 + (0.30333667993545532) * emb_t4_11 + (-0.124007947742939) * emb_t4_12 + (-0.76294177770614624) * emb_t4_13 + (-1.2880825996398926) * emb_t4_14 + (0.11231882870197296) * emb_t4_15 + (0.1663372665643692) * emb_t4_16 + (-0.5747302770614624) * emb_t4_17 + (0.76319235563278198) * emb_t4_18 + (-0.48425021767616272) * emb_t4_19 + (1.0075786113739014) * emb_t4_20 + (0.16069261729717255) * emb_t4_21 + (1.0026110410690308) * emb_t4_22 + (0.38304290175437927) * emb_t4_23 + (0.24022093415260315) * emb_t4_24 + (-0.16676315665245056) * emb_t4_25 + (0.91000211238861084) * emb_t4_26 + (0.39167574048042297) * emb_t4_27 + (0.56759536266326904) * emb_t4_28 + (-0.58527714014053345) * emb_t4_29 + (0.73821783065795898) * emb_t4_30 + (-0.32880124449729919) * emb_t4_31);
    gate_z = sigmoid((0.79299730062484741) + (-0.027064105495810509) * emb_t4_0 + (0.20082099735736847) * emb_t4_1 + (-0.083119586110115051) * emb_t4_2 + (0.53957635164260864) * emb_t4_3 + (0.1354551762342453) * emb_t4_4 + (-0.19360654056072235) * emb_t4_5 + (-0.30477848649024963) * emb_t4_6 + (0.068888269364833832) * emb_t4_7 + (0.47375929355621338) * emb_t4_8 + (-1.5231810808181763) * emb_t4_9 + (-1.1086150407791138) * emb_t4_10 + (0.41673663258552551) * emb_t4_11 + (0.90833044052124023) * emb_t4_12 + (0.29405942559242249) * emb_t4_13 + (-0.042784176766872406) * emb_t4_14 + (0.079109050333499908) * emb_t4_15 + (-0.057013873010873795) * emb_t4_16 + (-0.18676765263080597) * emb_t4_17 + (-0.85328942537307739) * emb_t4_18 + (0.70597219467163086) * emb_t4_19 + (0.36894994974136353) * emb_t4_20 + (0.22028890252113342) * emb_t4_21 + (-0.46142220497131348) * emb_t4_22 + (0.12788334488868713) * emb_t4_23 + (0.18959525227546692) * emb_t4_24 + (0.035026714205741882) * emb_t4_25 + (0.11414226144552231) * emb_t4_26 + (-0.04329448938369751) * emb_t4_27 + (-0.3182770311832428) * emb_t4_28 + (0.1335231214761734) * emb_t4_29 + (0.090200990438461304) * emb_t4_30 + (-0.52365535497665405) * emb_t4_31);
    gate_n = tanh((-0.90731567144393921) + (0.040611237287521362) * emb_t4_0 + (-0.41411229968070984) * emb_t4_1 + (0.021151717752218246) * emb_t4_2 + (-0.52548331022262573) * emb_t4_3 + (-0.28180500864982605) * emb_t4_4 + (0.014201437123119831) * emb_t4_5 + (-0.6126408576965332) * emb_t4_6 + (0.0057191355153918266) * emb_t4_7 + (-3.944404125213623) * emb_t4_8 + (1.2117656469345093) * emb_t4_9 + (0.46447497606277466) * emb_t4_10 + (-0.91557866334915161) * emb_t4_11 + (-2.3790998458862305) * emb_t4_12 + (-0.70899116992950439) * emb_t4_13 + (0.0011631192173808813) * emb_t4_14 + (0.038372106850147247) * emb_t4_15 + (0.00066819478524848819) * emb_t4_16 + (0.041574627161026001) * emb_t4_17 + (0.79649323225021362) * emb_t4_18 + (-0.640663743019104) * emb_t4_19 + (-0.69782650470733643) * emb_t4_20 + (0.0026893818285316229) * emb_t4_21 + (1.4329062700271606) * emb_t4_22 + (-0.013378274627029896) * emb_t4_23 + (0.018060175701975822) * emb_t4_24 + (-0.028674205765128136) * emb_t4_25 + (0.18378809094429016) * emb_t4_26 + (0.00046005446347407997) * emb_t4_27 + (0.38440057635307312) * emb_t4_28 + (-0.56628847122192383) * emb_t4_29 + (0.64225625991821289) * emb_t4_30 + (5.971837043762207) * emb_t4_31 + gate_r * (-0.84544110298156738));
    gru_0_rev_t4_h_26 = (1.0 - gate_z) * gate_n;
    // h=27
    gate_r = sigmoid((-0.28838735818862915) + (-0.12775494158267975) * emb_t4_0 + (-0.65382856130599976) * emb_t4_1 + (-0.19045965373516083) * emb_t4_2 + (0.097327068448066711) * emb_t4_3 + (-0.10653271526098251) * emb_t4_4 + (0.072829671204090118) * emb_t4_5 + (-0.29010465741157532) * emb_t4_6 + (0.0012492064852267504) * emb_t4_7 + (-0.34479519724845886) * emb_t4_8 + (1.1645447015762329) * emb_t4_9 + (0.83605712652206421) * emb_t4_10 + (-0.45607984066009521) * emb_t4_11 + (-0.2492637038230896) * emb_t4_12 + (-0.62689906358718872) * emb_t4_13 + (0.070960491895675659) * emb_t4_14 + (0.079203739762306213) * emb_t4_15 + (-0.076263971626758575) * emb_t4_16 + (0.13599513471126556) * emb_t4_17 + (0.42974796891212463) * emb_t4_18 + (-1.1318570375442505) * emb_t4_19 + (0.48880240321159363) * emb_t4_20 + (0.051998291164636612) * emb_t4_21 + (0.42914858460426331) * emb_t4_22 + (-0.01748170331120491) * emb_t4_23 + (-0.038346122950315475) * emb_t4_24 + (0.091468855738639832) * emb_t4_25 + (0.026125462725758553) * emb_t4_26 + (-0.015486192889511585) * emb_t4_27 + (0.4156186580657959) * emb_t4_28 + (-0.8787391185760498) * emb_t4_29 + (-0.15778593719005585) * emb_t4_30 + (0.27063861489295959) * emb_t4_31);
    gate_z = sigmoid((0.35888591408729553) + (0.057985201478004456) * emb_t4_0 + (-1.229061484336853) * emb_t4_1 + (-0.093904830515384674) * emb_t4_2 + (0.25780606269836426) * emb_t4_3 + (-0.78116273880004883) * emb_t4_4 + (-0.10171163827180862) * emb_t4_5 + (-1.1307939291000366) * emb_t4_6 + (-0.12000943720340729) * emb_t4_7 + (-0.22703295946121216) * emb_t4_8 + (0.54988890886306763) * emb_t4_9 + (0.72025120258331299) * emb_t4_10 + (0.18257036805152893) * emb_t4_11 + (0.14522440731525421) * emb_t4_12 + (-0.71747899055480957) * emb_t4_13 + (0.065938860177993774) * emb_t4_14 + (0.11685853451490402) * emb_t4_15 + (-0.044144365936517715) * emb_t4_16 + (-0.51338726282119751) * emb_t4_17 + (0.48327180743217468) * emb_t4_18 + (-0.34779548645019531) * emb_t4_19 + (0.66968512535095215) * emb_t4_20 + (0.072815977036952972) * emb_t4_21 + (-0.24615706503391266) * emb_t4_22 + (0.059988964349031448) * emb_t4_23 + (0.052907653152942657) * emb_t4_24 + (-0.098041810095310211) * emb_t4_25 + (0.53089380264282227) * emb_t4_26 + (0.052757371217012405) * emb_t4_27 + (0.82761645317077637) * emb_t4_28 + (-1.2994484901428223) * emb_t4_29 + (0.52887821197509766) * emb_t4_30 + (-0.024682680144906044) * emb_t4_31);
    gate_n = tanh((-0.047713205218315125) + (-0.016649127006530762) * emb_t4_0 + (0.58704453706741333) * emb_t4_1 + (0.0584246926009655) * emb_t4_2 + (-0.38829708099365234) * emb_t4_3 + (-0.25300896167755127) * emb_t4_4 + (-0.0077520618215203285) * emb_t4_5 + (0.21356388926506042) * emb_t4_6 + (-0.0085561675950884819) * emb_t4_7 + (0.18371473252773285) * emb_t4_8 + (-0.19693094491958618) * emb_t4_9 + (-0.59392267465591431) * emb_t4_10 + (-0.062116306275129318) * emb_t4_11 + (0.29781702160835266) * emb_t4_12 + (0.063150368630886078) * emb_t4_13 + (0.0067759542725980282) * emb_t4_14 + (-0.024168150499463081) * emb_t4_15 + (0.039339721202850342) * emb_t4_16 + (0.5686957836151123) * emb_t4_17 + (-0.34141770005226135) * emb_t4_18 + (0.25632962584495544) * emb_t4_19 + (-0.079191148281097412) * emb_t4_20 + (-0.025720799341797829) * emb_t4_21 + (-0.072777166962623596) * emb_t4_22 + (0.066706106066703796) * emb_t4_23 + (-0.021409489214420319) * emb_t4_24 + (0.0090079819783568382) * emb_t4_25 + (0.13014742732048035) * emb_t4_26 + (0.004746326245367527) * emb_t4_27 + (-0.0029057154897600412) * emb_t4_28 + (0.33299833536148071) * emb_t4_29 + (-0.18592241406440735) * emb_t4_30 + (-0.23573879897594452) * emb_t4_31 + gate_r * (-0.077536784112453461));
    gru_0_rev_t4_h_27 = (1.0 - gate_z) * gate_n;
    // h=28
    gate_r = sigmoid((-3.223726749420166) + (-0.50374925136566162) * emb_t4_0 + (-0.0060921492986381054) * emb_t4_1 + (-1.1717541217803955) * emb_t4_2 + (-1.4255013465881348) * emb_t4_3 + (0.8177715539932251) * emb_t4_4 + (0.99798011779785156) * emb_t4_5 + (1.0119441747665405) * emb_t4_6 + (0.89161092042922974) * emb_t4_7 + (-1.1490973234176636) * emb_t4_8 + (0.73435819149017334) * emb_t4_9 + (0.92881792783737183) * emb_t4_10 + (-1.443163275718689) * emb_t4_11 + (-1.5906031131744385) * emb_t4_12 + (0.39812728762626648) * emb_t4_13 + (0.84641408920288086) * emb_t4_14 + (1.042570948600769) * emb_t4_15 + (-1.1562560796737671) * emb_t4_16 + (2.0544154644012451) * emb_t4_17 + (0.54507094621658325) * emb_t4_18 + (-0.98366236686706543) * emb_t4_19 + (-1.2089365720748901) * emb_t4_20 + (1.1239421367645264) * emb_t4_21 + (0.61438602209091187) * emb_t4_22 + (-1.1751329898834229) * emb_t4_23 + (0.27446293830871582) * emb_t4_24 + (0.19412040710449219) * emb_t4_25 + (-1.3688305616378784) * emb_t4_26 + (-0.87827438116073608) * emb_t4_27 + (-0.052114479243755341) * emb_t4_28 + (0.70097959041595459) * emb_t4_29 + (-0.81168657541275024) * emb_t4_30 + (0.77497553825378418) * emb_t4_31);
    gate_z = sigmoid((-1.0287853479385376) + (0.015959650278091431) * emb_t4_0 + (-0.10917361825704575) * emb_t4_1 + (0.0038664324674755335) * emb_t4_2 + (-0.34313762187957764) * emb_t4_3 + (0.079974204301834106) * emb_t4_4 + (-0.0050696199759840965) * emb_t4_5 + (0.30202478170394897) * emb_t4_6 + (0.016299471259117126) * emb_t4_7 + (-0.37119421362876892) * emb_t4_8 + (0.14748655259609222) * emb_t4_9 + (0.098997950553894043) * emb_t4_10 + (-0.17143040895462036) * emb_t4_11 + (-0.14863243699073792) * emb_t4_12 + (-0.50074857473373413) * emb_t4_13 + (-0.0066119744442403316) * emb_t4_14 + (0.0062181991524994373) * emb_t4_15 + (-0.0039601582102477551) * emb_t4_16 + (-0.039921097457408905) * emb_t4_17 + (-0.36193844676017761) * emb_t4_18 + (-0.078754901885986328) * emb_t4_19 + (-0.15168026089668274) * emb_t4_20 + (0.01042141392827034) * emb_t4_21 + (0.50493699312210083) * emb_t4_22 + (0.0086669167503714561) * emb_t4_23 + (0.0025645392015576363) * emb_t4_24 + (-2.6937397706205957e-05) * emb_t4_25 + (-0.19944648444652557) * emb_t4_26 + (0.012681541964411736) * emb_t4_27 + (0.53197020292282104) * emb_t4_28 + (-0.52922958135604858) * emb_t4_29 + (-0.32621997594833374) * emb_t4_30 + (-0.028814399614930153) * emb_t4_31);
    gate_n = tanh((0.015682810917496681) + (-0.0028612110763788223) * emb_t4_0 + (0.76588118076324463) * emb_t4_1 + (-0.016478892415761948) * emb_t4_2 + (0.022905955091118813) * emb_t4_3 + (0.087676852941513062) * emb_t4_4 + (-0.0021213993895798922) * emb_t4_5 + (-0.11658130586147308) * emb_t4_6 + (0.021493831649422646) * emb_t4_7 + (0.079030066728591919) * emb_t4_8 + (-0.28577327728271484) * emb_t4_9 + (-0.6160319447517395) * emb_t4_10 + (-0.2271735817193985) * emb_t4_11 + (0.18431033194065094) * emb_t4_12 + (0.098106585443019867) * emb_t4_13 + (-0.0024460304994136095) * emb_t4_14 + (0.0059418138116598129) * emb_t4_15 + (-0.028032291680574417) * emb_t4_16 + (0.0019606738351285458) * emb_t4_17 + (-0.07372012734413147) * emb_t4_18 + (0.44747662544250488) * emb_t4_19 + (-0.37852990627288818) * emb_t4_20 + (0.006864610593765974) * emb_t4_21 + (-0.21461723744869232) * emb_t4_22 + (-0.0026383912190794945) * emb_t4_23 + (0.036656603217124939) * emb_t4_24 + (0.00085717358160763979) * emb_t4_25 + (-0.44618454575538635) * emb_t4_26 + (-0.01754099503159523) * emb_t4_27 + (-0.80827975273132324) * emb_t4_28 + (0.50963252782821655) * emb_t4_29 + (-0.36569380760192871) * emb_t4_30 + (-0.26319250464439392) * emb_t4_31 + gate_r * (0.23870672285556793));
    gru_0_rev_t4_h_28 = (1.0 - gate_z) * gate_n;
    // h=29
    gate_r = sigmoid((0.32173404097557068) + (0.055921368300914764) * emb_t4_0 + (-0.10297276824712753) * emb_t4_1 + (0.2520657479763031) * emb_t4_2 + (0.20899145305156708) * emb_t4_3 + (-0.18162235617637634) * emb_t4_4 + (-0.19413299858570099) * emb_t4_5 + (-0.11049717664718628) * emb_t4_6 + (-0.031090311706066132) * emb_t4_7 + (0.26408037543296814) * emb_t4_8 + (-0.58010190725326538) * emb_t4_9 + (-0.23026017844676971) * emb_t4_10 + (0.32242998480796814) * emb_t4_11 + (-0.40609273314476013) * emb_t4_12 + (-0.052805755287408829) * emb_t4_13 + (0.016613006591796875) * emb_t4_14 + (0.1435447633266449) * emb_t4_15 + (0.062877900898456573) * emb_t4_16 + (-0.29014921188354492) * emb_t4_17 + (-0.45784842967987061) * emb_t4_18 + (0.47331643104553223) * emb_t4_19 + (0.19354303181171417) * emb_t4_20 + (-0.11089349538087845) * emb_t4_21 + (0.18104308843612671) * emb_t4_22 + (-0.0060321786440908909) * emb_t4_23 + (0.050856292247772217) * emb_t4_24 + (0.015622256323695183) * emb_t4_25 + (0.54216903448104858) * emb_t4_26 + (0.13367205858230591) * emb_t4_27 + (0.19604146480560303) * emb_t4_28 + (-0.39428332448005676) * emb_t4_29 + (0.38894477486610413) * emb_t4_30 + (-0.15739230811595917) * emb_t4_31);
    gate_z = sigmoid((-0.54896610975265503) + (0.00029152326169423759) * emb_t4_0 + (-0.094816580414772034) * emb_t4_1 + (0.0090483035892248154) * emb_t4_2 + (-0.13170795142650604) * emb_t4_3 + (0.1378169059753418) * emb_t4_4 + (-0.0034486122895032167) * emb_t4_5 + (0.046504195779561996) * emb_t4_6 + (-0.011009851470589638) * emb_t4_7 + (-0.094083964824676514) * emb_t4_8 + (-0.38025590777397156) * emb_t4_9 + (-0.089739739894866943) * emb_t4_10 + (0.23595318198204041) * emb_t4_11 + (-0.40508601069450378) * emb_t4_12 + (-0.49295026063919067) * emb_t4_13 + (0.021975168958306313) * emb_t4_14 + (0.003388871205970645) * emb_t4_15 + (0.015692479908466339) * emb_t4_16 + (-0.37197506427764893) * emb_t4_17 + (-0.19381240010261536) * emb_t4_18 + (-0.28285592794418335) * emb_t4_19 + (0.00163104641251266) * emb_t4_20 + (-0.0035075356718152761) * emb_t4_21 + (0.25814786553382874) * emb_t4_22 + (-0.0088165663182735443) * emb_t4_23 + (0.0050007919780910015) * emb_t4_24 + (-0.012685704044997692) * emb_t4_25 + (-0.02663898840546608) * emb_t4_26 + (0.0079759908840060234) * emb_t4_27 + (-0.083886630833148956) * emb_t4_28 + (-0.18716727197170258) * emb_t4_29 + (0.46683016419410706) * emb_t4_30 + (0.15733791887760162) * emb_t4_31);
    gate_n = tanh((0.1339261382818222) + (0.037234421819448471) * emb_t4_0 + (0.22782236337661743) * emb_t4_1 + (-0.097569793462753296) * emb_t4_2 + (0.12717312574386597) * emb_t4_3 + (0.094165749847888947) * emb_t4_4 + (0.084420561790466309) * emb_t4_5 + (0.31452459096908569) * emb_t4_6 + (0.075050383806228638) * emb_t4_7 + (0.17073485255241394) * emb_t4_8 + (0.21176472306251526) * emb_t4_9 + (-0.27245441079139709) * emb_t4_10 + (0.12528933584690094) * emb_t4_11 + (0.35852527618408203) * emb_t4_12 + (-0.41233080625534058) * emb_t4_13 + (-0.025097206234931946) * emb_t4_14 + (-0.025500664487481117) * emb_t4_15 + (-0.090332649648189545) * emb_t4_16 + (0.18825747072696686) * emb_t4_17 + (-0.29260486364364624) * emb_t4_18 + (0.27466890215873718) * emb_t4_19 + (0.32294335961341858) * emb_t4_20 + (0.019552579149603844) * emb_t4_21 + (-0.57671517133712769) * emb_t4_22 + (0.006399927195161581) * emb_t4_23 + (-0.047378212213516235) * emb_t4_24 + (0.049574848264455795) * emb_t4_25 + (0.11396224051713943) * emb_t4_26 + (-0.040766052901744843) * emb_t4_27 + (0.14726428687572479) * emb_t4_28 + (0.099061928689479828) * emb_t4_29 + (0.27095654606819153) * emb_t4_30 + (-0.21277682483196259) * emb_t4_31 + gate_r * (0.30990120768547058));
    gru_0_rev_t4_h_29 = (1.0 - gate_z) * gate_n;
    // h=30
    gate_r = sigmoid((1.34485924243927) + (0.13437739014625549) * emb_t4_0 + (-0.68271768093109131) * emb_t4_1 + (0.49135574698448181) * emb_t4_2 + (1.1417891979217529) * emb_t4_3 + (-1.0022807121276855) * emb_t4_4 + (-0.35174247622489929) * emb_t4_5 + (-0.54898923635482788) * emb_t4_6 + (-0.097089953720569611) * emb_t4_7 + (0.71768605709075928) * emb_t4_8 + (-0.18571466207504272) * emb_t4_9 + (-0.30236780643463135) * emb_t4_10 + (0.24225807189941406) * emb_t4_11 + (0.76618862152099609) * emb_t4_12 + (-0.56919378042221069) * emb_t4_13 + (-0.40195751190185547) * emb_t4_14 + (-0.75822955369949341) * emb_t4_15 + (0.31165164709091187) * emb_t4_16 + (-0.66277271509170532) * emb_t4_17 + (0.46557658910751343) * emb_t4_18 + (-0.077644221484661102) * emb_t4_19 + (0.45029938220977783) * emb_t4_20 + (-0.079259045422077179) * emb_t4_21 + (-0.52297294139862061) * emb_t4_22 + (0.39606240391731262) * emb_t4_23 + (-0.54204702377319336) * emb_t4_24 + (0.31168773770332336) * emb_t4_25 + (0.59590786695480347) * emb_t4_26 + (0.33031272888183594) * emb_t4_27 + (0.93750518560409546) * emb_t4_28 + (-0.53985309600830078) * emb_t4_29 + (0.24347959458827972) * emb_t4_30 + (-0.73059821128845215) * emb_t4_31);
    gate_z = sigmoid((2.4693558216094971) + (0.00021757114154752344) * emb_t4_0 + (0.46421575546264648) * emb_t4_1 + (-0.00030185966170392931) * emb_t4_2 + (0.065278105437755585) * emb_t4_3 + (-0.14363428950309753) * emb_t4_4 + (-0.0028275663498789072) * emb_t4_5 + (-0.83252483606338501) * emb_t4_6 + (0.0013708201004192233) * emb_t4_7 + (-0.047714404761791229) * emb_t4_8 + (0.025521334260702133) * emb_t4_9 + (-0.16822236776351929) * emb_t4_10 + (-0.048964995890855789) * emb_t4_11 + (-0.029366066679358482) * emb_t4_12 + (-0.13888542354106903) * emb_t4_13 + (-0.00022115629690233618) * emb_t4_14 + (-0.0032231998629868031) * emb_t4_15 + (-0.0014266866492107511) * emb_t4_16 + (-0.20793220400810242) * emb_t4_17 + (0.054136335849761963) * emb_t4_18 + (-0.10494299978017807) * emb_t4_19 + (0.018051652237772942) * emb_t4_20 + (-0.001057760207913816) * emb_t4_21 + (-0.89191895723342896) * emb_t4_22 + (8.7058346252888441e-05) * emb_t4_23 + (-0.0016783669125288725) * emb_t4_24 + (0.00087555707432329655) * emb_t4_25 + (0.045518454164266586) * emb_t4_26 + (0.0013514308957383037) * emb_t4_27 + (-0.20011988282203674) * emb_t4_28 + (0.035798594355583191) * emb_t4_29 + (-0.27706009149551392) * emb_t4_30 + (-0.43592292070388794) * emb_t4_31);
    gate_n = tanh((0.59525293111801147) + (0.0018575324211269617) * emb_t4_0 + (0.32688444852828979) * emb_t4_1 + (0.66818028688430786) * emb_t4_2 + (0.64994454383850098) * emb_t4_3 + (-0.087553784251213074) * emb_t4_4 + (-0.44244146347045898) * emb_t4_5 + (-0.33246675133705139) * emb_t4_6 + (-0.88599085807800293) * emb_t4_7 + (0.62896829843521118) * emb_t4_8 + (-1.4044672250747681) * emb_t4_9 + (-1.1333514451980591) * emb_t4_10 + (0.7360990047454834) * emb_t4_11 + (0.93042445182800293) * emb_t4_12 + (-0.20440147817134857) * emb_t4_13 + (0.27329704165458679) * emb_t4_14 + (-0.15040417015552521) * emb_t4_15 + (0.45051681995391846) * emb_t4_16 + (-0.38770368695259094) * emb_t4_17 + (-1.6893484592437744) * emb_t4_18 + (1.6857953071594238) * emb_t4_19 + (0.38518908619880676) * emb_t4_20 + (0.021238734945654869) * emb_t4_21 + (-0.64961028099060059) * emb_t4_22 + (0.26621630787849426) * emb_t4_23 + (0.056149821728467941) * emb_t4_24 + (-0.40234822034835815) * emb_t4_25 + (-0.10873445868492126) * emb_t4_26 + (0.035416297614574432) * emb_t4_27 + (0.15445223450660706) * emb_t4_28 + (-0.52254718542098999) * emb_t4_29 + (0.024773156270384789) * emb_t4_30 + (-1.2572534084320068) * emb_t4_31 + gate_r * (0.65501070022583008));
    gru_0_rev_t4_h_30 = (1.0 - gate_z) * gate_n;
    // h=31
    gate_r = sigmoid((-1.4357271194458008) + (-0.20934654772281647) * emb_t4_0 + (0.71249628067016602) * emb_t4_1 + (-0.3303925096988678) * emb_t4_2 + (-0.86453908681869507) * emb_t4_3 + (1.1432772874832153) * emb_t4_4 + (0.39348995685577393) * emb_t4_5 + (0.86815184354782104) * emb_t4_6 + (0.26343333721160889) * emb_t4_7 + (-0.40029409527778625) * emb_t4_8 + (0.6163591742515564) * emb_t4_9 + (0.66140139102935791) * emb_t4_10 + (-0.86761289834976196) * emb_t4_11 + (-0.46693247556686401) * emb_t4_12 + (0.73712128400802612) * emb_t4_13 + (0.097350329160690308) * emb_t4_14 + (0.19880978763103485) * emb_t4_15 + (-0.50683003664016724) * emb_t4_16 + (1.6393564939498901) * emb_t4_17 + (0.20705430209636688) * emb_t4_18 + (-0.77220833301544189) * emb_t4_19 + (-0.75397765636444092) * emb_t4_20 + (0.71801590919494629) * emb_t4_21 + (0.74062275886535645) * emb_t4_22 + (-0.74361580610275269) * emb_t4_23 + (0.079540923237800598) * emb_t4_24 + (0.60188525915145874) * emb_t4_25 + (-0.69794625043869019) * emb_t4_26 + (-0.054687183350324631) * emb_t4_27 + (-0.36121436953544617) * emb_t4_28 + (0.82962000370025635) * emb_t4_29 + (-0.73071646690368652) * emb_t4_30 + (0.28604793548583984) * emb_t4_31);
    gate_z = sigmoid((0.58876138925552368) + (-0.065116465091705322) * emb_t4_0 + (-1.8003759384155273) * emb_t4_1 + (0.069223910570144653) * emb_t4_2 + (0.59188461303710938) * emb_t4_3 + (-2.6046082973480225) * emb_t4_4 + (-0.09179958701133728) * emb_t4_5 + (-1.7053453922271729) * emb_t4_6 + (-0.07705669105052948) * emb_t4_7 + (-0.14361445605754852) * emb_t4_8 + (0.94912004470825195) * emb_t4_9 + (0.3851427435874939) * emb_t4_10 + (0.77020663022994995) * emb_t4_11 + (-0.37819057703018188) * emb_t4_12 + (-2.3966660499572754) * emb_t4_13 + (0.077805705368518829) * emb_t4_14 + (-0.21843737363815308) * emb_t4_15 + (-0.027483154088258743) * emb_t4_16 + (-0.85050064325332642) * emb_t4_17 + (0.45104283094406128) * emb_t4_18 + (-0.24056658148765564) * emb_t4_19 + (1.135401725769043) * emb_t4_20 + (-0.064725853502750397) * emb_t4_21 + (-0.039093133062124252) * emb_t4_22 + (-0.075684994459152222) * emb_t4_23 + (-0.050215009599924088) * emb_t4_24 + (-0.024101167917251587) * emb_t4_25 + (1.0703381299972534) * emb_t4_26 + (-0.0049634180031716824) * emb_t4_27 + (1.8455902338027954) * emb_t4_28 + (-2.320936918258667) * emb_t4_29 + (2.7980337142944336) * emb_t4_30 + (0.24805188179016113) * emb_t4_31);
    gate_n = tanh((-0.09081733226776123) + (0.25902971625328064) * emb_t4_0 + (-2.3275558948516846) * emb_t4_1 + (0.20978960394859314) * emb_t4_2 + (0.12174080312252045) * emb_t4_3 + (-0.23300406336784363) * emb_t4_4 + (-0.56231361627578735) * emb_t4_5 + (-0.46115985512733459) * emb_t4_6 + (0.25583997368812561) * emb_t4_7 + (-0.20606839656829834) * emb_t4_8 + (0.92734450101852417) * emb_t4_9 + (0.67620748281478882) * emb_t4_10 + (-0.24576212465763092) * emb_t4_11 + (-0.56451708078384399) * emb_t4_12 + (-1.0121785402297974) * emb_t4_13 + (-0.20770791172981262) * emb_t4_14 + (-0.23147024214267731) * emb_t4_15 + (0.0023880954831838608) * emb_t4_16 + (0.4062449038028717) * emb_t4_17 + (0.71637147665023804) * emb_t4_18 + (-0.13081304728984833) * emb_t4_19 + (-0.089473411440849304) * emb_t4_20 + (0.0033172369003295898) * emb_t4_21 + (0.027581281960010529) * emb_t4_22 + (0.45136824250221252) * emb_t4_23 + (-0.34524276852607727) * emb_t4_24 + (-0.21640866994857788) * emb_t4_25 + (0.10429202765226364) * emb_t4_26 + (-0.15629658102989197) * emb_t4_27 + (1.8547009229660034) * emb_t4_28 + (-1.8275818824768066) * emb_t4_29 + (0.30391713976860046) * emb_t4_30 + (-0.099162474274635315) * emb_t4_31 + gate_r * (-0.064446546137332916));
    gru_0_rev_t4_h_31 = (1.0 - gate_z) * gate_n;

    // RV step t=3
    // h=0
    gate_r = sigmoid((-2.9835760593414307) + (-0.2894538938999176) * emb_t3_0 + (-1.0065344572067261) * emb_t3_1 + (-0.2484540194272995) * emb_t3_2 + (-1.6565470695495605) * emb_t3_3 + (1.4283560514450073) * emb_t3_4 + (1.1049230098724365) * emb_t3_5 + (1.5637035369873047) * emb_t3_6 + (0.61245578527450562) * emb_t3_7 + (-0.76217371225357056) * emb_t3_8 + (1.0227657556533813) * emb_t3_9 + (1.000507116317749) * emb_t3_10 + (-1.6554383039474487) * emb_t3_11 + (-1.7877154350280762) * emb_t3_12 + (0.15166507661342621) * emb_t3_13 + (0.86731231212615967) * emb_t3_14 + (0.49553677439689636) * emb_t3_15 + (-1.1724370718002319) * emb_t3_16 + (1.6185518503189087) * emb_t3_17 + (0.97716200351715088) * emb_t3_18 + (-1.3622130155563354) * emb_t3_19 + (-1.409847617149353) * emb_t3_20 + (0.5451006293296814) * emb_t3_21 + (1.1372634172439575) * emb_t3_22 + (0.68434017896652222) * emb_t3_23 + (0.8193785548210144) * emb_t3_24 + (0.2640354335308075) * emb_t3_25 + (-1.8077752590179443) * emb_t3_26 + (-1.2768290042877197) * emb_t3_27 + (0.52384662628173828) * emb_t3_28 + (-0.40466684103012085) * emb_t3_29 + (-1.1958518028259277) * emb_t3_30 + (0.97426825761795044) * emb_t3_31 + (-0.66171276569366455) * gru_0_rev_t4_h_0 + (0.11302153021097183) * gru_0_rev_t4_h_1 + (0.15363197028636932) * gru_0_rev_t4_h_2 + (-0.63874822854995728) * gru_0_rev_t4_h_3 + (0.39977651834487915) * gru_0_rev_t4_h_4 + (0.60273611545562744) * gru_0_rev_t4_h_5 + (0.3833472728729248) * gru_0_rev_t4_h_6 + (-0.17516469955444336) * gru_0_rev_t4_h_7 + (-0.26453778147697449) * gru_0_rev_t4_h_8 + (-0.38692152500152588) * gru_0_rev_t4_h_9 + (0.69033241271972656) * gru_0_rev_t4_h_10 + (0.062574639916419983) * gru_0_rev_t4_h_11 + (-0.93805861473083496) * gru_0_rev_t4_h_12 + (-0.6669161319732666) * gru_0_rev_t4_h_13 + (-0.24802747368812561) * gru_0_rev_t4_h_14 + (0.13093450665473938) * gru_0_rev_t4_h_15 + (-1.2142215967178345) * gru_0_rev_t4_h_16 + (0.95255064964294434) * gru_0_rev_t4_h_17 + (-0.46209904551506042) * gru_0_rev_t4_h_18 + (-0.58068346977233887) * gru_0_rev_t4_h_19 + (-1.0782487392425537) * gru_0_rev_t4_h_20 + (-0.36318895220756531) * gru_0_rev_t4_h_21 + (0.80645138025283813) * gru_0_rev_t4_h_22 + (-0.97894376516342163) * gru_0_rev_t4_h_23 + (-0.45522260665893555) * gru_0_rev_t4_h_24 + (1.1860064268112183) * gru_0_rev_t4_h_25 + (0.26387348771095276) * gru_0_rev_t4_h_26 + (-0.68701446056365967) * gru_0_rev_t4_h_27 + (-0.077054761350154877) * gru_0_rev_t4_h_28 + (-1.1045714616775513) * gru_0_rev_t4_h_29 + (-0.5391804575920105) * gru_0_rev_t4_h_30 + (0.39775756001472473) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-0.23713213205337524) + (-0.094452530145645142) * emb_t3_0 + (0.21141506731510162) * emb_t3_1 + (-0.028694683685898781) * emb_t3_2 + (0.09788871556520462) * emb_t3_3 + (-0.30816355347633362) * emb_t3_4 + (0.01998172327876091) * emb_t3_5 + (0.055055197328329086) * emb_t3_6 + (0.0012398603139445186) * emb_t3_7 + (-0.3471817672252655) * emb_t3_8 + (-0.015082758851349354) * emb_t3_9 + (-0.0455658920109272) * emb_t3_10 + (-0.38441550731658936) * emb_t3_11 + (-0.11193738877773285) * emb_t3_12 + (-0.52671444416046143) * emb_t3_13 + (0.021289674565196037) * emb_t3_14 + (-0.04076920822262764) * emb_t3_15 + (0.0047816503793001175) * emb_t3_16 + (0.22122785449028015) * emb_t3_17 + (0.4573395848274231) * emb_t3_18 + (-0.61744415760040283) * emb_t3_19 + (-0.14113922417163849) * emb_t3_20 + (0.027857039123773575) * emb_t3_21 + (-0.027806330472230911) * emb_t3_22 + (0.076793096959590912) * emb_t3_23 + (-0.022407537326216698) * emb_t3_24 + (-0.030158311128616333) * emb_t3_25 + (0.44543731212615967) * emb_t3_26 + (0.0095486780628561974) * emb_t3_27 + (0.53045326471328735) * emb_t3_28 + (-0.9014277458190918) * emb_t3_29 + (0.33636349439620972) * emb_t3_30 + (0.13960909843444824) * emb_t3_31 + (-0.25840005278587341) * gru_0_rev_t4_h_0 + (0.56619709730148315) * gru_0_rev_t4_h_1 + (0.90653711557388306) * gru_0_rev_t4_h_2 + (-0.22494626045227051) * gru_0_rev_t4_h_3 + (-4.2699055671691895) * gru_0_rev_t4_h_4 + (-1.0955593585968018) * gru_0_rev_t4_h_5 + (-0.16564513742923737) * gru_0_rev_t4_h_6 + (-1.4752612113952637) * gru_0_rev_t4_h_7 + (-0.28121107816696167) * gru_0_rev_t4_h_8 + (-0.00090577802620828152) * gru_0_rev_t4_h_9 + (-0.50413447618484497) * gru_0_rev_t4_h_10 + (-0.5382378101348877) * gru_0_rev_t4_h_11 + (-0.097594469785690308) * gru_0_rev_t4_h_12 + (-0.2044183760881424) * gru_0_rev_t4_h_13 + (-1.0650172233581543) * gru_0_rev_t4_h_14 + (-0.10785684734582901) * gru_0_rev_t4_h_15 + (-1.7066498994827271) * gru_0_rev_t4_h_16 + (1.1109918355941772) * gru_0_rev_t4_h_17 + (0.49356824159622192) * gru_0_rev_t4_h_18 + (-0.7627527117729187) * gru_0_rev_t4_h_19 + (-1.2511959075927734) * gru_0_rev_t4_h_20 + (0.39400914311408997) * gru_0_rev_t4_h_21 + (-0.017753327265381813) * gru_0_rev_t4_h_22 + (-0.065627939999103546) * gru_0_rev_t4_h_23 + (-0.0020900401286780834) * gru_0_rev_t4_h_24 + (1.2537212371826172) * gru_0_rev_t4_h_25 + (0.14415863156318665) * gru_0_rev_t4_h_26 + (0.55119097232818604) * gru_0_rev_t4_h_27 + (-0.20890535414218903) * gru_0_rev_t4_h_28 + (-0.070202142000198364) * gru_0_rev_t4_h_29 + (-0.2511688768863678) * gru_0_rev_t4_h_30 + (-1.1328696012496948) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.31142440438270569) + (-0.019339106976985931) * emb_t3_0 + (-1.083100438117981) * emb_t3_1 + (0.034396085888147354) * emb_t3_2 + (-0.13810527324676514) * emb_t3_3 + (-1.248698353767395) * emb_t3_4 + (0.040851529687643051) * emb_t3_5 + (-1.6545813083648682) * emb_t3_6 + (-0.011575773358345032) * emb_t3_7 + (0.090101957321166992) * emb_t3_8 + (0.40074479579925537) * emb_t3_9 + (0.16766327619552612) * emb_t3_10 + (0.29562315344810486) * emb_t3_11 + (0.097509466111660004) * emb_t3_12 + (-1.1618857383728027) * emb_t3_13 + (-0.023454835638403893) * emb_t3_14 + (0.0025133476592600346) * emb_t3_15 + (0.011139494366943836) * emb_t3_16 + (-0.64154452085494995) * emb_t3_17 + (0.12155960500240326) * emb_t3_18 + (0.24741975963115692) * emb_t3_19 + (0.48124334216117859) * emb_t3_20 + (-0.053347807377576828) * emb_t3_21 + (0.22831031680107117) * emb_t3_22 + (0.0040268870070576668) * emb_t3_23 + (-0.045491855591535568) * emb_t3_24 + (0.032861612737178802) * emb_t3_25 + (0.82190942764282227) * emb_t3_26 + (-0.028285810723900795) * emb_t3_27 + (0.96199721097946167) * emb_t3_28 + (-1.1373158693313599) * emb_t3_29 + (1.228196382522583) * emb_t3_30 + (-0.13546010851860046) * emb_t3_31 + gate_r * ((-0.075502410531044006) + (0.0021051350049674511) * gru_0_rev_t4_h_0 + (0.407743901014328) * gru_0_rev_t4_h_1 + (-0.0074434997513890266) * gru_0_rev_t4_h_2 + (0.24393901228904724) * gru_0_rev_t4_h_3 + (-0.51341235637664795) * gru_0_rev_t4_h_4 + (0.002257415559142828) * gru_0_rev_t4_h_5 + (-0.18504583835601807) * gru_0_rev_t4_h_6 + (0.19699925184249878) * gru_0_rev_t4_h_7 + (-0.05100611224770546) * gru_0_rev_t4_h_8 + (0.30424720048904419) * gru_0_rev_t4_h_9 + (0.083247773349285126) * gru_0_rev_t4_h_10 + (-0.2414746880531311) * gru_0_rev_t4_h_11 + (0.17132896184921265) * gru_0_rev_t4_h_12 + (0.033440746366977692) * gru_0_rev_t4_h_13 + (-0.56965017318725586) * gru_0_rev_t4_h_14 + (-0.28460824489593506) * gru_0_rev_t4_h_15 + (-0.43859180808067322) * gru_0_rev_t4_h_16 + (0.45228603482246399) * gru_0_rev_t4_h_17 + (0.1388857513666153) * gru_0_rev_t4_h_18 + (0.10764802247285843) * gru_0_rev_t4_h_19 + (-0.66124504804611206) * gru_0_rev_t4_h_20 + (0.27030390501022339) * gru_0_rev_t4_h_21 + (-0.24082593619823456) * gru_0_rev_t4_h_22 + (0.25963419675827026) * gru_0_rev_t4_h_23 + (0.25316798686981201) * gru_0_rev_t4_h_24 + (0.37955716252326965) * gru_0_rev_t4_h_25 + (-0.056946448981761932) * gru_0_rev_t4_h_26 + (0.1152973473072052) * gru_0_rev_t4_h_27 + (-0.29929167032241821) * gru_0_rev_t4_h_28 + (0.50757741928100586) * gru_0_rev_t4_h_29 + (0.17659857869148254) * gru_0_rev_t4_h_30 + (-0.49162876605987549) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_0 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_0;
    // h=1
    gate_r = sigmoid((0.4216620922088623) + (0.040358386933803558) * emb_t3_0 + (0.79457920789718628) * emb_t3_1 + (0.073323294520378113) * emb_t3_2 + (0.11622408032417297) * emb_t3_3 + (-0.33492177724838257) * emb_t3_4 + (0.015712980180978775) * emb_t3_5 + (-0.27669963240623474) * emb_t3_6 + (-0.028263602405786514) * emb_t3_7 + (0.63715058565139771) * emb_t3_8 + (-5.6999020576477051) * emb_t3_9 + (-3.4735171794891357) * emb_t3_10 + (0.53878825902938843) * emb_t3_11 + (0.41282382607460022) * emb_t3_12 + (0.52130669355392456) * emb_t3_13 + (0.032681141048669815) * emb_t3_14 + (0.0037251824978739023) * emb_t3_15 + (0.10511696338653564) * emb_t3_16 + (0.096871748566627502) * emb_t3_17 + (-1.4801664352416992) * emb_t3_18 + (0.89164203405380249) * emb_t3_19 + (0.37726473808288574) * emb_t3_20 + (-0.0081274267286062241) * emb_t3_21 + (-0.98772859573364258) * emb_t3_22 + (-0.021713085472583771) * emb_t3_23 + (0.05414251983165741) * emb_t3_24 + (-0.10559131950139999) * emb_t3_25 + (0.3659203052520752) * emb_t3_26 + (0.0032646018080413342) * emb_t3_27 + (-0.88622325658798218) * emb_t3_28 + (0.68386071920394897) * emb_t3_29 + (-0.57752048969268799) * emb_t3_30 + (-0.11037802696228027) * emb_t3_31 + (0.29063689708709717) * gru_0_rev_t4_h_0 + (0.49930816888809204) * gru_0_rev_t4_h_1 + (-0.14707185328006744) * gru_0_rev_t4_h_2 + (0.21852485835552216) * gru_0_rev_t4_h_3 + (0.23063808679580688) * gru_0_rev_t4_h_4 + (0.13878858089447021) * gru_0_rev_t4_h_5 + (-0.49122563004493713) * gru_0_rev_t4_h_6 + (0.037130303680896759) * gru_0_rev_t4_h_7 + (0.33809769153594971) * gru_0_rev_t4_h_8 + (0.1874627023935318) * gru_0_rev_t4_h_9 + (-0.27309772372245789) * gru_0_rev_t4_h_10 + (0.074446938931941986) * gru_0_rev_t4_h_11 + (0.25147086381912231) * gru_0_rev_t4_h_12 + (0.026847090572118759) * gru_0_rev_t4_h_13 + (-0.69294577836990356) * gru_0_rev_t4_h_14 + (-0.17525571584701538) * gru_0_rev_t4_h_15 + (-0.10398393869400024) * gru_0_rev_t4_h_16 + (-0.044569235295057297) * gru_0_rev_t4_h_17 + (0.028681084513664246) * gru_0_rev_t4_h_18 + (-0.063757240772247314) * gru_0_rev_t4_h_19 + (0.061059817671775818) * gru_0_rev_t4_h_20 + (0.075141444802284241) * gru_0_rev_t4_h_21 + (-0.22920502722263336) * gru_0_rev_t4_h_22 + (0.3240930438041687) * gru_0_rev_t4_h_23 + (-0.096938595175743103) * gru_0_rev_t4_h_24 + (0.04003104567527771) * gru_0_rev_t4_h_25 + (-0.10175108909606934) * gru_0_rev_t4_h_26 + (-0.10257846117019653) * gru_0_rev_t4_h_27 + (-0.0020812309812754393) * gru_0_rev_t4_h_28 + (-0.036343488842248917) * gru_0_rev_t4_h_29 + (0.32778254151344299) * gru_0_rev_t4_h_30 + (-0.55698633193969727) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-0.46039289236068726) + (0.060518428683280945) * emb_t3_0 + (1.1332238912582397) * emb_t3_1 + (0.038747049868106842) * emb_t3_2 + (-0.4428306519985199) * emb_t3_3 + (1.1608535051345825) * emb_t3_4 + (0.13420116901397705) * emb_t3_5 + (1.0308222770690918) * emb_t3_6 + (0.0410185307264328) * emb_t3_7 + (0.16079102456569672) * emb_t3_8 + (0.14993944764137268) * emb_t3_9 + (-0.35022842884063721) * emb_t3_10 + (-0.31914260983467102) * emb_t3_11 + (0.43606829643249512) * emb_t3_12 + (1.1248135566711426) * emb_t3_13 + (0.021003365516662598) * emb_t3_14 + (0.0059432140551507473) * emb_t3_15 + (-0.10131619870662689) * emb_t3_16 + (0.92381668090820312) * emb_t3_17 + (-0.13260744512081146) * emb_t3_18 + (0.18333296477794647) * emb_t3_19 + (-0.0073598409071564674) * emb_t3_20 + (0.0083366269245743752) * emb_t3_21 + (0.39938196539878845) * emb_t3_22 + (-0.23865433037281036) * emb_t3_23 + (0.2018158882856369) * emb_t3_24 + (-0.085929840803146362) * emb_t3_25 + (-0.91146039962768555) * emb_t3_26 + (0.016306772828102112) * emb_t3_27 + (-0.42052999138832092) * emb_t3_28 + (0.7816932201385498) * emb_t3_29 + (-0.84993302822113037) * emb_t3_30 + (0.026607520878314972) * emb_t3_31 + (-0.35462647676467896) * gru_0_rev_t4_h_0 + (0.22121721506118774) * gru_0_rev_t4_h_1 + (-0.39565634727478027) * gru_0_rev_t4_h_2 + (-0.60939866304397583) * gru_0_rev_t4_h_3 + (-0.76712030172348022) * gru_0_rev_t4_h_4 + (0.0934949591755867) * gru_0_rev_t4_h_5 + (0.38812124729156494) * gru_0_rev_t4_h_6 + (-0.57990086078643799) * gru_0_rev_t4_h_7 + (-0.67781519889831543) * gru_0_rev_t4_h_8 + (0.049504291266202927) * gru_0_rev_t4_h_9 + (0.46710342168807983) * gru_0_rev_t4_h_10 + (0.31663206219673157) * gru_0_rev_t4_h_11 + (-0.29980668425559998) * gru_0_rev_t4_h_12 + (-0.69022190570831299) * gru_0_rev_t4_h_13 + (-0.2194649875164032) * gru_0_rev_t4_h_14 + (-0.32256206870079041) * gru_0_rev_t4_h_15 + (-2.4069602489471436) * gru_0_rev_t4_h_16 + (1.6488825082778931) * gru_0_rev_t4_h_17 + (0.43223670125007629) * gru_0_rev_t4_h_18 + (-0.17650189995765686) * gru_0_rev_t4_h_19 + (0.18415188789367676) * gru_0_rev_t4_h_20 + (0.19487585127353668) * gru_0_rev_t4_h_21 + (0.34607139229774475) * gru_0_rev_t4_h_22 + (-0.88741487264633179) * gru_0_rev_t4_h_23 + (0.43227696418762207) * gru_0_rev_t4_h_24 + (1.7091822624206543) * gru_0_rev_t4_h_25 + (-0.23319399356842041) * gru_0_rev_t4_h_26 + (-0.81513410806655884) * gru_0_rev_t4_h_27 + (-0.24119873344898224) * gru_0_rev_t4_h_28 + (-0.90161997079849243) * gru_0_rev_t4_h_29 + (-0.45850229263305664) * gru_0_rev_t4_h_30 + (0.5530286431312561) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.0017191440565511584) + (0.034440875053405762) * emb_t3_0 + (-0.66524612903594971) * emb_t3_1 + (0.065156638622283936) * emb_t3_2 + (-0.0072310366667807102) * emb_t3_3 + (-0.11210089921951294) * emb_t3_4 + (-0.019568353891372681) * emb_t3_5 + (0.044101700186729431) * emb_t3_6 + (-0.0176859050989151) * emb_t3_7 + (0.40532231330871582) * emb_t3_8 + (1.5651329755783081) * emb_t3_9 + (1.3349515199661255) * emb_t3_10 + (-0.28234502673149109) * emb_t3_11 + (-0.18285919725894928) * emb_t3_12 + (-0.69954246282577515) * emb_t3_13 + (-0.0063655716367065907) * emb_t3_14 + (-0.0084611810743808746) * emb_t3_15 + (0.03270857036113739) * emb_t3_16 + (-0.088633738458156586) * emb_t3_17 + (0.39253699779510498) * emb_t3_18 + (-0.799480140209198) * emb_t3_19 + (0.16929744184017181) * emb_t3_20 + (-0.0080615635961294174) * emb_t3_21 + (-0.018845891579985619) * emb_t3_22 + (0.0087021738290786743) * emb_t3_23 + (0.0067608607932925224) * emb_t3_24 + (-0.014747118577361107) * emb_t3_25 + (0.2206137478351593) * emb_t3_26 + (0.00846844632178545) * emb_t3_27 + (0.85196274518966675) * emb_t3_28 + (-1.0941895246505737) * emb_t3_29 + (0.46526119112968445) * emb_t3_30 + (0.18320520222187042) * emb_t3_31 + gate_r * ((-0.033734701573848724) + (-0.65148890018463135) * gru_0_rev_t4_h_0 + (-0.29127770662307739) * gru_0_rev_t4_h_1 + (-0.28160685300827026) * gru_0_rev_t4_h_2 + (-0.66901451349258423) * gru_0_rev_t4_h_3 + (0.27646133303642273) * gru_0_rev_t4_h_4 + (0.28928685188293457) * gru_0_rev_t4_h_5 + (0.88689833879470825) * gru_0_rev_t4_h_6 + (-0.5923309326171875) * gru_0_rev_t4_h_7 + (-0.63618797063827515) * gru_0_rev_t4_h_8 + (-0.50787943601608276) * gru_0_rev_t4_h_9 + (0.54846715927124023) * gru_0_rev_t4_h_10 + (0.079715996980667114) * gru_0_rev_t4_h_11 + (-0.65225464105606079) * gru_0_rev_t4_h_12 + (-0.6725810170173645) * gru_0_rev_t4_h_13 + (0.43253809213638306) * gru_0_rev_t4_h_14 + (0.64755821228027344) * gru_0_rev_t4_h_15 + (-0.57009172439575195) * gru_0_rev_t4_h_16 + (0.66640806198120117) * gru_0_rev_t4_h_17 + (-0.41376969218254089) * gru_0_rev_t4_h_18 + (-0.26733264327049255) * gru_0_rev_t4_h_19 + (-0.53358191251754761) * gru_0_rev_t4_h_20 + (-0.64937096834182739) * gru_0_rev_t4_h_21 + (0.45653778314590454) * gru_0_rev_t4_h_22 + (-0.61136186122894287) * gru_0_rev_t4_h_23 + (0.0065281358547508717) * gru_0_rev_t4_h_24 + (0.31315848231315613) * gru_0_rev_t4_h_25 + (0.72279375791549683) * gru_0_rev_t4_h_26 + (0.025569086894392967) * gru_0_rev_t4_h_27 + (0.32870444655418396) * gru_0_rev_t4_h_28 + (-0.68236809968948364) * gru_0_rev_t4_h_29 + (-0.43511655926704407) * gru_0_rev_t4_h_30 + (0.58863735198974609) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_1 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_1;
    // h=2
    gate_r = sigmoid((0.74615961313247681) + (-0.08885645866394043) * emb_t3_0 + (1.0937559604644775) * emb_t3_1 + (0.11653187125921249) * emb_t3_2 + (0.73037058115005493) * emb_t3_3 + (0.32688421010971069) * emb_t3_4 + (-1.1882870197296143) * emb_t3_5 + (-0.064901135861873627) * emb_t3_6 + (-0.41705429553985596) * emb_t3_7 + (0.56586074829101562) * emb_t3_8 + (-3.226313591003418) * emb_t3_9 + (-1.6568456888198853) * emb_t3_10 + (-0.39169976115226746) * emb_t3_11 + (0.61035889387130737) * emb_t3_12 + (0.35834527015686035) * emb_t3_13 + (-1.1571964025497437) * emb_t3_14 + (-0.33319815993309021) * emb_t3_15 + (0.75961244106292725) * emb_t3_16 + (-0.1129801943898201) * emb_t3_17 + (-1.5690505504608154) * emb_t3_18 + (1.4574296474456787) * emb_t3_19 + (0.54301714897155762) * emb_t3_20 + (-0.59782576560974121) * emb_t3_21 + (-1.8494070768356323) * emb_t3_22 + (-0.57249343395233154) * emb_t3_23 + (0.45289716124534607) * emb_t3_24 + (0.27596387267112732) * emb_t3_25 + (0.032521408051252365) * emb_t3_26 + (-0.24957029521465302) * emb_t3_27 + (-0.23151740431785583) * emb_t3_28 + (0.65897327661514282) * emb_t3_29 + (0.087767727673053741) * emb_t3_30 + (-0.68677932024002075) * emb_t3_31 + (0.010508894920349121) * gru_0_rev_t4_h_0 + (0.94539523124694824) * gru_0_rev_t4_h_1 + (0.62732094526290894) * gru_0_rev_t4_h_2 + (0.52737289667129517) * gru_0_rev_t4_h_3 + (-1.8211337327957153) * gru_0_rev_t4_h_4 + (0.43607053160667419) * gru_0_rev_t4_h_5 + (-1.0171912908554077) * gru_0_rev_t4_h_6 + (5.8880720138549805) * gru_0_rev_t4_h_7 + (0.59144747257232666) * gru_0_rev_t4_h_8 + (0.55661219358444214) * gru_0_rev_t4_h_9 + (-0.7498089075088501) * gru_0_rev_t4_h_10 + (-0.60518431663513184) * gru_0_rev_t4_h_11 + (0.51497483253479004) * gru_0_rev_t4_h_12 + (0.61492317914962769) * gru_0_rev_t4_h_13 + (0.14193277060985565) * gru_0_rev_t4_h_14 + (-0.12360066175460815) * gru_0_rev_t4_h_15 + (-0.73215228319168091) * gru_0_rev_t4_h_16 + (0.77796733379364014) * gru_0_rev_t4_h_17 + (0.4768655002117157) * gru_0_rev_t4_h_18 + (-0.20286975800991058) * gru_0_rev_t4_h_19 + (-0.0024720123037695885) * gru_0_rev_t4_h_20 + (0.058465827256441116) * gru_0_rev_t4_h_21 + (0.35632675886154175) * gru_0_rev_t4_h_22 + (1.166296124458313) * gru_0_rev_t4_h_23 + (-0.094238884747028351) * gru_0_rev_t4_h_24 + (0.85864800214767456) * gru_0_rev_t4_h_25 + (-0.2578561007976532) * gru_0_rev_t4_h_26 + (1.1561166048049927) * gru_0_rev_t4_h_27 + (0.99397587776184082) * gru_0_rev_t4_h_28 + (0.6104508638381958) * gru_0_rev_t4_h_29 + (0.13866399228572845) * gru_0_rev_t4_h_30 + (0.90917086601257324) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((1.4295028448104858) + (0.0030123933684080839) * emb_t3_0 + (0.34719598293304443) * emb_t3_1 + (-0.010751851834356785) * emb_t3_2 + (0.2233523428440094) * emb_t3_3 + (0.051800966262817383) * emb_t3_4 + (0.0036630355753004551) * emb_t3_5 + (0.074413977563381195) * emb_t3_6 + (0.0042781578376889229) * emb_t3_7 + (0.53331613540649414) * emb_t3_8 + (0.00049478036817163229) * emb_t3_9 + (-0.38463446497917175) * emb_t3_10 + (0.66199463605880737) * emb_t3_11 + (0.19998748600482941) * emb_t3_12 + (-0.18887631595134735) * emb_t3_13 + (-0.0023455999325960875) * emb_t3_14 + (0.0091478358954191208) * emb_t3_15 + (-0.0051097404211759567) * emb_t3_16 + (-0.25639131665229797) * emb_t3_17 + (-0.33122223615646362) * emb_t3_18 + (0.051683567464351654) * emb_t3_19 + (0.39044225215911865) * emb_t3_20 + (0.00028479064349085093) * emb_t3_21 + (0.27298229932785034) * emb_t3_22 + (-0.010792865417897701) * emb_t3_23 + (-0.0038974529597908258) * emb_t3_24 + (-0.011434595100581646) * emb_t3_25 + (0.24560485780239105) * emb_t3_26 + (-0.0067862076684832573) * emb_t3_27 + (0.18143868446350098) * emb_t3_28 + (0.11124227941036224) * emb_t3_29 + (-0.16090299189090729) * emb_t3_30 + (-1.1402376890182495) * emb_t3_31 + (0.64153593778610229) * gru_0_rev_t4_h_0 + (-0.080723457038402557) * gru_0_rev_t4_h_1 + (1.8206311464309692) * gru_0_rev_t4_h_2 + (0.25486290454864502) * gru_0_rev_t4_h_3 + (2.8634231090545654) * gru_0_rev_t4_h_4 + (-0.48377466201782227) * gru_0_rev_t4_h_5 + (0.027038371190428734) * gru_0_rev_t4_h_6 + (0.15608504414558411) * gru_0_rev_t4_h_7 + (-0.19426518678665161) * gru_0_rev_t4_h_8 + (0.71346110105514526) * gru_0_rev_t4_h_9 + (-0.27552139759063721) * gru_0_rev_t4_h_10 + (-1.4955865144729614) * gru_0_rev_t4_h_11 + (0.41586387157440186) * gru_0_rev_t4_h_12 + (0.38122349977493286) * gru_0_rev_t4_h_13 + (1.7790079116821289) * gru_0_rev_t4_h_14 + (-0.75020605325698853) * gru_0_rev_t4_h_15 + (-0.27019527554512024) * gru_0_rev_t4_h_16 + (0.45898067951202393) * gru_0_rev_t4_h_17 + (0.68123781681060791) * gru_0_rev_t4_h_18 + (0.4934464693069458) * gru_0_rev_t4_h_19 + (0.43265348672866821) * gru_0_rev_t4_h_20 + (0.6732143759727478) * gru_0_rev_t4_h_21 + (-0.29066020250320435) * gru_0_rev_t4_h_22 + (0.57048743963241577) * gru_0_rev_t4_h_23 + (-0.59704256057739258) * gru_0_rev_t4_h_24 + (0.55708193778991699) * gru_0_rev_t4_h_25 + (0.0772852823138237) * gru_0_rev_t4_h_26 + (-0.83306646347045898) * gru_0_rev_t4_h_27 + (-0.78588360548019409) * gru_0_rev_t4_h_28 + (0.15895184874534607) * gru_0_rev_t4_h_29 + (0.11376319825649261) * gru_0_rev_t4_h_30 + (0.81079196929931641) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.054261401295661926) + (-0.0029363944195210934) * emb_t3_0 + (-0.020234154537320137) * emb_t3_1 + (-0.035539023578166962) * emb_t3_2 + (0.087563574314117432) * emb_t3_3 + (-0.31429487466812134) * emb_t3_4 + (-0.30938434600830078) * emb_t3_5 + (-0.29067340493202209) * emb_t3_6 + (0.11690608412027359) * emb_t3_7 + (-0.021563621237874031) * emb_t3_8 + (0.82431697845458984) * emb_t3_9 + (0.11660616844892502) * emb_t3_10 + (-0.020250139757990837) * emb_t3_11 + (-0.056436717510223389) * emb_t3_12 + (-0.19005453586578369) * emb_t3_13 + (0.068130187690258026) * emb_t3_14 + (0.0094068422913551331) * emb_t3_15 + (-0.087542258203029633) * emb_t3_16 + (-0.27825480699539185) * emb_t3_17 + (0.34196183085441589) * emb_t3_18 + (-0.75081723928451538) * emb_t3_19 + (0.15506298840045929) * emb_t3_20 + (0.075114354491233826) * emb_t3_21 + (0.11321459710597992) * emb_t3_22 + (0.12183143198490143) * emb_t3_23 + (0.41414940357208252) * emb_t3_24 + (0.14087295532226562) * emb_t3_25 + (-0.2452787458896637) * emb_t3_26 + (-0.061310745775699615) * emb_t3_27 + (-0.33511528372764587) * emb_t3_28 + (-0.53857207298278809) * emb_t3_29 + (-0.01773926243185997) * emb_t3_30 + (0.18156217038631439) * emb_t3_31 + gate_r * ((-0.073369190096855164) + (-0.23131980001926422) * gru_0_rev_t4_h_0 + (-0.50646108388900757) * gru_0_rev_t4_h_1 + (-1.462727427482605) * gru_0_rev_t4_h_2 + (-0.086019307374954224) * gru_0_rev_t4_h_3 + (-1.336686372756958) * gru_0_rev_t4_h_4 + (0.45855599641799927) * gru_0_rev_t4_h_5 + (0.93011635541915894) * gru_0_rev_t4_h_6 + (-0.65488433837890625) * gru_0_rev_t4_h_7 + (0.2914002537727356) * gru_0_rev_t4_h_8 + (-0.38009744882583618) * gru_0_rev_t4_h_9 + (-0.42240986227989197) * gru_0_rev_t4_h_10 + (0.61652100086212158) * gru_0_rev_t4_h_11 + (-0.11742183566093445) * gru_0_rev_t4_h_12 + (-0.034337978810071945) * gru_0_rev_t4_h_13 + (-1.4059441089630127) * gru_0_rev_t4_h_14 + (0.77382552623748779) * gru_0_rev_t4_h_15 + (0.59325569868087769) * gru_0_rev_t4_h_16 + (-0.76044201850891113) * gru_0_rev_t4_h_17 + (-0.65359842777252197) * gru_0_rev_t4_h_18 + (0.13702438771724701) * gru_0_rev_t4_h_19 + (-0.14995910227298737) * gru_0_rev_t4_h_20 + (-1.4265211820602417) * gru_0_rev_t4_h_21 + (0.11495514214038849) * gru_0_rev_t4_h_22 + (0.26488798856735229) * gru_0_rev_t4_h_23 + (1.0022495985031128) * gru_0_rev_t4_h_24 + (-0.54483765363693237) * gru_0_rev_t4_h_25 + (0.5877498984336853) * gru_0_rev_t4_h_26 + (2.4662716388702393) * gru_0_rev_t4_h_27 + (1.2822643518447876) * gru_0_rev_t4_h_28 + (0.41444221138954163) * gru_0_rev_t4_h_29 + (-0.15483802556991577) * gru_0_rev_t4_h_30 + (-0.64323866367340088) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_2 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_2;
    // h=3
    gate_r = sigmoid((-1.2693327665328979) + (-0.18729329109191895) * emb_t3_0 + (0.89130485057830811) * emb_t3_1 + (0.37625452876091003) * emb_t3_2 + (-0.77646291255950928) * emb_t3_3 + (0.28546142578125) * emb_t3_4 + (0.1039729043841362) * emb_t3_5 + (0.58586239814758301) * emb_t3_6 + (-0.81807762384414673) * emb_t3_7 + (-0.48910436034202576) * emb_t3_8 + (0.076232723891735077) * emb_t3_9 + (0.0089441603049635887) * emb_t3_10 + (-0.92309528589248657) * emb_t3_11 + (-0.55719113349914551) * emb_t3_12 + (0.46199291944503784) * emb_t3_13 + (0.47896400094032288) * emb_t3_14 + (1.1286525726318359) * emb_t3_15 + (0.097555242478847504) * emb_t3_16 + (0.72513651847839355) * emb_t3_17 + (0.46851438283920288) * emb_t3_18 + (-0.59397679567337036) * emb_t3_19 + (-0.74950617551803589) * emb_t3_20 + (0.577414870262146) * emb_t3_21 + (0.7755962610244751) * emb_t3_22 + (0.1846974790096283) * emb_t3_23 + (0.081343889236450195) * emb_t3_24 + (1.7035981416702271) * emb_t3_25 + (-0.61382204294204712) * emb_t3_26 + (-0.70568162202835083) * emb_t3_27 + (-0.4217681884765625) * emb_t3_28 + (1.0495849847793579) * emb_t3_29 + (-0.52108216285705566) * emb_t3_30 + (0.454201340675354) * emb_t3_31 + (0.74760991334915161) * gru_0_rev_t4_h_0 + (-0.15963934361934662) * gru_0_rev_t4_h_1 + (-0.11239095777273178) * gru_0_rev_t4_h_2 + (-0.24377867579460144) * gru_0_rev_t4_h_3 + (0.30327039957046509) * gru_0_rev_t4_h_4 + (-0.076263293623924255) * gru_0_rev_t4_h_5 + (0.35183990001678467) * gru_0_rev_t4_h_6 + (-1.6495217084884644) * gru_0_rev_t4_h_7 + (-0.21011121571063995) * gru_0_rev_t4_h_8 + (-0.043168481439352036) * gru_0_rev_t4_h_9 + (-0.50252878665924072) * gru_0_rev_t4_h_10 + (0.29712751507759094) * gru_0_rev_t4_h_11 + (-0.39753389358520508) * gru_0_rev_t4_h_12 + (-0.34713676571846008) * gru_0_rev_t4_h_13 + (0.90248531103134155) * gru_0_rev_t4_h_14 + (-0.35044181346893311) * gru_0_rev_t4_h_15 + (0.56424808502197266) * gru_0_rev_t4_h_16 + (-0.46203437447547913) * gru_0_rev_t4_h_17 + (0.20646359026432037) * gru_0_rev_t4_h_18 + (0.25040349364280701) * gru_0_rev_t4_h_19 + (0.011906848289072514) * gru_0_rev_t4_h_20 + (-0.11615702509880066) * gru_0_rev_t4_h_21 + (-0.35530972480773926) * gru_0_rev_t4_h_22 + (-1.7412235736846924) * gru_0_rev_t4_h_23 + (-0.70898103713989258) * gru_0_rev_t4_h_24 + (-0.36314603686332703) * gru_0_rev_t4_h_25 + (-0.32708948850631714) * gru_0_rev_t4_h_26 + (-1.7031530141830444) * gru_0_rev_t4_h_27 + (0.21826902031898499) * gru_0_rev_t4_h_28 + (-0.9329521656036377) * gru_0_rev_t4_h_29 + (0.0067374706268310547) * gru_0_rev_t4_h_30 + (0.42226570844650269) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((1.6078463792800903) + (-0.001726062735542655) * emb_t3_0 + (0.077014490962028503) * emb_t3_1 + (-0.0044821808114647865) * emb_t3_2 + (0.10917814075946808) * emb_t3_3 + (0.37941429018974304) * emb_t3_4 + (0.0041542504914104939) * emb_t3_5 + (0.25740176439285278) * emb_t3_6 + (-0.0036479898262768984) * emb_t3_7 + (-0.059008967131376266) * emb_t3_8 + (0.12668302655220032) * emb_t3_9 + (0.082020103931427002) * emb_t3_10 + (0.2527521550655365) * emb_t3_11 + (0.070899859070777893) * emb_t3_12 + (0.47202906012535095) * emb_t3_13 + (0.00078425806714221835) * emb_t3_14 + (-0.0017647622153162956) * emb_t3_15 + (-0.001397377229295671) * emb_t3_16 + (-0.076351754367351532) * emb_t3_17 + (0.14220768213272095) * emb_t3_18 + (-0.21766521036624908) * emb_t3_19 + (0.2430431991815567) * emb_t3_20 + (-0.0016410897951573133) * emb_t3_21 + (-0.35762676596641541) * emb_t3_22 + (-0.00052992359269410372) * emb_t3_23 + (-0.0022541859652847052) * emb_t3_24 + (0.0086500328034162521) * emb_t3_25 + (0.12148726731538773) * emb_t3_26 + (-0.0031367745250463486) * emb_t3_27 + (0.019585469737648964) * emb_t3_28 + (0.3592568039894104) * emb_t3_29 + (0.049357231706380844) * emb_t3_30 + (0.34058290719985962) * emb_t3_31 + (0.20944654941558838) * gru_0_rev_t4_h_0 + (-0.54520362615585327) * gru_0_rev_t4_h_1 + (-0.26559269428253174) * gru_0_rev_t4_h_2 + (0.98639374971389771) * gru_0_rev_t4_h_3 + (0.94667625427246094) * gru_0_rev_t4_h_4 + (-0.14707294106483459) * gru_0_rev_t4_h_5 + (-0.50636059045791626) * gru_0_rev_t4_h_6 + (-0.76436245441436768) * gru_0_rev_t4_h_7 + (0.34315243363380432) * gru_0_rev_t4_h_8 + (0.57954269647598267) * gru_0_rev_t4_h_9 + (-0.70877265930175781) * gru_0_rev_t4_h_10 + (-0.031379468739032745) * gru_0_rev_t4_h_11 + (0.63599133491516113) * gru_0_rev_t4_h_12 + (0.6406676173210144) * gru_0_rev_t4_h_13 + (-0.077039197087287903) * gru_0_rev_t4_h_14 + (-0.22860909998416901) * gru_0_rev_t4_h_15 + (-0.27556782960891724) * gru_0_rev_t4_h_16 + (0.034608207643032074) * gru_0_rev_t4_h_17 + (0.63466763496398926) * gru_0_rev_t4_h_18 + (0.84635531902313232) * gru_0_rev_t4_h_19 + (0.15895190834999084) * gru_0_rev_t4_h_20 + (0.31160223484039307) * gru_0_rev_t4_h_21 + (-0.66052037477493286) * gru_0_rev_t4_h_22 + (1.0918036699295044) * gru_0_rev_t4_h_23 + (-0.1505594402551651) * gru_0_rev_t4_h_24 + (-0.047489326447248459) * gru_0_rev_t4_h_25 + (-0.25472390651702881) * gru_0_rev_t4_h_26 + (0.024349924176931381) * gru_0_rev_t4_h_27 + (-0.076744481921195984) * gru_0_rev_t4_h_28 + (1.0069873332977295) * gru_0_rev_t4_h_29 + (1.4696241617202759) * gru_0_rev_t4_h_30 + (0.17604227364063263) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.4309772253036499) + (-0.026210254058241844) * emb_t3_0 + (0.23744942247867584) * emb_t3_1 + (-0.061120368540287018) * emb_t3_2 + (0.57514357566833496) * emb_t3_3 + (-0.16420482099056244) * emb_t3_4 + (-0.15247580409049988) * emb_t3_5 + (-0.025387577712535858) * emb_t3_6 + (-0.063496649265289307) * emb_t3_7 + (0.76471704244613647) * emb_t3_8 + (-0.86447417736053467) * emb_t3_9 + (-0.58499574661254883) * emb_t3_10 + (0.30235102772712708) * emb_t3_11 + (0.34290716052055359) * emb_t3_12 + (0.31330606341362) * emb_t3_13 + (-0.039406627416610718) * emb_t3_14 + (0.059008199721574783) * emb_t3_15 + (0.071378849446773529) * emb_t3_16 + (-0.27085781097412109) * emb_t3_17 + (-1.2381625175476074) * emb_t3_18 + (0.80788356065750122) * emb_t3_19 + (0.4392111599445343) * emb_t3_20 + (0.063526660203933716) * emb_t3_21 + (-1.7766882181167603) * emb_t3_22 + (0.044288210570812225) * emb_t3_23 + (0.029589410871267319) * emb_t3_24 + (-0.075754851102828979) * emb_t3_25 + (0.53334522247314453) * emb_t3_26 + (0.054795470088720322) * emb_t3_27 + (-0.4979516863822937) * emb_t3_28 + (0.11023539304733276) * emb_t3_29 + (-0.12318271398544312) * emb_t3_30 + (-0.99751871824264526) * emb_t3_31 + gate_r * ((-0.10919719189405441) + (0.28630056977272034) * gru_0_rev_t4_h_0 + (-0.11834424734115601) * gru_0_rev_t4_h_1 + (-0.13483290374279022) * gru_0_rev_t4_h_2 + (0.32286292314529419) * gru_0_rev_t4_h_3 + (0.1283978670835495) * gru_0_rev_t4_h_4 + (0.049704223871231079) * gru_0_rev_t4_h_5 + (-0.037686057388782501) * gru_0_rev_t4_h_6 + (-2.0566840171813965) * gru_0_rev_t4_h_7 + (-0.041945870965719223) * gru_0_rev_t4_h_8 + (0.19028849899768829) * gru_0_rev_t4_h_9 + (0.68664753437042236) * gru_0_rev_t4_h_10 + (-0.075616724789142609) * gru_0_rev_t4_h_11 + (0.28503879904747009) * gru_0_rev_t4_h_12 + (0.33768099546432495) * gru_0_rev_t4_h_13 + (1.0225725173950195) * gru_0_rev_t4_h_14 + (0.057981051504611969) * gru_0_rev_t4_h_15 + (1.0458639860153198) * gru_0_rev_t4_h_16 + (-1.2272806167602539) * gru_0_rev_t4_h_17 + (0.19868351519107819) * gru_0_rev_t4_h_18 + (0.12467325478792191) * gru_0_rev_t4_h_19 + (0.1654781848192215) * gru_0_rev_t4_h_20 + (0.072424128651618958) * gru_0_rev_t4_h_21 + (-0.10840775072574615) * gru_0_rev_t4_h_22 + (-0.23652976751327515) * gru_0_rev_t4_h_23 + (1.3367893695831299) * gru_0_rev_t4_h_24 + (-0.70007967948913574) * gru_0_rev_t4_h_25 + (-0.13775315880775452) * gru_0_rev_t4_h_26 + (0.098355211317539215) * gru_0_rev_t4_h_27 + (-0.29333484172821045) * gru_0_rev_t4_h_28 + (-0.71339744329452515) * gru_0_rev_t4_h_29 + (0.65865904092788696) * gru_0_rev_t4_h_30 + (0.72680258750915527) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_3 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_3;
    // h=4
    gate_r = sigmoid((-1.3685516119003296) + (0.2236257940530777) * emb_t3_0 + (0.2315046638250351) * emb_t3_1 + (-0.0069134663790464401) * emb_t3_2 + (-1.3870807886123657) * emb_t3_3 + (-0.10641256719827652) * emb_t3_4 + (-0.53056198358535767) * emb_t3_5 + (-0.11012519896030426) * emb_t3_6 + (-0.10570209473371506) * emb_t3_7 + (-0.66879916191101074) * emb_t3_8 + (0.23310942947864532) * emb_t3_9 + (0.59494161605834961) * emb_t3_10 + (-1.0102554559707642) * emb_t3_11 + (-0.85333633422851562) * emb_t3_12 + (0.24490706622600555) * emb_t3_13 + (-0.5255168080329895) * emb_t3_14 + (0.31045553088188171) * emb_t3_15 + (-0.26299077272415161) * emb_t3_16 + (0.8356509804725647) * emb_t3_17 + (0.0081240134313702583) * emb_t3_18 + (-0.20643709599971771) * emb_t3_19 + (-0.74964088201522827) * emb_t3_20 + (-0.4777131974697113) * emb_t3_21 + (0.11391793936491013) * emb_t3_22 + (0.72878921031951904) * emb_t3_23 + (-0.38144084811210632) * emb_t3_24 + (0.33510813117027283) * emb_t3_25 + (-1.3575292825698853) * emb_t3_26 + (-0.18604283034801483) * emb_t3_27 + (-0.43928316235542297) * emb_t3_28 + (-0.24148491024971008) * emb_t3_29 + (-0.30673620104789734) * emb_t3_30 + (1.8704019784927368) * emb_t3_31 + (-1.5176869630813599) * gru_0_rev_t4_h_0 + (0.33462414145469666) * gru_0_rev_t4_h_1 + (-0.043390817940235138) * gru_0_rev_t4_h_2 + (0.051610849797725677) * gru_0_rev_t4_h_3 + (-0.046019449830055237) * gru_0_rev_t4_h_4 + (0.27918964624404907) * gru_0_rev_t4_h_5 + (-0.2583807110786438) * gru_0_rev_t4_h_6 + (1.4942536354064941) * gru_0_rev_t4_h_7 + (-0.76942700147628784) * gru_0_rev_t4_h_8 + (-0.26429453492164612) * gru_0_rev_t4_h_9 + (-1.8271079063415527) * gru_0_rev_t4_h_10 + (-0.18192505836486816) * gru_0_rev_t4_h_11 + (-0.061841432005167007) * gru_0_rev_t4_h_12 + (-0.06073419377207756) * gru_0_rev_t4_h_13 + (0.14449687302112579) * gru_0_rev_t4_h_14 + (1.2870470285415649) * gru_0_rev_t4_h_15 + (1.9416691064834595) * gru_0_rev_t4_h_16 + (-1.7386958599090576) * gru_0_rev_t4_h_17 + (-1.5043016672134399) * gru_0_rev_t4_h_18 + (-0.19966986775398254) * gru_0_rev_t4_h_19 + (-0.40226748585700989) * gru_0_rev_t4_h_20 + (-0.15110856294631958) * gru_0_rev_t4_h_21 + (2.3585426807403564) * gru_0_rev_t4_h_22 + (-1.137647271156311) * gru_0_rev_t4_h_23 + (0.83992177248001099) * gru_0_rev_t4_h_24 + (-1.6327506303787231) * gru_0_rev_t4_h_25 + (0.14638935029506683) * gru_0_rev_t4_h_26 + (-0.34793215990066528) * gru_0_rev_t4_h_27 + (1.371954083442688) * gru_0_rev_t4_h_28 + (-0.17712399363517761) * gru_0_rev_t4_h_29 + (-0.29120057821273804) * gru_0_rev_t4_h_30 + (-3.8920629024505615) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((2.4346427917480469) + (0.076031491160392761) * emb_t3_0 + (-0.07498527318239212) * emb_t3_1 + (-0.12274941056966782) * emb_t3_2 + (1.3836251497268677) * emb_t3_3 + (-0.38983270525932312) * emb_t3_4 + (-0.34554648399353027) * emb_t3_5 + (-0.27028623223304749) * emb_t3_6 + (0.30968695878982544) * emb_t3_7 + (1.8473078012466431) * emb_t3_8 + (-0.43921613693237305) * emb_t3_9 + (-0.56298470497131348) * emb_t3_10 + (1.5358134508132935) * emb_t3_11 + (1.5420798063278198) * emb_t3_12 + (-0.065896123647689819) * emb_t3_13 + (-0.10415127873420715) * emb_t3_14 + (0.080940008163452148) * emb_t3_15 + (-0.26589882373809814) * emb_t3_16 + (-0.45362770557403564) * emb_t3_17 + (-0.62490648031234741) * emb_t3_18 + (0.78356188535690308) * emb_t3_19 + (1.0456368923187256) * emb_t3_20 + (-0.0038928152061998844) * emb_t3_21 + (-0.5675768256187439) * emb_t3_22 + (0.049756228923797607) * emb_t3_23 + (-0.14089852571487427) * emb_t3_24 + (0.065446317195892334) * emb_t3_25 + (0.33768534660339355) * emb_t3_26 + (0.0066933473572134972) * emb_t3_27 + (-0.19684574007987976) * emb_t3_28 + (0.13190034031867981) * emb_t3_29 + (-0.26188069581985474) * emb_t3_30 + (-2.0341219902038574) * emb_t3_31 + (0.82830727100372314) * gru_0_rev_t4_h_0 + (-0.55882412195205688) * gru_0_rev_t4_h_1 + (-0.68620026111602783) * gru_0_rev_t4_h_2 + (-0.051439899951219559) * gru_0_rev_t4_h_3 + (0.59136044979095459) * gru_0_rev_t4_h_4 + (-0.19802726805210114) * gru_0_rev_t4_h_5 + (0.50041300058364868) * gru_0_rev_t4_h_6 + (-1.5836582183837891) * gru_0_rev_t4_h_7 + (0.08773387223482132) * gru_0_rev_t4_h_8 + (0.1568247526884079) * gru_0_rev_t4_h_9 + (-3.2137653827667236) * gru_0_rev_t4_h_10 + (0.46419224143028259) * gru_0_rev_t4_h_11 + (-0.38636547327041626) * gru_0_rev_t4_h_12 + (0.037277359515428543) * gru_0_rev_t4_h_13 + (1.4729127883911133) * gru_0_rev_t4_h_14 + (-0.63946199417114258) * gru_0_rev_t4_h_15 + (-0.98365658521652222) * gru_0_rev_t4_h_16 + (0.97828996181488037) * gru_0_rev_t4_h_17 + (0.5215451717376709) * gru_0_rev_t4_h_18 + (-0.41277766227722168) * gru_0_rev_t4_h_19 + (0.56945174932479858) * gru_0_rev_t4_h_20 + (0.51766586303710938) * gru_0_rev_t4_h_21 + (-0.50247299671173096) * gru_0_rev_t4_h_22 + (-0.14092275500297546) * gru_0_rev_t4_h_23 + (-1.6134154796600342) * gru_0_rev_t4_h_24 + (0.81506723165512085) * gru_0_rev_t4_h_25 + (-0.059442754834890366) * gru_0_rev_t4_h_26 + (-1.0661146640777588) * gru_0_rev_t4_h_27 + (0.48368716239929199) * gru_0_rev_t4_h_28 + (-0.57892632484436035) * gru_0_rev_t4_h_29 + (0.10891690850257874) * gru_0_rev_t4_h_30 + (-1.043377161026001) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.016163228079676628) + (-0.027884617447853088) * emb_t3_0 + (-0.080985419452190399) * emb_t3_1 + (-0.035114459693431854) * emb_t3_2 + (0.16090622544288635) * emb_t3_3 + (-0.43337962031364441) * emb_t3_4 + (0.059590533375740051) * emb_t3_5 + (-0.17441758513450623) * emb_t3_6 + (-0.122524693608284) * emb_t3_7 + (-0.21187984943389893) * emb_t3_8 + (-0.44347575306892395) * emb_t3_9 + (0.18624871969223022) * emb_t3_10 + (-0.23481367528438568) * emb_t3_11 + (0.091380417346954346) * emb_t3_12 + (0.32930436730384827) * emb_t3_13 + (-0.0055515216663479805) * emb_t3_14 + (0.005958891473710537) * emb_t3_15 + (-0.019560828804969788) * emb_t3_16 + (0.16434705257415771) * emb_t3_17 + (-0.32695618271827698) * emb_t3_18 + (-0.22283002734184265) * emb_t3_19 + (-0.12126600742340088) * emb_t3_20 + (-0.021952878683805466) * emb_t3_21 + (-0.062434587627649307) * emb_t3_22 + (0.056233879178762436) * emb_t3_23 + (-0.053126074373722076) * emb_t3_24 + (0.071384981274604797) * emb_t3_25 + (-0.20940221846103668) * emb_t3_26 + (-0.03841070830821991) * emb_t3_27 + (0.072856955230236053) * emb_t3_28 + (-0.30034703016281128) * emb_t3_29 + (-0.0074970419518649578) * emb_t3_30 + (-0.014893620274960995) * emb_t3_31 + gate_r * ((-0.0051035168580710888) + (0.15627464652061462) * gru_0_rev_t4_h_0 + (-0.43296098709106445) * gru_0_rev_t4_h_1 + (-0.15945829451084137) * gru_0_rev_t4_h_2 + (0.39040097594261169) * gru_0_rev_t4_h_3 + (-0.3233923614025116) * gru_0_rev_t4_h_4 + (-0.06083524227142334) * gru_0_rev_t4_h_5 + (-0.14569543302059174) * gru_0_rev_t4_h_6 + (1.5100235939025879) * gru_0_rev_t4_h_7 + (0.0083974450826644897) * gru_0_rev_t4_h_8 + (0.19252222776412964) * gru_0_rev_t4_h_9 + (0.65073412656784058) * gru_0_rev_t4_h_10 + (-0.30895915627479553) * gru_0_rev_t4_h_11 + (0.2541634738445282) * gru_0_rev_t4_h_12 + (0.32581555843353271) * gru_0_rev_t4_h_13 + (-0.35917925834655762) * gru_0_rev_t4_h_14 + (-0.39058998227119446) * gru_0_rev_t4_h_15 + (-0.68778294324874878) * gru_0_rev_t4_h_16 + (0.64351177215576172) * gru_0_rev_t4_h_17 + (0.69160449504852295) * gru_0_rev_t4_h_18 + (-0.030609171837568283) * gru_0_rev_t4_h_19 + (0.5217246413230896) * gru_0_rev_t4_h_20 + (0.13319502770900726) * gru_0_rev_t4_h_21 + (0.17218521237373352) * gru_0_rev_t4_h_22 + (0.67964494228363037) * gru_0_rev_t4_h_23 + (-0.01172297541052103) * gru_0_rev_t4_h_24 + (0.40349218249320984) * gru_0_rev_t4_h_25 + (-0.10605806112289429) * gru_0_rev_t4_h_26 + (-0.3236878514289856) * gru_0_rev_t4_h_27 + (-4.5056571960449219) * gru_0_rev_t4_h_28 + (-0.25567620992660522) * gru_0_rev_t4_h_29 + (0.24665170907974243) * gru_0_rev_t4_h_30 + (0.36845201253890991) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_4 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_4;
    // h=5
    gate_r = sigmoid((-1.5634896755218506) + (-0.62903255224227905) * emb_t3_0 + (0.36245304346084595) * emb_t3_1 + (-1.5545089244842529) * emb_t3_2 + (-1.2221488952636719) * emb_t3_3 + (0.65975433588027954) * emb_t3_4 + (2.0174753665924072) * emb_t3_5 + (0.62188005447387695) * emb_t3_6 + (0.56032282114028931) * emb_t3_7 + (-1.1194415092468262) * emb_t3_8 + (0.67931801080703735) * emb_t3_9 + (0.99105501174926758) * emb_t3_10 + (-0.79531687498092651) * emb_t3_11 + (-0.61260032653808594) * emb_t3_12 + (0.48130452632904053) * emb_t3_13 + (0.67230534553527832) * emb_t3_14 + (-0.74714452028274536) * emb_t3_15 + (-0.75569170713424683) * emb_t3_16 + (0.44226035475730896) * emb_t3_17 + (0.8893393874168396) * emb_t3_18 + (-0.861533522605896) * emb_t3_19 + (-0.84034454822540283) * emb_t3_20 + (-0.22506797313690186) * emb_t3_21 + (0.74993497133255005) * emb_t3_22 + (1.0221257209777832) * emb_t3_23 + (0.57013022899627686) * emb_t3_24 + (0.77331399917602539) * emb_t3_25 + (-0.71970087289810181) * emb_t3_26 + (1.2238805294036865) * emb_t3_27 + (-0.45674803853034973) * emb_t3_28 + (0.46003538370132446) * emb_t3_29 + (-0.019631205126643181) * emb_t3_30 + (0.46944329142570496) * emb_t3_31 + (-0.52130001783370972) * gru_0_rev_t4_h_0 + (-0.37136068940162659) * gru_0_rev_t4_h_1 + (-0.43722158670425415) * gru_0_rev_t4_h_2 + (-0.33028349280357361) * gru_0_rev_t4_h_3 + (0.51361548900604248) * gru_0_rev_t4_h_4 + (0.13733898103237152) * gru_0_rev_t4_h_5 + (0.68767011165618896) * gru_0_rev_t4_h_6 + (0.071959584951400757) * gru_0_rev_t4_h_7 + (-0.38118234276771545) * gru_0_rev_t4_h_8 + (-0.78445178270339966) * gru_0_rev_t4_h_9 + (0.43489992618560791) * gru_0_rev_t4_h_10 + (0.5997612476348877) * gru_0_rev_t4_h_11 + (-0.62875503301620483) * gru_0_rev_t4_h_12 + (-0.47714206576347351) * gru_0_rev_t4_h_13 + (-0.20654270052909851) * gru_0_rev_t4_h_14 + (0.57482802867889404) * gru_0_rev_t4_h_15 + (-0.35105672478675842) * gru_0_rev_t4_h_16 + (0.20398081839084625) * gru_0_rev_t4_h_17 + (-0.41657176613807678) * gru_0_rev_t4_h_18 + (-0.1551842987537384) * gru_0_rev_t4_h_19 + (-0.40059015154838562) * gru_0_rev_t4_h_20 + (-0.93062072992324829) * gru_0_rev_t4_h_21 + (1.1976312398910522) * gru_0_rev_t4_h_22 + (-0.91361039876937866) * gru_0_rev_t4_h_23 + (-1.186490535736084) * gru_0_rev_t4_h_24 + (0.29758509993553162) * gru_0_rev_t4_h_25 + (0.56176978349685669) * gru_0_rev_t4_h_26 + (-0.24216729402542114) * gru_0_rev_t4_h_27 + (0.46204689145088196) * gru_0_rev_t4_h_28 + (-0.35485908389091492) * gru_0_rev_t4_h_29 + (-0.0811505988240242) * gru_0_rev_t4_h_30 + (0.095859818160533905) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((1.4312663078308105) + (-0.16836337745189667) * emb_t3_0 + (0.44441503286361694) * emb_t3_1 + (0.16264483332633972) * emb_t3_2 + (1.0687229633331299) * emb_t3_3 + (-0.57740002870559692) * emb_t3_4 + (0.24474041163921356) * emb_t3_5 + (-0.72791266441345215) * emb_t3_6 + (-0.090155191719532013) * emb_t3_7 + (0.52850556373596191) * emb_t3_8 + (-0.095212966203689575) * emb_t3_9 + (-0.75963431596755981) * emb_t3_10 + (0.29542917013168335) * emb_t3_11 + (0.52279412746429443) * emb_t3_12 + (0.2410600334405899) * emb_t3_13 + (-0.10806937515735626) * emb_t3_14 + (-0.29624739289283752) * emb_t3_15 + (0.1450391411781311) * emb_t3_16 + (-0.64505428075790405) * emb_t3_17 + (-0.70188021659851074) * emb_t3_18 + (0.37090384960174561) * emb_t3_19 + (0.72022032737731934) * emb_t3_20 + (-0.4697345495223999) * emb_t3_21 + (-1.1323502063751221) * emb_t3_22 + (0.8552585244178772) * emb_t3_23 + (-0.4344315230846405) * emb_t3_24 + (0.35562679171562195) * emb_t3_25 + (1.0576106309890747) * emb_t3_26 + (0.1960688978433609) * emb_t3_27 + (-0.066304668784141541) * emb_t3_28 + (0.4063924252986908) * emb_t3_29 + (0.48414763808250427) * emb_t3_30 + (-0.76584368944168091) * emb_t3_31 + (-0.23218044638633728) * gru_0_rev_t4_h_0 + (1.9157075881958008) * gru_0_rev_t4_h_1 + (0.79789841175079346) * gru_0_rev_t4_h_2 + (-0.2710033655166626) * gru_0_rev_t4_h_3 + (0.008863586001098156) * gru_0_rev_t4_h_4 + (-0.10704480111598969) * gru_0_rev_t4_h_5 + (0.27443027496337891) * gru_0_rev_t4_h_6 + (-1.036899209022522) * gru_0_rev_t4_h_7 + (-0.52171427011489868) * gru_0_rev_t4_h_8 + (-0.27688512206077576) * gru_0_rev_t4_h_9 + (0.75124704837799072) * gru_0_rev_t4_h_10 + (0.33620738983154297) * gru_0_rev_t4_h_11 + (-0.46434158086776733) * gru_0_rev_t4_h_12 + (-0.32043787837028503) * gru_0_rev_t4_h_13 + (-0.41969200968742371) * gru_0_rev_t4_h_14 + (-0.28003242611885071) * gru_0_rev_t4_h_15 + (-1.6925849914550781) * gru_0_rev_t4_h_16 + (1.4436765909194946) * gru_0_rev_t4_h_17 + (0.60188126564025879) * gru_0_rev_t4_h_18 + (0.1620410829782486) * gru_0_rev_t4_h_19 + (-0.81033867597579956) * gru_0_rev_t4_h_20 + (-0.15799511969089508) * gru_0_rev_t4_h_21 + (0.54191887378692627) * gru_0_rev_t4_h_22 + (-0.43402019143104553) * gru_0_rev_t4_h_23 + (-0.69133609533309937) * gru_0_rev_t4_h_24 + (1.5803579092025757) * gru_0_rev_t4_h_25 + (0.25366368889808655) * gru_0_rev_t4_h_26 + (-0.86119824647903442) * gru_0_rev_t4_h_27 + (-0.34871438145637512) * gru_0_rev_t4_h_28 + (-0.70540827512741089) * gru_0_rev_t4_h_29 + (0.17851059138774872) * gru_0_rev_t4_h_30 + (-0.58656758069992065) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.095938041806221008) + (0.019716093316674232) * emb_t3_0 + (-0.10058939456939697) * emb_t3_1 + (0.042951811105012894) * emb_t3_2 + (-0.24419373273849487) * emb_t3_3 + (0.19518949091434479) * emb_t3_4 + (0.031617607921361923) * emb_t3_5 + (-0.091009944677352905) * emb_t3_6 + (-0.12042555958032608) * emb_t3_7 + (0.024757981300354004) * emb_t3_8 + (0.084511339664459229) * emb_t3_9 + (0.0086361942812800407) * emb_t3_10 + (-0.04753856360912323) * emb_t3_11 + (-0.091400280594825745) * emb_t3_12 + (-0.13011062145233154) * emb_t3_13 + (0.041920062154531479) * emb_t3_14 + (-0.018763028085231781) * emb_t3_15 + (0.064093425869941711) * emb_t3_16 + (-0.20723046362400055) * emb_t3_17 + (0.41586199402809143) * emb_t3_18 + (-0.29028573632240295) * emb_t3_19 + (-0.40064457058906555) * emb_t3_20 + (-0.022126013413071632) * emb_t3_21 + (-0.0042889942415058613) * emb_t3_22 + (-0.065435081720352173) * emb_t3_23 + (0.02503061480820179) * emb_t3_24 + (0.017134957015514374) * emb_t3_25 + (0.19566901028156281) * emb_t3_26 + (-0.005349836777895689) * emb_t3_27 + (0.24285364151000977) * emb_t3_28 + (-0.4245639443397522) * emb_t3_29 + (-0.36877095699310303) * emb_t3_30 + (0.13548864424228668) * emb_t3_31 + gate_r * ((0.30367663502693176) + (-0.21925845742225647) * gru_0_rev_t4_h_0 + (0.1360149085521698) * gru_0_rev_t4_h_1 + (-0.26325544714927673) * gru_0_rev_t4_h_2 + (-0.12602405250072479) * gru_0_rev_t4_h_3 + (0.7043379545211792) * gru_0_rev_t4_h_4 + (-0.97235512733459473) * gru_0_rev_t4_h_5 + (-0.014679952524602413) * gru_0_rev_t4_h_6 + (-0.15824307501316071) * gru_0_rev_t4_h_7 + (0.15404582023620605) * gru_0_rev_t4_h_8 + (-0.43847677111625671) * gru_0_rev_t4_h_9 + (-0.23484046757221222) * gru_0_rev_t4_h_10 + (0.37851807475090027) * gru_0_rev_t4_h_11 + (-0.12264784425497055) * gru_0_rev_t4_h_12 + (-0.2416316419839859) * gru_0_rev_t4_h_13 + (-0.79253119230270386) * gru_0_rev_t4_h_14 + (0.22376212477684021) * gru_0_rev_t4_h_15 + (-0.39215880632400513) * gru_0_rev_t4_h_16 + (0.1366795152425766) * gru_0_rev_t4_h_17 + (-1.0293195247650146) * gru_0_rev_t4_h_18 + (0.30127441883087158) * gru_0_rev_t4_h_19 + (-0.38694325089454651) * gru_0_rev_t4_h_20 + (-1.2344837188720703) * gru_0_rev_t4_h_21 + (-0.1256253570318222) * gru_0_rev_t4_h_22 + (0.093954093754291534) * gru_0_rev_t4_h_23 + (0.76088172197341919) * gru_0_rev_t4_h_24 + (-0.015533034689724445) * gru_0_rev_t4_h_25 + (0.12514603137969971) * gru_0_rev_t4_h_26 + (0.82483482360839844) * gru_0_rev_t4_h_27 + (0.51157355308532715) * gru_0_rev_t4_h_28 + (0.074196554720401764) * gru_0_rev_t4_h_29 + (-0.035619284957647324) * gru_0_rev_t4_h_30 + (-0.12469020485877991) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_5 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_5;
    // h=6
    gate_r = sigmoid((-0.16276088356971741) + (0.20025475323200226) * emb_t3_0 + (0.17347058653831482) * emb_t3_1 + (0.35707581043243408) * emb_t3_2 + (0.46974825859069824) * emb_t3_3 + (0.22605399787425995) * emb_t3_4 + (-0.32701298594474792) * emb_t3_5 + (0.16208638250827789) * emb_t3_6 + (0.052859973162412643) * emb_t3_7 + (-0.19004581868648529) * emb_t3_8 + (-0.77393364906311035) * emb_t3_9 + (-0.43571323156356812) * emb_t3_10 + (0.16889031231403351) * emb_t3_11 + (0.090000458061695099) * emb_t3_12 + (0.39088490605354309) * emb_t3_13 + (-0.22382055222988129) * emb_t3_14 + (0.053270865231752396) * emb_t3_15 + (-0.044224943965673447) * emb_t3_16 + (0.27830639481544495) * emb_t3_17 + (-0.60966300964355469) * emb_t3_18 + (0.19745741784572601) * emb_t3_19 + (-0.1724993884563446) * emb_t3_20 + (0.15035286545753479) * emb_t3_21 + (0.082759574055671692) * emb_t3_22 + (0.41038119792938232) * emb_t3_23 + (0.065190263092517853) * emb_t3_24 + (0.06509023904800415) * emb_t3_25 + (0.29210397601127625) * emb_t3_26 + (-0.041783846914768219) * emb_t3_27 + (-0.28990316390991211) * emb_t3_28 + (0.36020195484161377) * emb_t3_29 + (0.42040523886680603) * emb_t3_30 + (0.37163341045379639) * emb_t3_31 + (-0.21160565316677094) * gru_0_rev_t4_h_0 + (-0.43299141526222229) * gru_0_rev_t4_h_1 + (-0.15619140863418579) * gru_0_rev_t4_h_2 + (-0.24331778287887573) * gru_0_rev_t4_h_3 + (0.69127798080444336) * gru_0_rev_t4_h_4 + (0.18465003371238708) * gru_0_rev_t4_h_5 + (-0.076429508626461029) * gru_0_rev_t4_h_6 + (1.2437895536422729) * gru_0_rev_t4_h_7 + (-0.071980014443397522) * gru_0_rev_t4_h_8 + (-0.14771556854248047) * gru_0_rev_t4_h_9 + (0.10667851567268372) * gru_0_rev_t4_h_10 + (0.48471561074256897) * gru_0_rev_t4_h_11 + (-0.24945235252380371) * gru_0_rev_t4_h_12 + (-0.080655574798583984) * gru_0_rev_t4_h_13 + (-0.70213758945465088) * gru_0_rev_t4_h_14 + (0.060988828539848328) * gru_0_rev_t4_h_15 + (0.068789690732955933) * gru_0_rev_t4_h_16 + (0.16076786816120148) * gru_0_rev_t4_h_17 + (-0.18428590893745422) * gru_0_rev_t4_h_18 + (-0.13233637809753418) * gru_0_rev_t4_h_19 + (0.071274608373641968) * gru_0_rev_t4_h_20 + (-0.28152570128440857) * gru_0_rev_t4_h_21 + (0.066040061414241791) * gru_0_rev_t4_h_22 + (0.22235620021820068) * gru_0_rev_t4_h_23 + (-0.031987171620130539) * gru_0_rev_t4_h_24 + (0.11746459454298019) * gru_0_rev_t4_h_25 + (0.068357512354850769) * gru_0_rev_t4_h_26 + (-0.026112357154488564) * gru_0_rev_t4_h_27 + (0.24510748684406281) * gru_0_rev_t4_h_28 + (0.26369297504425049) * gru_0_rev_t4_h_29 + (-0.16678951680660248) * gru_0_rev_t4_h_30 + (-0.94864827394485474) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((0.43828460574150085) + (-0.11457296460866928) * emb_t3_0 + (0.95512300729751587) * emb_t3_1 + (-0.1657164990901947) * emb_t3_2 + (0.082567401230335236) * emb_t3_3 + (0.038362599909305573) * emb_t3_4 + (-0.21106328070163727) * emb_t3_5 + (-0.10894918441772461) * emb_t3_6 + (0.04673212394118309) * emb_t3_7 + (0.14320369064807892) * emb_t3_8 + (-1.4584397077560425) * emb_t3_9 + (-0.94442278146743774) * emb_t3_10 + (0.28447550535202026) * emb_t3_11 + (0.33804842829704285) * emb_t3_12 + (0.73368620872497559) * emb_t3_13 + (0.031311057507991791) * emb_t3_14 + (0.04951082170009613) * emb_t3_15 + (0.012886076234281063) * emb_t3_16 + (-0.029510708525776863) * emb_t3_17 + (-0.8211861252784729) * emb_t3_18 + (0.97318583726882935) * emb_t3_19 + (0.065554253756999969) * emb_t3_20 + (0.21369661390781403) * emb_t3_21 + (-0.60520964860916138) * emb_t3_22 + (-0.10672582685947418) * emb_t3_23 + (-0.083651915192604065) * emb_t3_24 + (-0.12971997261047363) * emb_t3_25 + (-0.15323644876480103) * emb_t3_26 + (0.092682525515556335) * emb_t3_27 + (-0.73803234100341797) * emb_t3_28 + (0.36626550555229187) * emb_t3_29 + (-0.61820012331008911) * emb_t3_30 + (-0.57488489151000977) * emb_t3_31 + (-0.30763837695121765) * gru_0_rev_t4_h_0 + (-0.43522155284881592) * gru_0_rev_t4_h_1 + (-0.91925054788589478) * gru_0_rev_t4_h_2 + (-0.1387687474489212) * gru_0_rev_t4_h_3 + (1.1318885087966919) * gru_0_rev_t4_h_4 + (-1.1622788906097412) * gru_0_rev_t4_h_5 + (0.47946533560752869) * gru_0_rev_t4_h_6 + (0.9563215970993042) * gru_0_rev_t4_h_7 + (-0.44825091958045959) * gru_0_rev_t4_h_8 + (-0.076530583202838898) * gru_0_rev_t4_h_9 + (0.27251368761062622) * gru_0_rev_t4_h_10 + (0.64492118358612061) * gru_0_rev_t4_h_11 + (-0.20508658885955811) * gru_0_rev_t4_h_12 + (-0.20993500947952271) * gru_0_rev_t4_h_13 + (-1.317862868309021) * gru_0_rev_t4_h_14 + (0.055477473884820938) * gru_0_rev_t4_h_15 + (-1.2852609157562256) * gru_0_rev_t4_h_16 + (0.68178564310073853) * gru_0_rev_t4_h_17 + (-0.058973051607608795) * gru_0_rev_t4_h_18 + (0.57081305980682373) * gru_0_rev_t4_h_19 + (-0.57976865768432617) * gru_0_rev_t4_h_20 + (-0.20554998517036438) * gru_0_rev_t4_h_21 + (-0.14002440869808197) * gru_0_rev_t4_h_22 + (-0.72047346830368042) * gru_0_rev_t4_h_23 + (1.0265729427337646) * gru_0_rev_t4_h_24 + (0.91255909204483032) * gru_0_rev_t4_h_25 + (-0.53481197357177734) * gru_0_rev_t4_h_26 + (0.4934675395488739) * gru_0_rev_t4_h_27 + (0.35276538133621216) * gru_0_rev_t4_h_28 + (-0.56664830446243286) * gru_0_rev_t4_h_29 + (0.14427343010902405) * gru_0_rev_t4_h_30 + (-0.72429937124252319) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.045015387237071991) + (0.017269458621740341) * emb_t3_0 + (0.37110093235969543) * emb_t3_1 + (-0.0012924645561724901) * emb_t3_2 + (-0.20327292382717133) * emb_t3_3 + (-0.22391784191131592) * emb_t3_4 + (-0.0038543003611266613) * emb_t3_5 + (-0.082848511636257172) * emb_t3_6 + (-0.055194873362779617) * emb_t3_7 + (-0.095518298447132111) * emb_t3_8 + (-0.92083251476287842) * emb_t3_9 + (-0.44550743699073792) * emb_t3_10 + (0.060151893645524979) * emb_t3_11 + (0.18334275484085083) * emb_t3_12 + (0.48310336470603943) * emb_t3_13 + (0.0055563142523169518) * emb_t3_14 + (0.023337433114647865) * emb_t3_15 + (-0.028754057362675667) * emb_t3_16 + (0.41201657056808472) * emb_t3_17 + (-0.9497947096824646) * emb_t3_18 + (0.66103571653366089) * emb_t3_19 + (0.014644306153059006) * emb_t3_20 + (0.0090339388698339462) * emb_t3_21 + (-0.37559798359870911) * emb_t3_22 + (0.0049393344670534134) * emb_t3_23 + (0.023944161832332611) * emb_t3_24 + (-0.01578749343752861) * emb_t3_25 + (-0.28385165333747864) * emb_t3_26 + (0.0053995572961866856) * emb_t3_27 + (-0.5838969349861145) * emb_t3_28 + (0.5506671667098999) * emb_t3_29 + (-0.062937475740909576) * emb_t3_30 + (0.48956561088562012) * emb_t3_31 + gate_r * ((-0.11357367038726807) + (0.22434690594673157) * gru_0_rev_t4_h_0 + (0.1113559901714325) * gru_0_rev_t4_h_1 + (1.1125682592391968) * gru_0_rev_t4_h_2 + (-0.085503637790679932) * gru_0_rev_t4_h_3 + (1.0051048994064331) * gru_0_rev_t4_h_4 + (0.10435006767511368) * gru_0_rev_t4_h_5 + (-0.67103195190429688) * gru_0_rev_t4_h_6 + (-0.45980706810951233) * gru_0_rev_t4_h_7 + (-0.072033204138278961) * gru_0_rev_t4_h_8 + (-0.085360169410705566) * gru_0_rev_t4_h_9 + (0.054272972047328949) * gru_0_rev_t4_h_10 + (0.3943212628364563) * gru_0_rev_t4_h_11 + (0.098068997263908386) * gru_0_rev_t4_h_12 + (-0.12638801336288452) * gru_0_rev_t4_h_13 + (0.32414388656616211) * gru_0_rev_t4_h_14 + (0.0065296655520796776) * gru_0_rev_t4_h_15 + (-0.13125437498092651) * gru_0_rev_t4_h_16 + (0.15912027657032013) * gru_0_rev_t4_h_17 + (0.10986104607582092) * gru_0_rev_t4_h_18 + (-0.11090215295553207) * gru_0_rev_t4_h_19 + (-0.029985817149281502) * gru_0_rev_t4_h_20 + (0.053073391318321228) * gru_0_rev_t4_h_21 + (0.098395273089408875) * gru_0_rev_t4_h_22 + (0.22477105259895325) * gru_0_rev_t4_h_23 + (-0.029570803046226501) * gru_0_rev_t4_h_24 + (0.13191024959087372) * gru_0_rev_t4_h_25 + (-0.22685550153255463) * gru_0_rev_t4_h_26 + (-1.9397813081741333) * gru_0_rev_t4_h_27 + (-0.96625411510467529) * gru_0_rev_t4_h_28 + (0.13890314102172852) * gru_0_rev_t4_h_29 + (-0.19285948574542999) * gru_0_rev_t4_h_30 + (0.98144543170928955) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_6 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_6;
    // h=7
    gate_r = sigmoid((1.9255975484848022) + (0.55523896217346191) * emb_t3_0 + (0.89170128107070923) * emb_t3_1 + (0.2156120091676712) * emb_t3_2 + (1.1129550933837891) * emb_t3_3 + (-0.53035211563110352) * emb_t3_4 + (-0.25143095850944519) * emb_t3_5 + (-0.50795894861221313) * emb_t3_6 + (0.866973876953125) * emb_t3_7 + (2.0420713424682617) * emb_t3_8 + (-1.1865967512130737) * emb_t3_9 + (-0.8294302225112915) * emb_t3_10 + (1.4127449989318848) * emb_t3_11 + (8.7584238052368164) * emb_t3_12 + (0.27749598026275635) * emb_t3_13 + (-0.32566460967063904) * emb_t3_14 + (0.3347194492816925) * emb_t3_15 + (0.18621660768985748) * emb_t3_16 + (-0.52024084329605103) * emb_t3_17 + (-1.1663960218429565) * emb_t3_18 + (1.1315882205963135) * emb_t3_19 + (0.93168950080871582) * emb_t3_20 + (-0.81291139125823975) * emb_t3_21 + (-1.8350151777267456) * emb_t3_22 + (-0.10416764765977859) * emb_t3_23 + (-0.34112545847892761) * emb_t3_24 + (-0.97905004024505615) * emb_t3_25 + (0.89600902795791626) * emb_t3_26 + (0.00066087965387851) * emb_t3_27 + (-0.92635774612426758) * emb_t3_28 + (0.47958353161811829) * emb_t3_29 + (0.7244299054145813) * emb_t3_30 + (-3.2421584129333496) * emb_t3_31 + (0.39172869920730591) * gru_0_rev_t4_h_0 + (0.48186835646629333) * gru_0_rev_t4_h_1 + (0.585368812084198) * gru_0_rev_t4_h_2 + (-0.032018762081861496) * gru_0_rev_t4_h_3 + (-0.46728315949440002) * gru_0_rev_t4_h_4 + (0.28085219860076904) * gru_0_rev_t4_h_5 + (-0.64261233806610107) * gru_0_rev_t4_h_6 + (3.9783861637115479) * gru_0_rev_t4_h_7 + (0.51194083690643311) * gru_0_rev_t4_h_8 + (0.043752722442150116) * gru_0_rev_t4_h_9 + (3.1213088035583496) * gru_0_rev_t4_h_10 + (-0.64484083652496338) * gru_0_rev_t4_h_11 + (-0.0058446857146918774) * gru_0_rev_t4_h_12 + (0.12697355449199677) * gru_0_rev_t4_h_13 + (0.14181293547153473) * gru_0_rev_t4_h_14 + (-0.56303876638412476) * gru_0_rev_t4_h_15 + (-0.19192390143871307) * gru_0_rev_t4_h_16 + (-0.033371470868587494) * gru_0_rev_t4_h_17 + (0.87587493658065796) * gru_0_rev_t4_h_18 + (-0.31108570098876953) * gru_0_rev_t4_h_19 + (-0.01539064384996891) * gru_0_rev_t4_h_20 + (0.38777539134025574) * gru_0_rev_t4_h_21 + (-0.41270214319229126) * gru_0_rev_t4_h_22 + (1.2283085584640503) * gru_0_rev_t4_h_23 + (-0.47133523225784302) * gru_0_rev_t4_h_24 + (0.02862192690372467) * gru_0_rev_t4_h_25 + (0.20215891301631927) * gru_0_rev_t4_h_26 + (0.26098421216011047) * gru_0_rev_t4_h_27 + (-0.69574820995330811) * gru_0_rev_t4_h_28 + (0.73384886980056763) * gru_0_rev_t4_h_29 + (-0.45512446761131287) * gru_0_rev_t4_h_30 + (1.3812969923019409) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((1.012992262840271) + (-0.047066505998373032) * emb_t3_0 + (-0.73198771476745605) * emb_t3_1 + (-0.042197540402412415) * emb_t3_2 + (0.72793388366699219) * emb_t3_3 + (-0.4706551730632782) * emb_t3_4 + (0.062597908079624176) * emb_t3_5 + (-0.78531628847122192) * emb_t3_6 + (0.13587543368339539) * emb_t3_7 + (0.19500631093978882) * emb_t3_8 + (0.78638374805450439) * emb_t3_9 + (0.42679259181022644) * emb_t3_10 + (0.21645635366439819) * emb_t3_11 + (0.42666754126548767) * emb_t3_12 + (-0.20513574779033661) * emb_t3_13 + (-0.064165227115154266) * emb_t3_14 + (-0.015597824938595295) * emb_t3_15 + (-0.0016061861533671618) * emb_t3_16 + (-0.573924720287323) * emb_t3_17 + (0.059122134000062943) * emb_t3_18 + (0.083723932504653931) * emb_t3_19 + (0.60947668552398682) * emb_t3_20 + (0.036745931953191757) * emb_t3_21 + (0.16261662542819977) * emb_t3_22 + (-0.012009855359792709) * emb_t3_23 + (0.047605734318494797) * emb_t3_24 + (0.042569983750581741) * emb_t3_25 + (0.58801406621932983) * emb_t3_26 + (-0.049603130668401718) * emb_t3_27 + (0.46339148283004761) * emb_t3_28 + (-0.76598042249679565) * emb_t3_29 + (0.37158751487731934) * emb_t3_30 + (-0.30164533853530884) * emb_t3_31 + (0.10948190093040466) * gru_0_rev_t4_h_0 + (-0.074184231460094452) * gru_0_rev_t4_h_1 + (-0.12812858819961548) * gru_0_rev_t4_h_2 + (0.21150031685829163) * gru_0_rev_t4_h_3 + (0.27057608962059021) * gru_0_rev_t4_h_4 + (-0.34003052115440369) * gru_0_rev_t4_h_5 + (0.078964821994304657) * gru_0_rev_t4_h_6 + (0.83969807624816895) * gru_0_rev_t4_h_7 + (-0.025544179603457451) * gru_0_rev_t4_h_8 + (0.2024395763874054) * gru_0_rev_t4_h_9 + (1.0721094608306885) * gru_0_rev_t4_h_10 + (0.24120631814002991) * gru_0_rev_t4_h_11 + (0.14776654541492462) * gru_0_rev_t4_h_12 + (0.25591591000556946) * gru_0_rev_t4_h_13 + (-0.0019344998290762305) * gru_0_rev_t4_h_14 + (0.19937022030353546) * gru_0_rev_t4_h_15 + (0.69300806522369385) * gru_0_rev_t4_h_16 + (-0.64994281530380249) * gru_0_rev_t4_h_17 + (-0.36564379930496216) * gru_0_rev_t4_h_18 + (0.62341701984405518) * gru_0_rev_t4_h_19 + (0.26049947738647461) * gru_0_rev_t4_h_20 + (0.0032317489385604858) * gru_0_rev_t4_h_21 + (-0.026106543838977814) * gru_0_rev_t4_h_22 + (-0.21958331763744354) * gru_0_rev_t4_h_23 + (-0.24645377695560455) * gru_0_rev_t4_h_24 + (-0.65362566709518433) * gru_0_rev_t4_h_25 + (-0.37656888365745544) * gru_0_rev_t4_h_26 + (0.26464098691940308) * gru_0_rev_t4_h_27 + (0.29647117853164673) * gru_0_rev_t4_h_28 + (-0.22323442995548248) * gru_0_rev_t4_h_29 + (0.195733442902565) * gru_0_rev_t4_h_30 + (-0.35351976752281189) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.070102639496326447) + (-0.0083256987854838371) * emb_t3_0 + (0.48970863223075867) * emb_t3_1 + (-0.015992360189557076) * emb_t3_2 + (-0.019377069547772408) * emb_t3_3 + (0.51630574464797974) * emb_t3_4 + (-0.10033709555864334) * emb_t3_5 + (-0.031198322772979736) * emb_t3_6 + (-0.025811705738306046) * emb_t3_7 + (0.15150557458400726) * emb_t3_8 + (0.025755628943443298) * emb_t3_9 + (0.28951391577720642) * emb_t3_10 + (0.13297167420387268) * emb_t3_11 + (-0.16793139278888702) * emb_t3_12 + (0.42544922232627869) * emb_t3_13 + (0.013488370925188065) * emb_t3_14 + (0.094314821064472198) * emb_t3_15 + (-0.049746453762054443) * emb_t3_16 + (-0.41539847850799561) * emb_t3_17 + (-0.54253751039505005) * emb_t3_18 + (0.19768832623958588) * emb_t3_19 + (-0.24333646893501282) * emb_t3_20 + (0.12760193645954132) * emb_t3_21 + (-0.019673768430948257) * emb_t3_22 + (0.12006796896457672) * emb_t3_23 + (0.059151895344257355) * emb_t3_24 + (-0.035049080848693848) * emb_t3_25 + (-0.20564790070056915) * emb_t3_26 + (-0.02051263116300106) * emb_t3_27 + (-0.5644868016242981) * emb_t3_28 + (0.25314801931381226) * emb_t3_29 + (-0.29811897873878479) * emb_t3_30 + (-0.21613103151321411) * emb_t3_31 + gate_r * ((-0.074222423136234283) + (-0.099218167364597321) * gru_0_rev_t4_h_0 + (0.46875375509262085) * gru_0_rev_t4_h_1 + (-0.069678492844104767) * gru_0_rev_t4_h_2 + (-0.18910343945026398) * gru_0_rev_t4_h_3 + (-0.17562925815582275) * gru_0_rev_t4_h_4 + (0.12054269760847092) * gru_0_rev_t4_h_5 + (-0.21582977473735809) * gru_0_rev_t4_h_6 + (-4.932948112487793) * gru_0_rev_t4_h_7 + (-0.28932300209999084) * gru_0_rev_t4_h_8 + (0.38628685474395752) * gru_0_rev_t4_h_9 + (-0.61952263116836548) * gru_0_rev_t4_h_10 + (-0.48972782492637634) * gru_0_rev_t4_h_11 + (0.025599438697099686) * gru_0_rev_t4_h_12 + (-0.11092989146709442) * gru_0_rev_t4_h_13 + (-0.54637497663497925) * gru_0_rev_t4_h_14 + (-0.34666895866394043) * gru_0_rev_t4_h_15 + (-0.78274786472320557) * gru_0_rev_t4_h_16 + (0.58346408605575562) * gru_0_rev_t4_h_17 + (0.67935961484909058) * gru_0_rev_t4_h_18 + (-0.17212332785129547) * gru_0_rev_t4_h_19 + (-0.38073354959487915) * gru_0_rev_t4_h_20 + (0.27400761842727661) * gru_0_rev_t4_h_21 + (0.020948033779859543) * gru_0_rev_t4_h_22 + (-0.60347694158554077) * gru_0_rev_t4_h_23 + (-0.45191735029220581) * gru_0_rev_t4_h_24 + (0.37151339650154114) * gru_0_rev_t4_h_25 + (0.03189520537853241) * gru_0_rev_t4_h_26 + (-1.0924900770187378) * gru_0_rev_t4_h_27 + (-0.53877502679824829) * gru_0_rev_t4_h_28 + (-0.13070081174373627) * gru_0_rev_t4_h_29 + (-0.1489107608795166) * gru_0_rev_t4_h_30 + (-1.6452224254608154) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_7 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_7;
    // h=8
    gate_r = sigmoid((-0.088317222893238068) + (-0.29859715700149536) * emb_t3_0 + (0.59277522563934326) * emb_t3_1 + (-0.4380335807800293) * emb_t3_2 + (-0.35593768954277039) * emb_t3_3 + (0.26711726188659668) * emb_t3_4 + (-0.067696087062358856) * emb_t3_5 + (-0.09071805328130722) * emb_t3_6 + (0.085169240832328796) * emb_t3_7 + (0.37693926692008972) * emb_t3_8 + (-0.45889070630073547) * emb_t3_9 + (-0.59728115797042847) * emb_t3_10 + (0.070683427155017853) * emb_t3_11 + (0.6882970929145813) * emb_t3_12 + (0.7901725172996521) * emb_t3_13 + (-0.63566619157791138) * emb_t3_14 + (0.295259028673172) * emb_t3_15 + (-0.11202562600374222) * emb_t3_16 + (0.10295461118221283) * emb_t3_17 + (-0.43338054418563843) * emb_t3_18 + (0.82146245241165161) * emb_t3_19 + (-0.51971602439880371) * emb_t3_20 + (0.018043039366602898) * emb_t3_21 + (-1.2643245458602905) * emb_t3_22 + (-0.088630355894565582) * emb_t3_23 + (-0.6161695122718811) * emb_t3_24 + (-0.53258198499679565) * emb_t3_25 + (-0.12352132052183151) * emb_t3_26 + (0.53737556934356689) * emb_t3_27 + (-0.31555074453353882) * emb_t3_28 + (0.64074826240539551) * emb_t3_29 + (-0.18776631355285645) * emb_t3_30 + (-0.63243919610977173) * emb_t3_31 + (0.62617415189743042) * gru_0_rev_t4_h_0 + (-0.16197025775909424) * gru_0_rev_t4_h_1 + (0.29004648327827454) * gru_0_rev_t4_h_2 + (-0.28624910116195679) * gru_0_rev_t4_h_3 + (-0.0020366625394672155) * gru_0_rev_t4_h_4 + (0.041773896664381027) * gru_0_rev_t4_h_5 + (0.035124368965625763) * gru_0_rev_t4_h_6 + (-0.17997060716152191) * gru_0_rev_t4_h_7 + (-0.28906926512718201) * gru_0_rev_t4_h_8 + (-0.36779206991195679) * gru_0_rev_t4_h_9 + (2.4502434730529785) * gru_0_rev_t4_h_10 + (-0.52541321516036987) * gru_0_rev_t4_h_11 + (-0.23546339571475983) * gru_0_rev_t4_h_12 + (-0.20954269170761108) * gru_0_rev_t4_h_13 + (-0.92633366584777832) * gru_0_rev_t4_h_14 + (-0.32826125621795654) * gru_0_rev_t4_h_15 + (-0.57394957542419434) * gru_0_rev_t4_h_16 + (0.4408237636089325) * gru_0_rev_t4_h_17 + (0.40594840049743652) * gru_0_rev_t4_h_18 + (0.032615821808576584) * gru_0_rev_t4_h_19 + (-0.1298442929983139) * gru_0_rev_t4_h_20 + (-0.15392215549945831) * gru_0_rev_t4_h_21 + (-0.16348840296268463) * gru_0_rev_t4_h_22 + (1.5557247400283813) * gru_0_rev_t4_h_23 + (1.3015639781951904) * gru_0_rev_t4_h_24 + (0.69812560081481934) * gru_0_rev_t4_h_25 + (0.18641066551208496) * gru_0_rev_t4_h_26 + (0.23763065040111542) * gru_0_rev_t4_h_27 + (3.2693886756896973) * gru_0_rev_t4_h_28 + (0.5948219895362854) * gru_0_rev_t4_h_29 + (-0.77733880281448364) * gru_0_rev_t4_h_30 + (-2.2952201366424561) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((1.7676719427108765) + (-0.00023765943478792906) * emb_t3_0 + (-0.67883878946304321) * emb_t3_1 + (0.019546473398804665) * emb_t3_2 + (0.57504260540008545) * emb_t3_3 + (-0.56773644685745239) * emb_t3_4 + (-0.038961723446846008) * emb_t3_5 + (-0.59113162755966187) * emb_t3_6 + (-0.053194526582956314) * emb_t3_7 + (0.73442691564559937) * emb_t3_8 + (-0.065437562763690948) * emb_t3_9 + (-0.70704537630081177) * emb_t3_10 + (1.3342037200927734) * emb_t3_11 + (0.54119563102722168) * emb_t3_12 + (-0.26398104429244995) * emb_t3_13 + (-0.044033762067556381) * emb_t3_14 + (0.0056064622476696968) * emb_t3_15 + (-0.024803906679153442) * emb_t3_16 + (-0.90262460708618164) * emb_t3_17 + (-0.18564625084400177) * emb_t3_18 + (0.4561082124710083) * emb_t3_19 + (0.85451072454452515) * emb_t3_20 + (-0.053171802312135696) * emb_t3_21 + (-0.83141034841537476) * emb_t3_22 + (0.027176834642887115) * emb_t3_23 + (-0.063192494213581085) * emb_t3_24 + (0.055789001286029816) * emb_t3_25 + (0.82528162002563477) * emb_t3_26 + (0.0019977150950580835) * emb_t3_27 + (0.062262360006570816) * emb_t3_28 + (-0.41623932123184204) * emb_t3_29 + (0.8691137433052063) * emb_t3_30 + (-0.74443256855010986) * emb_t3_31 + (0.4341684877872467) * gru_0_rev_t4_h_0 + (0.031590636819601059) * gru_0_rev_t4_h_1 + (0.33133596181869507) * gru_0_rev_t4_h_2 + (0.32885575294494629) * gru_0_rev_t4_h_3 + (-0.051725134253501892) * gru_0_rev_t4_h_4 + (-0.22603708505630493) * gru_0_rev_t4_h_5 + (-0.030123105272650719) * gru_0_rev_t4_h_6 + (0.5195155143737793) * gru_0_rev_t4_h_7 + (0.091428652405738831) * gru_0_rev_t4_h_8 + (0.32979577779769897) * gru_0_rev_t4_h_9 + (-0.524372398853302) * gru_0_rev_t4_h_10 + (-0.20191121101379395) * gru_0_rev_t4_h_11 + (0.36239379644393921) * gru_0_rev_t4_h_12 + (0.38666456937789917) * gru_0_rev_t4_h_13 + (-0.55470597743988037) * gru_0_rev_t4_h_14 + (-1.0592482089996338) * gru_0_rev_t4_h_15 + (-0.088621601462364197) * gru_0_rev_t4_h_16 + (0.22369356453418732) * gru_0_rev_t4_h_17 + (0.34317123889923096) * gru_0_rev_t4_h_18 + (0.3642844557762146) * gru_0_rev_t4_h_19 + (0.068334683775901794) * gru_0_rev_t4_h_20 + (0.17198368906974792) * gru_0_rev_t4_h_21 + (0.37937608361244202) * gru_0_rev_t4_h_22 + (-0.2613385021686554) * gru_0_rev_t4_h_23 + (0.13427364826202393) * gru_0_rev_t4_h_24 + (-0.0045855510979890823) * gru_0_rev_t4_h_25 + (-0.27998852729797363) * gru_0_rev_t4_h_26 + (-0.24751241505146027) * gru_0_rev_t4_h_27 + (4.2543282508850098) * gru_0_rev_t4_h_28 + (2.6005380153656006) * gru_0_rev_t4_h_29 + (-0.17552550137042999) * gru_0_rev_t4_h_30 + (-0.52563506364822388) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.11516551673412323) + (-0.30722233653068542) * emb_t3_0 + (0.21935297548770905) * emb_t3_1 + (-0.10048635303974152) * emb_t3_2 + (0.60413885116577148) * emb_t3_3 + (-0.00069453363539651036) * emb_t3_4 + (-0.060450449585914612) * emb_t3_5 + (0.4743863046169281) * emb_t3_6 + (0.35428830981254578) * emb_t3_7 + (0.89534968137741089) * emb_t3_8 + (-1.1169939041137695) * emb_t3_9 + (-0.90294241905212402) * emb_t3_10 + (0.3525691032409668) * emb_t3_11 + (0.91655135154724121) * emb_t3_12 + (0.38453042507171631) * emb_t3_13 + (0.27479523420333862) * emb_t3_14 + (-0.021351942792534828) * emb_t3_15 + (-0.36118367314338684) * emb_t3_16 + (0.3721655011177063) * emb_t3_17 + (-1.381151556968689) * emb_t3_18 + (1.558931827545166) * emb_t3_19 + (0.24192021787166595) * emb_t3_20 + (0.19281555712223053) * emb_t3_21 + (-2.0417885780334473) * emb_t3_22 + (0.18458203971385956) * emb_t3_23 + (0.38974288105964661) * emb_t3_24 + (0.071693979203701019) * emb_t3_25 + (0.37011626362800598) * emb_t3_26 + (-0.72757446765899658) * emb_t3_27 + (-0.70288264751434326) * emb_t3_28 + (-0.043969228863716125) * emb_t3_29 + (-0.49711495637893677) * emb_t3_30 + (-0.20480358600616455) * emb_t3_31 + gate_r * ((-0.068669766187667847) + (1.045810341835022) * gru_0_rev_t4_h_0 + (0.22553922235965729) * gru_0_rev_t4_h_1 + (0.27877417206764221) * gru_0_rev_t4_h_2 + (0.12600564956665039) * gru_0_rev_t4_h_3 + (-0.27317756414413452) * gru_0_rev_t4_h_4 + (0.099178388714790344) * gru_0_rev_t4_h_5 + (-0.16373594105243683) * gru_0_rev_t4_h_6 + (-1.4425332546234131) * gru_0_rev_t4_h_7 + (-0.39900258183479309) * gru_0_rev_t4_h_8 + (0.075282633304595947) * gru_0_rev_t4_h_9 + (2.6329457759857178) * gru_0_rev_t4_h_10 + (0.058665905147790909) * gru_0_rev_t4_h_11 + (-0.024100221693515778) * gru_0_rev_t4_h_12 + (0.10941191762685776) * gru_0_rev_t4_h_13 + (0.51433193683624268) * gru_0_rev_t4_h_14 + (-0.083181008696556091) * gru_0_rev_t4_h_15 + (-0.30437901616096497) * gru_0_rev_t4_h_16 + (0.35483658313751221) * gru_0_rev_t4_h_17 + (0.3343537449836731) * gru_0_rev_t4_h_18 + (-0.27165552973747253) * gru_0_rev_t4_h_19 + (0.21938556432723999) * gru_0_rev_t4_h_20 + (0.083546444773674011) * gru_0_rev_t4_h_21 + (-0.20614944398403168) * gru_0_rev_t4_h_22 + (-0.90260946750640869) * gru_0_rev_t4_h_23 + (2.0459318161010742) * gru_0_rev_t4_h_24 + (0.37966838479042053) * gru_0_rev_t4_h_25 + (0.44350579380989075) * gru_0_rev_t4_h_26 + (0.2263934463262558) * gru_0_rev_t4_h_27 + (2.6458022594451904) * gru_0_rev_t4_h_28 + (1.0511258840560913) * gru_0_rev_t4_h_29 + (-0.72365152835845947) * gru_0_rev_t4_h_30 + (-1.4416626691818237) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_8 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_8;
    // h=9
    gate_r = sigmoid((0.9948272705078125) + (-0.15560701489448547) * emb_t3_0 + (0.93296557664871216) * emb_t3_1 + (-0.29702147841453552) * emb_t3_2 + (0.0034452064428478479) * emb_t3_3 + (0.37517359852790833) * emb_t3_4 + (0.62616831064224243) * emb_t3_5 + (0.54468649625778198) * emb_t3_6 + (-2.6662132740020752) * emb_t3_7 + (3.7957842350006104) * emb_t3_8 + (-1.1920335292816162) * emb_t3_9 + (-1.2930651903152466) * emb_t3_10 + (0.77808529138565063) * emb_t3_11 + (7.5570454597473145) * emb_t3_12 + (0.56379145383834839) * emb_t3_13 + (-0.25856849551200867) * emb_t3_14 + (0.26747101545333862) * emb_t3_15 + (-0.49149933457374573) * emb_t3_16 + (0.32623070478439331) * emb_t3_17 + (-1.2964415550231934) * emb_t3_18 + (1.7554880380630493) * emb_t3_19 + (-0.023007405921816826) * emb_t3_20 + (0.77137076854705811) * emb_t3_21 + (-4.7274293899536133) * emb_t3_22 + (-0.35579517483711243) * emb_t3_23 + (-0.098790682852268219) * emb_t3_24 + (-0.97251492738723755) * emb_t3_25 + (-0.14317280054092407) * emb_t3_26 + (-0.80601811408996582) * emb_t3_27 + (-0.23854458332061768) * emb_t3_28 + (0.3480689525604248) * emb_t3_29 + (-0.079403534531593323) * emb_t3_30 + (-2.862332820892334) * emb_t3_31 + (-0.33036631345748901) * gru_0_rev_t4_h_0 + (0.45379176735877991) * gru_0_rev_t4_h_1 + (0.4288698136806488) * gru_0_rev_t4_h_2 + (-0.45173758268356323) * gru_0_rev_t4_h_3 + (-0.56834709644317627) * gru_0_rev_t4_h_4 + (0.45033958554267883) * gru_0_rev_t4_h_5 + (-0.26429811120033264) * gru_0_rev_t4_h_6 + (1.1013802289962769) * gru_0_rev_t4_h_7 + (0.57711982727050781) * gru_0_rev_t4_h_8 + (-0.43285039067268372) * gru_0_rev_t4_h_9 + (0.99901467561721802) * gru_0_rev_t4_h_10 + (-0.37200263142585754) * gru_0_rev_t4_h_11 + (-0.35222119092941284) * gru_0_rev_t4_h_12 + (-0.42447978258132935) * gru_0_rev_t4_h_13 + (-0.35462626814842224) * gru_0_rev_t4_h_14 + (0.01230945810675621) * gru_0_rev_t4_h_15 + (-0.94778966903686523) * gru_0_rev_t4_h_16 + (0.72926455736160278) * gru_0_rev_t4_h_17 + (0.16774776577949524) * gru_0_rev_t4_h_18 + (-0.42764866352081299) * gru_0_rev_t4_h_19 + (-0.3535827100276947) * gru_0_rev_t4_h_20 + (0.63479304313659668) * gru_0_rev_t4_h_21 + (0.064777255058288574) * gru_0_rev_t4_h_22 + (-0.030379192903637886) * gru_0_rev_t4_h_23 + (0.41131207346916199) * gru_0_rev_t4_h_24 + (0.77693986892700195) * gru_0_rev_t4_h_25 + (0.58052581548690796) * gru_0_rev_t4_h_26 + (-0.35305911302566528) * gru_0_rev_t4_h_27 + (-0.089263051748275757) * gru_0_rev_t4_h_28 + (-0.11678925901651382) * gru_0_rev_t4_h_29 + (-0.54261136054992676) * gru_0_rev_t4_h_30 + (0.61902374029159546) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((0.37533152103424072) + (-0.030614938586950302) * emb_t3_0 + (1.6962347030639648) * emb_t3_1 + (0.15319781005382538) * emb_t3_2 + (0.27374917268753052) * emb_t3_3 + (0.72963517904281616) * emb_t3_4 + (-0.11105795204639435) * emb_t3_5 + (0.23851336538791656) * emb_t3_6 + (-0.067529633641242981) * emb_t3_7 + (0.30174866318702698) * emb_t3_8 + (-2.0908222198486328) * emb_t3_9 + (-1.0966730117797852) * emb_t3_10 + (0.60387927293777466) * emb_t3_11 + (0.29930877685546875) * emb_t3_12 + (0.98631161451339722) * emb_t3_13 + (0.0058492203243076801) * emb_t3_14 + (-0.049653958529233932) * emb_t3_15 + (0.13023962080478668) * emb_t3_16 + (0.07884661853313446) * emb_t3_17 + (-0.42228594422340393) * emb_t3_18 + (1.0615423917770386) * emb_t3_19 + (-0.13277958333492279) * emb_t3_20 + (0.010803588666021824) * emb_t3_21 + (-0.48536893725395203) * emb_t3_22 + (0.055356647819280624) * emb_t3_23 + (-0.063386350870132446) * emb_t3_24 + (-0.25398683547973633) * emb_t3_25 + (-0.22189944982528687) * emb_t3_26 + (0.048635315150022507) * emb_t3_27 + (-0.90204781293869019) * emb_t3_28 + (1.1696432828903198) * emb_t3_29 + (-0.25330430269241333) * emb_t3_30 + (0.17070676386356354) * emb_t3_31 + (-0.065395481884479523) * gru_0_rev_t4_h_0 + (-0.40669092535972595) * gru_0_rev_t4_h_1 + (0.20278750360012054) * gru_0_rev_t4_h_2 + (-0.67577540874481201) * gru_0_rev_t4_h_3 + (-0.36952322721481323) * gru_0_rev_t4_h_4 + (0.45765706896781921) * gru_0_rev_t4_h_5 + (0.7733466625213623) * gru_0_rev_t4_h_6 + (-0.30216634273529053) * gru_0_rev_t4_h_7 + (-0.48941141366958618) * gru_0_rev_t4_h_8 + (-0.70608770847320557) * gru_0_rev_t4_h_9 + (0.21633316576480865) * gru_0_rev_t4_h_10 + (0.017328379675745964) * gru_0_rev_t4_h_11 + (-0.64473414421081543) * gru_0_rev_t4_h_12 + (-0.79716402292251587) * gru_0_rev_t4_h_13 + (-0.71458137035369873) * gru_0_rev_t4_h_14 + (-0.16558457911014557) * gru_0_rev_t4_h_15 + (-0.47774955630302429) * gru_0_rev_t4_h_16 + (0.51722991466522217) * gru_0_rev_t4_h_17 + (0.24065205454826355) * gru_0_rev_t4_h_18 + (-0.42887350916862488) * gru_0_rev_t4_h_19 + (-0.29276555776596069) * gru_0_rev_t4_h_20 + (-0.34935054183006287) * gru_0_rev_t4_h_21 + (0.13584330677986145) * gru_0_rev_t4_h_22 + (-0.77710241079330444) * gru_0_rev_t4_h_23 + (-0.6899954080581665) * gru_0_rev_t4_h_24 + (0.52415382862091064) * gru_0_rev_t4_h_25 + (0.50599747896194458) * gru_0_rev_t4_h_26 + (-1.6090726852416992) * gru_0_rev_t4_h_27 + (-0.68330579996109009) * gru_0_rev_t4_h_28 + (-0.22142037749290466) * gru_0_rev_t4_h_29 + (-0.68026524782180786) * gru_0_rev_t4_h_30 + (0.54192692041397095) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.23018018901348114) + (0.040882468223571777) * emb_t3_0 + (0.017970947548747063) * emb_t3_1 + (-0.059332888573408127) * emb_t3_2 + (-0.55593621730804443) * emb_t3_3 + (-0.28659060597419739) * emb_t3_4 + (0.073795787990093231) * emb_t3_5 + (-0.15439136326313019) * emb_t3_6 + (0.40341395139694214) * emb_t3_7 + (1.1105508804321289) * emb_t3_8 + (-0.0077962786890566349) * emb_t3_9 + (-0.59185028076171875) * emb_t3_10 + (0.29747265577316284) * emb_t3_11 + (0.81642383337020874) * emb_t3_12 + (-0.388226717710495) * emb_t3_13 + (-0.094587624073028564) * emb_t3_14 + (-0.055437855422496796) * emb_t3_15 + (-0.36119735240936279) * emb_t3_16 + (-0.055192776024341583) * emb_t3_17 + (-0.8903014063835144) * emb_t3_18 + (0.59483474493026733) * emb_t3_19 + (0.041678100824356079) * emb_t3_20 + (0.008398003876209259) * emb_t3_21 + (-0.68829488754272461) * emb_t3_22 + (0.36530813574790955) * emb_t3_23 + (0.17174878716468811) * emb_t3_24 + (0.17922626435756683) * emb_t3_25 + (0.15266311168670654) * emb_t3_26 + (-0.17142131924629211) * emb_t3_27 + (-0.35156989097595215) * emb_t3_28 + (0.22318530082702637) * emb_t3_29 + (0.48994293808937073) * emb_t3_30 + (-0.92399001121520996) * emb_t3_31 + gate_r * ((0.96686816215515137) + (-0.48653674125671387) * gru_0_rev_t4_h_0 + (0.036449111998081207) * gru_0_rev_t4_h_1 + (-0.055406101047992706) * gru_0_rev_t4_h_2 + (0.050759457051753998) * gru_0_rev_t4_h_3 + (0.074713461101055145) * gru_0_rev_t4_h_4 + (0.21921283006668091) * gru_0_rev_t4_h_5 + (-0.27963429689407349) * gru_0_rev_t4_h_6 + (-0.89817965030670166) * gru_0_rev_t4_h_7 + (0.12752449512481689) * gru_0_rev_t4_h_8 + (-0.014859331771731377) * gru_0_rev_t4_h_9 + (-0.45467722415924072) * gru_0_rev_t4_h_10 + (-0.043476864695549011) * gru_0_rev_t4_h_11 + (-0.055452924221754074) * gru_0_rev_t4_h_12 + (0.018106590956449509) * gru_0_rev_t4_h_13 + (0.44886025786399841) * gru_0_rev_t4_h_14 + (0.5860898494720459) * gru_0_rev_t4_h_15 + (0.43164139986038208) * gru_0_rev_t4_h_16 + (-0.40332496166229248) * gru_0_rev_t4_h_17 + (-0.35233530402183533) * gru_0_rev_t4_h_18 + (0.037796162068843842) * gru_0_rev_t4_h_19 + (0.079951688647270203) * gru_0_rev_t4_h_20 + (0.20511813461780548) * gru_0_rev_t4_h_21 + (0.0059912754222750664) * gru_0_rev_t4_h_22 + (0.67916035652160645) * gru_0_rev_t4_h_23 + (-0.20231929421424866) * gru_0_rev_t4_h_24 + (-0.69970041513442993) * gru_0_rev_t4_h_25 + (-0.1322803795337677) * gru_0_rev_t4_h_26 + (0.60638254880905151) * gru_0_rev_t4_h_27 + (0.19018220901489258) * gru_0_rev_t4_h_28 + (0.114395372569561) * gru_0_rev_t4_h_29 + (-0.0091315433382987976) * gru_0_rev_t4_h_30 + (-1.0583988428115845) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_9 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_9;
    // h=10
    gate_r = sigmoid((0.88041150569915771) + (-0.33314657211303711) * emb_t3_0 + (-0.061852548271417618) * emb_t3_1 + (0.15153881907463074) * emb_t3_2 + (0.73445171117782593) * emb_t3_3 + (-1.0025272369384766) * emb_t3_4 + (0.013858617283403873) * emb_t3_5 + (-0.65061432123184204) * emb_t3_6 + (0.1410490870475769) * emb_t3_7 + (0.62026971578598022) * emb_t3_8 + (0.11467281728982925) * emb_t3_9 + (0.28752008080482483) * emb_t3_10 + (0.80265837907791138) * emb_t3_11 + (1.5358299016952515) * emb_t3_12 + (-1.0008670091629028) * emb_t3_13 + (-0.91726851463317871) * emb_t3_14 + (0.20866914093494415) * emb_t3_15 + (-0.65957295894622803) * emb_t3_16 + (-0.40234485268592834) * emb_t3_17 + (-0.49843314290046692) * emb_t3_18 + (0.29021480679512024) * emb_t3_19 + (0.49456650018692017) * emb_t3_20 + (0.17322084307670593) * emb_t3_21 + (-0.30176076292991638) * emb_t3_22 + (-0.17468239367008209) * emb_t3_23 + (-0.15749503672122955) * emb_t3_24 + (0.41441875696182251) * emb_t3_25 + (0.78653347492218018) * emb_t3_26 + (-0.81280392408370972) * emb_t3_27 + (0.50572609901428223) * emb_t3_28 + (-0.55641835927963257) * emb_t3_29 + (1.1146214008331299) * emb_t3_30 + (-0.57240164279937744) * emb_t3_31 + (0.37582162022590637) * gru_0_rev_t4_h_0 + (-0.56848663091659546) * gru_0_rev_t4_h_1 + (-0.3927619457244873) * gru_0_rev_t4_h_2 + (0.27896291017532349) * gru_0_rev_t4_h_3 + (-0.33511233329772949) * gru_0_rev_t4_h_4 + (-0.65476018190383911) * gru_0_rev_t4_h_5 + (0.35148382186889648) * gru_0_rev_t4_h_6 + (3.0000004768371582) * gru_0_rev_t4_h_7 + (0.35487645864486694) * gru_0_rev_t4_h_8 + (-0.021676624193787575) * gru_0_rev_t4_h_9 + (2.6084620952606201) * gru_0_rev_t4_h_10 + (0.24674332141876221) * gru_0_rev_t4_h_11 + (0.18019342422485352) * gru_0_rev_t4_h_12 + (-0.085849247872829437) * gru_0_rev_t4_h_13 + (-0.14005902409553528) * gru_0_rev_t4_h_14 + (0.081243075430393219) * gru_0_rev_t4_h_15 + (4.6623001098632812) * gru_0_rev_t4_h_16 + (-3.283299446105957) * gru_0_rev_t4_h_17 + (0.054675314575433731) * gru_0_rev_t4_h_18 + (0.53612655401229858) * gru_0_rev_t4_h_19 + (2.5621414184570312) * gru_0_rev_t4_h_20 + (0.01807616651058197) * gru_0_rev_t4_h_21 + (-1.5238802433013916) * gru_0_rev_t4_h_22 + (1.733642578125) * gru_0_rev_t4_h_23 + (2.8208439350128174) * gru_0_rev_t4_h_24 + (-5.5182070732116699) * gru_0_rev_t4_h_25 + (0.00088173930998891592) * gru_0_rev_t4_h_26 + (2.2334170341491699) * gru_0_rev_t4_h_27 + (-0.05094292014837265) * gru_0_rev_t4_h_28 + (-0.21899732947349548) * gru_0_rev_t4_h_29 + (0.19660782814025879) * gru_0_rev_t4_h_30 + (0.91329765319824219) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((0.94025146961212158) + (-0.055128280073404312) * emb_t3_0 + (-0.38388177752494812) * emb_t3_1 + (-0.0075555485673248768) * emb_t3_2 + (0.45786809921264648) * emb_t3_3 + (-0.768807053565979) * emb_t3_4 + (0.048790626227855682) * emb_t3_5 + (-0.82025003433227539) * emb_t3_6 + (0.054189302027225494) * emb_t3_7 + (0.21040645241737366) * emb_t3_8 + (-0.17354248464107513) * emb_t3_9 + (-0.39329808950424194) * emb_t3_10 + (0.88528746366500854) * emb_t3_11 + (0.37616336345672607) * emb_t3_12 + (-0.16758330166339874) * emb_t3_13 + (0.0810728520154953) * emb_t3_14 + (-0.067571081221103668) * emb_t3_15 + (-0.034666981548070908) * emb_t3_16 + (-0.81840217113494873) * emb_t3_17 + (-0.56302231550216675) * emb_t3_18 + (-0.20403428375720978) * emb_t3_19 + (0.40622910857200623) * emb_t3_20 + (-0.0047821858897805214) * emb_t3_21 + (-0.38002270460128784) * emb_t3_22 + (-0.041609831154346466) * emb_t3_23 + (0.0048080887645483017) * emb_t3_24 + (0.11000420898199081) * emb_t3_25 + (0.61589086055755615) * emb_t3_26 + (0.030096324160695076) * emb_t3_27 + (0.23305623233318329) * emb_t3_28 + (-0.50568485260009766) * emb_t3_29 + (0.86426627635955811) * emb_t3_30 + (-0.34773877263069153) * emb_t3_31 + (-0.24720610678195953) * gru_0_rev_t4_h_0 + (0.57130897045135498) * gru_0_rev_t4_h_1 + (-0.083969265222549438) * gru_0_rev_t4_h_2 + (-0.089153103530406952) * gru_0_rev_t4_h_3 + (0.45026677846908569) * gru_0_rev_t4_h_4 + (-0.10256867855787277) * gru_0_rev_t4_h_5 + (0.055366136133670807) * gru_0_rev_t4_h_6 + (1.5807949304580688) * gru_0_rev_t4_h_7 + (-0.13186173141002655) * gru_0_rev_t4_h_8 + (-0.15778392553329468) * gru_0_rev_t4_h_9 + (-0.26837974786758423) * gru_0_rev_t4_h_10 + (0.068723224103450775) * gru_0_rev_t4_h_11 + (-0.11840256303548813) * gru_0_rev_t4_h_12 + (-0.11369362473487854) * gru_0_rev_t4_h_13 + (-2.4821617603302002) * gru_0_rev_t4_h_14 + (0.52796751260757446) * gru_0_rev_t4_h_15 + (-0.46477913856506348) * gru_0_rev_t4_h_16 + (0.34198692440986633) * gru_0_rev_t4_h_17 + (-0.24040165543556213) * gru_0_rev_t4_h_18 + (0.051991015672683716) * gru_0_rev_t4_h_19 + (-0.57912135124206543) * gru_0_rev_t4_h_20 + (-0.39821410179138184) * gru_0_rev_t4_h_21 + (0.019327882677316666) * gru_0_rev_t4_h_22 + (-0.21481029689311981) * gru_0_rev_t4_h_23 + (0.39889144897460938) * gru_0_rev_t4_h_24 + (0.26065635681152344) * gru_0_rev_t4_h_25 + (-0.39521080255508423) * gru_0_rev_t4_h_26 + (-0.69795686006546021) * gru_0_rev_t4_h_27 + (0.11574947834014893) * gru_0_rev_t4_h_28 + (-0.39468258619308472) * gru_0_rev_t4_h_29 + (-0.12830539047718048) * gru_0_rev_t4_h_30 + (-2.4387886524200439) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.050970137119293213) + (-0.0084421355277299881) * emb_t3_0 + (0.25063276290893555) * emb_t3_1 + (0.004513672087341547) * emb_t3_2 + (-0.1969171017408371) * emb_t3_3 + (0.33182415366172791) * emb_t3_4 + (0.052020303905010223) * emb_t3_5 + (0.076562628149986267) * emb_t3_6 + (0.12660343945026398) * emb_t3_7 + (0.14278951287269592) * emb_t3_8 + (-0.047504980117082596) * emb_t3_9 + (0.12127996981143951) * emb_t3_10 + (-0.045387797057628632) * emb_t3_11 + (0.19630531966686249) * emb_t3_12 + (0.27372300624847412) * emb_t3_13 + (-0.048866834491491318) * emb_t3_14 + (-0.053699858486652374) * emb_t3_15 + (0.0095550818368792534) * emb_t3_16 + (0.14115393161773682) * emb_t3_17 + (0.45962423086166382) * emb_t3_18 + (-0.20257261395454407) * emb_t3_19 + (-0.1729653924703598) * emb_t3_20 + (-0.088452346622943878) * emb_t3_21 + (-0.010871979407966137) * emb_t3_22 + (0.050594594329595566) * emb_t3_23 + (-0.030299292877316475) * emb_t3_24 + (0.10581396520137787) * emb_t3_25 + (0.051439329981803894) * emb_t3_26 + (-0.010545365512371063) * emb_t3_27 + (-0.25608080625534058) * emb_t3_28 + (0.19220797717571259) * emb_t3_29 + (-0.053969398140907288) * emb_t3_30 + (0.19188903272151947) * emb_t3_31 + gate_r * ((-0.063596904277801514) + (0.11555033922195435) * gru_0_rev_t4_h_0 + (0.74510228633880615) * gru_0_rev_t4_h_1 + (0.51603114604949951) * gru_0_rev_t4_h_2 + (0.13425399363040924) * gru_0_rev_t4_h_3 + (-0.11020798236131668) * gru_0_rev_t4_h_4 + (0.3724333643913269) * gru_0_rev_t4_h_5 + (-0.31523925065994263) * gru_0_rev_t4_h_6 + (-0.24684545397758484) * gru_0_rev_t4_h_7 + (-0.35091191530227661) * gru_0_rev_t4_h_8 + (0.15537343919277191) * gru_0_rev_t4_h_9 + (-0.6342729926109314) * gru_0_rev_t4_h_10 + (-0.71345824003219604) * gru_0_rev_t4_h_11 + (-0.083758071064949036) * gru_0_rev_t4_h_12 + (0.094321653246879578) * gru_0_rev_t4_h_13 + (1.2081514596939087) * gru_0_rev_t4_h_14 + (-0.51926213502883911) * gru_0_rev_t4_h_15 + (0.051160413771867752) * gru_0_rev_t4_h_16 + (0.37092563509941101) * gru_0_rev_t4_h_17 + (0.33427786827087402) * gru_0_rev_t4_h_18 + (-0.45640766620635986) * gru_0_rev_t4_h_19 + (-0.6903424859046936) * gru_0_rev_t4_h_20 + (0.78131663799285889) * gru_0_rev_t4_h_21 + (0.096044473350048065) * gru_0_rev_t4_h_22 + (-0.0063566900789737701) * gru_0_rev_t4_h_23 + (-1.0714023113250732) * gru_0_rev_t4_h_24 + (0.23617559671401978) * gru_0_rev_t4_h_25 + (0.1633574366569519) * gru_0_rev_t4_h_26 + (-1.3664042949676514) * gru_0_rev_t4_h_27 + (-0.61340934038162231) * gru_0_rev_t4_h_28 + (-0.016778977587819099) * gru_0_rev_t4_h_29 + (0.075385689735412598) * gru_0_rev_t4_h_30 + (1.0953154563903809) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_10 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_10;
    // h=11
    gate_r = sigmoid((-0.088519908487796783) + (-0.42864495515823364) * emb_t3_0 + (0.7868722677230835) * emb_t3_1 + (-0.34357810020446777) * emb_t3_2 + (0.073531664907932281) * emb_t3_3 + (0.11682534962892532) * emb_t3_4 + (0.1238856241106987) * emb_t3_5 + (0.18413998186588287) * emb_t3_6 + (-1.8615565299987793) * emb_t3_7 + (0.93350785970687866) * emb_t3_8 + (0.19804410636425018) * emb_t3_9 + (0.33198854327201843) * emb_t3_10 + (0.046571392565965652) * emb_t3_11 + (1.0062586069107056) * emb_t3_12 + (-0.054774396121501923) * emb_t3_13 + (-0.21212901175022125) * emb_t3_14 + (-0.43435359001159668) * emb_t3_15 + (-0.06130300834774971) * emb_t3_16 + (0.41468393802642822) * emb_t3_17 + (-0.10650640726089478) * emb_t3_18 + (-0.25482472777366638) * emb_t3_19 + (-0.60928440093994141) * emb_t3_20 + (0.58590090274810791) * emb_t3_21 + (-1.3707834482192993) * emb_t3_22 + (0.13742563128471375) * emb_t3_23 + (0.35796582698822021) * emb_t3_24 + (0.42272579669952393) * emb_t3_25 + (0.12809407711029053) * emb_t3_26 + (-0.1792895644903183) * emb_t3_27 + (0.15057668089866638) * emb_t3_28 + (0.56269282102584839) * emb_t3_29 + (-0.28416174650192261) * emb_t3_30 + (-0.18545739352703094) * emb_t3_31 + (-0.52450227737426758) * gru_0_rev_t4_h_0 + (-0.49170643091201782) * gru_0_rev_t4_h_1 + (-0.42881661653518677) * gru_0_rev_t4_h_2 + (-0.12681812047958374) * gru_0_rev_t4_h_3 + (0.15041913092136383) * gru_0_rev_t4_h_4 + (-0.060731712728738785) * gru_0_rev_t4_h_5 + (0.43205425143241882) * gru_0_rev_t4_h_6 + (1.3533313274383545) * gru_0_rev_t4_h_7 + (0.23804718255996704) * gru_0_rev_t4_h_8 + (-0.52905625104904175) * gru_0_rev_t4_h_9 + (-0.19125188887119293) * gru_0_rev_t4_h_10 + (0.61348217725753784) * gru_0_rev_t4_h_11 + (0.057588085532188416) * gru_0_rev_t4_h_12 + (-0.073104962706565857) * gru_0_rev_t4_h_13 + (-1.6106152534484863) * gru_0_rev_t4_h_14 + (1.028748631477356) * gru_0_rev_t4_h_15 + (1.3377426862716675) * gru_0_rev_t4_h_16 + (-1.009540319442749) * gru_0_rev_t4_h_17 + (-1.9335154294967651) * gru_0_rev_t4_h_18 + (-0.27509790658950806) * gru_0_rev_t4_h_19 + (0.094396278262138367) * gru_0_rev_t4_h_20 + (-0.278694748878479) * gru_0_rev_t4_h_21 + (-0.87878197431564331) * gru_0_rev_t4_h_22 + (-0.52533465623855591) * gru_0_rev_t4_h_23 + (3.0889935493469238) * gru_0_rev_t4_h_24 + (-1.2695188522338867) * gru_0_rev_t4_h_25 + (0.11158113926649094) * gru_0_rev_t4_h_26 + (0.38616469502449036) * gru_0_rev_t4_h_27 + (2.0345416069030762) * gru_0_rev_t4_h_28 + (0.73288291692733765) * gru_0_rev_t4_h_29 + (-0.36438235640525818) * gru_0_rev_t4_h_30 + (-0.64026772975921631) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((1.7369898557662964) + (-0.012829374521970749) * emb_t3_0 + (-0.3034624457359314) * emb_t3_1 + (-0.018585545942187309) * emb_t3_2 + (0.40256702899932861) * emb_t3_3 + (-0.34696996212005615) * emb_t3_4 + (0.019062630832195282) * emb_t3_5 + (0.026088079437613487) * emb_t3_6 + (0.00062856113072484732) * emb_t3_7 + (1.0484764575958252) * emb_t3_8 + (-0.2815234363079071) * emb_t3_9 + (-0.54315048456192017) * emb_t3_10 + (0.43050926923751831) * emb_t3_11 + (0.41857770085334778) * emb_t3_12 + (0.19282424449920654) * emb_t3_13 + (0.0088970763608813286) * emb_t3_14 + (-0.01559915579855442) * emb_t3_15 + (0.0017699571326375008) * emb_t3_16 + (0.1569383442401886) * emb_t3_17 + (-0.083910614252090454) * emb_t3_18 + (0.14798794686794281) * emb_t3_19 + (0.5737144947052002) * emb_t3_20 + (-0.015245171263813972) * emb_t3_21 + (-0.18728677928447723) * emb_t3_22 + (0.019998202100396156) * emb_t3_23 + (0.0017829691059887409) * emb_t3_24 + (0.0033025036100298166) * emb_t3_25 + (0.037912268191576004) * emb_t3_26 + (-0.0052588833495974541) * emb_t3_27 + (-0.19140951335430145) * emb_t3_28 + (0.073352336883544922) * emb_t3_29 + (-0.29260814189910889) * emb_t3_30 + (-0.37189415097236633) * emb_t3_31 + (1.1653696298599243) * gru_0_rev_t4_h_0 + (-0.30127629637718201) * gru_0_rev_t4_h_1 + (0.5379260778427124) * gru_0_rev_t4_h_2 + (0.5191771388053894) * gru_0_rev_t4_h_3 + (-0.34840878844261169) * gru_0_rev_t4_h_4 + (0.52658861875534058) * gru_0_rev_t4_h_5 + (-0.32707387208938599) * gru_0_rev_t4_h_6 + (0.27267852425575256) * gru_0_rev_t4_h_7 + (1.0802546739578247) * gru_0_rev_t4_h_8 + (0.6144377589225769) * gru_0_rev_t4_h_9 + (-0.92711484432220459) * gru_0_rev_t4_h_10 + (-0.20005427300930023) * gru_0_rev_t4_h_11 + (0.50665616989135742) * gru_0_rev_t4_h_12 + (0.86161512136459351) * gru_0_rev_t4_h_13 + (-0.093426153063774109) * gru_0_rev_t4_h_14 + (-1.1513744592666626) * gru_0_rev_t4_h_15 + (-0.2620064914226532) * gru_0_rev_t4_h_16 + (-0.25931015610694885) * gru_0_rev_t4_h_17 + (1.3783576488494873) * gru_0_rev_t4_h_18 + (0.14820756018161774) * gru_0_rev_t4_h_19 + (0.40327391028404236) * gru_0_rev_t4_h_20 + (0.72830891609191895) * gru_0_rev_t4_h_21 + (-0.69288235902786255) * gru_0_rev_t4_h_22 + (0.87931126356124878) * gru_0_rev_t4_h_23 + (-0.18318454921245575) * gru_0_rev_t4_h_24 + (-0.1315414160490036) * gru_0_rev_t4_h_25 + (0.12363363802433014) * gru_0_rev_t4_h_26 + (0.18342964351177216) * gru_0_rev_t4_h_27 + (-0.98871219158172607) * gru_0_rev_t4_h_28 + (0.68603658676147461) * gru_0_rev_t4_h_29 + (0.3711206316947937) * gru_0_rev_t4_h_30 + (-0.78182774782180786) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.025761548429727554) + (0.069977223873138428) * emb_t3_0 + (0.20830993354320526) * emb_t3_1 + (0.14105051755905151) * emb_t3_2 + (-0.50288283824920654) * emb_t3_3 + (0.38622820377349854) * emb_t3_4 + (-0.057550672441720963) * emb_t3_5 + (0.48497274518013) * emb_t3_6 + (0.084617651998996735) * emb_t3_7 + (0.38710039854049683) * emb_t3_8 + (-0.64426285028457642) * emb_t3_9 + (-0.82916635274887085) * emb_t3_10 + (0.35207411646842957) * emb_t3_11 + (0.1262006014585495) * emb_t3_12 + (0.90183573961257935) * emb_t3_13 + (0.1929076611995697) * emb_t3_14 + (-0.18534901738166809) * emb_t3_15 + (-0.1705472469329834) * emb_t3_16 + (0.10561834275722504) * emb_t3_17 + (-0.75537437200546265) * emb_t3_18 + (0.57868236303329468) * emb_t3_19 + (-0.10405415296554565) * emb_t3_20 + (-0.010821156203746796) * emb_t3_21 + (-0.23685908317565918) * emb_t3_22 + (-0.039659082889556885) * emb_t3_23 + (0.10234694927930832) * emb_t3_24 + (-0.30255493521690369) * emb_t3_25 + (-0.33071556687355042) * emb_t3_26 + (-0.021039482206106186) * emb_t3_27 + (-0.34970936179161072) * emb_t3_28 + (1.241974949836731) * emb_t3_29 + (-0.97688531875610352) * emb_t3_30 + (-0.37848377227783203) * emb_t3_31 + gate_r * ((0.049158003181219101) + (-2.5199196338653564) * gru_0_rev_t4_h_0 + (-0.1532285064458847) * gru_0_rev_t4_h_1 + (-0.28990978002548218) * gru_0_rev_t4_h_2 + (0.21891331672668457) * gru_0_rev_t4_h_3 + (1.3632622957229614) * gru_0_rev_t4_h_4 + (-0.56353622674942017) * gru_0_rev_t4_h_5 + (0.24899974465370178) * gru_0_rev_t4_h_6 + (0.54435694217681885) * gru_0_rev_t4_h_7 + (-0.12521761655807495) * gru_0_rev_t4_h_8 + (-0.082278899848461151) * gru_0_rev_t4_h_9 + (0.065157122910022736) * gru_0_rev_t4_h_10 + (0.25670388340950012) * gru_0_rev_t4_h_11 + (0.22750470042228699) * gru_0_rev_t4_h_12 + (0.10440580546855927) * gru_0_rev_t4_h_13 + (-1.1531356573104858) * gru_0_rev_t4_h_14 + (1.1128920316696167) * gru_0_rev_t4_h_15 + (0.22253809869289398) * gru_0_rev_t4_h_16 + (-0.27949514985084534) * gru_0_rev_t4_h_17 + (-0.9801439642906189) * gru_0_rev_t4_h_18 + (0.13310952484607697) * gru_0_rev_t4_h_19 + (0.055367808789014816) * gru_0_rev_t4_h_20 + (-0.69082802534103394) * gru_0_rev_t4_h_21 + (-0.2825779914855957) * gru_0_rev_t4_h_22 + (-0.20035140216350555) * gru_0_rev_t4_h_23 + (0.709381103515625) * gru_0_rev_t4_h_24 + (-0.24176488816738129) * gru_0_rev_t4_h_25 + (-0.14128953218460083) * gru_0_rev_t4_h_26 + (0.56165432929992676) * gru_0_rev_t4_h_27 + (0.7360345721244812) * gru_0_rev_t4_h_28 + (0.28040635585784912) * gru_0_rev_t4_h_29 + (0.019601406529545784) * gru_0_rev_t4_h_30 + (-0.58079463243484497) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_11 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_11;
    // h=12
    gate_r = sigmoid((0.19926956295967102) + (-0.067331664264202118) * emb_t3_0 + (-0.74870485067367554) * emb_t3_1 + (0.87782996892929077) * emb_t3_2 + (0.31495362520217896) * emb_t3_3 + (-0.46559882164001465) * emb_t3_4 + (-0.10391244292259216) * emb_t3_5 + (-0.35722678899765015) * emb_t3_6 + (0.11593266576528549) * emb_t3_7 + (-0.61379820108413696) * emb_t3_8 + (0.68002063035964966) * emb_t3_9 + (0.903969407081604) * emb_t3_10 + (0.090398751199245453) * emb_t3_11 + (-1.0834028720855713) * emb_t3_12 + (-0.29198557138442993) * emb_t3_13 + (0.12228428572416306) * emb_t3_14 + (-0.053074423223733902) * emb_t3_15 + (0.56703066825866699) * emb_t3_16 + (-0.50466364622116089) * emb_t3_17 + (0.59465503692626953) * emb_t3_18 + (-0.84894925355911255) * emb_t3_19 + (0.16116119921207428) * emb_t3_20 + (0.081396572291851044) * emb_t3_21 + (1.1139926910400391) * emb_t3_22 + (-0.36552879214286804) * emb_t3_23 + (-0.31935560703277588) * emb_t3_24 + (0.69322383403778076) * emb_t3_25 + (0.12548811733722687) * emb_t3_26 + (0.37135154008865356) * emb_t3_27 + (0.26834577322006226) * emb_t3_28 + (-0.7400164008140564) * emb_t3_29 + (0.6406102180480957) * emb_t3_30 + (0.8193548321723938) * emb_t3_31 + (-1.152967095375061) * gru_0_rev_t4_h_0 + (-0.42618089914321899) * gru_0_rev_t4_h_1 + (-0.41477814316749573) * gru_0_rev_t4_h_2 + (0.4650803804397583) * gru_0_rev_t4_h_3 + (0.4746650755405426) * gru_0_rev_t4_h_4 + (-0.40200591087341309) * gru_0_rev_t4_h_5 + (0.37977620959281921) * gru_0_rev_t4_h_6 + (1.1922966241836548) * gru_0_rev_t4_h_7 + (0.12096361815929413) * gru_0_rev_t4_h_8 + (0.36775404214859009) * gru_0_rev_t4_h_9 + (-0.20184609293937683) * gru_0_rev_t4_h_10 + (0.5188327431678772) * gru_0_rev_t4_h_11 + (0.3690822422504425) * gru_0_rev_t4_h_12 + (0.28430989384651184) * gru_0_rev_t4_h_13 + (-1.165608286857605) * gru_0_rev_t4_h_14 + (0.1916331946849823) * gru_0_rev_t4_h_15 + (-0.1736333817243576) * gru_0_rev_t4_h_16 + (0.69475317001342773) * gru_0_rev_t4_h_17 + (0.58986818790435791) * gru_0_rev_t4_h_18 + (0.30341178178787231) * gru_0_rev_t4_h_19 + (0.33858805894851685) * gru_0_rev_t4_h_20 + (-0.33076784014701843) * gru_0_rev_t4_h_21 + (0.53841149806976318) * gru_0_rev_t4_h_22 + (1.5521508455276489) * gru_0_rev_t4_h_23 + (-0.15137939155101776) * gru_0_rev_t4_h_24 + (0.35671043395996094) * gru_0_rev_t4_h_25 + (-0.41138556599617004) * gru_0_rev_t4_h_26 + (-0.061208188533782959) * gru_0_rev_t4_h_27 + (-0.30568671226501465) * gru_0_rev_t4_h_28 + (1.1905635595321655) * gru_0_rev_t4_h_29 + (0.38567867875099182) * gru_0_rev_t4_h_30 + (-1.1514574289321899) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((0.37525436282157898) + (0.02873268723487854) * emb_t3_0 + (0.46333634853363037) * emb_t3_1 + (0.054666042327880859) * emb_t3_2 + (-0.15520849823951721) * emb_t3_3 + (-0.059237387031316757) * emb_t3_4 + (0.19809821248054504) * emb_t3_5 + (-0.059524267911911011) * emb_t3_6 + (0.00017535801453050226) * emb_t3_7 + (-0.24859246611595154) * emb_t3_8 + (-0.14470908045768738) * emb_t3_9 + (-0.27431604266166687) * emb_t3_10 + (0.27241688966751099) * emb_t3_11 + (0.021912628784775734) * emb_t3_12 + (0.1983388364315033) * emb_t3_13 + (0.04460076242685318) * emb_t3_14 + (-0.11417511105537415) * emb_t3_15 + (0.042615737766027451) * emb_t3_16 + (-0.15254925191402435) * emb_t3_17 + (-0.40131354331970215) * emb_t3_18 + (0.24146825075149536) * emb_t3_19 + (0.049813337624073029) * emb_t3_20 + (-0.084806904196739197) * emb_t3_21 + (-0.56833231449127197) * emb_t3_22 + (-0.080430969595909119) * emb_t3_23 + (0.11878390610218048) * emb_t3_24 + (-0.10057906061410904) * emb_t3_25 + (-0.1895512193441391) * emb_t3_26 + (-0.037268240004777908) * emb_t3_27 + (0.0044636367820203304) * emb_t3_28 + (0.18313175439834595) * emb_t3_29 + (0.0052720755338668823) * emb_t3_30 + (-0.40464058518409729) * emb_t3_31 + (0.2913953959941864) * gru_0_rev_t4_h_0 + (-0.81941401958465576) * gru_0_rev_t4_h_1 + (-0.5564042329788208) * gru_0_rev_t4_h_2 + (0.25269341468811035) * gru_0_rev_t4_h_3 + (0.20209775865077972) * gru_0_rev_t4_h_4 + (-0.51500815153121948) * gru_0_rev_t4_h_5 + (-0.061461549252271652) * gru_0_rev_t4_h_6 + (-0.77233684062957764) * gru_0_rev_t4_h_7 + (0.025002617388963699) * gru_0_rev_t4_h_8 + (0.018661594018340111) * gru_0_rev_t4_h_9 + (-0.36502650380134583) * gru_0_rev_t4_h_10 + (0.24471358954906464) * gru_0_rev_t4_h_11 + (0.18682549893856049) * gru_0_rev_t4_h_12 + (0.208945631980896) * gru_0_rev_t4_h_13 + (-1.1756341457366943) * gru_0_rev_t4_h_14 + (-0.25109323859214783) * gru_0_rev_t4_h_15 + (0.060894258320331573) * gru_0_rev_t4_h_16 + (-0.14090479910373688) * gru_0_rev_t4_h_17 + (0.14421434700489044) * gru_0_rev_t4_h_18 + (0.34605896472930908) * gru_0_rev_t4_h_19 + (0.29497864842414856) * gru_0_rev_t4_h_20 + (-0.41002354025840759) * gru_0_rev_t4_h_21 + (-0.018054341897368431) * gru_0_rev_t4_h_22 + (0.1549048125743866) * gru_0_rev_t4_h_23 + (-0.14631557464599609) * gru_0_rev_t4_h_24 + (0.004433823749423027) * gru_0_rev_t4_h_25 + (-0.58208829164505005) * gru_0_rev_t4_h_26 + (1.0596952438354492) * gru_0_rev_t4_h_27 + (0.39443084597587585) * gru_0_rev_t4_h_28 + (0.13179558515548706) * gru_0_rev_t4_h_29 + (0.18735851347446442) * gru_0_rev_t4_h_30 + (-0.23727965354919434) * gru_0_rev_t4_h_31);
    gate_n = tanh((1.3918232917785645) + (0.0099478065967559814) * emb_t3_0 + (0.60018932819366455) * emb_t3_1 + (0.028263276442885399) * emb_t3_2 + (1.4671456813812256) * emb_t3_3 + (-0.22006136178970337) * emb_t3_4 + (-0.014997608028352261) * emb_t3_5 + (-0.42907947301864624) * emb_t3_6 + (0.015719899907708168) * emb_t3_7 + (2.4035546779632568) * emb_t3_8 + (-0.33133906126022339) * emb_t3_9 + (-0.87221884727478027) * emb_t3_10 + (0.9308820366859436) * emb_t3_11 + (1.2722036838531494) * emb_t3_12 + (-0.0019454191206023097) * emb_t3_13 + (-0.0041214493103325367) * emb_t3_14 + (0.0023075088392943144) * emb_t3_15 + (0.010803038254380226) * emb_t3_16 + (-0.52183854579925537) * emb_t3_17 + (-0.45135071873664856) * emb_t3_18 + (0.20699004828929901) * emb_t3_19 + (0.58852016925811768) * emb_t3_20 + (-0.026288965716958046) * emb_t3_21 + (-1.0162254571914673) * emb_t3_22 + (0.0084366220980882645) * emb_t3_23 + (-0.027270687744021416) * emb_t3_24 + (-0.013432336039841175) * emb_t3_25 + (0.55314731597900391) * emb_t3_26 + (0.041914753615856171) * emb_t3_27 + (-0.20794588327407837) * emb_t3_28 + (0.16753177344799042) * emb_t3_29 + (0.22720544040203094) * emb_t3_30 + (-2.2309696674346924) * emb_t3_31 + gate_r * ((1.3616474866867065) + (0.50933831930160522) * gru_0_rev_t4_h_0 + (-0.60737228393554688) * gru_0_rev_t4_h_1 + (0.22894114255905151) * gru_0_rev_t4_h_2 + (-0.10425108671188354) * gru_0_rev_t4_h_3 + (-0.71201807260513306) * gru_0_rev_t4_h_4 + (0.24756258726119995) * gru_0_rev_t4_h_5 + (-0.22004891932010651) * gru_0_rev_t4_h_6 + (1.0562359094619751) * gru_0_rev_t4_h_7 + (0.99730032682418823) * gru_0_rev_t4_h_8 + (0.51488411426544189) * gru_0_rev_t4_h_9 + (-0.58587527275085449) * gru_0_rev_t4_h_10 + (-0.93631559610366821) * gru_0_rev_t4_h_11 + (0.76236546039581299) * gru_0_rev_t4_h_12 + (0.46081671118736267) * gru_0_rev_t4_h_13 + (-0.44189038872718811) * gru_0_rev_t4_h_14 + (-0.76974391937255859) * gru_0_rev_t4_h_15 + (-0.12188678979873657) * gru_0_rev_t4_h_16 + (-0.066877119243144989) * gru_0_rev_t4_h_17 + (0.93988686800003052) * gru_0_rev_t4_h_18 + (-0.56055700778961182) * gru_0_rev_t4_h_19 + (-0.17324274778366089) * gru_0_rev_t4_h_20 + (0.3536430299282074) * gru_0_rev_t4_h_21 + (0.083113238215446472) * gru_0_rev_t4_h_22 + (-0.2850271463394165) * gru_0_rev_t4_h_23 + (0.71385693550109863) * gru_0_rev_t4_h_24 + (0.060215111821889877) * gru_0_rev_t4_h_25 + (0.074162386357784271) * gru_0_rev_t4_h_26 + (0.38747349381446838) * gru_0_rev_t4_h_27 + (0.10983505845069885) * gru_0_rev_t4_h_28 + (0.91629123687744141) * gru_0_rev_t4_h_29 + (-0.70545458793640137) * gru_0_rev_t4_h_30 + (-1.5211039781570435) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_12 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_12;
    // h=13
    gate_r = sigmoid((-0.8471907377243042) + (0.55413860082626343) * emb_t3_0 + (-0.61571353673934937) * emb_t3_1 + (-0.40594193339347839) * emb_t3_2 + (0.081596903502941132) * emb_t3_3 + (-0.52892470359802246) * emb_t3_4 + (0.67255669832229614) * emb_t3_5 + (-0.27922585606575012) * emb_t3_6 + (1.9742788076400757) * emb_t3_7 + (-7.3871927261352539) * emb_t3_8 + (0.71850454807281494) * emb_t3_9 + (1.0384657382965088) * emb_t3_10 + (-0.42498612403869629) * emb_t3_11 + (-2.058356761932373) * emb_t3_12 + (-0.35568952560424805) * emb_t3_13 + (0.24166402220726013) * emb_t3_14 + (-0.33188208937644958) * emb_t3_15 + (-0.80781394243240356) * emb_t3_16 + (-0.32437142729759216) * emb_t3_17 + (0.81620621681213379) * emb_t3_18 + (-1.0332520008087158) * emb_t3_19 + (0.15213945508003235) * emb_t3_20 + (0.31029251217842102) * emb_t3_21 + (1.6249688863754272) * emb_t3_22 + (0.095902420580387115) * emb_t3_23 + (-0.59736859798431396) * emb_t3_24 + (0.35210147500038147) * emb_t3_25 + (0.43775841593742371) * emb_t3_26 + (0.055683411657810211) * emb_t3_27 + (0.61002242565155029) * emb_t3_28 + (-0.5278933048248291) * emb_t3_29 + (0.88334602117538452) * emb_t3_30 + (7.2100882530212402) * emb_t3_31 + (0.29979994893074036) * gru_0_rev_t4_h_0 + (-0.58250343799591064) * gru_0_rev_t4_h_1 + (-0.61810380220413208) * gru_0_rev_t4_h_2 + (0.76327866315841675) * gru_0_rev_t4_h_3 + (0.6424410343170166) * gru_0_rev_t4_h_4 + (-0.606484055519104) * gru_0_rev_t4_h_5 + (0.64771151542663574) * gru_0_rev_t4_h_6 + (-0.58999770879745483) * gru_0_rev_t4_h_7 + (-0.64163613319396973) * gru_0_rev_t4_h_8 + (0.66019940376281738) * gru_0_rev_t4_h_9 + (1.7583069801330566) * gru_0_rev_t4_h_10 + (0.50139689445495605) * gru_0_rev_t4_h_11 + (0.61399620771408081) * gru_0_rev_t4_h_12 + (0.5569576621055603) * gru_0_rev_t4_h_13 + (0.33033141493797302) * gru_0_rev_t4_h_14 + (-0.79901301860809326) * gru_0_rev_t4_h_15 + (0.09501311182975769) * gru_0_rev_t4_h_16 + (-0.09077279269695282) * gru_0_rev_t4_h_17 + (0.62744373083114624) * gru_0_rev_t4_h_18 + (0.5144050121307373) * gru_0_rev_t4_h_19 + (0.69006848335266113) * gru_0_rev_t4_h_20 + (-0.68002456426620483) * gru_0_rev_t4_h_21 + (0.020000956952571869) * gru_0_rev_t4_h_22 + (0.55412942171096802) * gru_0_rev_t4_h_23 + (-0.43619713187217712) * gru_0_rev_t4_h_24 + (-0.17633101344108582) * gru_0_rev_t4_h_25 + (-0.46805799007415771) * gru_0_rev_t4_h_26 + (-0.85939669609069824) * gru_0_rev_t4_h_27 + (-0.64625060558319092) * gru_0_rev_t4_h_28 + (0.30139774084091187) * gru_0_rev_t4_h_29 + (0.48804333806037903) * gru_0_rev_t4_h_30 + (-1.9475244283676147) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((0.6680489182472229) + (0.0025599468499422073) * emb_t3_0 + (0.2076709121465683) * emb_t3_1 + (0.00098374695517122746) * emb_t3_2 + (0.20989960432052612) * emb_t3_3 + (0.21669933199882507) * emb_t3_4 + (-0.011526999063789845) * emb_t3_5 + (-0.32647332549095154) * emb_t3_6 + (0.016910377889871597) * emb_t3_7 + (0.12821713089942932) * emb_t3_8 + (-0.024750072509050369) * emb_t3_9 + (-0.17117558419704437) * emb_t3_10 + (0.28039613366127014) * emb_t3_11 + (0.19344037771224976) * emb_t3_12 + (-0.051016397774219513) * emb_t3_13 + (-0.010580402798950672) * emb_t3_14 + (0.0066116815432906151) * emb_t3_15 + (-0.018739279359579086) * emb_t3_16 + (0.091853834688663483) * emb_t3_17 + (-0.36166143417358398) * emb_t3_18 + (-0.13729137182235718) * emb_t3_19 + (-0.21852181851863861) * emb_t3_20 + (-0.000277818733593449) * emb_t3_21 + (-0.24793429672718048) * emb_t3_22 + (0.0026213398668915033) * emb_t3_23 + (-0.014627248048782349) * emb_t3_24 + (0.0023010277654975653) * emb_t3_25 + (-0.40856611728668213) * emb_t3_26 + (0.007384889293462038) * emb_t3_27 + (-0.44331687688827515) * emb_t3_28 + (0.33899307250976562) * emb_t3_29 + (0.30118456482887268) * emb_t3_30 + (0.030001640319824219) * emb_t3_31 + (0.44404423236846924) * gru_0_rev_t4_h_0 + (-0.059366010129451752) * gru_0_rev_t4_h_1 + (-0.43969017267227173) * gru_0_rev_t4_h_2 + (0.68955773115158081) * gru_0_rev_t4_h_3 + (1.4737228155136108) * gru_0_rev_t4_h_4 + (-0.07194066047668457) * gru_0_rev_t4_h_5 + (-0.16347278654575348) * gru_0_rev_t4_h_6 + (0.095672927796840668) * gru_0_rev_t4_h_7 + (0.44194367527961731) * gru_0_rev_t4_h_8 + (0.72568786144256592) * gru_0_rev_t4_h_9 + (-0.59930193424224854) * gru_0_rev_t4_h_10 + (0.37113985419273376) * gru_0_rev_t4_h_11 + (0.81125396490097046) * gru_0_rev_t4_h_12 + (1.3822822570800781) * gru_0_rev_t4_h_13 + (-0.30195268988609314) * gru_0_rev_t4_h_14 + (-0.30409157276153564) * gru_0_rev_t4_h_15 + (0.060159791260957718) * gru_0_rev_t4_h_16 + (0.0039875274524092674) * gru_0_rev_t4_h_17 + (0.13589692115783691) * gru_0_rev_t4_h_18 + (0.85547852516174316) * gru_0_rev_t4_h_19 + (0.11313410103321075) * gru_0_rev_t4_h_20 + (-0.20945070683956146) * gru_0_rev_t4_h_21 + (-0.61154496669769287) * gru_0_rev_t4_h_22 + (0.94375568628311157) * gru_0_rev_t4_h_23 + (0.2744562029838562) * gru_0_rev_t4_h_24 + (-0.10227073729038239) * gru_0_rev_t4_h_25 + (-0.5439145565032959) * gru_0_rev_t4_h_26 + (-0.013965140096843243) * gru_0_rev_t4_h_27 + (0.25039374828338623) * gru_0_rev_t4_h_28 + (0.78877425193786621) * gru_0_rev_t4_h_29 + (1.1751112937927246) * gru_0_rev_t4_h_30 + (-1.5134786367416382) * gru_0_rev_t4_h_31);
    gate_n = tanh((1.4192674160003662) + (-0.0024527641944587231) * emb_t3_0 + (0.013600567355751991) * emb_t3_1 + (0.021397409960627556) * emb_t3_2 + (0.98087441921234131) * emb_t3_3 + (0.017589518800377846) * emb_t3_4 + (-0.020491674542427063) * emb_t3_5 + (-0.37787339091300964) * emb_t3_6 + (-0.0058721285313367844) * emb_t3_7 + (0.60607171058654785) * emb_t3_8 + (-0.67578792572021484) * emb_t3_9 + (-0.017862968146800995) * emb_t3_10 + (1.1348549127578735) * emb_t3_11 + (1.12957763671875) * emb_t3_12 + (0.17881251871585846) * emb_t3_13 + (0.029307989403605461) * emb_t3_14 + (0.0087201977148652077) * emb_t3_15 + (0.013434852473437786) * emb_t3_16 + (-0.37021809816360474) * emb_t3_17 + (-0.30552935600280762) * emb_t3_18 + (0.28159856796264648) * emb_t3_19 + (1.4146416187286377) * emb_t3_20 + (0.013037398457527161) * emb_t3_21 + (-0.11863017827272415) * emb_t3_22 + (0.00060954084619879723) * emb_t3_23 + (0.045046281069517136) * emb_t3_24 + (-0.049778178334236145) * emb_t3_25 + (0.45883461833000183) * emb_t3_26 + (0.0030700014904141426) * emb_t3_27 + (0.28979590535163879) * emb_t3_28 + (0.44459515810012817) * emb_t3_29 + (0.18634524941444397) * emb_t3_30 + (-0.9519842267036438) * emb_t3_31 + gate_r * ((1.7175730466842651) + (0.5348198413848877) * gru_0_rev_t4_h_0 + (-0.59048044681549072) * gru_0_rev_t4_h_1 + (-0.26212593913078308) * gru_0_rev_t4_h_2 + (0.12535680830478668) * gru_0_rev_t4_h_3 + (-0.089570716023445129) * gru_0_rev_t4_h_4 + (0.081398852169513702) * gru_0_rev_t4_h_5 + (-0.63666623830795288) * gru_0_rev_t4_h_6 + (2.2149322032928467) * gru_0_rev_t4_h_7 + (2.364588737487793) * gru_0_rev_t4_h_8 + (0.66077816486358643) * gru_0_rev_t4_h_9 + (0.16463252902030945) * gru_0_rev_t4_h_10 + (-0.31596317887306213) * gru_0_rev_t4_h_11 + (0.67131721973419189) * gru_0_rev_t4_h_12 + (0.47142013907432556) * gru_0_rev_t4_h_13 + (-0.31374850869178772) * gru_0_rev_t4_h_14 + (-0.14539438486099243) * gru_0_rev_t4_h_15 + (-0.078977547585964203) * gru_0_rev_t4_h_16 + (0.076109133660793304) * gru_0_rev_t4_h_17 + (0.42512047290802002) * gru_0_rev_t4_h_18 + (0.020884789526462555) * gru_0_rev_t4_h_19 + (0.16993480920791626) * gru_0_rev_t4_h_20 + (0.7105908989906311) * gru_0_rev_t4_h_21 + (-0.064879380166530609) * gru_0_rev_t4_h_22 + (0.57408970594406128) * gru_0_rev_t4_h_23 + (0.66315275430679321) * gru_0_rev_t4_h_24 + (0.048693250864744186) * gru_0_rev_t4_h_25 + (-0.16680102050304413) * gru_0_rev_t4_h_26 + (0.31079500913619995) * gru_0_rev_t4_h_27 + (-0.32845118641853333) * gru_0_rev_t4_h_28 + (-0.45419532060623169) * gru_0_rev_t4_h_29 + (-0.23532944917678833) * gru_0_rev_t4_h_30 + (-1.4830582141876221) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_13 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_13;
    // h=14
    gate_r = sigmoid((0.4441811740398407) + (0.36075064539909363) * emb_t3_0 + (1.3077433109283447) * emb_t3_1 + (0.10506085306406021) * emb_t3_2 + (0.30991849303245544) * emb_t3_3 + (0.34923911094665527) * emb_t3_4 + (-0.2855791449546814) * emb_t3_5 + (0.77927654981613159) * emb_t3_6 + (0.11512690037488937) * emb_t3_7 + (0.12239233404397964) * emb_t3_8 + (-0.91336655616760254) * emb_t3_9 + (-0.36862480640411377) * emb_t3_10 + (0.5283663272857666) * emb_t3_11 + (0.32265979051589966) * emb_t3_12 + (0.75916504859924316) * emb_t3_13 + (-0.45579206943511963) * emb_t3_14 + (0.13288974761962891) * emb_t3_15 + (-0.011488001793622971) * emb_t3_16 + (0.26103127002716064) * emb_t3_17 + (-0.68207436800003052) * emb_t3_18 + (0.56140989065170288) * emb_t3_19 + (-0.09335692971944809) * emb_t3_20 + (0.17620952427387238) * emb_t3_21 + (-0.41434291005134583) * emb_t3_22 + (0.15505670011043549) * emb_t3_23 + (0.074162617325782776) * emb_t3_24 + (0.15997406840324402) * emb_t3_25 + (-0.24888993799686432) * emb_t3_26 + (0.046698622405529022) * emb_t3_27 + (-0.66703903675079346) * emb_t3_28 + (0.83388769626617432) * emb_t3_29 + (-0.1665327250957489) * emb_t3_30 + (-0.14907297492027283) * emb_t3_31 + (-0.47300103306770325) * gru_0_rev_t4_h_0 + (0.59751266241073608) * gru_0_rev_t4_h_1 + (-0.055107012391090393) * gru_0_rev_t4_h_2 + (-0.20534910261631012) * gru_0_rev_t4_h_3 + (0.39500054717063904) * gru_0_rev_t4_h_4 + (-0.32876405119895935) * gru_0_rev_t4_h_5 + (0.042265884578227997) * gru_0_rev_t4_h_6 + (-0.6149517297744751) * gru_0_rev_t4_h_7 + (-1.1125409603118896) * gru_0_rev_t4_h_8 + (-0.016246214509010315) * gru_0_rev_t4_h_9 + (0.778664231300354) * gru_0_rev_t4_h_10 + (-0.08731929212808609) * gru_0_rev_t4_h_11 + (-0.21484239399433136) * gru_0_rev_t4_h_12 + (-0.25358453392982483) * gru_0_rev_t4_h_13 + (-0.26356691122055054) * gru_0_rev_t4_h_14 + (-0.49490004777908325) * gru_0_rev_t4_h_15 + (-2.1910548210144043) * gru_0_rev_t4_h_16 + (1.7228842973709106) * gru_0_rev_t4_h_17 + (0.12617671489715576) * gru_0_rev_t4_h_18 + (-0.89203786849975586) * gru_0_rev_t4_h_19 + (-1.3543477058410645) * gru_0_rev_t4_h_20 + (0.060202784836292267) * gru_0_rev_t4_h_21 + (0.083776295185089111) * gru_0_rev_t4_h_22 + (-0.80347937345504761) * gru_0_rev_t4_h_23 + (-0.87052291631698608) * gru_0_rev_t4_h_24 + (1.7914775609970093) * gru_0_rev_t4_h_25 + (-0.25633341073989868) * gru_0_rev_t4_h_26 + (-2.2118616104125977) * gru_0_rev_t4_h_27 + (-0.44575229287147522) * gru_0_rev_t4_h_28 + (-0.89758461713790894) * gru_0_rev_t4_h_29 + (-0.47347837686538696) * gru_0_rev_t4_h_30 + (2.6847836971282959) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((0.22907911241054535) + (-0.053022883832454681) * emb_t3_0 + (-2.0112128257751465) * emb_t3_1 + (-0.17153991758823395) * emb_t3_2 + (0.33761188387870789) * emb_t3_3 + (-1.4350898265838623) * emb_t3_4 + (-0.032737910747528076) * emb_t3_5 + (-0.70515894889831543) * emb_t3_6 + (0.061784304678440094) * emb_t3_7 + (-0.37807756662368774) * emb_t3_8 + (0.84044498205184937) * emb_t3_9 + (0.64871752262115479) * emb_t3_10 + (-0.18615145981311798) * emb_t3_11 + (-0.48771470785140991) * emb_t3_12 + (-2.0230305194854736) * emb_t3_13 + (-0.050683092325925827) * emb_t3_14 + (0.17341475188732147) * emb_t3_15 + (0.019496751949191093) * emb_t3_16 + (-0.91630542278289795) * emb_t3_17 + (0.54210352897644043) * emb_t3_18 + (-0.57203561067581177) * emb_t3_19 + (0.28487011790275574) * emb_t3_20 + (0.16342206299304962) * emb_t3_21 + (0.59586191177368164) * emb_t3_22 + (0.22398652136325836) * emb_t3_23 + (0.053156107664108276) * emb_t3_24 + (-0.0074884542264044285) * emb_t3_25 + (0.99484026432037354) * emb_t3_26 + (-0.041708830744028091) * emb_t3_27 + (1.833073616027832) * emb_t3_28 + (-2.54404616355896) * emb_t3_29 + (1.1508170366287231) * emb_t3_30 + (0.63742166757583618) * emb_t3_31 + (0.13191932439804077) * gru_0_rev_t4_h_0 + (0.79859471321105957) * gru_0_rev_t4_h_1 + (0.45518675446510315) * gru_0_rev_t4_h_2 + (0.39587196707725525) * gru_0_rev_t4_h_3 + (-1.512626051902771) * gru_0_rev_t4_h_4 + (-0.043950680643320084) * gru_0_rev_t4_h_5 + (-1.1029238700866699) * gru_0_rev_t4_h_6 + (-1.3446437120437622) * gru_0_rev_t4_h_7 + (0.29621458053588867) * gru_0_rev_t4_h_8 + (0.529529869556427) * gru_0_rev_t4_h_9 + (-0.32516399025917053) * gru_0_rev_t4_h_10 + (-0.94395071268081665) * gru_0_rev_t4_h_11 + (0.30835649371147156) * gru_0_rev_t4_h_12 + (0.17433534562587738) * gru_0_rev_t4_h_13 + (0.93995416164398193) * gru_0_rev_t4_h_14 + (-0.15609341859817505) * gru_0_rev_t4_h_15 + (0.33003601431846619) * gru_0_rev_t4_h_16 + (-0.37536534667015076) * gru_0_rev_t4_h_17 + (0.078198634088039398) * gru_0_rev_t4_h_18 + (0.020891113206744194) * gru_0_rev_t4_h_19 + (0.070556767284870148) * gru_0_rev_t4_h_20 + (0.57522761821746826) * gru_0_rev_t4_h_21 + (-0.052774533629417419) * gru_0_rev_t4_h_22 + (0.28552937507629395) * gru_0_rev_t4_h_23 + (0.070500299334526062) * gru_0_rev_t4_h_24 + (-0.076249457895755768) * gru_0_rev_t4_h_25 + (-0.10668905079364777) * gru_0_rev_t4_h_26 + (0.42986583709716797) * gru_0_rev_t4_h_27 + (-0.29443103075027466) * gru_0_rev_t4_h_28 + (0.65921938419342041) * gru_0_rev_t4_h_29 + (0.12133187055587769) * gru_0_rev_t4_h_30 + (-0.065160714089870453) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.0047882925719022751) + (0.0072417380288243294) * emb_t3_0 + (-1.1025224924087524) * emb_t3_1 + (0.040932387113571167) * emb_t3_2 + (0.28991508483886719) * emb_t3_3 + (-0.74824637174606323) * emb_t3_4 + (0.023332331329584122) * emb_t3_5 + (-0.1807473748922348) * emb_t3_6 + (-0.0094903288409113884) * emb_t3_7 + (0.303212970495224) * emb_t3_8 + (0.19635353982448578) * emb_t3_9 + (-0.21143828332424164) * emb_t3_10 + (0.19519101083278656) * emb_t3_11 + (-0.36399301886558533) * emb_t3_12 + (-1.0259802341461182) * emb_t3_13 + (-0.0026821310166269541) * emb_t3_14 + (-0.03891880065202713) * emb_t3_15 + (0.017421802505850792) * emb_t3_16 + (-0.17275097966194153) * emb_t3_17 + (0.57019633054733276) * emb_t3_18 + (-0.061267741024494171) * emb_t3_19 + (-0.30537161231040955) * emb_t3_20 + (-0.037297904491424561) * emb_t3_21 + (0.12500278651714325) * emb_t3_22 + (0.0059627131558954716) * emb_t3_23 + (-0.010628154501318932) * emb_t3_24 + (0.012551397085189819) * emb_t3_25 + (0.08045678585767746) * emb_t3_26 + (0.034582793712615967) * emb_t3_27 + (0.37388166785240173) * emb_t3_28 + (-0.94272834062576294) * emb_t3_29 + (-0.037900727242231369) * emb_t3_30 + (0.21891963481903076) * emb_t3_31 + gate_r * ((-0.34946075081825256) + (0.14728428423404694) * gru_0_rev_t4_h_0 + (0.34427520632743835) * gru_0_rev_t4_h_1 + (0.11687976866960526) * gru_0_rev_t4_h_2 + (0.028850214555859566) * gru_0_rev_t4_h_3 + (-0.039298083633184433) * gru_0_rev_t4_h_4 + (-0.45888757705688477) * gru_0_rev_t4_h_5 + (-0.22160577774047852) * gru_0_rev_t4_h_6 + (0.37915119528770447) * gru_0_rev_t4_h_7 + (-0.072529420256614685) * gru_0_rev_t4_h_8 + (0.339678555727005) * gru_0_rev_t4_h_9 + (-0.19300557672977448) * gru_0_rev_t4_h_10 + (-0.2106761634349823) * gru_0_rev_t4_h_11 + (0.25486093759536743) * gru_0_rev_t4_h_12 + (0.35720565915107727) * gru_0_rev_t4_h_13 + (-0.64478611946105957) * gru_0_rev_t4_h_14 + (-0.40338718891143799) * gru_0_rev_t4_h_15 + (-2.2825348377227783) * gru_0_rev_t4_h_16 + (1.0920039415359497) * gru_0_rev_t4_h_17 + (0.3353075385093689) * gru_0_rev_t4_h_18 + (0.20127418637275696) * gru_0_rev_t4_h_19 + (-0.32649162411689758) * gru_0_rev_t4_h_20 + (0.63634324073791504) * gru_0_rev_t4_h_21 + (-0.19105319678783417) * gru_0_rev_t4_h_22 + (-0.032888993620872498) * gru_0_rev_t4_h_23 + (0.38882622122764587) * gru_0_rev_t4_h_24 + (0.80700600147247314) * gru_0_rev_t4_h_25 + (-0.41047960519790649) * gru_0_rev_t4_h_26 + (-0.57779455184936523) * gru_0_rev_t4_h_27 + (-0.69464486837387085) * gru_0_rev_t4_h_28 + (0.05276123434305191) * gru_0_rev_t4_h_29 + (0.06033354252576828) * gru_0_rev_t4_h_30 + (0.15512140095233917) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_14 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_14;
    // h=15
    gate_r = sigmoid((-2.5485363006591797) + (-1.0981466770172119) * emb_t3_0 + (0.17039939761161804) * emb_t3_1 + (-1.1289713382720947) * emb_t3_2 + (-1.5023065805435181) * emb_t3_3 + (0.91546201705932617) * emb_t3_4 + (0.8393784761428833) * emb_t3_5 + (1.4448281526565552) * emb_t3_6 + (1.1443384885787964) * emb_t3_7 + (-0.94598031044006348) * emb_t3_8 + (1.2868512868881226) * emb_t3_9 + (1.0692732334136963) * emb_t3_10 + (-1.866188645362854) * emb_t3_11 + (-1.2244753837585449) * emb_t3_12 + (0.69439452886581421) * emb_t3_13 + (0.20707008242607117) * emb_t3_14 + (0.9440767765045166) * emb_t3_15 + (-1.0659303665161133) * emb_t3_16 + (1.251213550567627) * emb_t3_17 + (1.2705866098403931) * emb_t3_18 + (-0.84995198249816895) * emb_t3_19 + (-1.6389269828796387) * emb_t3_20 + (0.64584022760391235) * emb_t3_21 + (1.0417753458023071) * emb_t3_22 + (-0.12841182947158813) * emb_t3_23 + (0.14785376191139221) * emb_t3_24 + (-0.26613712310791016) * emb_t3_25 + (-1.4654747247695923) * emb_t3_26 + (-0.96218967437744141) * emb_t3_27 + (-0.065828926861286163) * emb_t3_28 + (0.54787540435791016) * emb_t3_29 + (-1.3537800312042236) * emb_t3_30 + (1.1862084865570068) * emb_t3_31 + (-0.84032374620437622) * gru_0_rev_t4_h_0 + (0.41991886496543884) * gru_0_rev_t4_h_1 + (-0.19990049302577972) * gru_0_rev_t4_h_2 + (-0.50825107097625732) * gru_0_rev_t4_h_3 + (0.38591307401657104) * gru_0_rev_t4_h_4 + (0.44718500971794128) * gru_0_rev_t4_h_5 + (-0.13357372581958771) * gru_0_rev_t4_h_6 + (0.89108937978744507) * gru_0_rev_t4_h_7 + (0.0091379322111606598) * gru_0_rev_t4_h_8 + (-0.43465954065322876) * gru_0_rev_t4_h_9 + (0.22464504837989807) * gru_0_rev_t4_h_10 + (0.049357995390892029) * gru_0_rev_t4_h_11 + (-0.33740928769111633) * gru_0_rev_t4_h_12 + (-0.52520924806594849) * gru_0_rev_t4_h_13 + (-0.7917335033416748) * gru_0_rev_t4_h_14 + (1.9985277652740479) * gru_0_rev_t4_h_15 + (-0.395781010389328) * gru_0_rev_t4_h_16 + (0.031900584697723389) * gru_0_rev_t4_h_17 + (-1.1270896196365356) * gru_0_rev_t4_h_18 + (-0.11487355828285217) * gru_0_rev_t4_h_19 + (-0.84388273954391479) * gru_0_rev_t4_h_20 + (-1.2945561408996582) * gru_0_rev_t4_h_21 + (0.53645896911621094) * gru_0_rev_t4_h_22 + (-0.52882009744644165) * gru_0_rev_t4_h_23 + (-0.011250211857259274) * gru_0_rev_t4_h_24 + (0.71421724557876587) * gru_0_rev_t4_h_25 + (0.44173499941825867) * gru_0_rev_t4_h_26 + (1.1884812116622925) * gru_0_rev_t4_h_27 + (0.82731008529663086) * gru_0_rev_t4_h_28 + (-0.41584998369216919) * gru_0_rev_t4_h_29 + (-0.54109483957290649) * gru_0_rev_t4_h_30 + (-1.2064334154129028) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-0.7214432954788208) + (0.059250675141811371) * emb_t3_0 + (-0.66896331310272217) * emb_t3_1 + (-0.19164617359638214) * emb_t3_2 + (-0.092587999999523163) * emb_t3_3 + (-0.10477571934461594) * emb_t3_4 + (0.10209141671657562) * emb_t3_5 + (-0.30720424652099609) * emb_t3_6 + (0.14000840485095978) * emb_t3_7 + (-0.25854814052581787) * emb_t3_8 + (0.25518879294395447) * emb_t3_9 + (0.1545366495847702) * emb_t3_10 + (-0.24109284579753876) * emb_t3_11 + (-0.79885894060134888) * emb_t3_12 + (-0.7995913028717041) * emb_t3_13 + (0.029181808233261108) * emb_t3_14 + (0.31742268800735474) * emb_t3_15 + (-0.23846352100372314) * emb_t3_16 + (0.10590140521526337) * emb_t3_17 + (0.4637124240398407) * emb_t3_18 + (-0.52289789915084839) * emb_t3_19 + (-0.52198821306228638) * emb_t3_20 + (0.30753082036972046) * emb_t3_21 + (0.48222053050994873) * emb_t3_22 + (-0.32363796234130859) * emb_t3_23 + (0.33859178423881531) * emb_t3_24 + (0.099730536341667175) * emb_t3_25 + (-0.25171643495559692) * emb_t3_26 + (-0.16489721834659576) * emb_t3_27 + (0.69695961475372314) * emb_t3_28 + (-0.19398064911365509) * emb_t3_29 + (0.24372236430644989) * emb_t3_30 + (0.66748279333114624) * emb_t3_31 + (-0.11073186993598938) * gru_0_rev_t4_h_0 + (0.88891160488128662) * gru_0_rev_t4_h_1 + (1.6598988771438599) * gru_0_rev_t4_h_2 + (-0.12348094582557678) * gru_0_rev_t4_h_3 + (-2.1093816757202148) * gru_0_rev_t4_h_4 + (-0.52487695217132568) * gru_0_rev_t4_h_5 + (-1.2472043037414551) * gru_0_rev_t4_h_6 + (0.0041666142642498016) * gru_0_rev_t4_h_7 + (0.12518784403800964) * gru_0_rev_t4_h_8 + (0.099406421184539795) * gru_0_rev_t4_h_9 + (-0.3632635772228241) * gru_0_rev_t4_h_10 + (-1.392386794090271) * gru_0_rev_t4_h_11 + (-0.18004234135150909) * gru_0_rev_t4_h_12 + (0.052649460732936859) * gru_0_rev_t4_h_13 + (-0.44097894430160522) * gru_0_rev_t4_h_14 + (0.17410333454608917) * gru_0_rev_t4_h_15 + (-0.71211248636245728) * gru_0_rev_t4_h_16 + (0.48138153553009033) * gru_0_rev_t4_h_17 + (0.091657303273677826) * gru_0_rev_t4_h_18 + (-0.75130981206893921) * gru_0_rev_t4_h_19 + (-0.50008130073547363) * gru_0_rev_t4_h_20 + (0.41103670001029968) * gru_0_rev_t4_h_21 + (-0.12482546269893646) * gru_0_rev_t4_h_22 + (0.13130612671375275) * gru_0_rev_t4_h_23 + (-0.16585564613342285) * gru_0_rev_t4_h_24 + (0.48140987753868103) * gru_0_rev_t4_h_25 + (0.11642260849475861) * gru_0_rev_t4_h_26 + (0.34932589530944824) * gru_0_rev_t4_h_27 + (0.016139358282089233) * gru_0_rev_t4_h_28 + (0.43949183821678162) * gru_0_rev_t4_h_29 + (-0.36188501119613647) * gru_0_rev_t4_h_30 + (-0.19152921438217163) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.11509934067726135) + (0.0086536100134253502) * emb_t3_0 + (0.53708797693252563) * emb_t3_1 + (-0.014071125537157059) * emb_t3_2 + (-0.23890426754951477) * emb_t3_3 + (0.46016910672187805) * emb_t3_4 + (0.00610391516238451) * emb_t3_5 + (0.23954620957374573) * emb_t3_6 + (-0.032185286283493042) * emb_t3_7 + (-0.75479906797409058) * emb_t3_8 + (0.028451530262827873) * emb_t3_9 + (-0.36921647191047668) * emb_t3_10 + (0.12913116812705994) * emb_t3_11 + (0.42067602276802063) * emb_t3_12 + (0.31604626774787903) * emb_t3_13 + (-0.011742912232875824) * emb_t3_14 + (0.028448460623621941) * emb_t3_15 + (-0.011185531504452229) * emb_t3_16 + (0.36221572756767273) * emb_t3_17 + (-0.26043137907981873) * emb_t3_18 + (0.42170342803001404) * emb_t3_19 + (-0.10561381280422211) * emb_t3_20 + (0.0082730865105986595) * emb_t3_21 + (-0.18132719397544861) * emb_t3_22 + (-0.018829261884093285) * emb_t3_23 + (-0.0086690681055188179) * emb_t3_24 + (0.021084075793623924) * emb_t3_25 + (-0.14471642673015594) * emb_t3_26 + (-0.017638092860579491) * emb_t3_27 + (-0.24931818246841431) * emb_t3_28 + (0.85941141843795776) * emb_t3_29 + (-0.81741935014724731) * emb_t3_30 + (0.43749606609344482) * emb_t3_31 + gate_r * ((-0.027562964707612991) + (0.015489273704588413) * gru_0_rev_t4_h_0 + (-0.97549933195114136) * gru_0_rev_t4_h_1 + (0.06262487918138504) * gru_0_rev_t4_h_2 + (-0.075633622705936432) * gru_0_rev_t4_h_3 + (0.47110438346862793) * gru_0_rev_t4_h_4 + (0.11156637966632843) * gru_0_rev_t4_h_5 + (0.71837514638900757) * gru_0_rev_t4_h_6 + (-0.59262967109680176) * gru_0_rev_t4_h_7 + (0.089354649186134338) * gru_0_rev_t4_h_8 + (-0.095260336995124817) * gru_0_rev_t4_h_9 + (-0.09775485098361969) * gru_0_rev_t4_h_10 + (0.21202416718006134) * gru_0_rev_t4_h_11 + (-0.13352282345294952) * gru_0_rev_t4_h_12 + (-0.1303238570690155) * gru_0_rev_t4_h_13 + (0.2545258104801178) * gru_0_rev_t4_h_14 + (-0.58088475465774536) * gru_0_rev_t4_h_15 + (-0.0067984526976943016) * gru_0_rev_t4_h_16 + (0.094669163227081299) * gru_0_rev_t4_h_17 + (0.40650469064712524) * gru_0_rev_t4_h_18 + (-0.077689841389656067) * gru_0_rev_t4_h_19 + (0.27820709347724915) * gru_0_rev_t4_h_20 + (0.21323083341121674) * gru_0_rev_t4_h_21 + (0.13759875297546387) * gru_0_rev_t4_h_22 + (-0.21619448065757751) * gru_0_rev_t4_h_23 + (-0.034883439540863037) * gru_0_rev_t4_h_24 + (-0.050587590783834457) * gru_0_rev_t4_h_25 + (-0.018033286556601524) * gru_0_rev_t4_h_26 + (-1.085039496421814) * gru_0_rev_t4_h_27 + (-0.32488527894020081) * gru_0_rev_t4_h_28 + (-0.40055689215660095) * gru_0_rev_t4_h_29 + (-0.26185822486877441) * gru_0_rev_t4_h_30 + (0.6597975492477417) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_15 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_15;
    // h=16
    gate_r = sigmoid((-3.6276388168334961) + (-0.55399399995803833) * emb_t3_0 + (1.1829593181610107) * emb_t3_1 + (-0.90462017059326172) * emb_t3_2 + (-1.6816167831420898) * emb_t3_3 + (1.5920102596282959) * emb_t3_4 + (1.3378474712371826) * emb_t3_5 + (0.99278193712234497) * emb_t3_6 + (1.3013887405395508) * emb_t3_7 + (-1.4189082384109497) * emb_t3_8 + (0.78257745504379272) * emb_t3_9 + (1.0267593860626221) * emb_t3_10 + (-1.8772982358932495) * emb_t3_11 + (-1.7390748262405396) * emb_t3_12 + (1.4438059329986572) * emb_t3_13 + (-0.31045487523078918) * emb_t3_14 + (0.88484835624694824) * emb_t3_15 + (-1.3324580192565918) * emb_t3_16 + (1.3524980545043945) * emb_t3_17 + (0.93577629327774048) * emb_t3_18 + (-1.3887078762054443) * emb_t3_19 + (-1.9425407648086548) * emb_t3_20 + (0.55787521600723267) * emb_t3_21 + (1.706667423248291) * emb_t3_22 + (-0.73649758100509644) * emb_t3_23 + (0.83116143941879272) * emb_t3_24 + (-1.2745752334594727) * emb_t3_25 + (-1.4535328149795532) * emb_t3_26 + (-1.6293405294418335) * emb_t3_27 + (-1.1243579387664795) * emb_t3_28 + (1.5127159357070923) * emb_t3_29 + (-1.9072438478469849) * emb_t3_30 + (1.3102514743804932) * emb_t3_31 + (-0.63430541753768921) * gru_0_rev_t4_h_0 + (-0.38782778382301331) * gru_0_rev_t4_h_1 + (-0.50044959783554077) * gru_0_rev_t4_h_2 + (-0.4720572829246521) * gru_0_rev_t4_h_3 + (0.77753108739852905) * gru_0_rev_t4_h_4 + (0.44707000255584717) * gru_0_rev_t4_h_5 + (0.31060010194778442) * gru_0_rev_t4_h_6 + (0.19035942852497101) * gru_0_rev_t4_h_7 + (-0.12437374144792557) * gru_0_rev_t4_h_8 + (-0.41829812526702881) * gru_0_rev_t4_h_9 + (0.58622545003890991) * gru_0_rev_t4_h_10 + (0.39621585607528687) * gru_0_rev_t4_h_11 + (-0.52238494157791138) * gru_0_rev_t4_h_12 + (-0.37827101349830627) * gru_0_rev_t4_h_13 + (-0.22664187848567963) * gru_0_rev_t4_h_14 + (0.17671079933643341) * gru_0_rev_t4_h_15 + (-0.74809795618057251) * gru_0_rev_t4_h_16 + (0.48865881562232971) * gru_0_rev_t4_h_17 + (-0.23975802958011627) * gru_0_rev_t4_h_18 + (-0.34601923823356628) * gru_0_rev_t4_h_19 + (-0.069485656917095184) * gru_0_rev_t4_h_20 + (-0.44457718729972839) * gru_0_rev_t4_h_21 + (0.39733707904815674) * gru_0_rev_t4_h_22 + (-0.2535155713558197) * gru_0_rev_t4_h_23 + (-0.2085772305727005) * gru_0_rev_t4_h_24 + (0.53145164251327515) * gru_0_rev_t4_h_25 + (0.30771464109420776) * gru_0_rev_t4_h_26 + (-0.048080570995807648) * gru_0_rev_t4_h_27 + (0.22401034832000732) * gru_0_rev_t4_h_28 + (-0.3403933048248291) * gru_0_rev_t4_h_29 + (-0.35568752884864807) * gru_0_rev_t4_h_30 + (-0.1032794788479805) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-3.0341415405273438) + (-0.24392977356910706) * emb_t3_0 + (-0.19663697481155396) * emb_t3_1 + (-0.45847463607788086) * emb_t3_2 + (-0.95124411582946777) * emb_t3_3 + (0.052034236490726471) * emb_t3_4 + (0.09866497665643692) * emb_t3_5 + (0.40371975302696228) * emb_t3_6 + (-0.14609228074550629) * emb_t3_7 + (-2.148754358291626) * emb_t3_8 + (2.3644254207611084) * emb_t3_9 + (2.224658727645874) * emb_t3_10 + (-1.3206096887588501) * emb_t3_11 + (-1.7818115949630737) * emb_t3_12 + (0.095168635249137878) * emb_t3_13 + (0.015438671223819256) * emb_t3_14 + (1.0705443620681763) * emb_t3_15 + (-0.39765426516532898) * emb_t3_16 + (0.98318248987197876) * emb_t3_17 + (1.4402689933776855) * emb_t3_18 + (-1.8661266565322876) * emb_t3_19 + (-1.0157074928283691) * emb_t3_20 + (0.27175894379615784) * emb_t3_21 + (2.0576980113983154) * emb_t3_22 + (0.76965421438217163) * emb_t3_23 + (0.22717304527759552) * emb_t3_24 + (0.36869752407073975) * emb_t3_25 + (-0.88211947679519653) * emb_t3_26 + (-0.17457166314125061) * emb_t3_27 + (0.075170420110225677) * emb_t3_28 + (-0.13373211026191711) * emb_t3_29 + (-0.96754521131515503) * emb_t3_30 + (1.6378720998764038) * emb_t3_31 + (-0.92106086015701294) * gru_0_rev_t4_h_0 + (0.060272838920354843) * gru_0_rev_t4_h_1 + (0.93467694520950317) * gru_0_rev_t4_h_2 + (-1.1873568296432495) * gru_0_rev_t4_h_3 + (-0.67131441831588745) * gru_0_rev_t4_h_4 + (1.0545490980148315) * gru_0_rev_t4_h_5 + (-0.25187182426452637) * gru_0_rev_t4_h_6 + (0.89419013261795044) * gru_0_rev_t4_h_7 + (-0.34290033578872681) * gru_0_rev_t4_h_8 + (-1.1153877973556519) * gru_0_rev_t4_h_9 + (-0.64823585748672485) * gru_0_rev_t4_h_10 + (-0.46745288372039795) * gru_0_rev_t4_h_11 + (-0.83656424283981323) * gru_0_rev_t4_h_12 + (-1.1805328130722046) * gru_0_rev_t4_h_13 + (0.4254353940486908) * gru_0_rev_t4_h_14 + (1.298667311668396) * gru_0_rev_t4_h_15 + (0.28493693470954895) * gru_0_rev_t4_h_16 + (-1.0235944986343384) * gru_0_rev_t4_h_17 + (-0.84474062919616699) * gru_0_rev_t4_h_18 + (-1.1878710985183716) * gru_0_rev_t4_h_19 + (-0.8365861177444458) * gru_0_rev_t4_h_20 + (-0.087390907108783722) * gru_0_rev_t4_h_21 + (0.5026850700378418) * gru_0_rev_t4_h_22 + (-1.6416463851928711) * gru_0_rev_t4_h_23 + (0.047915473580360413) * gru_0_rev_t4_h_24 + (-0.16374517977237701) * gru_0_rev_t4_h_25 + (1.0091251134872437) * gru_0_rev_t4_h_26 + (0.75389552116394043) * gru_0_rev_t4_h_27 + (-0.39469188451766968) * gru_0_rev_t4_h_28 + (0.70527738332748413) * gru_0_rev_t4_h_29 + (-0.82120418548583984) * gru_0_rev_t4_h_30 + (0.17818468809127808) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.00054617202840745449) + (0.0045771966688334942) * emb_t3_0 + (0.17028774321079254) * emb_t3_1 + (-0.0083374436944723129) * emb_t3_2 + (0.115583635866642) * emb_t3_3 + (0.43597325682640076) * emb_t3_4 + (-0.022567637264728546) * emb_t3_5 + (0.11851710826158524) * emb_t3_6 + (-0.0018321617972105742) * emb_t3_7 + (0.2643856406211853) * emb_t3_8 + (-1.4264582395553589) * emb_t3_9 + (-0.79762095212936401) * emb_t3_10 + (0.097066275775432587) * emb_t3_11 + (-0.10985676199197769) * emb_t3_12 + (0.32709237933158875) * emb_t3_13 + (0.0044286008924245834) * emb_t3_14 + (0.013022799976170063) * emb_t3_15 + (0.0037355748936533928) * emb_t3_16 + (-0.077571108937263489) * emb_t3_17 + (-0.19987742602825165) * emb_t3_18 + (0.56083059310913086) * emb_t3_19 + (-0.33396464586257935) * emb_t3_20 + (0.031821254640817642) * emb_t3_21 + (0.010200436227023602) * emb_t3_22 + (-0.010865524411201477) * emb_t3_23 + (0.028364550322294235) * emb_t3_24 + (-0.011354763060808182) * emb_t3_25 + (0.023156503215432167) * emb_t3_26 + (-0.0046282000839710236) * emb_t3_27 + (-0.24959765374660492) * emb_t3_28 + (1.0619994401931763) * emb_t3_29 + (-0.012424244545400143) * emb_t3_30 + (-0.15213806927204132) * emb_t3_31 + gate_r * ((-0.1024572029709816) + (-0.036896683275699615) * gru_0_rev_t4_h_0 + (-0.30683368444442749) * gru_0_rev_t4_h_1 + (-0.022686855867505074) * gru_0_rev_t4_h_2 + (-0.20158526301383972) * gru_0_rev_t4_h_3 + (0.46320971846580505) * gru_0_rev_t4_h_4 + (0.23454533517360687) * gru_0_rev_t4_h_5 + (-0.10740939527750015) * gru_0_rev_t4_h_6 + (-0.070548512041568756) * gru_0_rev_t4_h_7 + (-0.018361698836088181) * gru_0_rev_t4_h_8 + (0.20104445517063141) * gru_0_rev_t4_h_9 + (0.085922606289386749) * gru_0_rev_t4_h_10 + (0.27017739415168762) * gru_0_rev_t4_h_11 + (-0.035158783197402954) * gru_0_rev_t4_h_12 + (-0.18372568488121033) * gru_0_rev_t4_h_13 + (-0.062561400234699249) * gru_0_rev_t4_h_14 + (-0.31387344002723694) * gru_0_rev_t4_h_15 + (-0.29109656810760498) * gru_0_rev_t4_h_16 + (0.36891195178031921) * gru_0_rev_t4_h_17 + (0.38066351413726807) * gru_0_rev_t4_h_18 + (-0.078261703252792358) * gru_0_rev_t4_h_19 + (0.34031844139099121) * gru_0_rev_t4_h_20 + (0.16210576891899109) * gru_0_rev_t4_h_21 + (-0.090740226209163666) * gru_0_rev_t4_h_22 + (-0.012792918831110001) * gru_0_rev_t4_h_23 + (-0.063309118151664734) * gru_0_rev_t4_h_24 + (0.088991329073905945) * gru_0_rev_t4_h_25 + (0.022358329966664314) * gru_0_rev_t4_h_26 + (-0.51240283250808716) * gru_0_rev_t4_h_27 + (-0.56314551830291748) * gru_0_rev_t4_h_28 + (-0.0030440313275903463) * gru_0_rev_t4_h_29 + (0.069535829126834869) * gru_0_rev_t4_h_30 + (0.35110753774642944) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_16 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_16;
    // h=17
    gate_r = sigmoid((-3.1107819080352783) + (-0.96565186977386475) * emb_t3_0 + (0.54152154922485352) * emb_t3_1 + (-1.1846390962600708) * emb_t3_2 + (-1.195543646812439) * emb_t3_3 + (1.0474015474319458) * emb_t3_4 + (0.7267029881477356) * emb_t3_5 + (0.70588850975036621) * emb_t3_6 + (0.81107205152511597) * emb_t3_7 + (-0.99850946664810181) * emb_t3_8 + (0.98403728008270264) * emb_t3_9 + (0.89941275119781494) * emb_t3_10 + (-1.1420797109603882) * emb_t3_11 + (-1.3212742805480957) * emb_t3_12 + (0.61673367023468018) * emb_t3_13 + (0.72625023126602173) * emb_t3_14 + (1.0770673751831055) * emb_t3_15 + (-1.2579820156097412) * emb_t3_16 + (1.4941186904907227) * emb_t3_17 + (0.80668115615844727) * emb_t3_18 + (-1.2636659145355225) * emb_t3_19 + (-1.6255443096160889) * emb_t3_20 + (0.72453922033309937) * emb_t3_21 + (0.77528786659240723) * emb_t3_22 + (-0.14455495774745941) * emb_t3_23 + (1.0300053358078003) * emb_t3_24 + (-0.16098590195178986) * emb_t3_25 + (-0.74074292182922363) * emb_t3_26 + (-0.30634444952011108) * emb_t3_27 + (-0.48927971720695496) * emb_t3_28 + (1.0149382352828979) * emb_t3_29 + (-0.6032065749168396) * emb_t3_30 + (1.2659003734588623) * emb_t3_31 + (-0.20233123004436493) * gru_0_rev_t4_h_0 + (0.19016188383102417) * gru_0_rev_t4_h_1 + (0.43732267618179321) * gru_0_rev_t4_h_2 + (-0.071062467992305756) * gru_0_rev_t4_h_3 + (0.033485233783721924) * gru_0_rev_t4_h_4 + (0.32883039116859436) * gru_0_rev_t4_h_5 + (-0.10530577600002289) * gru_0_rev_t4_h_6 + (-0.39411160349845886) * gru_0_rev_t4_h_7 + (-0.1745867133140564) * gru_0_rev_t4_h_8 + (0.18422587215900421) * gru_0_rev_t4_h_9 + (0.19872839748859406) * gru_0_rev_t4_h_10 + (-0.031527109444141388) * gru_0_rev_t4_h_11 + (-0.087531782686710358) * gru_0_rev_t4_h_12 + (-0.20170301198959351) * gru_0_rev_t4_h_13 + (-0.091431200504302979) * gru_0_rev_t4_h_14 + (0.083853952586650848) * gru_0_rev_t4_h_15 + (-1.2609012126922607) * gru_0_rev_t4_h_16 + (1.3111658096313477) * gru_0_rev_t4_h_17 + (-0.0055467234924435616) * gru_0_rev_t4_h_18 + (-0.13807164132595062) * gru_0_rev_t4_h_19 + (0.12110999971628189) * gru_0_rev_t4_h_20 + (-0.024304771795868874) * gru_0_rev_t4_h_21 + (0.20001758635044098) * gru_0_rev_t4_h_22 + (0.048840496689081192) * gru_0_rev_t4_h_23 + (-0.67743992805480957) * gru_0_rev_t4_h_24 + (1.4329780340194702) * gru_0_rev_t4_h_25 + (-0.099132128059864044) * gru_0_rev_t4_h_26 + (-0.56757593154907227) * gru_0_rev_t4_h_27 + (-0.10171158611774445) * gru_0_rev_t4_h_28 + (-0.10781319439411163) * gru_0_rev_t4_h_29 + (-0.075801722705364227) * gru_0_rev_t4_h_30 + (0.16612102091312408) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-2.0034410953521729) + (0.5234794020652771) * emb_t3_0 + (0.016087613999843597) * emb_t3_1 + (0.6930534839630127) * emb_t3_2 + (-0.73686337471008301) * emb_t3_3 + (0.580849289894104) * emb_t3_4 + (-0.003114079125225544) * emb_t3_5 + (0.83411157131195068) * emb_t3_6 + (0.42322385311126709) * emb_t3_7 + (-1.4112616777420044) * emb_t3_8 + (2.4097495079040527) * emb_t3_9 + (1.8141844272613525) * emb_t3_10 + (-0.9813302755355835) * emb_t3_11 + (-1.1346726417541504) * emb_t3_12 + (0.62405312061309814) * emb_t3_13 + (0.82887643575668335) * emb_t3_14 + (0.27686628699302673) * emb_t3_15 + (-0.1316993236541748) * emb_t3_16 + (0.94877243041992188) * emb_t3_17 + (1.8238505125045776) * emb_t3_18 + (-1.1620571613311768) * emb_t3_19 + (-0.24408441781997681) * emb_t3_20 + (-0.21168693900108337) * emb_t3_21 + (1.3034882545471191) * emb_t3_22 + (-0.23716039955615997) * emb_t3_23 + (-0.14831389486789703) * emb_t3_24 + (-0.054054338485002518) * emb_t3_25 + (-0.4632478654384613) * emb_t3_26 + (-0.17461040616035461) * emb_t3_27 + (-0.050040788948535919) * emb_t3_28 + (0.15523026883602142) * emb_t3_29 + (-0.65608829259872437) * emb_t3_30 + (1.0230476856231689) * emb_t3_31 + (-0.71461087465286255) * gru_0_rev_t4_h_0 + (0.23222826421260834) * gru_0_rev_t4_h_1 + (0.64182913303375244) * gru_0_rev_t4_h_2 + (-1.3457337617874146) * gru_0_rev_t4_h_3 + (-1.0134751796722412) * gru_0_rev_t4_h_4 + (0.5788729190826416) * gru_0_rev_t4_h_5 + (-0.16059845685958862) * gru_0_rev_t4_h_6 + (2.8751013278961182) * gru_0_rev_t4_h_7 + (-0.33799093961715698) * gru_0_rev_t4_h_8 + (-1.1026483774185181) * gru_0_rev_t4_h_9 + (-0.02886112779378891) * gru_0_rev_t4_h_10 + (-0.81473344564437866) * gru_0_rev_t4_h_11 + (-0.66556310653686523) * gru_0_rev_t4_h_12 + (-0.84895825386047363) * gru_0_rev_t4_h_13 + (-1.5744349956512451) * gru_0_rev_t4_h_14 + (0.56217062473297119) * gru_0_rev_t4_h_15 + (-0.58613330125808716) * gru_0_rev_t4_h_16 + (0.43522065877914429) * gru_0_rev_t4_h_17 + (-0.13434462249279022) * gru_0_rev_t4_h_18 + (-1.2454590797424316) * gru_0_rev_t4_h_19 + (-0.76768648624420166) * gru_0_rev_t4_h_20 + (-0.33272668719291687) * gru_0_rev_t4_h_21 + (0.92151135206222534) * gru_0_rev_t4_h_22 + (-0.17863357067108154) * gru_0_rev_t4_h_23 + (-0.66749840974807739) * gru_0_rev_t4_h_24 + (0.56746804714202881) * gru_0_rev_t4_h_25 + (1.1728404760360718) * gru_0_rev_t4_h_26 + (0.23780401051044464) * gru_0_rev_t4_h_27 + (0.24831905961036682) * gru_0_rev_t4_h_28 + (-0.18696905672550201) * gru_0_rev_t4_h_29 + (-1.3057055473327637) * gru_0_rev_t4_h_30 + (-0.88776707649230957) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.022157993167638779) + (-0.015913363546133041) * emb_t3_0 + (-0.61482137441635132) * emb_t3_1 + (0.0076300408691167831) * emb_t3_2 + (-0.021139446645975113) * emb_t3_3 + (-0.28343075513839722) * emb_t3_4 + (-0.017258845269680023) * emb_t3_5 + (-0.41530627012252808) * emb_t3_6 + (0.037708468735218048) * emb_t3_7 + (-0.17013177275657654) * emb_t3_8 + (0.85230022668838501) * emb_t3_9 + (0.16671329736709595) * emb_t3_10 + (0.0058722039684653282) * emb_t3_11 + (-0.56553143262863159) * emb_t3_12 + (-0.60855954885482788) * emb_t3_13 + (0.030933454632759094) * emb_t3_14 + (-0.0046227886341512203) * emb_t3_15 + (0.0071983765810728073) * emb_t3_16 + (-0.21838642656803131) * emb_t3_17 + (0.25267964601516724) * emb_t3_18 + (-0.42689117789268494) * emb_t3_19 + (0.0053769955411553383) * emb_t3_20 + (0.064662173390388489) * emb_t3_21 + (0.26178878545761108) * emb_t3_22 + (-0.043964389711618423) * emb_t3_23 + (0.11218304932117462) * emb_t3_24 + (-0.035765327513217926) * emb_t3_25 + (0.25849226117134094) * emb_t3_26 + (-0.016273008659482002) * emb_t3_27 + (0.32490220665931702) * emb_t3_28 + (-0.017818063497543335) * emb_t3_29 + (0.27783492207527161) * emb_t3_30 + (0.003300385782495141) * emb_t3_31 + gate_r * ((-0.28120747208595276) + (-0.10952715575695038) * gru_0_rev_t4_h_0 + (-0.29696652293205261) * gru_0_rev_t4_h_1 + (-0.51199507713317871) * gru_0_rev_t4_h_2 + (-0.13169659674167633) * gru_0_rev_t4_h_3 + (-0.16285727918148041) * gru_0_rev_t4_h_4 + (-0.021461253985762596) * gru_0_rev_t4_h_5 + (0.444417804479599) * gru_0_rev_t4_h_6 + (0.53523284196853638) * gru_0_rev_t4_h_7 + (-0.033214885741472244) * gru_0_rev_t4_h_8 + (-0.41355264186859131) * gru_0_rev_t4_h_9 + (-0.14424490928649902) * gru_0_rev_t4_h_10 + (0.043347444385290146) * gru_0_rev_t4_h_11 + (-0.062026038765907288) * gru_0_rev_t4_h_12 + (-0.15492072701454163) * gru_0_rev_t4_h_13 + (-0.21697166562080383) * gru_0_rev_t4_h_14 + (0.15517586469650269) * gru_0_rev_t4_h_15 + (0.9418373703956604) * gru_0_rev_t4_h_16 + (-0.66384464502334595) * gru_0_rev_t4_h_17 + (-0.53127771615982056) * gru_0_rev_t4_h_18 + (-0.11406728625297546) * gru_0_rev_t4_h_19 + (-0.17877869307994843) * gru_0_rev_t4_h_20 + (-0.10461205244064331) * gru_0_rev_t4_h_21 + (0.12005145847797394) * gru_0_rev_t4_h_22 + (-0.34081727266311646) * gru_0_rev_t4_h_23 + (0.65072494745254517) * gru_0_rev_t4_h_24 + (-0.47842538356781006) * gru_0_rev_t4_h_25 + (0.14357955753803253) * gru_0_rev_t4_h_26 + (0.62297195196151733) * gru_0_rev_t4_h_27 + (0.73873627185821533) * gru_0_rev_t4_h_28 + (-0.1808314323425293) * gru_0_rev_t4_h_29 + (-0.16651353240013123) * gru_0_rev_t4_h_30 + (-0.22049768269062042) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_17 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_17;
    // h=18
    gate_r = sigmoid((-0.036454733461141586) + (-0.065201081335544586) * emb_t3_0 + (0.53062635660171509) * emb_t3_1 + (0.011271261610090733) * emb_t3_2 + (-0.24644921720027924) * emb_t3_3 + (0.16306582093238831) * emb_t3_4 + (-0.031682509928941727) * emb_t3_5 + (0.19659058749675751) * emb_t3_6 + (-0.022091209888458252) * emb_t3_7 + (0.16437581181526184) * emb_t3_8 + (-0.62140697240829468) * emb_t3_9 + (-0.0472455695271492) * emb_t3_10 + (-0.040558211505413055) * emb_t3_11 + (-0.34304314851760864) * emb_t3_12 + (0.85213363170623779) * emb_t3_13 + (-0.036205735057592392) * emb_t3_14 + (-0.15391191840171814) * emb_t3_15 + (0.16102422773838043) * emb_t3_16 + (-0.10120628774166107) * emb_t3_17 + (-0.41253086924552917) * emb_t3_18 + (0.53241938352584839) * emb_t3_19 + (0.27077949047088623) * emb_t3_20 + (-0.067844681441783905) * emb_t3_21 + (-0.09389805793762207) * emb_t3_22 + (0.18802960216999054) * emb_t3_23 + (-0.16243058443069458) * emb_t3_24 + (0.13230270147323608) * emb_t3_25 + (-0.28899893164634705) * emb_t3_26 + (0.04551282525062561) * emb_t3_27 + (-0.85732436180114746) * emb_t3_28 + (0.97620159387588501) * emb_t3_29 + (-0.46704152226448059) * emb_t3_30 + (0.43740251660346985) * emb_t3_31 + (-0.31014582514762878) * gru_0_rev_t4_h_0 + (-0.27740916609764099) * gru_0_rev_t4_h_1 + (-0.13692207634449005) * gru_0_rev_t4_h_2 + (-0.18351444602012634) * gru_0_rev_t4_h_3 + (0.3955267071723938) * gru_0_rev_t4_h_4 + (0.61727398633956909) * gru_0_rev_t4_h_5 + (0.75191801786422729) * gru_0_rev_t4_h_6 + (0.12577928602695465) * gru_0_rev_t4_h_7 + (0.32658562064170837) * gru_0_rev_t4_h_8 + (-0.62723571062088013) * gru_0_rev_t4_h_9 + (0.22056719660758972) * gru_0_rev_t4_h_10 + (0.65634894371032715) * gru_0_rev_t4_h_11 + (-0.256826251745224) * gru_0_rev_t4_h_12 + (-0.15052461624145508) * gru_0_rev_t4_h_13 + (0.26246601343154907) * gru_0_rev_t4_h_14 + (0.59137058258056641) * gru_0_rev_t4_h_15 + (0.22866854071617126) * gru_0_rev_t4_h_16 + (-0.36130735278129578) * gru_0_rev_t4_h_17 + (-0.59114271402359009) * gru_0_rev_t4_h_18 + (0.049988172948360443) * gru_0_rev_t4_h_19 + (0.14335088431835175) * gru_0_rev_t4_h_20 + (-0.68247944116592407) * gru_0_rev_t4_h_21 + (0.2539266049861908) * gru_0_rev_t4_h_22 + (-0.20980735123157501) * gru_0_rev_t4_h_23 + (-0.37050604820251465) * gru_0_rev_t4_h_24 + (-0.20567706227302551) * gru_0_rev_t4_h_25 + (0.55900520086288452) * gru_0_rev_t4_h_26 + (0.47461509704589844) * gru_0_rev_t4_h_27 + (0.64477711915969849) * gru_0_rev_t4_h_28 + (-0.32492560148239136) * gru_0_rev_t4_h_29 + (-0.30946910381317139) * gru_0_rev_t4_h_30 + (-0.36402598023414612) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-1.4978121519088745) + (-0.43860715627670288) * emb_t3_0 + (-0.85169357061386108) * emb_t3_1 + (-0.35603117942810059) * emb_t3_2 + (-0.74947535991668701) * emb_t3_3 + (0.43814629316329956) * emb_t3_4 + (1.2335069179534912) * emb_t3_5 + (0.11379426717758179) * emb_t3_6 + (0.3493688702583313) * emb_t3_7 + (-0.78740262985229492) * emb_t3_8 + (1.4865201711654663) * emb_t3_9 + (1.6285649538040161) * emb_t3_10 + (-0.83910524845123291) * emb_t3_11 + (-0.50544434785842896) * emb_t3_12 + (-0.6168939471244812) * emb_t3_13 + (0.071439191699028015) * emb_t3_14 + (0.57882249355316162) * emb_t3_15 + (0.25527212023735046) * emb_t3_16 + (0.15450169146060944) * emb_t3_17 + (1.3401434421539307) * emb_t3_18 + (-0.59255146980285645) * emb_t3_19 + (-0.83472800254821777) * emb_t3_20 + (0.97425329685211182) * emb_t3_21 + (1.2894057035446167) * emb_t3_22 + (-0.6093219518661499) * emb_t3_23 + (0.11822836101055145) * emb_t3_24 + (0.62713336944580078) * emb_t3_25 + (0.049175392836332321) * emb_t3_26 + (-0.28905946016311646) * emb_t3_27 + (0.93095046281814575) * emb_t3_28 + (-0.13380184769630432) * emb_t3_29 + (-0.40445157885551453) * emb_t3_30 + (1.008270263671875) * emb_t3_31 + (-0.64940285682678223) * gru_0_rev_t4_h_0 + (0.71977269649505615) * gru_0_rev_t4_h_1 + (1.6658852100372314) * gru_0_rev_t4_h_2 + (-0.87621033191680908) * gru_0_rev_t4_h_3 + (-0.89861506223678589) * gru_0_rev_t4_h_4 + (0.48969870805740356) * gru_0_rev_t4_h_5 + (-1.4465377330780029) * gru_0_rev_t4_h_6 + (1.1334482431411743) * gru_0_rev_t4_h_7 + (0.079959176480770111) * gru_0_rev_t4_h_8 + (-0.48874688148498535) * gru_0_rev_t4_h_9 + (-0.20848652720451355) * gru_0_rev_t4_h_10 + (-1.3624874353408813) * gru_0_rev_t4_h_11 + (-0.65216982364654541) * gru_0_rev_t4_h_12 + (-0.68870538473129272) * gru_0_rev_t4_h_13 + (-1.2986053228378296) * gru_0_rev_t4_h_14 + (0.93401521444320679) * gru_0_rev_t4_h_15 + (-0.20590585470199585) * gru_0_rev_t4_h_16 + (-0.11357800662517548) * gru_0_rev_t4_h_17 + (-0.90102255344390869) * gru_0_rev_t4_h_18 + (-1.3119759559631348) * gru_0_rev_t4_h_19 + (-0.64724498987197876) * gru_0_rev_t4_h_20 + (-0.30955231189727783) * gru_0_rev_t4_h_21 + (-0.044852811843156815) * gru_0_rev_t4_h_22 + (0.098182216286659241) * gru_0_rev_t4_h_23 + (0.58551216125488281) * gru_0_rev_t4_h_24 + (0.056228511035442352) * gru_0_rev_t4_h_25 + (0.88548767566680908) * gru_0_rev_t4_h_26 + (1.4373846054077148) * gru_0_rev_t4_h_27 + (0.87520700693130493) * gru_0_rev_t4_h_28 + (0.098160222172737122) * gru_0_rev_t4_h_29 + (-1.2477080821990967) * gru_0_rev_t4_h_30 + (-1.3633562326431274) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.046371109783649445) + (-0.0048591182567179203) * emb_t3_0 + (-0.45264828205108643) * emb_t3_1 + (-0.0063616624101996422) * emb_t3_2 + (0.053491745144128799) * emb_t3_3 + (-0.058726012706756592) * emb_t3_4 + (-0.0034763820003718138) * emb_t3_5 + (0.010522292926907539) * emb_t3_6 + (-0.0053152083419263363) * emb_t3_7 + (0.048255186527967453) * emb_t3_8 + (0.23834626376628876) * emb_t3_9 + (-0.067361995577812195) * emb_t3_10 + (0.1652316153049469) * emb_t3_11 + (-0.27158817648887634) * emb_t3_12 + (-0.094877012073993683) * emb_t3_13 + (-0.018849676474928856) * emb_t3_14 + (-0.0021181304473429918) * emb_t3_15 + (-0.012360644526779652) * emb_t3_16 + (-0.52830427885055542) * emb_t3_17 + (0.073907561600208282) * emb_t3_18 + (-0.1474204957485199) * emb_t3_19 + (0.12769855558872223) * emb_t3_20 + (0.0068980911746621132) * emb_t3_21 + (0.24603369832038879) * emb_t3_22 + (0.0046543306671082973) * emb_t3_23 + (-0.0067050261422991753) * emb_t3_24 + (0.013961959630250931) * emb_t3_25 + (-0.060271337628364563) * emb_t3_26 + (-0.0037825689651072025) * emb_t3_27 + (0.12672163546085358) * emb_t3_28 + (0.26538461446762085) * emb_t3_29 + (-0.22168616950511932) * emb_t3_30 + (-0.0025916832964867353) * emb_t3_31 + gate_r * ((-0.2609228789806366) + (0.27079212665557861) * gru_0_rev_t4_h_0 + (0.14235800504684448) * gru_0_rev_t4_h_1 + (0.46891775727272034) * gru_0_rev_t4_h_2 + (0.37441706657409668) * gru_0_rev_t4_h_3 + (-0.54129791259765625) * gru_0_rev_t4_h_4 + (0.16615977883338928) * gru_0_rev_t4_h_5 + (-0.47832059860229492) * gru_0_rev_t4_h_6 + (0.95402622222900391) * gru_0_rev_t4_h_7 + (0.5018647313117981) * gru_0_rev_t4_h_8 + (-0.051480025053024292) * gru_0_rev_t4_h_9 + (-0.17704662680625916) * gru_0_rev_t4_h_10 + (-0.22220806777477264) * gru_0_rev_t4_h_11 + (0.14800167083740234) * gru_0_rev_t4_h_12 + (0.22095254063606262) * gru_0_rev_t4_h_13 + (0.19439986348152161) * gru_0_rev_t4_h_14 + (0.086853310465812683) * gru_0_rev_t4_h_15 + (0.47668072581291199) * gru_0_rev_t4_h_16 + (-0.6771773099899292) * gru_0_rev_t4_h_17 + (-0.54262280464172363) * gru_0_rev_t4_h_18 + (0.16507872939109802) * gru_0_rev_t4_h_19 + (0.16644509136676788) * gru_0_rev_t4_h_20 + (-0.055201549082994461) * gru_0_rev_t4_h_21 + (-0.19203230738639832) * gru_0_rev_t4_h_22 + (0.11677657067775726) * gru_0_rev_t4_h_23 + (-0.096300505101680756) * gru_0_rev_t4_h_24 + (-0.49790403246879578) * gru_0_rev_t4_h_25 + (-0.044098787009716034) * gru_0_rev_t4_h_26 + (0.16939212381839752) * gru_0_rev_t4_h_27 + (0.36898502707481384) * gru_0_rev_t4_h_28 + (0.20624212920665741) * gru_0_rev_t4_h_29 + (0.11892404407262802) * gru_0_rev_t4_h_30 + (-0.33130854368209839) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_18 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_18;
    // h=19
    gate_r = sigmoid((0.60123640298843384) + (-0.090696848928928375) * emb_t3_0 + (0.63431203365325928) * emb_t3_1 + (0.057218778878450394) * emb_t3_2 + (-0.23073315620422363) * emb_t3_3 + (0.340861976146698) * emb_t3_4 + (0.25616341829299927) * emb_t3_5 + (-0.096920974552631378) * emb_t3_6 + (-0.30860334634780884) * emb_t3_7 + (1.917966365814209) * emb_t3_8 + (-2.1318411827087402) * emb_t3_9 + (-1.2897759675979614) * emb_t3_10 + (0.3156813383102417) * emb_t3_11 + (3.2653563022613525) * emb_t3_12 + (0.6604047417640686) * emb_t3_13 + (-0.20446567237377167) * emb_t3_14 + (0.099141389131546021) * emb_t3_15 + (-0.065083891153335571) * emb_t3_16 + (0.097014501690864563) * emb_t3_17 + (-1.0433775186538696) * emb_t3_18 + (1.4585690498352051) * emb_t3_19 + (-0.16509515047073364) * emb_t3_20 + (0.40098559856414795) * emb_t3_21 + (-2.3982560634613037) * emb_t3_22 + (0.24840317666530609) * emb_t3_23 + (-0.050794906914234161) * emb_t3_24 + (-0.081716492772102356) * emb_t3_25 + (-0.31634053587913513) * emb_t3_26 + (0.080328591167926788) * emb_t3_27 + (-1.2798395156860352) * emb_t3_28 + (0.54768049716949463) * emb_t3_29 + (-0.87233614921569824) * emb_t3_30 + (-1.960204005241394) * emb_t3_31 + (0.56995725631713867) * gru_0_rev_t4_h_0 + (0.38819831609725952) * gru_0_rev_t4_h_1 + (0.32874280214309692) * gru_0_rev_t4_h_2 + (-0.24375368654727936) * gru_0_rev_t4_h_3 + (-0.41709408164024353) * gru_0_rev_t4_h_4 + (0.32952672243118286) * gru_0_rev_t4_h_5 + (-0.42873916029930115) * gru_0_rev_t4_h_6 + (1.0151400566101074) * gru_0_rev_t4_h_7 + (-0.18202802538871765) * gru_0_rev_t4_h_8 + (-0.31640017032623291) * gru_0_rev_t4_h_9 + (-0.47432714700698853) * gru_0_rev_t4_h_10 + (-0.23502682149410248) * gru_0_rev_t4_h_11 + (-0.39145630598068237) * gru_0_rev_t4_h_12 + (-0.20364117622375488) * gru_0_rev_t4_h_13 + (-0.21853236854076385) * gru_0_rev_t4_h_14 + (-0.35489535331726074) * gru_0_rev_t4_h_15 + (-0.051155928522348404) * gru_0_rev_t4_h_16 + (-0.026069493964314461) * gru_0_rev_t4_h_17 + (0.66035604476928711) * gru_0_rev_t4_h_18 + (-0.31003931164741516) * gru_0_rev_t4_h_19 + (-0.3114008903503418) * gru_0_rev_t4_h_20 + (0.23489589989185333) * gru_0_rev_t4_h_21 + (0.11714031547307968) * gru_0_rev_t4_h_22 + (0.2432517409324646) * gru_0_rev_t4_h_23 + (0.098395377397537231) * gru_0_rev_t4_h_24 + (0.094755388796329498) * gru_0_rev_t4_h_25 + (0.32841521501541138) * gru_0_rev_t4_h_26 + (0.2338944673538208) * gru_0_rev_t4_h_27 + (0.1302904337644577) * gru_0_rev_t4_h_28 + (0.089705213904380798) * gru_0_rev_t4_h_29 + (-0.57217729091644287) * gru_0_rev_t4_h_30 + (-1.1658240556716919) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((2.4300346374511719) + (-0.0051412573084235191) * emb_t3_0 + (-0.3225063681602478) * emb_t3_1 + (-0.02895328588783741) * emb_t3_2 + (0.3751218318939209) * emb_t3_3 + (-0.071810543537139893) * emb_t3_4 + (-0.0087339403107762337) * emb_t3_5 + (0.0056174639612436295) * emb_t3_6 + (-0.014164562337100506) * emb_t3_7 + (0.37523475289344788) * emb_t3_8 + (0.24843846261501312) * emb_t3_9 + (0.11024381965398788) * emb_t3_10 + (0.31875023245811462) * emb_t3_11 + (0.49581238627433777) * emb_t3_12 + (0.093487769365310669) * emb_t3_13 + (-0.012458187527954578) * emb_t3_14 + (0.03368275985121727) * emb_t3_15 + (-0.018859509378671646) * emb_t3_16 + (0.30735662579536438) * emb_t3_17 + (0.05697900801897049) * emb_t3_18 + (0.50854825973510742) * emb_t3_19 + (0.41150546073913574) * emb_t3_20 + (0.03356890007853508) * emb_t3_21 + (-0.24917949736118317) * emb_t3_22 + (0.018723750486969948) * emb_t3_23 + (0.02020379900932312) * emb_t3_24 + (0.027616111561655998) * emb_t3_25 + (0.10162147879600525) * emb_t3_26 + (-0.04969797283411026) * emb_t3_27 + (-0.35087665915489197) * emb_t3_28 + (0.48617285490036011) * emb_t3_29 + (-0.23653492331504822) * emb_t3_30 + (-0.40728408098220825) * emb_t3_31 + (0.4259607195854187) * gru_0_rev_t4_h_0 + (-0.97200846672058105) * gru_0_rev_t4_h_1 + (0.2391398549079895) * gru_0_rev_t4_h_2 + (0.95246434211730957) * gru_0_rev_t4_h_3 + (2.3122310638427734) * gru_0_rev_t4_h_4 + (-0.422708660364151) * gru_0_rev_t4_h_5 + (0.54156863689422607) * gru_0_rev_t4_h_6 + (0.49582445621490479) * gru_0_rev_t4_h_7 + (0.773845374584198) * gru_0_rev_t4_h_8 + (0.85593748092651367) * gru_0_rev_t4_h_9 + (-0.52564465999603271) * gru_0_rev_t4_h_10 + (-0.078888766467571259) * gru_0_rev_t4_h_11 + (1.04546058177948) * gru_0_rev_t4_h_12 + (1.0552409887313843) * gru_0_rev_t4_h_13 + (-0.18941314518451691) * gru_0_rev_t4_h_14 + (0.12903094291687012) * gru_0_rev_t4_h_15 + (0.77466017007827759) * gru_0_rev_t4_h_16 + (-0.75558102130889893) * gru_0_rev_t4_h_17 + (0.39964947104454041) * gru_0_rev_t4_h_18 + (1.3209904432296753) * gru_0_rev_t4_h_19 + (0.83801740407943726) * gru_0_rev_t4_h_20 + (-0.77495056390762329) * gru_0_rev_t4_h_21 + (-0.9098467230796814) * gru_0_rev_t4_h_22 + (1.0565752983093262) * gru_0_rev_t4_h_23 + (1.2158849239349365) * gru_0_rev_t4_h_24 + (-0.59673994779586792) * gru_0_rev_t4_h_25 + (-0.56512492895126343) * gru_0_rev_t4_h_26 + (1.2025930881500244) * gru_0_rev_t4_h_27 + (0.76449179649353027) * gru_0_rev_t4_h_28 + (0.68718147277832031) * gru_0_rev_t4_h_29 + (1.0968666076660156) * gru_0_rev_t4_h_30 + (-0.30808612704277039) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.41683101654052734) + (0.15079621970653534) * emb_t3_0 + (0.75203430652618408) * emb_t3_1 + (0.15180236101150513) * emb_t3_2 + (0.56286221742630005) * emb_t3_3 + (-0.12597629427909851) * emb_t3_4 + (-0.26728802919387817) * emb_t3_5 + (-0.0061264797113835812) * emb_t3_6 + (0.09531867504119873) * emb_t3_7 + (0.70012187957763672) * emb_t3_8 + (-0.29852434992790222) * emb_t3_9 + (-0.47693061828613281) * emb_t3_10 + (0.10405405610799789) * emb_t3_11 + (1.3601082563400269) * emb_t3_12 + (0.12594461441040039) * emb_t3_13 + (0.18855847418308258) * emb_t3_14 + (0.091632500290870667) * emb_t3_15 + (0.049250539392232895) * emb_t3_16 + (-0.28092131018638611) * emb_t3_17 + (-0.30399131774902344) * emb_t3_18 + (0.9413483738899231) * emb_t3_19 + (0.47450956702232361) * emb_t3_20 + (-0.038550343364477158) * emb_t3_21 + (-0.85411477088928223) * emb_t3_22 + (-0.22600859403610229) * emb_t3_23 + (0.16237011551856995) * emb_t3_24 + (-0.38356611132621765) * emb_t3_25 + (-0.049156934022903442) * emb_t3_26 + (0.13897094130516052) * emb_t3_27 + (-0.11754735559225082) * emb_t3_28 + (0.00051393453031778336) * emb_t3_29 + (-0.77287799119949341) * emb_t3_30 + (-0.81934696435928345) * emb_t3_31 + gate_r * ((0.49530044198036194) + (0.049860347062349319) * gru_0_rev_t4_h_0 + (0.76703488826751709) * gru_0_rev_t4_h_1 + (0.62489598989486694) * gru_0_rev_t4_h_2 + (-0.23823939263820648) * gru_0_rev_t4_h_3 + (-0.5461469292640686) * gru_0_rev_t4_h_4 + (0.43172052502632141) * gru_0_rev_t4_h_5 + (-0.59742045402526855) * gru_0_rev_t4_h_6 + (1.5485072135925293) * gru_0_rev_t4_h_7 + (-0.081950098276138306) * gru_0_rev_t4_h_8 + (-0.038622237741947174) * gru_0_rev_t4_h_9 + (-0.66333013772964478) * gru_0_rev_t4_h_10 + (-0.75067037343978882) * gru_0_rev_t4_h_11 + (-0.3003598153591156) * gru_0_rev_t4_h_12 + (-0.35605457425117493) * gru_0_rev_t4_h_13 + (-0.7872309684753418) * gru_0_rev_t4_h_14 + (-0.50493168830871582) * gru_0_rev_t4_h_15 + (-0.16750071942806244) * gru_0_rev_t4_h_16 + (0.300179123878479) * gru_0_rev_t4_h_17 + (-0.86126643419265747) * gru_0_rev_t4_h_18 + (-0.58338648080825806) * gru_0_rev_t4_h_19 + (-0.40295472741127014) * gru_0_rev_t4_h_20 + (0.90753555297851562) * gru_0_rev_t4_h_21 + (-0.64459210634231567) * gru_0_rev_t4_h_22 + (0.85666817426681519) * gru_0_rev_t4_h_23 + (0.90827560424804688) * gru_0_rev_t4_h_24 + (0.28461691737174988) * gru_0_rev_t4_h_25 + (0.51095730066299438) * gru_0_rev_t4_h_26 + (-0.0027374541386961937) * gru_0_rev_t4_h_27 + (-0.62179118394851685) * gru_0_rev_t4_h_28 + (-0.56332075595855713) * gru_0_rev_t4_h_29 + (-0.76602470874786377) * gru_0_rev_t4_h_30 + (-0.95611107349395752) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_19 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_19;
    // h=20
    gate_r = sigmoid((0.30574136972427368) + (-0.096371293067932129) * emb_t3_0 + (0.78394633531570435) * emb_t3_1 + (-0.19684949517250061) * emb_t3_2 + (0.015630219131708145) * emb_t3_3 + (0.66065418720245361) * emb_t3_4 + (-0.031988333910703659) * emb_t3_5 + (0.12387829273939133) * emb_t3_6 + (0.016236612573266029) * emb_t3_7 + (0.60808330774307251) * emb_t3_8 + (-1.2002642154693604) * emb_t3_9 + (-1.0488544702529907) * emb_t3_10 + (0.1953919529914856) * emb_t3_11 + (0.49646413326263428) * emb_t3_12 + (0.83269304037094116) * emb_t3_13 + (0.057752717286348343) * emb_t3_14 + (0.027285249903798103) * emb_t3_15 + (-0.10062924027442932) * emb_t3_16 + (0.36470234394073486) * emb_t3_17 + (-1.4042959213256836) * emb_t3_18 + (0.47666895389556885) * emb_t3_19 + (-0.045229211449623108) * emb_t3_20 + (-0.029340252280235291) * emb_t3_21 + (-0.012155872769653797) * emb_t3_22 + (0.28922238945960999) * emb_t3_23 + (-0.012967183254659176) * emb_t3_24 + (-0.24206057190895081) * emb_t3_25 + (0.18798315525054932) * emb_t3_26 + (0.031028348952531815) * emb_t3_27 + (-1.1486427783966064) * emb_t3_28 + (1.0719989538192749) * emb_t3_29 + (-0.23517680168151855) * emb_t3_30 + (-0.76001191139221191) * emb_t3_31 + (0.29008477926254272) * gru_0_rev_t4_h_0 + (0.43456417322158813) * gru_0_rev_t4_h_1 + (0.71545624732971191) * gru_0_rev_t4_h_2 + (-0.13522092998027802) * gru_0_rev_t4_h_3 + (-0.57246524095535278) * gru_0_rev_t4_h_4 + (0.30482968688011169) * gru_0_rev_t4_h_5 + (-0.8470192551612854) * gru_0_rev_t4_h_6 + (0.097406201064586639) * gru_0_rev_t4_h_7 + (0.33608806133270264) * gru_0_rev_t4_h_8 + (-0.20028805732727051) * gru_0_rev_t4_h_9 + (0.25270557403564453) * gru_0_rev_t4_h_10 + (-0.2281852662563324) * gru_0_rev_t4_h_11 + (0.19141937792301178) * gru_0_rev_t4_h_12 + (0.060193493962287903) * gru_0_rev_t4_h_13 + (0.65485465526580811) * gru_0_rev_t4_h_14 + (-0.49229976534843445) * gru_0_rev_t4_h_15 + (-0.44837653636932373) * gru_0_rev_t4_h_16 + (0.38803461194038391) * gru_0_rev_t4_h_17 + (0.23619577288627625) * gru_0_rev_t4_h_18 + (-0.55703765153884888) * gru_0_rev_t4_h_19 + (-0.101089246571064) * gru_0_rev_t4_h_20 + (0.25306162238121033) * gru_0_rev_t4_h_21 + (0.043593514710664749) * gru_0_rev_t4_h_22 + (-0.062151357531547546) * gru_0_rev_t4_h_23 + (-0.20577748119831085) * gru_0_rev_t4_h_24 + (0.51868361234664917) * gru_0_rev_t4_h_25 + (0.38319280743598938) * gru_0_rev_t4_h_26 + (-0.18794938921928406) * gru_0_rev_t4_h_27 + (-0.37288874387741089) * gru_0_rev_t4_h_28 + (0.038253989070653915) * gru_0_rev_t4_h_29 + (-0.3785688579082489) * gru_0_rev_t4_h_30 + (-0.081888392567634583) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-0.013074534013867378) + (-0.078633993864059448) * emb_t3_0 + (1.5888527631759644) * emb_t3_1 + (-0.31464824080467224) * emb_t3_2 + (-0.0094735957682132721) * emb_t3_3 + (1.0337593555450439) * emb_t3_4 + (0.13330365717411041) * emb_t3_5 + (0.8087729811668396) * emb_t3_6 + (0.040261942893266678) * emb_t3_7 + (0.021398577839136124) * emb_t3_8 + (-0.47170218825340271) * emb_t3_9 + (-0.52772510051727295) * emb_t3_10 + (-0.10679770261049271) * emb_t3_11 + (0.17782081663608551) * emb_t3_12 + (1.8314095735549927) * emb_t3_13 + (0.043360203504562378) * emb_t3_14 + (0.33600574731826782) * emb_t3_15 + (-0.14760537445545197) * emb_t3_16 + (0.10373607277870178) * emb_t3_17 + (-0.6005403995513916) * emb_t3_18 + (0.53539389371871948) * emb_t3_19 + (-0.46471387147903442) * emb_t3_20 + (0.089228086173534393) * emb_t3_21 + (-0.15671248733997345) * emb_t3_22 + (-0.29380211234092712) * emb_t3_23 + (0.027899496257305145) * emb_t3_24 + (-0.15816964209079742) * emb_t3_25 + (-1.030306339263916) * emb_t3_26 + (-0.060929596424102783) * emb_t3_27 + (-1.3685263395309448) * emb_t3_28 + (1.3131042718887329) * emb_t3_29 + (-1.2264167070388794) * emb_t3_30 + (-0.24501195549964905) * emb_t3_31 + (-0.11779849231243134) * gru_0_rev_t4_h_0 + (-0.057751413434743881) * gru_0_rev_t4_h_1 + (-0.82389891147613525) * gru_0_rev_t4_h_2 + (-0.2451271265745163) * gru_0_rev_t4_h_3 + (2.1771302223205566) * gru_0_rev_t4_h_4 + (-0.78046870231628418) * gru_0_rev_t4_h_5 + (0.19221308827400208) * gru_0_rev_t4_h_6 + (0.39636901021003723) * gru_0_rev_t4_h_7 + (-0.23138920962810516) * gru_0_rev_t4_h_8 + (0.037157505750656128) * gru_0_rev_t4_h_9 + (0.27382385730743408) * gru_0_rev_t4_h_10 + (0.40058815479278564) * gru_0_rev_t4_h_11 + (-0.093243151903152466) * gru_0_rev_t4_h_12 + (-0.23992981016635895) * gru_0_rev_t4_h_13 + (0.46627107262611389) * gru_0_rev_t4_h_14 + (-0.20813947916030884) * gru_0_rev_t4_h_15 + (-1.3122349977493286) * gru_0_rev_t4_h_16 + (0.83763432502746582) * gru_0_rev_t4_h_17 + (-0.068385049700737) * gru_0_rev_t4_h_18 + (0.44184210896492004) * gru_0_rev_t4_h_19 + (-0.42737862467765808) * gru_0_rev_t4_h_20 + (-0.16682411730289459) * gru_0_rev_t4_h_21 + (-0.045943085104227066) * gru_0_rev_t4_h_22 + (-0.30070790648460388) * gru_0_rev_t4_h_23 + (0.5342327356338501) * gru_0_rev_t4_h_24 + (0.69349390268325806) * gru_0_rev_t4_h_25 + (-0.4382246732711792) * gru_0_rev_t4_h_26 + (-0.28722220659255981) * gru_0_rev_t4_h_27 + (-0.04669291153550148) * gru_0_rev_t4_h_28 + (-0.54635238647460938) * gru_0_rev_t4_h_29 + (0.42229104042053223) * gru_0_rev_t4_h_30 + (-0.20507647097110748) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.22971293330192566) + (0.029820721596479416) * emb_t3_0 + (0.80022686719894409) * emb_t3_1 + (0.046054650098085403) * emb_t3_2 + (-0.15211004018783569) * emb_t3_3 + (0.46707683801651001) * emb_t3_4 + (0.042870365083217621) * emb_t3_5 + (0.57972168922424316) * emb_t3_6 + (-0.014915795065462589) * emb_t3_7 + (0.41252151131629944) * emb_t3_8 + (-2.7285985946655273) * emb_t3_9 + (-1.6888195276260376) * emb_t3_10 + (-0.16130271553993225) * emb_t3_11 + (0.33149287104606628) * emb_t3_12 + (0.70486479997634888) * emb_t3_13 + (-0.007321289274841547) * emb_t3_14 + (0.0081356512382626534) * emb_t3_15 + (0.040817584842443466) * emb_t3_16 + (0.11674167215824127) * emb_t3_17 + (-0.89962577819824219) * emb_t3_18 + (0.66304612159729004) * emb_t3_19 + (0.22929759323596954) * emb_t3_20 + (0.018466096371412277) * emb_t3_21 + (-0.6468697190284729) * emb_t3_22 + (-0.076123885810375214) * emb_t3_23 + (0.018611298874020576) * emb_t3_24 + (0.042857419699430466) * emb_t3_25 + (0.11565127968788147) * emb_t3_26 + (-0.015362804755568504) * emb_t3_27 + (-0.1429801732301712) * emb_t3_28 + (0.426605224609375) * emb_t3_29 + (-0.17170427739620209) * emb_t3_30 + (-0.24655194580554962) * emb_t3_31 + gate_r * ((0.30836334824562073) + (0.272757887840271) * gru_0_rev_t4_h_0 + (-0.31748035550117493) * gru_0_rev_t4_h_1 + (0.68388497829437256) * gru_0_rev_t4_h_2 + (-0.12723776698112488) * gru_0_rev_t4_h_3 + (-0.89988642930984497) * gru_0_rev_t4_h_4 + (0.19017995893955231) * gru_0_rev_t4_h_5 + (-0.31037247180938721) * gru_0_rev_t4_h_6 + (0.49958139657974243) * gru_0_rev_t4_h_7 + (0.095766514539718628) * gru_0_rev_t4_h_8 + (-0.038461852818727493) * gru_0_rev_t4_h_9 + (0.081803873181343079) * gru_0_rev_t4_h_10 + (-0.11820783466100693) * gru_0_rev_t4_h_11 + (0.31407442688941956) * gru_0_rev_t4_h_12 + (-0.04573744535446167) * gru_0_rev_t4_h_13 + (0.50406968593597412) * gru_0_rev_t4_h_14 + (-0.29925087094306946) * gru_0_rev_t4_h_15 + (0.011413566768169403) * gru_0_rev_t4_h_16 + (-0.010602635331451893) * gru_0_rev_t4_h_17 + (0.25172498822212219) * gru_0_rev_t4_h_18 + (-0.25610029697418213) * gru_0_rev_t4_h_19 + (0.21399395167827606) * gru_0_rev_t4_h_20 + (0.17045196890830994) * gru_0_rev_t4_h_21 + (0.021990209817886353) * gru_0_rev_t4_h_22 + (-0.24323795735836029) * gru_0_rev_t4_h_23 + (0.1460147351026535) * gru_0_rev_t4_h_24 + (0.17138604819774628) * gru_0_rev_t4_h_25 + (0.094791419804096222) * gru_0_rev_t4_h_26 + (-0.47857460379600525) * gru_0_rev_t4_h_27 + (-0.12914192676544189) * gru_0_rev_t4_h_28 + (0.12111596018075943) * gru_0_rev_t4_h_29 + (-0.30202102661132812) * gru_0_rev_t4_h_30 + (0.49750059843063354) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_20 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_20;
    // h=21
    gate_r = sigmoid((-0.81632357835769653) + (-0.15533007681369781) * emb_t3_0 + (0.25004518032073975) * emb_t3_1 + (-0.59654700756072998) * emb_t3_2 + (-0.45024439692497253) * emb_t3_3 + (0.22536042332649231) * emb_t3_4 + (0.68719732761383057) * emb_t3_5 + (0.29456955194473267) * emb_t3_6 + (0.20197322964668274) * emb_t3_7 + (-0.68620979785919189) * emb_t3_8 + (0.77394843101501465) * emb_t3_9 + (0.35862115025520325) * emb_t3_10 + (-0.45027703046798706) * emb_t3_11 + (-0.39216193556785583) * emb_t3_12 + (-0.10403089970350266) * emb_t3_13 + (0.1512303352355957) * emb_t3_14 + (0.20774814486503601) * emb_t3_15 + (-0.34698522090911865) * emb_t3_16 + (0.11772714555263519) * emb_t3_17 + (0.74905049800872803) * emb_t3_18 + (-1.4287266731262207) * emb_t3_19 + (-0.19436617195606232) * emb_t3_20 + (-0.047971762716770172) * emb_t3_21 + (0.63111799955368042) * emb_t3_22 + (-0.73483830690383911) * emb_t3_23 + (-1.1406437158584595) * emb_t3_24 + (0.32612848281860352) * emb_t3_25 + (-0.16619542241096497) * emb_t3_26 + (-0.64201676845550537) * emb_t3_27 + (0.25412452220916748) * emb_t3_28 + (-0.034536037594079971) * emb_t3_29 + (-0.6244158148765564) * emb_t3_30 + (0.56147545576095581) * emb_t3_31 + (0.030036494135856628) * gru_0_rev_t4_h_0 + (-0.1817948967218399) * gru_0_rev_t4_h_1 + (-0.14791704714298248) * gru_0_rev_t4_h_2 + (-0.24522660672664642) * gru_0_rev_t4_h_3 + (-0.53708952665328979) * gru_0_rev_t4_h_4 + (0.57012075185775757) * gru_0_rev_t4_h_5 + (-0.021905357018113136) * gru_0_rev_t4_h_6 + (-0.70877552032470703) * gru_0_rev_t4_h_7 + (-0.19124811887741089) * gru_0_rev_t4_h_8 + (-0.39274734258651733) * gru_0_rev_t4_h_9 + (-0.27341416478157043) * gru_0_rev_t4_h_10 + (-0.080758281052112579) * gru_0_rev_t4_h_11 + (-0.3769582211971283) * gru_0_rev_t4_h_12 + (-0.39521673321723938) * gru_0_rev_t4_h_13 + (2.1075365543365479) * gru_0_rev_t4_h_14 + (0.036332488059997559) * gru_0_rev_t4_h_15 + (-1.6385825872421265) * gru_0_rev_t4_h_16 + (1.2308347225189209) * gru_0_rev_t4_h_17 + (0.32625627517700195) * gru_0_rev_t4_h_18 + (-0.30761229991912842) * gru_0_rev_t4_h_19 + (0.094761870801448822) * gru_0_rev_t4_h_20 + (-0.13354326784610748) * gru_0_rev_t4_h_21 + (0.31828978657722473) * gru_0_rev_t4_h_22 + (-0.99566406011581421) * gru_0_rev_t4_h_23 + (-0.69903439283370972) * gru_0_rev_t4_h_24 + (1.7141659259796143) * gru_0_rev_t4_h_25 + (0.17539328336715698) * gru_0_rev_t4_h_26 + (0.378182053565979) * gru_0_rev_t4_h_27 + (-0.35687345266342163) * gru_0_rev_t4_h_28 + (0.059338703751564026) * gru_0_rev_t4_h_29 + (-0.36650443077087402) * gru_0_rev_t4_h_30 + (0.67648077011108398) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-0.74580198526382446) + (0.41014713048934937) * emb_t3_0 + (0.23182281851768494) * emb_t3_1 + (0.13059556484222412) * emb_t3_2 + (-0.094242304563522339) * emb_t3_3 + (0.94689780473709106) * emb_t3_4 + (0.34524530172348022) * emb_t3_5 + (0.89168083667755127) * emb_t3_6 + (-0.36694890260696411) * emb_t3_7 + (-0.17787168920040131) * emb_t3_8 + (0.62961816787719727) * emb_t3_9 + (0.48802617192268372) * emb_t3_10 + (-0.26804685592651367) * emb_t3_11 + (-0.34741714596748352) * emb_t3_12 + (0.21053895354270935) * emb_t3_13 + (0.056148260831832886) * emb_t3_14 + (-0.19469892978668213) * emb_t3_15 + (-0.1933322548866272) * emb_t3_16 + (0.47850921750068665) * emb_t3_17 + (-0.17392952740192413) * emb_t3_18 + (-0.45702219009399414) * emb_t3_19 + (-0.58957219123840332) * emb_t3_20 + (-0.43115532398223877) * emb_t3_21 + (0.49823564291000366) * emb_t3_22 + (-0.7252575159072876) * emb_t3_23 + (-0.26195994019508362) * emb_t3_24 + (0.012542654760181904) * emb_t3_25 + (-0.79435580968856812) * emb_t3_26 + (-0.15644161403179169) * emb_t3_27 + (-0.28429168462753296) * emb_t3_28 + (0.75150197744369507) * emb_t3_29 + (-0.55153673887252808) * emb_t3_30 + (0.40481123328208923) * emb_t3_31 + (-0.65018826723098755) * gru_0_rev_t4_h_0 + (0.23003622889518738) * gru_0_rev_t4_h_1 + (-0.60091352462768555) * gru_0_rev_t4_h_2 + (0.010578064247965813) * gru_0_rev_t4_h_3 + (3.5816988945007324) * gru_0_rev_t4_h_4 + (-1.0982723236083984) * gru_0_rev_t4_h_5 + (0.16565942764282227) * gru_0_rev_t4_h_6 + (0.030678221955895424) * gru_0_rev_t4_h_7 + (-0.2647654116153717) * gru_0_rev_t4_h_8 + (0.049863900989294052) * gru_0_rev_t4_h_9 + (0.57620209455490112) * gru_0_rev_t4_h_10 + (0.42354625463485718) * gru_0_rev_t4_h_11 + (-0.11818486452102661) * gru_0_rev_t4_h_12 + (-0.35285103321075439) * gru_0_rev_t4_h_13 + (-0.33257588744163513) * gru_0_rev_t4_h_14 + (0.32060518860816956) * gru_0_rev_t4_h_15 + (-1.756679892539978) * gru_0_rev_t4_h_16 + (0.9892461895942688) * gru_0_rev_t4_h_17 + (-0.40303543210029602) * gru_0_rev_t4_h_18 + (0.35417014360427856) * gru_0_rev_t4_h_19 + (-1.5172733068466187) * gru_0_rev_t4_h_20 + (-0.017582299187779427) * gru_0_rev_t4_h_21 + (0.25691404938697815) * gru_0_rev_t4_h_22 + (-0.0060996357351541519) * gru_0_rev_t4_h_23 + (0.3703618049621582) * gru_0_rev_t4_h_24 + (1.4592447280883789) * gru_0_rev_t4_h_25 + (-0.14088185131549835) * gru_0_rev_t4_h_26 + (0.28511446714401245) * gru_0_rev_t4_h_27 + (0.34392303228378296) * gru_0_rev_t4_h_28 + (-0.37724888324737549) * gru_0_rev_t4_h_29 + (0.3921085000038147) * gru_0_rev_t4_h_30 + (1.4043868780136108) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.064671911299228668) + (-0.0145057188346982) * emb_t3_0 + (-0.45209154486656189) * emb_t3_1 + (-0.016878098249435425) * emb_t3_2 + (-0.43513000011444092) * emb_t3_3 + (-0.10596102476119995) * emb_t3_4 + (0.024203134700655937) * emb_t3_5 + (-0.28881499171257019) * emb_t3_6 + (-0.0098277358338236809) * emb_t3_7 + (0.13458746671676636) * emb_t3_8 + (0.8168601393699646) * emb_t3_9 + (0.54673868417739868) * emb_t3_10 + (-0.013148934580385685) * emb_t3_11 + (0.17140950262546539) * emb_t3_12 + (-0.75303566455841064) * emb_t3_13 + (-0.0048305625095963478) * emb_t3_14 + (0.0017919479869306087) * emb_t3_15 + (-0.01953292079269886) * emb_t3_16 + (-0.34601119160652161) * emb_t3_17 + (0.34857809543609619) * emb_t3_18 + (-0.13400174677371979) * emb_t3_19 + (0.30393022298812866) * emb_t3_20 + (0.016960266977548599) * emb_t3_21 + (0.079755917191505432) * emb_t3_22 + (-0.014274687506258488) * emb_t3_23 + (-0.010848176665604115) * emb_t3_24 + (0.014527259394526482) * emb_t3_25 + (-0.10188835859298706) * emb_t3_26 + (-0.017021981999278069) * emb_t3_27 + (0.4810810387134552) * emb_t3_28 + (-0.74018782377243042) * emb_t3_29 + (0.27836692333221436) * emb_t3_30 + (-0.20410780608654022) * emb_t3_31 + gate_r * ((-0.03882262110710144) + (0.23613323271274567) * gru_0_rev_t4_h_0 + (0.547199547290802) * gru_0_rev_t4_h_1 + (-0.080379486083984375) * gru_0_rev_t4_h_2 + (0.11759023368358612) * gru_0_rev_t4_h_3 + (0.40053084492683411) * gru_0_rev_t4_h_4 + (-0.0051631508395075798) * gru_0_rev_t4_h_5 + (-0.29391166567802429) * gru_0_rev_t4_h_6 + (-2.9377017021179199) * gru_0_rev_t4_h_7 + (-0.19085779786109924) * gru_0_rev_t4_h_8 + (-0.034337308257818222) * gru_0_rev_t4_h_9 + (0.46432998776435852) * gru_0_rev_t4_h_10 + (0.043750230222940445) * gru_0_rev_t4_h_11 + (-0.21605478227138519) * gru_0_rev_t4_h_12 + (0.13423877954483032) * gru_0_rev_t4_h_13 + (0.32390531897544861) * gru_0_rev_t4_h_14 + (0.28931945562362671) * gru_0_rev_t4_h_15 + (1.3561997413635254) * gru_0_rev_t4_h_16 + (-0.89693480730056763) * gru_0_rev_t4_h_17 + (-0.11550487577915192) * gru_0_rev_t4_h_18 + (0.25660702586174011) * gru_0_rev_t4_h_19 + (-0.12810270488262177) * gru_0_rev_t4_h_20 + (-0.01962827704846859) * gru_0_rev_t4_h_21 + (-0.0072524254210293293) * gru_0_rev_t4_h_22 + (-0.39640045166015625) * gru_0_rev_t4_h_23 + (0.61379718780517578) * gru_0_rev_t4_h_24 + (-1.319873571395874) * gru_0_rev_t4_h_25 + (-0.071038857102394104) * gru_0_rev_t4_h_26 + (0.51573324203491211) * gru_0_rev_t4_h_27 + (0.15873563289642334) * gru_0_rev_t4_h_28 + (-0.077660836279392242) * gru_0_rev_t4_h_29 + (0.056553315371274948) * gru_0_rev_t4_h_30 + (-0.64311128854751587) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_21 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_21;
    // h=22
    gate_r = sigmoid((0.32870063185691833) + (-0.077598646283149719) * emb_t3_0 + (-0.12727274000644684) * emb_t3_1 + (-0.32023012638092041) * emb_t3_2 + (0.10055723041296005) * emb_t3_3 + (-0.62927377223968506) * emb_t3_4 + (0.14438393712043762) * emb_t3_5 + (-0.44472554326057434) * emb_t3_6 + (-0.16689799726009369) * emb_t3_7 + (-0.0067595671862363815) * emb_t3_8 + (-0.17882181704044342) * emb_t3_9 + (0.56066477298736572) * emb_t3_10 + (-0.071845710277557373) * emb_t3_11 + (-0.63292938470840454) * emb_t3_12 + (-0.061934899538755417) * emb_t3_13 + (0.0032900529913604259) * emb_t3_14 + (-0.16320358216762543) * emb_t3_15 + (0.46593967080116272) * emb_t3_16 + (-0.40324035286903381) * emb_t3_17 + (0.27885061502456665) * emb_t3_18 + (-0.74125570058822632) * emb_t3_19 + (0.37897410988807678) * emb_t3_20 + (-0.080790154635906219) * emb_t3_21 + (0.019687112420797348) * emb_t3_22 + (-0.43844661116600037) * emb_t3_23 + (0.014504094608128071) * emb_t3_24 + (-0.44512251019477844) * emb_t3_25 + (0.17529314756393433) * emb_t3_26 + (-0.25938299298286438) * emb_t3_27 + (0.20370449125766754) * emb_t3_28 + (-0.42857608199119568) * emb_t3_29 + (0.76999980211257935) * emb_t3_30 + (0.13001042604446411) * emb_t3_31 + (0.012551396153867245) * gru_0_rev_t4_h_0 + (0.0085055259987711906) * gru_0_rev_t4_h_1 + (0.014457453042268753) * gru_0_rev_t4_h_2 + (0.49727776646614075) * gru_0_rev_t4_h_3 + (-0.1673801988363266) * gru_0_rev_t4_h_4 + (-0.29700899124145508) * gru_0_rev_t4_h_5 + (-0.33129352331161499) * gru_0_rev_t4_h_6 + (1.0138317346572876) * gru_0_rev_t4_h_7 + (-0.051358554512262344) * gru_0_rev_t4_h_8 + (0.66814243793487549) * gru_0_rev_t4_h_9 + (-0.84981012344360352) * gru_0_rev_t4_h_10 + (-0.0097070168703794479) * gru_0_rev_t4_h_11 + (0.50274187326431274) * gru_0_rev_t4_h_12 + (0.5099753737449646) * gru_0_rev_t4_h_13 + (-1.7709659337997437) * gru_0_rev_t4_h_14 + (-0.26266393065452576) * gru_0_rev_t4_h_15 + (0.070702902972698212) * gru_0_rev_t4_h_16 + (0.027287090197205544) * gru_0_rev_t4_h_17 + (0.25169706344604492) * gru_0_rev_t4_h_18 + (-0.1601155549287796) * gru_0_rev_t4_h_19 + (0.13819383084774017) * gru_0_rev_t4_h_20 + (0.19380401074886322) * gru_0_rev_t4_h_21 + (-0.4714038074016571) * gru_0_rev_t4_h_22 + (0.68250167369842529) * gru_0_rev_t4_h_23 + (0.27278736233711243) * gru_0_rev_t4_h_24 + (0.12594527006149292) * gru_0_rev_t4_h_25 + (-0.13713422417640686) * gru_0_rev_t4_h_26 + (-0.80008792877197266) * gru_0_rev_t4_h_27 + (0.34874257445335388) * gru_0_rev_t4_h_28 + (1.1264675855636597) * gru_0_rev_t4_h_29 + (0.27757617831230164) * gru_0_rev_t4_h_30 + (-1.2893474102020264) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((0.39693024754524231) + (0.010230946354568005) * emb_t3_0 + (-0.47218921780586243) * emb_t3_1 + (0.097433693706989288) * emb_t3_2 + (0.32850766181945801) * emb_t3_3 + (-0.31571677327156067) * emb_t3_4 + (0.10928338021039963) * emb_t3_5 + (-0.071918308734893799) * emb_t3_6 + (0.0096652237698435783) * emb_t3_7 + (0.42622661590576172) * emb_t3_8 + (-0.6314467191696167) * emb_t3_9 + (-0.5540047287940979) * emb_t3_10 + (0.58308660984039307) * emb_t3_11 + (0.41726681590080261) * emb_t3_12 + (-0.30103424191474915) * emb_t3_13 + (-0.078893117606639862) * emb_t3_14 + (0.085925668478012085) * emb_t3_15 + (0.05362258106470108) * emb_t3_16 + (0.023656098172068596) * emb_t3_17 + (-0.40956547856330872) * emb_t3_18 + (0.24052409827709198) * emb_t3_19 + (0.16636624932289124) * emb_t3_20 + (-0.053386863321065903) * emb_t3_21 + (0.0068326340988278389) * emb_t3_22 + (0.031989037990570068) * emb_t3_23 + (-0.2554301917552948) * emb_t3_24 + (0.12300414592027664) * emb_t3_25 + (-0.081419952213764191) * emb_t3_26 + (0.081370718777179718) * emb_t3_27 + (0.52485525608062744) * emb_t3_28 + (-0.25920924544334412) * emb_t3_29 + (0.050281360745429993) * emb_t3_30 + (-0.26076352596282959) * emb_t3_31 + (-0.13461494445800781) * gru_0_rev_t4_h_0 + (-0.5723576545715332) * gru_0_rev_t4_h_1 + (-0.31034043431282043) * gru_0_rev_t4_h_2 + (0.26939558982849121) * gru_0_rev_t4_h_3 + (0.31477206945419312) * gru_0_rev_t4_h_4 + (-0.083796277642250061) * gru_0_rev_t4_h_5 + (0.68200564384460449) * gru_0_rev_t4_h_6 + (0.015656586736440659) * gru_0_rev_t4_h_7 + (-0.10043171048164368) * gru_0_rev_t4_h_8 + (-0.19634667038917542) * gru_0_rev_t4_h_9 + (0.52963244915008545) * gru_0_rev_t4_h_10 + (0.02350473590195179) * gru_0_rev_t4_h_11 + (0.073429234325885773) * gru_0_rev_t4_h_12 + (-0.065192468464374542) * gru_0_rev_t4_h_13 + (-0.41146591305732727) * gru_0_rev_t4_h_14 + (0.029939549043774605) * gru_0_rev_t4_h_15 + (0.21214859187602997) * gru_0_rev_t4_h_16 + (-0.28571996092796326) * gru_0_rev_t4_h_17 + (-0.48747232556343079) * gru_0_rev_t4_h_18 + (0.25559329986572266) * gru_0_rev_t4_h_19 + (0.25654563307762146) * gru_0_rev_t4_h_20 + (-0.13593241572380066) * gru_0_rev_t4_h_21 + (0.055764798074960709) * gru_0_rev_t4_h_22 + (-0.6828647255897522) * gru_0_rev_t4_h_23 + (0.14541517198085785) * gru_0_rev_t4_h_24 + (-0.082175113260746002) * gru_0_rev_t4_h_25 + (0.058972310274839401) * gru_0_rev_t4_h_26 + (-0.84776854515075684) * gru_0_rev_t4_h_27 + (0.47608709335327148) * gru_0_rev_t4_h_28 + (0.22962296009063721) * gru_0_rev_t4_h_29 + (0.30654478073120117) * gru_0_rev_t4_h_30 + (0.37256088852882385) * gru_0_rev_t4_h_31);
    gate_n = tanh((-3.4135909080505371) + (0.002728540450334549) * emb_t3_0 + (-0.27497506141662598) * emb_t3_1 + (0.0029159768018871546) * emb_t3_2 + (-0.13194204866886139) * emb_t3_3 + (-0.056994132697582245) * emb_t3_4 + (0.0006965980282984674) * emb_t3_5 + (0.44180935621261597) * emb_t3_6 + (0.00088222773047164083) * emb_t3_7 + (0.0082344608381390572) * emb_t3_8 + (-0.033774677664041519) * emb_t3_9 + (0.53089648485183716) * emb_t3_10 + (-0.16563704609870911) * emb_t3_11 + (0.020524762570858002) * emb_t3_12 + (0.28117311000823975) * emb_t3_13 + (-0.0043445685878396034) * emb_t3_14 + (0.0034962492063641548) * emb_t3_15 + (-0.00084853387670591474) * emb_t3_16 + (0.040554888546466827) * emb_t3_17 + (0.35078164935112) * emb_t3_18 + (-0.3072967529296875) * emb_t3_19 + (-0.11760462075471878) * emb_t3_20 + (-0.0014168376801535487) * emb_t3_21 + (-0.037649985402822495) * emb_t3_22 + (-0.0021140382159501314) * emb_t3_23 + (-0.0032717080321162939) * emb_t3_24 + (0.0039416556246578693) * emb_t3_25 + (-0.038618061691522598) * emb_t3_26 + (0.00077581842197105289) * emb_t3_27 + (0.065976612269878387) * emb_t3_28 + (0.21243771910667419) * emb_t3_29 + (0.34293198585510254) * emb_t3_30 + (0.37474724650382996) * emb_t3_31 + gate_r * ((-3.4165711402893066) + (-1.0572010278701782) * gru_0_rev_t4_h_0 + (0.76402002573013306) * gru_0_rev_t4_h_1 + (-0.7172510027885437) * gru_0_rev_t4_h_2 + (-0.91790354251861572) * gru_0_rev_t4_h_3 + (1.2348778247833252) * gru_0_rev_t4_h_4 + (0.43827912211418152) * gru_0_rev_t4_h_5 + (1.148149847984314) * gru_0_rev_t4_h_6 + (-1.2835228443145752) * gru_0_rev_t4_h_7 + (-2.4781920909881592) * gru_0_rev_t4_h_8 + (-0.90043646097183228) * gru_0_rev_t4_h_9 + (2.1606545448303223) * gru_0_rev_t4_h_10 + (1.3142671585083008) * gru_0_rev_t4_h_11 + (-0.4072534441947937) * gru_0_rev_t4_h_12 + (-0.42482134699821472) * gru_0_rev_t4_h_13 + (1.4162136316299438) * gru_0_rev_t4_h_14 + (0.54700541496276855) * gru_0_rev_t4_h_15 + (-0.7384033203125) * gru_0_rev_t4_h_16 + (1.076383113861084) * gru_0_rev_t4_h_17 + (-1.0547444820404053) * gru_0_rev_t4_h_18 + (-0.37132364511489868) * gru_0_rev_t4_h_19 + (0.46305972337722778) * gru_0_rev_t4_h_20 + (-1.1141586303710938) * gru_0_rev_t4_h_21 + (-0.13127243518829346) * gru_0_rev_t4_h_22 + (-1.157027006149292) * gru_0_rev_t4_h_23 + (-1.3827331066131592) * gru_0_rev_t4_h_24 + (1.0131667852401733) * gru_0_rev_t4_h_25 + (0.12766462564468384) * gru_0_rev_t4_h_26 + (-1.1904133558273315) * gru_0_rev_t4_h_27 + (-0.49130567908287048) * gru_0_rev_t4_h_28 + (-3.3528614044189453) * gru_0_rev_t4_h_29 + (-0.52101564407348633) * gru_0_rev_t4_h_30 + (0.56442910432815552) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_22 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_22;
    // h=23
    gate_r = sigmoid((0.6727975606918335) + (0.15331923961639404) * emb_t3_0 + (0.19076457619667053) * emb_t3_1 + (0.041639707982540131) * emb_t3_2 + (0.086788080632686615) * emb_t3_3 + (0.40731707215309143) * emb_t3_4 + (0.046675305813550949) * emb_t3_5 + (0.53039056062698364) * emb_t3_6 + (-0.26320245862007141) * emb_t3_7 + (3.864422082901001) * emb_t3_8 + (-0.3848341703414917) * emb_t3_9 + (-0.096491813659667969) * emb_t3_10 + (0.11183642596006393) * emb_t3_11 + (6.1263818740844727) * emb_t3_12 + (0.82057327032089233) * emb_t3_13 + (-0.33826020359992981) * emb_t3_14 + (-1.0511786937713623) * emb_t3_15 + (-0.77991348505020142) * emb_t3_16 + (0.15794000029563904) * emb_t3_17 + (-0.34941175580024719) * emb_t3_18 + (0.74547916650772095) * emb_t3_19 + (0.18030849099159241) * emb_t3_20 + (0.61507946252822876) * emb_t3_21 + (-1.170180082321167) * emb_t3_22 + (0.42506828904151917) * emb_t3_23 + (0.10956092923879623) * emb_t3_24 + (0.27264097332954407) * emb_t3_25 + (-0.78987628221511841) * emb_t3_26 + (-0.38116616010665894) * emb_t3_27 + (-0.78061223030090332) * emb_t3_28 + (0.38897690176963806) * emb_t3_29 + (-0.72332066297531128) * emb_t3_30 + (-6.2226972579956055) * emb_t3_31 + (-0.2336336225271225) * gru_0_rev_t4_h_0 + (0.4087541401386261) * gru_0_rev_t4_h_1 + (0.35056540369987488) * gru_0_rev_t4_h_2 + (-0.51323610544204712) * gru_0_rev_t4_h_3 + (-0.41747727990150452) * gru_0_rev_t4_h_4 + (0.4970528781414032) * gru_0_rev_t4_h_5 + (-0.143475741147995) * gru_0_rev_t4_h_6 + (-2.038870096206665) * gru_0_rev_t4_h_7 + (0.27701282501220703) * gru_0_rev_t4_h_8 + (-0.28624480962753296) * gru_0_rev_t4_h_9 + (0.53097295761108398) * gru_0_rev_t4_h_10 + (-0.20609082281589508) * gru_0_rev_t4_h_11 + (-0.40064823627471924) * gru_0_rev_t4_h_12 + (-0.33729743957519531) * gru_0_rev_t4_h_13 + (1.7965576648712158) * gru_0_rev_t4_h_14 + (-0.32379621267318726) * gru_0_rev_t4_h_15 + (1.041434645652771) * gru_0_rev_t4_h_16 + (-0.37770804762840271) * gru_0_rev_t4_h_17 + (-0.083221308887004852) * gru_0_rev_t4_h_18 + (-0.58349615335464478) * gru_0_rev_t4_h_19 + (-0.81493842601776123) * gru_0_rev_t4_h_20 + (0.16538241505622864) * gru_0_rev_t4_h_21 + (-0.82770282030105591) * gru_0_rev_t4_h_22 + (1.0054172277450562) * gru_0_rev_t4_h_23 + (0.054529301822185516) * gru_0_rev_t4_h_24 + (-0.73493587970733643) * gru_0_rev_t4_h_25 + (0.51083832979202271) * gru_0_rev_t4_h_26 + (0.64808773994445801) * gru_0_rev_t4_h_27 + (-0.75693023204803467) * gru_0_rev_t4_h_28 + (-0.30791401863098145) * gru_0_rev_t4_h_29 + (-0.53437697887420654) * gru_0_rev_t4_h_30 + (0.84135603904724121) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-0.81445848941802979) + (0.00043014364200644195) * emb_t3_0 + (-0.2161974161863327) * emb_t3_1 + (-0.0027795892674475908) * emb_t3_2 + (-0.0603770911693573) * emb_t3_3 + (0.1652170717716217) * emb_t3_4 + (0.00091139733558520675) * emb_t3_5 + (-0.14932477474212646) * emb_t3_6 + (0.00092351622879505157) * emb_t3_7 + (0.03801090270280838) * emb_t3_8 + (-0.059916872531175613) * emb_t3_9 + (-0.28817501664161682) * emb_t3_10 + (-0.066594876348972321) * emb_t3_11 + (-0.46100166440010071) * emb_t3_12 + (0.36268642544746399) * emb_t3_13 + (-6.2344491880139685e-07) * emb_t3_14 + (-0.0016302572330459952) * emb_t3_15 + (-0.0021349424496293068) * emb_t3_16 + (0.47143852710723877) * emb_t3_17 + (0.39460316300392151) * emb_t3_18 + (-0.46239304542541504) * emb_t3_19 + (-0.12200218439102173) * emb_t3_20 + (-8.3172235463280231e-05) * emb_t3_21 + (0.1636136919260025) * emb_t3_22 + (0.00035267483326606452) * emb_t3_23 + (-0.00015512465324718505) * emb_t3_24 + (0.0024075089022517204) * emb_t3_25 + (-0.018496673554182053) * emb_t3_26 + (-0.0006459130672737956) * emb_t3_27 + (-0.34508103132247925) * emb_t3_28 + (-0.33571326732635498) * emb_t3_29 + (-0.25194844603538513) * emb_t3_30 + (0.023423835635185242) * emb_t3_31 + (-0.27480053901672363) * gru_0_rev_t4_h_0 + (0.6029478907585144) * gru_0_rev_t4_h_1 + (0.093613401055335999) * gru_0_rev_t4_h_2 + (-0.93568253517150879) * gru_0_rev_t4_h_3 + (-0.72381049394607544) * gru_0_rev_t4_h_4 + (0.2315870076417923) * gru_0_rev_t4_h_5 + (0.43033063411712646) * gru_0_rev_t4_h_6 + (-0.14601825177669525) * gru_0_rev_t4_h_7 + (-0.32152420282363892) * gru_0_rev_t4_h_8 + (-0.9383808970451355) * gru_0_rev_t4_h_9 + (0.24782095849514008) * gru_0_rev_t4_h_10 + (0.091387927532196045) * gru_0_rev_t4_h_11 + (-0.60664302110671997) * gru_0_rev_t4_h_12 + (-0.78158479928970337) * gru_0_rev_t4_h_13 + (-0.02315213531255722) * gru_0_rev_t4_h_14 + (0.32525959610939026) * gru_0_rev_t4_h_15 + (-0.29633909463882446) * gru_0_rev_t4_h_16 + (0.17126950621604919) * gru_0_rev_t4_h_17 + (-0.18991521000862122) * gru_0_rev_t4_h_18 + (-0.80608069896697998) * gru_0_rev_t4_h_19 + (-0.30633252859115601) * gru_0_rev_t4_h_20 + (-0.084870748221874237) * gru_0_rev_t4_h_21 + (0.44345256686210632) * gru_0_rev_t4_h_22 + (-0.47282901406288147) * gru_0_rev_t4_h_23 + (0.090940177440643311) * gru_0_rev_t4_h_24 + (0.074187710881233215) * gru_0_rev_t4_h_25 + (0.52107971906661987) * gru_0_rev_t4_h_26 + (-0.15343435108661652) * gru_0_rev_t4_h_27 + (0.15878739953041077) * gru_0_rev_t4_h_28 + (-0.58388334512710571) * gru_0_rev_t4_h_29 + (-0.94425046443939209) * gru_0_rev_t4_h_30 + (0.18047496676445007) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.81481647491455078) + (0.38457006216049194) * emb_t3_0 + (0.49048694968223572) * emb_t3_1 + (0.96388512849807739) * emb_t3_2 + (0.54865503311157227) * emb_t3_3 + (-0.056372877210378647) * emb_t3_4 + (0.41909492015838623) * emb_t3_5 + (0.15156026184558868) * emb_t3_6 + (-1.1325676441192627) * emb_t3_7 + (3.7597672939300537) * emb_t3_8 + (-0.6779559850692749) * emb_t3_9 + (-0.8543325662612915) * emb_t3_10 + (0.72184109687805176) * emb_t3_11 + (3.5904181003570557) * emb_t3_12 + (0.09551035612821579) * emb_t3_13 + (0.025600003078579903) * emb_t3_14 + (-0.3581484854221344) * emb_t3_15 + (-0.17473210394382477) * emb_t3_16 + (-0.10362590849399567) * emb_t3_17 + (-0.95575052499771118) * emb_t3_18 + (1.0804091691970825) * emb_t3_19 + (1.1961759328842163) * emb_t3_20 + (-0.43121173977851868) * emb_t3_21 + (-1.5881068706512451) * emb_t3_22 + (-0.53644019365310669) * emb_t3_23 + (-0.42774546146392822) * emb_t3_24 + (-1.1619769334793091) * emb_t3_25 + (0.41951170563697815) * emb_t3_26 + (-0.46760568022727966) * emb_t3_27 + (-0.46871235966682434) * emb_t3_28 + (0.20510822534561157) * emb_t3_29 + (0.071247518062591553) * emb_t3_30 + (-3.4489779472351074) * emb_t3_31 + gate_r * ((0.72348600625991821) + (-0.21128959953784943) * gru_0_rev_t4_h_0 + (0.43582364916801453) * gru_0_rev_t4_h_1 + (0.28417354822158813) * gru_0_rev_t4_h_2 + (-0.16446900367736816) * gru_0_rev_t4_h_3 + (-0.35114353895187378) * gru_0_rev_t4_h_4 + (0.19662401080131531) * gru_0_rev_t4_h_5 + (-0.89716655015945435) * gru_0_rev_t4_h_6 + (-1.3547604084014893) * gru_0_rev_t4_h_7 + (0.093750834465026855) * gru_0_rev_t4_h_8 + (0.047388970851898193) * gru_0_rev_t4_h_9 + (1.3295098543167114) * gru_0_rev_t4_h_10 + (-0.53259295225143433) * gru_0_rev_t4_h_11 + (-0.031151574105024338) * gru_0_rev_t4_h_12 + (-0.097738146781921387) * gru_0_rev_t4_h_13 + (1.545184850692749) * gru_0_rev_t4_h_14 + (-0.63869458436965942) * gru_0_rev_t4_h_15 + (0.19257925450801849) * gru_0_rev_t4_h_16 + (0.15669120848178864) * gru_0_rev_t4_h_17 + (0.10782385617494583) * gru_0_rev_t4_h_18 + (-0.30630472302436829) * gru_0_rev_t4_h_19 + (-0.32552281022071838) * gru_0_rev_t4_h_20 + (0.83168798685073853) * gru_0_rev_t4_h_21 + (0.91527825593948364) * gru_0_rev_t4_h_22 + (-0.46431750059127808) * gru_0_rev_t4_h_23 + (-1.0346543788909912) * gru_0_rev_t4_h_24 + (-0.085599184036254883) * gru_0_rev_t4_h_25 + (0.2071634829044342) * gru_0_rev_t4_h_26 + (0.92889952659606934) * gru_0_rev_t4_h_27 + (-0.67975056171417236) * gru_0_rev_t4_h_28 + (1.9859566688537598) * gru_0_rev_t4_h_29 + (-0.36501923203468323) * gru_0_rev_t4_h_30 + (-1.6718012094497681) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_23 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_23;
    // h=24
    gate_r = sigmoid((0.67366540431976318) + (0.41744104027748108) * emb_t3_0 + (-0.058972612023353577) * emb_t3_1 + (-0.40895506739616394) * emb_t3_2 + (-0.24018912017345428) * emb_t3_3 + (-0.24757079780101776) * emb_t3_4 + (-0.13943079113960266) * emb_t3_5 + (0.052713871002197266) * emb_t3_6 + (0.21726503968238831) * emb_t3_7 + (0.5896485447883606) * emb_t3_8 + (-0.1245899572968483) * emb_t3_9 + (-0.5707390308380127) * emb_t3_10 + (0.16533045470714569) * emb_t3_11 + (0.34912854433059692) * emb_t3_12 + (0.50022178888320923) * emb_t3_13 + (-0.55664843320846558) * emb_t3_14 + (0.1970478743314743) * emb_t3_15 + (-0.059312544763088226) * emb_t3_16 + (-0.15058945119380951) * emb_t3_17 + (-0.37469914555549622) * emb_t3_18 + (0.024496898055076599) * emb_t3_19 + (0.52491331100463867) * emb_t3_20 + (-0.39102199673652649) * emb_t3_21 + (-0.7402040958404541) * emb_t3_22 + (0.50304657220840454) * emb_t3_23 + (-0.33863544464111328) * emb_t3_24 + (0.49096950888633728) * emb_t3_25 + (0.026264974847435951) * emb_t3_26 + (-0.09327089786529541) * emb_t3_27 + (-0.3275819718837738) * emb_t3_28 + (0.23906369507312775) * emb_t3_29 + (0.50904238224029541) * emb_t3_30 + (-0.56786048412322998) * emb_t3_31 + (0.14269463717937469) * gru_0_rev_t4_h_0 + (0.051370784640312195) * gru_0_rev_t4_h_1 + (0.01738586463034153) * gru_0_rev_t4_h_2 + (0.56573235988616943) * gru_0_rev_t4_h_3 + (1.7958309650421143) * gru_0_rev_t4_h_4 + (-0.33615660667419434) * gru_0_rev_t4_h_5 + (0.19951942563056946) * gru_0_rev_t4_h_6 + (0.26972317695617676) * gru_0_rev_t4_h_7 + (0.50088328123092651) * gru_0_rev_t4_h_8 + (0.50990968942642212) * gru_0_rev_t4_h_9 + (-0.38520386815071106) * gru_0_rev_t4_h_10 + (-0.21905809640884399) * gru_0_rev_t4_h_11 + (0.70846635103225708) * gru_0_rev_t4_h_12 + (0.43805631995201111) * gru_0_rev_t4_h_13 + (0.50936460494995117) * gru_0_rev_t4_h_14 + (0.35883694887161255) * gru_0_rev_t4_h_15 + (0.015351373702287674) * gru_0_rev_t4_h_16 + (-0.046346381306648254) * gru_0_rev_t4_h_17 + (0.44200322031974792) * gru_0_rev_t4_h_18 + (0.69019240140914917) * gru_0_rev_t4_h_19 + (0.35603445768356323) * gru_0_rev_t4_h_20 + (-0.20450533926486969) * gru_0_rev_t4_h_21 + (-0.11160223931074142) * gru_0_rev_t4_h_22 + (0.31017038226127625) * gru_0_rev_t4_h_23 + (-0.19124738872051239) * gru_0_rev_t4_h_24 + (-0.044110305607318878) * gru_0_rev_t4_h_25 + (-0.52142542600631714) * gru_0_rev_t4_h_26 + (0.44860795140266418) * gru_0_rev_t4_h_27 + (0.3724696934223175) * gru_0_rev_t4_h_28 + (0.17023472487926483) * gru_0_rev_t4_h_29 + (0.42052951455116272) * gru_0_rev_t4_h_30 + (-0.27891340851783752) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-0.089968547224998474) + (0.0035437550395727158) * emb_t3_0 + (-0.41170632839202881) * emb_t3_1 + (-0.0065493029542267323) * emb_t3_2 + (0.30897712707519531) * emb_t3_3 + (-0.40353056788444519) * emb_t3_4 + (0.039284799247980118) * emb_t3_5 + (-0.35245269536972046) * emb_t3_6 + (0.32541763782501221) * emb_t3_7 + (-0.53564023971557617) * emb_t3_8 + (0.91905266046524048) * emb_t3_9 + (0.6215406060218811) * emb_t3_10 + (-0.60992449522018433) * emb_t3_11 + (-0.66984701156616211) * emb_t3_12 + (-0.71973097324371338) * emb_t3_13 + (-0.24336706101894379) * emb_t3_14 + (0.19901297986507416) * emb_t3_15 + (-0.086203522980213165) * emb_t3_16 + (-0.083043746650218964) * emb_t3_17 + (0.73421323299407959) * emb_t3_18 + (-0.65435928106307983) * emb_t3_19 + (0.020578369498252869) * emb_t3_20 + (0.0076341279782354832) * emb_t3_21 + (0.62878262996673584) * emb_t3_22 + (0.33913680911064148) * emb_t3_23 + (0.10401933640241623) * emb_t3_24 + (0.13025492429733276) * emb_t3_25 + (0.33629330992698669) * emb_t3_26 + (-0.15593381226062775) * emb_t3_27 + (0.31515595316886902) * emb_t3_28 + (-1.214504599571228) * emb_t3_29 + (-0.031459454447031021) * emb_t3_30 + (0.21881510317325592) * emb_t3_31 + (-0.95069128274917603) * gru_0_rev_t4_h_0 + (0.00093002984067425132) * gru_0_rev_t4_h_1 + (-0.10658379644155502) * gru_0_rev_t4_h_2 + (-0.089646667242050171) * gru_0_rev_t4_h_3 + (-0.02388995885848999) * gru_0_rev_t4_h_4 + (0.28394243121147156) * gru_0_rev_t4_h_5 + (0.039136152714490891) * gru_0_rev_t4_h_6 + (-0.28206238150596619) * gru_0_rev_t4_h_7 + (0.18053607642650604) * gru_0_rev_t4_h_8 + (-0.18236845731735229) * gru_0_rev_t4_h_9 + (-0.11108490079641342) * gru_0_rev_t4_h_10 + (0.13154307007789612) * gru_0_rev_t4_h_11 + (-0.24384129047393799) * gru_0_rev_t4_h_12 + (-0.31315195560455322) * gru_0_rev_t4_h_13 + (0.088394507765769958) * gru_0_rev_t4_h_14 + (0.46463701128959656) * gru_0_rev_t4_h_15 + (0.077141061425209045) * gru_0_rev_t4_h_16 + (-0.17428953945636749) * gru_0_rev_t4_h_17 + (-0.077680014073848724) * gru_0_rev_t4_h_18 + (-0.23562674224376678) * gru_0_rev_t4_h_19 + (0.10676784813404083) * gru_0_rev_t4_h_20 + (0.02173144742846489) * gru_0_rev_t4_h_21 + (0.61774402856826782) * gru_0_rev_t4_h_22 + (0.87275677919387817) * gru_0_rev_t4_h_23 + (0.047052614390850067) * gru_0_rev_t4_h_24 + (-0.023214766755700111) * gru_0_rev_t4_h_25 + (0.026824237778782845) * gru_0_rev_t4_h_26 + (0.21747009456157684) * gru_0_rev_t4_h_27 + (0.073165416717529297) * gru_0_rev_t4_h_28 + (0.53063690662384033) * gru_0_rev_t4_h_29 + (-0.022814569994807243) * gru_0_rev_t4_h_30 + (-0.41640233993530273) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.04569472000002861) + (-0.0074193072505295277) * emb_t3_0 + (-0.041296377778053284) * emb_t3_1 + (0.016267554834485054) * emb_t3_2 + (-0.25593018531799316) * emb_t3_3 + (0.19248059391975403) * emb_t3_4 + (0.002783370204269886) * emb_t3_5 + (0.2984984815120697) * emb_t3_6 + (0.030059311538934708) * emb_t3_7 + (0.17830801010131836) * emb_t3_8 + (-0.1281745433807373) * emb_t3_9 + (-0.015046579763293266) * emb_t3_10 + (0.081237882375717163) * emb_t3_11 + (-0.0057075684890151024) * emb_t3_12 + (0.099380098283290863) * emb_t3_13 + (-0.035550795495510101) * emb_t3_14 + (-0.027449626475572586) * emb_t3_15 + (0.039211396127939224) * emb_t3_16 + (-0.040178477764129639) * emb_t3_17 + (-0.015397191978991032) * emb_t3_18 + (0.460518479347229) * emb_t3_19 + (0.10052689909934998) * emb_t3_20 + (0.0034078720491379499) * emb_t3_21 + (-0.28633278608322144) * emb_t3_22 + (0.053041413426399231) * emb_t3_23 + (-0.0020833560265600681) * emb_t3_24 + (0.026963373646140099) * emb_t3_25 + (-0.32211649417877197) * emb_t3_26 + (-0.014405340887606144) * emb_t3_27 + (-0.2402542382478714) * emb_t3_28 + (-0.09135621041059494) * emb_t3_29 + (-0.22630250453948975) * emb_t3_30 + (0.039756480604410172) * emb_t3_31 + gate_r * ((-0.22250570356845856) + (0.18535834550857544) * gru_0_rev_t4_h_0 + (-0.34250974655151367) * gru_0_rev_t4_h_1 + (-0.031266823410987854) * gru_0_rev_t4_h_2 + (-0.0064742136746644974) * gru_0_rev_t4_h_3 + (0.24923768639564514) * gru_0_rev_t4_h_4 + (-0.26109397411346436) * gru_0_rev_t4_h_5 + (-0.0054349726997315884) * gru_0_rev_t4_h_6 + (-0.61438959836959839) * gru_0_rev_t4_h_7 + (-0.3687756359577179) * gru_0_rev_t4_h_8 + (0.20085503160953522) * gru_0_rev_t4_h_9 + (0.34990838170051575) * gru_0_rev_t4_h_10 + (0.075484178960323334) * gru_0_rev_t4_h_11 + (-0.047056660056114197) * gru_0_rev_t4_h_12 + (-0.091964311897754669) * gru_0_rev_t4_h_13 + (-0.18652556836605072) * gru_0_rev_t4_h_14 + (-0.47474566102027893) * gru_0_rev_t4_h_15 + (-0.27452763915061951) * gru_0_rev_t4_h_16 + (0.43240085244178772) * gru_0_rev_t4_h_17 + (0.27289038896560669) * gru_0_rev_t4_h_18 + (-0.067988410592079163) * gru_0_rev_t4_h_19 + (0.061755284667015076) * gru_0_rev_t4_h_20 + (0.26457113027572632) * gru_0_rev_t4_h_21 + (0.018274255096912384) * gru_0_rev_t4_h_22 + (-0.084193132817745209) * gru_0_rev_t4_h_23 + (-1.2925624847412109) * gru_0_rev_t4_h_24 + (0.30076608061790466) * gru_0_rev_t4_h_25 + (-0.1579572856426239) * gru_0_rev_t4_h_26 + (-0.99114418029785156) * gru_0_rev_t4_h_27 + (-0.52298396825790405) * gru_0_rev_t4_h_28 + (-0.21513223648071289) * gru_0_rev_t4_h_29 + (0.036279048770666122) * gru_0_rev_t4_h_30 + (0.59338879585266113) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_24 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_24;
    // h=25
    gate_r = sigmoid((-2.1282727718353271) + (0.25715795159339905) * emb_t3_0 + (0.039369940757751465) * emb_t3_1 + (-0.69823688268661499) * emb_t3_2 + (-0.54066795110702515) * emb_t3_3 + (0.13336622714996338) * emb_t3_4 + (-0.76071882247924805) * emb_t3_5 + (0.83323013782501221) * emb_t3_6 + (0.24302217364311218) * emb_t3_7 + (-1.4435840845108032) * emb_t3_8 + (0.99740076065063477) * emb_t3_9 + (1.7969180345535278) * emb_t3_10 + (-1.2062828540802002) * emb_t3_11 + (-2.2306809425354004) * emb_t3_12 + (0.23912440240383148) * emb_t3_13 + (0.22273263335227966) * emb_t3_14 + (0.66886323690414429) * emb_t3_15 + (-0.35155683755874634) * emb_t3_16 + (0.5605512261390686) * emb_t3_17 + (2.6281325817108154) * emb_t3_18 + (-2.4750547409057617) * emb_t3_19 + (-0.48113414645195007) * emb_t3_20 + (0.87681955099105835) * emb_t3_21 + (2.0862770080566406) * emb_t3_22 + (-0.28890585899353027) * emb_t3_23 + (0.71180576086044312) * emb_t3_24 + (-0.043380346149206161) * emb_t3_25 + (-0.72959303855895996) * emb_t3_26 + (-1.0318795442581177) * emb_t3_27 + (0.10062818974256516) * emb_t3_28 + (0.033288445323705673) * emb_t3_29 + (-0.68417483568191528) * emb_t3_30 + (1.0320874452590942) * emb_t3_31 + (-1.7415764331817627) * gru_0_rev_t4_h_0 + (0.26815244555473328) * gru_0_rev_t4_h_1 + (0.12367847561836243) * gru_0_rev_t4_h_2 + (-0.51850265264511108) * gru_0_rev_t4_h_3 + (-0.095595285296440125) * gru_0_rev_t4_h_4 + (0.34669646620750427) * gru_0_rev_t4_h_5 + (-0.1818036288022995) * gru_0_rev_t4_h_6 + (0.48994845151901245) * gru_0_rev_t4_h_7 + (-0.88920152187347412) * gru_0_rev_t4_h_8 + (-0.38310292363166809) * gru_0_rev_t4_h_9 + (-3.020172119140625) * gru_0_rev_t4_h_10 + (-0.055746704339981079) * gru_0_rev_t4_h_11 + (-0.62192428112030029) * gru_0_rev_t4_h_12 + (-0.5865510106086731) * gru_0_rev_t4_h_13 + (1.9717116355895996) * gru_0_rev_t4_h_14 + (1.4940533638000488) * gru_0_rev_t4_h_15 + (0.58843499422073364) * gru_0_rev_t4_h_16 + (-0.55594617128372192) * gru_0_rev_t4_h_17 + (-2.1769082546234131) * gru_0_rev_t4_h_18 + (-0.295869380235672) * gru_0_rev_t4_h_19 + (-0.18789000809192657) * gru_0_rev_t4_h_20 + (-0.093806028366088867) * gru_0_rev_t4_h_21 + (0.1455027163028717) * gru_0_rev_t4_h_22 + (-0.42079815268516541) * gru_0_rev_t4_h_23 + (0.40558597445487976) * gru_0_rev_t4_h_24 + (-0.51599377393722534) * gru_0_rev_t4_h_25 + (0.40537089109420776) * gru_0_rev_t4_h_26 + (-0.46880385279655457) * gru_0_rev_t4_h_27 + (-0.76468777656555176) * gru_0_rev_t4_h_28 + (0.14057911932468414) * gru_0_rev_t4_h_29 + (-0.11037451773881912) * gru_0_rev_t4_h_30 + (0.71562111377716064) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-1.0343008041381836) + (-0.11894117295742035) * emb_t3_0 + (0.33630552887916565) * emb_t3_1 + (-0.43691104650497437) * emb_t3_2 + (-0.33420899510383606) * emb_t3_3 + (0.18126337230205536) * emb_t3_4 + (-0.024748319759964943) * emb_t3_5 + (0.048608753830194473) * emb_t3_6 + (0.014354699291288853) * emb_t3_7 + (-0.80990129709243774) * emb_t3_8 + (-0.10408443957567215) * emb_t3_9 + (0.30223920941352844) * emb_t3_10 + (-0.43656617403030396) * emb_t3_11 + (-0.97778981924057007) * emb_t3_12 + (-0.4272264838218689) * emb_t3_13 + (-0.016624113544821739) * emb_t3_14 + (-0.030560998246073723) * emb_t3_15 + (-0.33663696050643921) * emb_t3_16 + (-0.039525032043457031) * emb_t3_17 + (0.66717666387557983) * emb_t3_18 + (-1.0760421752929688) * emb_t3_19 + (-0.022832207381725311) * emb_t3_20 + (0.23127028346061707) * emb_t3_21 + (0.3310091495513916) * emb_t3_22 + (-0.030763942748308182) * emb_t3_23 + (0.40938636660575867) * emb_t3_24 + (0.11012759059667587) * emb_t3_25 + (-0.59098529815673828) * emb_t3_26 + (-0.28985694050788879) * emb_t3_27 + (-0.033977396786212921) * emb_t3_28 + (-0.3845120370388031) * emb_t3_29 + (-0.098012767732143402) * emb_t3_30 + (0.79540520906448364) * emb_t3_31 + (-0.50631767511367798) * gru_0_rev_t4_h_0 + (0.12040683627128601) * gru_0_rev_t4_h_1 + (-0.047518521547317505) * gru_0_rev_t4_h_2 + (-0.36903250217437744) * gru_0_rev_t4_h_3 + (-0.051628038287162781) * gru_0_rev_t4_h_4 + (0.18097741901874542) * gru_0_rev_t4_h_5 + (0.26798900961875916) * gru_0_rev_t4_h_6 + (0.97339987754821777) * gru_0_rev_t4_h_7 + (-0.71724379062652588) * gru_0_rev_t4_h_8 + (-0.43429860472679138) * gru_0_rev_t4_h_9 + (0.35988825559616089) * gru_0_rev_t4_h_10 + (-0.084392614662647247) * gru_0_rev_t4_h_11 + (-0.51822680234909058) * gru_0_rev_t4_h_12 + (-0.48624813556671143) * gru_0_rev_t4_h_13 + (0.82186418771743774) * gru_0_rev_t4_h_14 + (0.62184375524520874) * gru_0_rev_t4_h_15 + (0.096959047019481659) * gru_0_rev_t4_h_16 + (0.029802223667502403) * gru_0_rev_t4_h_17 + (-0.61865490674972534) * gru_0_rev_t4_h_18 + (0.017203563824295998) * gru_0_rev_t4_h_19 + (-0.46033075451850891) * gru_0_rev_t4_h_20 + (-0.18573528528213501) * gru_0_rev_t4_h_21 + (0.041650526225566864) * gru_0_rev_t4_h_22 + (0.54404103755950928) * gru_0_rev_t4_h_23 + (-0.49267116189002991) * gru_0_rev_t4_h_24 + (0.08655848354101181) * gru_0_rev_t4_h_25 + (0.3059343695640564) * gru_0_rev_t4_h_26 + (-0.63302385807037354) * gru_0_rev_t4_h_27 + (-0.78362071514129639) * gru_0_rev_t4_h_28 + (-0.5129428505897522) * gru_0_rev_t4_h_29 + (-0.029349762946367264) * gru_0_rev_t4_h_30 + (1.0771907567977905) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.030487675219774246) + (0.021830381825566292) * emb_t3_0 + (-0.40206196904182434) * emb_t3_1 + (-0.034422937780618668) * emb_t3_2 + (0.42191627621650696) * emb_t3_3 + (-0.21854633092880249) * emb_t3_4 + (-0.0052112117409706116) * emb_t3_5 + (-0.079658888280391693) * emb_t3_6 + (-0.030271556228399277) * emb_t3_7 + (-0.27175208926200867) * emb_t3_8 + (0.36174112558364868) * emb_t3_9 + (0.2726496160030365) * emb_t3_10 + (-0.30267807841300964) * emb_t3_11 + (-0.38848069310188293) * emb_t3_12 + (-0.8245423436164856) * emb_t3_13 + (-0.014803031459450722) * emb_t3_14 + (0.035825669765472412) * emb_t3_15 + (-0.010822847485542297) * emb_t3_16 + (-0.06533648818731308) * emb_t3_17 + (0.44106262922286987) * emb_t3_18 + (-0.42275154590606689) * emb_t3_19 + (-0.089276671409606934) * emb_t3_20 + (0.012546977028250694) * emb_t3_21 + (0.29032301902770996) * emb_t3_22 + (0.00018747766443993896) * emb_t3_23 + (-0.035291362553834915) * emb_t3_24 + (0.0084596937522292137) * emb_t3_25 + (0.25339648127555847) * emb_t3_26 + (-0.0075440709479153156) * emb_t3_27 + (0.16011030972003937) * emb_t3_28 + (-0.92615741491317749) * emb_t3_29 + (-0.32100898027420044) * emb_t3_30 + (0.14961324632167816) * emb_t3_31 + gate_r * ((0.17084111273288727) + (-0.16247931122779846) * gru_0_rev_t4_h_0 + (0.098844632506370544) * gru_0_rev_t4_h_1 + (-0.16990236937999725) * gru_0_rev_t4_h_2 + (0.024445340037345886) * gru_0_rev_t4_h_3 + (0.074169710278511047) * gru_0_rev_t4_h_4 + (-0.28140616416931152) * gru_0_rev_t4_h_5 + (0.074391596019268036) * gru_0_rev_t4_h_6 + (-0.95866340398788452) * gru_0_rev_t4_h_7 + (0.46271583437919617) * gru_0_rev_t4_h_8 + (-0.076209753751754761) * gru_0_rev_t4_h_9 + (0.43781700730323792) * gru_0_rev_t4_h_10 + (0.12236149609088898) * gru_0_rev_t4_h_11 + (-0.04691014438867569) * gru_0_rev_t4_h_12 + (-0.084284484386444092) * gru_0_rev_t4_h_13 + (-1.9550158977508545) * gru_0_rev_t4_h_14 + (-0.081279538571834564) * gru_0_rev_t4_h_15 + (-0.031900741159915924) * gru_0_rev_t4_h_16 + (-0.10668447613716125) * gru_0_rev_t4_h_17 + (0.76080596446990967) * gru_0_rev_t4_h_18 + (0.20110666751861572) * gru_0_rev_t4_h_19 + (-0.036240570247173309) * gru_0_rev_t4_h_20 + (0.25625172257423401) * gru_0_rev_t4_h_21 + (-0.69214427471160889) * gru_0_rev_t4_h_22 + (-0.61910760402679443) * gru_0_rev_t4_h_23 + (-0.57684111595153809) * gru_0_rev_t4_h_24 + (0.031999442726373672) * gru_0_rev_t4_h_25 + (-0.17071206867694855) * gru_0_rev_t4_h_26 + (0.36911526322364807) * gru_0_rev_t4_h_27 + (0.93288439512252808) * gru_0_rev_t4_h_28 + (-0.49287793040275574) * gru_0_rev_t4_h_29 + (0.019953466951847076) * gru_0_rev_t4_h_30 + (0.20954501628875732) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_25 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_25;
    // h=26
    gate_r = sigmoid((0.75765615701675415) + (0.046318113803863525) * emb_t3_0 + (-0.66292101144790649) * emb_t3_1 + (-0.55082404613494873) * emb_t3_2 + (0.1813732236623764) * emb_t3_3 + (-0.46879014372825623) * emb_t3_4 + (-0.13508045673370361) * emb_t3_5 + (-0.86223125457763672) * emb_t3_6 + (0.68482619524002075) * emb_t3_7 + (0.43473109602928162) * emb_t3_8 + (0.76691830158233643) * emb_t3_9 + (0.52833789587020874) * emb_t3_10 + (0.30333667993545532) * emb_t3_11 + (-0.124007947742939) * emb_t3_12 + (-0.76294177770614624) * emb_t3_13 + (-1.2880825996398926) * emb_t3_14 + (0.11231882870197296) * emb_t3_15 + (0.1663372665643692) * emb_t3_16 + (-0.5747302770614624) * emb_t3_17 + (0.76319235563278198) * emb_t3_18 + (-0.48425021767616272) * emb_t3_19 + (1.0075786113739014) * emb_t3_20 + (0.16069261729717255) * emb_t3_21 + (1.0026110410690308) * emb_t3_22 + (0.38304290175437927) * emb_t3_23 + (0.24022093415260315) * emb_t3_24 + (-0.16676315665245056) * emb_t3_25 + (0.91000211238861084) * emb_t3_26 + (0.39167574048042297) * emb_t3_27 + (0.56759536266326904) * emb_t3_28 + (-0.58527714014053345) * emb_t3_29 + (0.73821783065795898) * emb_t3_30 + (-0.32880124449729919) * emb_t3_31 + (0.11188821494579315) * gru_0_rev_t4_h_0 + (0.2613842785358429) * gru_0_rev_t4_h_1 + (0.29577532410621643) * gru_0_rev_t4_h_2 + (0.15138596296310425) * gru_0_rev_t4_h_3 + (-0.070334434509277344) * gru_0_rev_t4_h_4 + (0.26328495144844055) * gru_0_rev_t4_h_5 + (-0.22294412553310394) * gru_0_rev_t4_h_6 + (1.5340173244476318) * gru_0_rev_t4_h_7 + (0.37769100069999695) * gru_0_rev_t4_h_8 + (-0.12613034248352051) * gru_0_rev_t4_h_9 + (-2.292698860168457) * gru_0_rev_t4_h_10 + (-0.09096778929233551) * gru_0_rev_t4_h_11 + (-0.08846571296453476) * gru_0_rev_t4_h_12 + (-0.1340768039226532) * gru_0_rev_t4_h_13 + (1.5742138624191284) * gru_0_rev_t4_h_14 + (0.39226651191711426) * gru_0_rev_t4_h_15 + (1.0402626991271973) * gru_0_rev_t4_h_16 + (-0.63429933786392212) * gru_0_rev_t4_h_17 + (-0.51690161228179932) * gru_0_rev_t4_h_18 + (-0.098514162003993988) * gru_0_rev_t4_h_19 + (-0.056971773505210876) * gru_0_rev_t4_h_20 + (0.21960990130901337) * gru_0_rev_t4_h_21 + (2.229719877243042) * gru_0_rev_t4_h_22 + (1.6684161424636841) * gru_0_rev_t4_h_23 + (1.0043972730636597) * gru_0_rev_t4_h_24 + (-0.50407499074935913) * gru_0_rev_t4_h_25 + (0.14979313313961029) * gru_0_rev_t4_h_26 + (1.1768268346786499) * gru_0_rev_t4_h_27 + (0.31384158134460449) * gru_0_rev_t4_h_28 + (2.5797989368438721) * gru_0_rev_t4_h_29 + (0.11986790597438812) * gru_0_rev_t4_h_30 + (0.67534381151199341) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((0.79299730062484741) + (-0.027064105495810509) * emb_t3_0 + (0.20082099735736847) * emb_t3_1 + (-0.083119586110115051) * emb_t3_2 + (0.53957635164260864) * emb_t3_3 + (0.1354551762342453) * emb_t3_4 + (-0.19360654056072235) * emb_t3_5 + (-0.30477848649024963) * emb_t3_6 + (0.068888269364833832) * emb_t3_7 + (0.47375929355621338) * emb_t3_8 + (-1.5231810808181763) * emb_t3_9 + (-1.1086150407791138) * emb_t3_10 + (0.41673663258552551) * emb_t3_11 + (0.90833044052124023) * emb_t3_12 + (0.29405942559242249) * emb_t3_13 + (-0.042784176766872406) * emb_t3_14 + (0.079109050333499908) * emb_t3_15 + (-0.057013873010873795) * emb_t3_16 + (-0.18676765263080597) * emb_t3_17 + (-0.85328942537307739) * emb_t3_18 + (0.70597219467163086) * emb_t3_19 + (0.36894994974136353) * emb_t3_20 + (0.22028890252113342) * emb_t3_21 + (-0.46142220497131348) * emb_t3_22 + (0.12788334488868713) * emb_t3_23 + (0.18959525227546692) * emb_t3_24 + (0.035026714205741882) * emb_t3_25 + (0.11414226144552231) * emb_t3_26 + (-0.04329448938369751) * emb_t3_27 + (-0.3182770311832428) * emb_t3_28 + (0.1335231214761734) * emb_t3_29 + (0.090200990438461304) * emb_t3_30 + (-0.52365535497665405) * emb_t3_31 + (0.067071519792079926) * gru_0_rev_t4_h_0 + (-0.17899514734745026) * gru_0_rev_t4_h_1 + (-0.10631134361028671) * gru_0_rev_t4_h_2 + (-0.38406479358673096) * gru_0_rev_t4_h_3 + (-0.050557371228933334) * gru_0_rev_t4_h_4 + (0.16926498711109161) * gru_0_rev_t4_h_5 + (-0.10211054980754852) * gru_0_rev_t4_h_6 + (0.36906921863555908) * gru_0_rev_t4_h_7 + (-0.27180781960487366) * gru_0_rev_t4_h_8 + (-0.05831514298915863) * gru_0_rev_t4_h_9 + (-0.27768620848655701) * gru_0_rev_t4_h_10 + (0.29511427879333496) * gru_0_rev_t4_h_11 + (-0.39774012565612793) * gru_0_rev_t4_h_12 + (-0.40687409043312073) * gru_0_rev_t4_h_13 + (-0.16129331290721893) * gru_0_rev_t4_h_14 + (0.28802651166915894) * gru_0_rev_t4_h_15 + (-0.94274860620498657) * gru_0_rev_t4_h_16 + (0.79296356439590454) * gru_0_rev_t4_h_17 + (-0.10134690254926682) * gru_0_rev_t4_h_18 + (0.15276019275188446) * gru_0_rev_t4_h_19 + (-0.1140035018324852) * gru_0_rev_t4_h_20 + (-0.71571922302246094) * gru_0_rev_t4_h_21 + (0.040674220770597458) * gru_0_rev_t4_h_22 + (-0.26998996734619141) * gru_0_rev_t4_h_23 + (-0.78018128871917725) * gru_0_rev_t4_h_24 + (0.72824853658676147) * gru_0_rev_t4_h_25 + (0.15566456317901611) * gru_0_rev_t4_h_26 + (-0.73915570974349976) * gru_0_rev_t4_h_27 + (0.055975887924432755) * gru_0_rev_t4_h_28 + (-0.13663908839225769) * gru_0_rev_t4_h_29 + (0.14239636063575745) * gru_0_rev_t4_h_30 + (-0.36144191026687622) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.90731567144393921) + (0.040611237287521362) * emb_t3_0 + (-0.41411229968070984) * emb_t3_1 + (0.021151717752218246) * emb_t3_2 + (-0.52548331022262573) * emb_t3_3 + (-0.28180500864982605) * emb_t3_4 + (0.014201437123119831) * emb_t3_5 + (-0.6126408576965332) * emb_t3_6 + (0.0057191355153918266) * emb_t3_7 + (-3.944404125213623) * emb_t3_8 + (1.2117656469345093) * emb_t3_9 + (0.46447497606277466) * emb_t3_10 + (-0.91557866334915161) * emb_t3_11 + (-2.3790998458862305) * emb_t3_12 + (-0.70899116992950439) * emb_t3_13 + (0.0011631192173808813) * emb_t3_14 + (0.038372106850147247) * emb_t3_15 + (0.00066819478524848819) * emb_t3_16 + (0.041574627161026001) * emb_t3_17 + (0.79649323225021362) * emb_t3_18 + (-0.640663743019104) * emb_t3_19 + (-0.69782650470733643) * emb_t3_20 + (0.0026893818285316229) * emb_t3_21 + (1.4329062700271606) * emb_t3_22 + (-0.013378274627029896) * emb_t3_23 + (0.018060175701975822) * emb_t3_24 + (-0.028674205765128136) * emb_t3_25 + (0.18378809094429016) * emb_t3_26 + (0.00046005446347407997) * emb_t3_27 + (0.38440057635307312) * emb_t3_28 + (-0.56628847122192383) * emb_t3_29 + (0.64225625991821289) * emb_t3_30 + (5.971837043762207) * emb_t3_31 + gate_r * ((-0.84544110298156738) + (-0.14094480872154236) * gru_0_rev_t4_h_0 + (-1.1121814250946045) * gru_0_rev_t4_h_1 + (-1.0046247243881226) * gru_0_rev_t4_h_2 + (0.752921462059021) * gru_0_rev_t4_h_3 + (0.93433761596679688) * gru_0_rev_t4_h_4 + (-0.82535618543624878) * gru_0_rev_t4_h_5 + (0.95297473669052124) * gru_0_rev_t4_h_6 + (0.0029607536271214485) * gru_0_rev_t4_h_7 + (-1.4766008853912354) * gru_0_rev_t4_h_8 + (0.73575884103775024) * gru_0_rev_t4_h_9 + (0.27932882308959961) * gru_0_rev_t4_h_10 + (1.0018240213394165) * gru_0_rev_t4_h_11 + (0.6735723614692688) * gru_0_rev_t4_h_12 + (0.72972679138183594) * gru_0_rev_t4_h_13 + (-0.022242072969675064) * gru_0_rev_t4_h_14 + (-0.097739093005657196) * gru_0_rev_t4_h_15 + (0.10150095075368881) * gru_0_rev_t4_h_16 + (0.11179295182228088) * gru_0_rev_t4_h_17 + (0.023565076291561127) * gru_0_rev_t4_h_18 + (0.85620260238647461) * gru_0_rev_t4_h_19 + (0.87793946266174316) * gru_0_rev_t4_h_20 + (-0.85726970434188843) * gru_0_rev_t4_h_21 + (0.0068724793381989002) * gru_0_rev_t4_h_22 + (0.047533616423606873) * gru_0_rev_t4_h_23 + (-0.18632641434669495) * gru_0_rev_t4_h_24 + (0.011354089714586735) * gru_0_rev_t4_h_25 + (-0.92407995462417603) * gru_0_rev_t4_h_26 + (-0.033183369785547256) * gru_0_rev_t4_h_27 + (-0.030213057994842529) * gru_0_rev_t4_h_28 + (0.015540355816483498) * gru_0_rev_t4_h_29 + (0.72507369518280029) * gru_0_rev_t4_h_30 + (0.52228587865829468) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_26 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_26;
    // h=27
    gate_r = sigmoid((-0.28838735818862915) + (-0.12775494158267975) * emb_t3_0 + (-0.65382856130599976) * emb_t3_1 + (-0.19045965373516083) * emb_t3_2 + (0.097327068448066711) * emb_t3_3 + (-0.10653271526098251) * emb_t3_4 + (0.072829671204090118) * emb_t3_5 + (-0.29010465741157532) * emb_t3_6 + (0.0012492064852267504) * emb_t3_7 + (-0.34479519724845886) * emb_t3_8 + (1.1645447015762329) * emb_t3_9 + (0.83605712652206421) * emb_t3_10 + (-0.45607984066009521) * emb_t3_11 + (-0.2492637038230896) * emb_t3_12 + (-0.62689906358718872) * emb_t3_13 + (0.070960491895675659) * emb_t3_14 + (0.079203739762306213) * emb_t3_15 + (-0.076263971626758575) * emb_t3_16 + (0.13599513471126556) * emb_t3_17 + (0.42974796891212463) * emb_t3_18 + (-1.1318570375442505) * emb_t3_19 + (0.48880240321159363) * emb_t3_20 + (0.051998291164636612) * emb_t3_21 + (0.42914858460426331) * emb_t3_22 + (-0.01748170331120491) * emb_t3_23 + (-0.038346122950315475) * emb_t3_24 + (0.091468855738639832) * emb_t3_25 + (0.026125462725758553) * emb_t3_26 + (-0.015486192889511585) * emb_t3_27 + (0.4156186580657959) * emb_t3_28 + (-0.8787391185760498) * emb_t3_29 + (-0.15778593719005585) * emb_t3_30 + (0.27063861489295959) * emb_t3_31 + (-1.1309669017791748) * gru_0_rev_t4_h_0 + (-0.456581711769104) * gru_0_rev_t4_h_1 + (-0.17114169895648956) * gru_0_rev_t4_h_2 + (0.020132562145590782) * gru_0_rev_t4_h_3 + (0.7891848087310791) * gru_0_rev_t4_h_4 + (0.34717199206352234) * gru_0_rev_t4_h_5 + (0.30549997091293335) * gru_0_rev_t4_h_6 + (0.34479978680610657) * gru_0_rev_t4_h_7 + (0.20261566340923309) * gru_0_rev_t4_h_8 + (0.23233379423618317) * gru_0_rev_t4_h_9 + (-0.040557723492383957) * gru_0_rev_t4_h_10 + (-0.15038713812828064) * gru_0_rev_t4_h_11 + (-0.15862782299518585) * gru_0_rev_t4_h_12 + (-0.35687530040740967) * gru_0_rev_t4_h_13 + (0.18652728199958801) * gru_0_rev_t4_h_14 + (2.5646445751190186) * gru_0_rev_t4_h_15 + (0.067586377263069153) * gru_0_rev_t4_h_16 + (-0.078579775989055634) * gru_0_rev_t4_h_17 + (0.3570081889629364) * gru_0_rev_t4_h_18 + (-0.019164416939020157) * gru_0_rev_t4_h_19 + (0.51750463247299194) * gru_0_rev_t4_h_20 + (-0.50923728942871094) * gru_0_rev_t4_h_21 + (0.53478693962097168) * gru_0_rev_t4_h_22 + (0.22680553793907166) * gru_0_rev_t4_h_23 + (-0.052391573786735535) * gru_0_rev_t4_h_24 + (-0.50380581617355347) * gru_0_rev_t4_h_25 + (0.12838569283485413) * gru_0_rev_t4_h_26 + (0.40620732307434082) * gru_0_rev_t4_h_27 + (0.9964069128036499) * gru_0_rev_t4_h_28 + (-0.16551297903060913) * gru_0_rev_t4_h_29 + (-0.33908167481422424) * gru_0_rev_t4_h_30 + (-0.084512822329998016) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((0.35888591408729553) + (0.057985201478004456) * emb_t3_0 + (-1.229061484336853) * emb_t3_1 + (-0.093904830515384674) * emb_t3_2 + (0.25780606269836426) * emb_t3_3 + (-0.78116273880004883) * emb_t3_4 + (-0.10171163827180862) * emb_t3_5 + (-1.1307939291000366) * emb_t3_6 + (-0.12000943720340729) * emb_t3_7 + (-0.22703295946121216) * emb_t3_8 + (0.54988890886306763) * emb_t3_9 + (0.72025120258331299) * emb_t3_10 + (0.18257036805152893) * emb_t3_11 + (0.14522440731525421) * emb_t3_12 + (-0.71747899055480957) * emb_t3_13 + (0.065938860177993774) * emb_t3_14 + (0.11685853451490402) * emb_t3_15 + (-0.044144365936517715) * emb_t3_16 + (-0.51338726282119751) * emb_t3_17 + (0.48327180743217468) * emb_t3_18 + (-0.34779548645019531) * emb_t3_19 + (0.66968512535095215) * emb_t3_20 + (0.072815977036952972) * emb_t3_21 + (-0.24615706503391266) * emb_t3_22 + (0.059988964349031448) * emb_t3_23 + (0.052907653152942657) * emb_t3_24 + (-0.098041810095310211) * emb_t3_25 + (0.53089380264282227) * emb_t3_26 + (0.052757371217012405) * emb_t3_27 + (0.82761645317077637) * emb_t3_28 + (-1.2994484901428223) * emb_t3_29 + (0.52887821197509766) * emb_t3_30 + (-0.024682680144906044) * emb_t3_31 + (0.11158986389636993) * gru_0_rev_t4_h_0 + (0.49135139584541321) * gru_0_rev_t4_h_1 + (0.15770751237869263) * gru_0_rev_t4_h_2 + (0.07265123724937439) * gru_0_rev_t4_h_3 + (-0.20700053870677948) * gru_0_rev_t4_h_4 + (0.0078451484441757202) * gru_0_rev_t4_h_5 + (-0.61411750316619873) * gru_0_rev_t4_h_6 + (-1.0652017593383789) * gru_0_rev_t4_h_7 + (-0.11482246220111847) * gru_0_rev_t4_h_8 + (0.45282486081123352) * gru_0_rev_t4_h_9 + (-0.20298931002616882) * gru_0_rev_t4_h_10 + (-0.049107715487480164) * gru_0_rev_t4_h_11 + (0.035068061202764511) * gru_0_rev_t4_h_12 + (0.13801810145378113) * gru_0_rev_t4_h_13 + (0.11914516240358353) * gru_0_rev_t4_h_14 + (-0.28433367609977722) * gru_0_rev_t4_h_15 + (-1.8576177358627319) * gru_0_rev_t4_h_16 + (1.5282077789306641) * gru_0_rev_t4_h_17 + (0.20380401611328125) * gru_0_rev_t4_h_18 + (0.10121822357177734) * gru_0_rev_t4_h_19 + (-0.89671832323074341) * gru_0_rev_t4_h_20 + (0.36157041788101196) * gru_0_rev_t4_h_21 + (0.11528143286705017) * gru_0_rev_t4_h_22 + (0.18409718573093414) * gru_0_rev_t4_h_23 + (-0.55056142807006836) * gru_0_rev_t4_h_24 + (1.2242661714553833) * gru_0_rev_t4_h_25 + (-0.58045822381973267) * gru_0_rev_t4_h_26 + (-0.9317023754119873) * gru_0_rev_t4_h_27 + (-0.40402442216873169) * gru_0_rev_t4_h_28 + (0.015234176069498062) * gru_0_rev_t4_h_29 + (0.48136574029922485) * gru_0_rev_t4_h_30 + (-0.17085112631320953) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.047713205218315125) + (-0.016649127006530762) * emb_t3_0 + (0.58704453706741333) * emb_t3_1 + (0.0584246926009655) * emb_t3_2 + (-0.38829708099365234) * emb_t3_3 + (-0.25300896167755127) * emb_t3_4 + (-0.0077520618215203285) * emb_t3_5 + (0.21356388926506042) * emb_t3_6 + (-0.0085561675950884819) * emb_t3_7 + (0.18371473252773285) * emb_t3_8 + (-0.19693094491958618) * emb_t3_9 + (-0.59392267465591431) * emb_t3_10 + (-0.062116306275129318) * emb_t3_11 + (0.29781702160835266) * emb_t3_12 + (0.063150368630886078) * emb_t3_13 + (0.0067759542725980282) * emb_t3_14 + (-0.024168150499463081) * emb_t3_15 + (0.039339721202850342) * emb_t3_16 + (0.5686957836151123) * emb_t3_17 + (-0.34141770005226135) * emb_t3_18 + (0.25632962584495544) * emb_t3_19 + (-0.079191148281097412) * emb_t3_20 + (-0.025720799341797829) * emb_t3_21 + (-0.072777166962623596) * emb_t3_22 + (0.066706106066703796) * emb_t3_23 + (-0.021409489214420319) * emb_t3_24 + (0.0090079819783568382) * emb_t3_25 + (0.13014742732048035) * emb_t3_26 + (0.004746326245367527) * emb_t3_27 + (-0.0029057154897600412) * emb_t3_28 + (0.33299833536148071) * emb_t3_29 + (-0.18592241406440735) * emb_t3_30 + (-0.23573879897594452) * emb_t3_31 + gate_r * ((-0.077536784112453461) + (0.47387462854385376) * gru_0_rev_t4_h_0 + (0.26142969727516174) * gru_0_rev_t4_h_1 + (0.39436501264572144) * gru_0_rev_t4_h_2 + (0.047577302902936935) * gru_0_rev_t4_h_3 + (-0.20607611536979675) * gru_0_rev_t4_h_4 + (-0.041538242250680923) * gru_0_rev_t4_h_5 + (-0.1908014714717865) * gru_0_rev_t4_h_6 + (-0.23753994703292847) * gru_0_rev_t4_h_7 + (-0.24452240765094757) * gru_0_rev_t4_h_8 + (0.062643870711326599) * gru_0_rev_t4_h_9 + (0.051524803042411804) * gru_0_rev_t4_h_10 + (0.28518819808959961) * gru_0_rev_t4_h_11 + (0.069971226155757904) * gru_0_rev_t4_h_12 + (-0.1728372722864151) * gru_0_rev_t4_h_13 + (-0.53107368946075439) * gru_0_rev_t4_h_14 + (-1.3357292413711548) * gru_0_rev_t4_h_15 + (-0.27316787838935852) * gru_0_rev_t4_h_16 + (0.066521607339382172) * gru_0_rev_t4_h_17 + (-0.22227656841278076) * gru_0_rev_t4_h_18 + (-0.11216698586940765) * gru_0_rev_t4_h_19 + (-0.0069983997382223606) * gru_0_rev_t4_h_20 + (0.96092551946640015) * gru_0_rev_t4_h_21 + (-0.024368168786168098) * gru_0_rev_t4_h_22 + (0.069280952215194702) * gru_0_rev_t4_h_23 + (-0.16178931295871735) * gru_0_rev_t4_h_24 + (0.23516058921813965) * gru_0_rev_t4_h_25 + (-0.16366320848464966) * gru_0_rev_t4_h_26 + (-0.88891959190368652) * gru_0_rev_t4_h_27 + (-0.59756022691726685) * gru_0_rev_t4_h_28 + (-0.20673182606697083) * gru_0_rev_t4_h_29 + (0.078742347657680511) * gru_0_rev_t4_h_30 + (0.4908815324306488) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_27 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_27;
    // h=28
    gate_r = sigmoid((-3.223726749420166) + (-0.50374925136566162) * emb_t3_0 + (-0.0060921492986381054) * emb_t3_1 + (-1.1717541217803955) * emb_t3_2 + (-1.4255013465881348) * emb_t3_3 + (0.8177715539932251) * emb_t3_4 + (0.99798011779785156) * emb_t3_5 + (1.0119441747665405) * emb_t3_6 + (0.89161092042922974) * emb_t3_7 + (-1.1490973234176636) * emb_t3_8 + (0.73435819149017334) * emb_t3_9 + (0.92881792783737183) * emb_t3_10 + (-1.443163275718689) * emb_t3_11 + (-1.5906031131744385) * emb_t3_12 + (0.39812728762626648) * emb_t3_13 + (0.84641408920288086) * emb_t3_14 + (1.042570948600769) * emb_t3_15 + (-1.1562560796737671) * emb_t3_16 + (2.0544154644012451) * emb_t3_17 + (0.54507094621658325) * emb_t3_18 + (-0.98366236686706543) * emb_t3_19 + (-1.2089365720748901) * emb_t3_20 + (1.1239421367645264) * emb_t3_21 + (0.61438602209091187) * emb_t3_22 + (-1.1751329898834229) * emb_t3_23 + (0.27446293830871582) * emb_t3_24 + (0.19412040710449219) * emb_t3_25 + (-1.3688305616378784) * emb_t3_26 + (-0.87827438116073608) * emb_t3_27 + (-0.052114479243755341) * emb_t3_28 + (0.70097959041595459) * emb_t3_29 + (-0.81168657541275024) * emb_t3_30 + (0.77497553825378418) * emb_t3_31 + (-0.21898141503334045) * gru_0_rev_t4_h_0 + (-0.16177693009376526) * gru_0_rev_t4_h_1 + (0.080824792385101318) * gru_0_rev_t4_h_2 + (-0.5995667576789856) * gru_0_rev_t4_h_3 + (0.23349162936210632) * gru_0_rev_t4_h_4 + (0.7586437463760376) * gru_0_rev_t4_h_5 + (0.21290956437587738) * gru_0_rev_t4_h_6 + (-1.0308233499526978) * gru_0_rev_t4_h_7 + (0.044573277235031128) * gru_0_rev_t4_h_8 + (-0.631122887134552) * gru_0_rev_t4_h_9 + (-0.86094164848327637) * gru_0_rev_t4_h_10 + (0.1894470602273941) * gru_0_rev_t4_h_11 + (-0.78434407711029053) * gru_0_rev_t4_h_12 + (-0.68892002105712891) * gru_0_rev_t4_h_13 + (0.38813692331314087) * gru_0_rev_t4_h_14 + (0.051740735769271851) * gru_0_rev_t4_h_15 + (-1.9397252798080444) * gru_0_rev_t4_h_16 + (1.7613838911056519) * gru_0_rev_t4_h_17 + (-0.41643437743186951) * gru_0_rev_t4_h_18 + (-0.20094926655292511) * gru_0_rev_t4_h_19 + (-0.16319407522678375) * gru_0_rev_t4_h_20 + (-0.1657823920249939) * gru_0_rev_t4_h_21 + (3.545724630355835) * gru_0_rev_t4_h_22 + (-2.2764198780059814) * gru_0_rev_t4_h_23 + (-0.36179989576339722) * gru_0_rev_t4_h_24 + (1.9269512891769409) * gru_0_rev_t4_h_25 + (0.38941067457199097) * gru_0_rev_t4_h_26 + (-0.99782508611679077) * gru_0_rev_t4_h_27 + (-0.61851859092712402) * gru_0_rev_t4_h_28 + (-0.6344190239906311) * gru_0_rev_t4_h_29 + (-0.50556516647338867) * gru_0_rev_t4_h_30 + (1.0234620571136475) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-1.0287853479385376) + (0.015959650278091431) * emb_t3_0 + (-0.10917361825704575) * emb_t3_1 + (0.0038664324674755335) * emb_t3_2 + (-0.34313762187957764) * emb_t3_3 + (0.079974204301834106) * emb_t3_4 + (-0.0050696199759840965) * emb_t3_5 + (0.30202478170394897) * emb_t3_6 + (0.016299471259117126) * emb_t3_7 + (-0.37119421362876892) * emb_t3_8 + (0.14748655259609222) * emb_t3_9 + (0.098997950553894043) * emb_t3_10 + (-0.17143040895462036) * emb_t3_11 + (-0.14863243699073792) * emb_t3_12 + (-0.50074857473373413) * emb_t3_13 + (-0.0066119744442403316) * emb_t3_14 + (0.0062181991524994373) * emb_t3_15 + (-0.0039601582102477551) * emb_t3_16 + (-0.039921097457408905) * emb_t3_17 + (-0.36193844676017761) * emb_t3_18 + (-0.078754901885986328) * emb_t3_19 + (-0.15168026089668274) * emb_t3_20 + (0.01042141392827034) * emb_t3_21 + (0.50493699312210083) * emb_t3_22 + (0.0086669167503714561) * emb_t3_23 + (0.0025645392015576363) * emb_t3_24 + (-2.6937397706205957e-05) * emb_t3_25 + (-0.19944648444652557) * emb_t3_26 + (0.012681541964411736) * emb_t3_27 + (0.53197020292282104) * emb_t3_28 + (-0.52922958135604858) * emb_t3_29 + (-0.32621997594833374) * emb_t3_30 + (-0.028814399614930153) * emb_t3_31 + (-0.12425541132688522) * gru_0_rev_t4_h_0 + (-1.1906119585037231) * gru_0_rev_t4_h_1 + (-0.10120080411434174) * gru_0_rev_t4_h_2 + (0.13015691936016083) * gru_0_rev_t4_h_3 + (0.77007424831390381) * gru_0_rev_t4_h_4 + (-1.7313281297683716) * gru_0_rev_t4_h_5 + (1.4806573390960693) * gru_0_rev_t4_h_6 + (-0.74530458450317383) * gru_0_rev_t4_h_7 + (-0.54932332038879395) * gru_0_rev_t4_h_8 + (1.3216233253479004) * gru_0_rev_t4_h_9 + (0.15572214126586914) * gru_0_rev_t4_h_10 + (0.32841327786445618) * gru_0_rev_t4_h_11 + (-0.077528730034828186) * gru_0_rev_t4_h_12 + (-0.18200114369392395) * gru_0_rev_t4_h_13 + (0.34731310606002808) * gru_0_rev_t4_h_14 + (0.18721625208854675) * gru_0_rev_t4_h_15 + (-0.61387276649475098) * gru_0_rev_t4_h_16 + (0.40356674790382385) * gru_0_rev_t4_h_17 + (-0.14278750121593475) * gru_0_rev_t4_h_18 + (0.26637163758277893) * gru_0_rev_t4_h_19 + (0.76617956161499023) * gru_0_rev_t4_h_20 + (-1.224164605140686) * gru_0_rev_t4_h_21 + (0.136479452252388) * gru_0_rev_t4_h_22 + (0.29875916242599487) * gru_0_rev_t4_h_23 + (-0.51792830228805542) * gru_0_rev_t4_h_24 + (0.88706904649734497) * gru_0_rev_t4_h_25 + (-1.7407180070877075) * gru_0_rev_t4_h_26 + (0.1754293292760849) * gru_0_rev_t4_h_27 + (0.25825628638267517) * gru_0_rev_t4_h_28 + (0.0072910096496343613) * gru_0_rev_t4_h_29 + (0.30732244253158569) * gru_0_rev_t4_h_30 + (0.22094285488128662) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.015682810917496681) + (-0.0028612110763788223) * emb_t3_0 + (0.76588118076324463) * emb_t3_1 + (-0.016478892415761948) * emb_t3_2 + (0.022905955091118813) * emb_t3_3 + (0.087676852941513062) * emb_t3_4 + (-0.0021213993895798922) * emb_t3_5 + (-0.11658130586147308) * emb_t3_6 + (0.021493831649422646) * emb_t3_7 + (0.079030066728591919) * emb_t3_8 + (-0.28577327728271484) * emb_t3_9 + (-0.6160319447517395) * emb_t3_10 + (-0.2271735817193985) * emb_t3_11 + (0.18431033194065094) * emb_t3_12 + (0.098106585443019867) * emb_t3_13 + (-0.0024460304994136095) * emb_t3_14 + (0.0059418138116598129) * emb_t3_15 + (-0.028032291680574417) * emb_t3_16 + (0.0019606738351285458) * emb_t3_17 + (-0.07372012734413147) * emb_t3_18 + (0.44747662544250488) * emb_t3_19 + (-0.37852990627288818) * emb_t3_20 + (0.006864610593765974) * emb_t3_21 + (-0.21461723744869232) * emb_t3_22 + (-0.0026383912190794945) * emb_t3_23 + (0.036656603217124939) * emb_t3_24 + (0.00085717358160763979) * emb_t3_25 + (-0.44618454575538635) * emb_t3_26 + (-0.01754099503159523) * emb_t3_27 + (-0.80827975273132324) * emb_t3_28 + (0.50963252782821655) * emb_t3_29 + (-0.36569380760192871) * emb_t3_30 + (-0.26319250464439392) * emb_t3_31 + gate_r * ((0.23870672285556793) + (-0.25844496488571167) * gru_0_rev_t4_h_0 + (-0.016018839552998543) * gru_0_rev_t4_h_1 + (0.1342872679233551) * gru_0_rev_t4_h_2 + (-0.021020567044615746) * gru_0_rev_t4_h_3 + (0.10909678041934967) * gru_0_rev_t4_h_4 + (0.19233147799968719) * gru_0_rev_t4_h_5 + (0.26790586113929749) * gru_0_rev_t4_h_6 + (-0.00074221636168658733) * gru_0_rev_t4_h_7 + (0.094256371259689331) * gru_0_rev_t4_h_8 + (0.080272264778614044) * gru_0_rev_t4_h_9 + (1.044577956199646) * gru_0_rev_t4_h_10 + (0.049362808465957642) * gru_0_rev_t4_h_11 + (-0.088120318949222565) * gru_0_rev_t4_h_12 + (0.095830045640468597) * gru_0_rev_t4_h_13 + (0.78975039720535278) * gru_0_rev_t4_h_14 + (-0.17252209782600403) * gru_0_rev_t4_h_15 + (-0.20530915260314941) * gru_0_rev_t4_h_16 + (0.19364537298679352) * gru_0_rev_t4_h_17 + (0.40031006932258606) * gru_0_rev_t4_h_18 + (-0.30817553400993347) * gru_0_rev_t4_h_19 + (0.30683240294456482) * gru_0_rev_t4_h_20 + (0.12626604735851288) * gru_0_rev_t4_h_21 + (-2.0702104568481445) * gru_0_rev_t4_h_22 + (1.4076708555221558) * gru_0_rev_t4_h_23 + (-0.15253695845603943) * gru_0_rev_t4_h_24 + (0.57646411657333374) * gru_0_rev_t4_h_25 + (0.073318362236022949) * gru_0_rev_t4_h_26 + (0.80632305145263672) * gru_0_rev_t4_h_27 + (-0.4860173761844635) * gru_0_rev_t4_h_28 + (0.84458023309707642) * gru_0_rev_t4_h_29 + (-0.19936780631542206) * gru_0_rev_t4_h_30 + (0.68439167737960815) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_28 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_28;
    // h=29
    gate_r = sigmoid((0.32173404097557068) + (0.055921368300914764) * emb_t3_0 + (-0.10297276824712753) * emb_t3_1 + (0.2520657479763031) * emb_t3_2 + (0.20899145305156708) * emb_t3_3 + (-0.18162235617637634) * emb_t3_4 + (-0.19413299858570099) * emb_t3_5 + (-0.11049717664718628) * emb_t3_6 + (-0.031090311706066132) * emb_t3_7 + (0.26408037543296814) * emb_t3_8 + (-0.58010190725326538) * emb_t3_9 + (-0.23026017844676971) * emb_t3_10 + (0.32242998480796814) * emb_t3_11 + (-0.40609273314476013) * emb_t3_12 + (-0.052805755287408829) * emb_t3_13 + (0.016613006591796875) * emb_t3_14 + (0.1435447633266449) * emb_t3_15 + (0.062877900898456573) * emb_t3_16 + (-0.29014921188354492) * emb_t3_17 + (-0.45784842967987061) * emb_t3_18 + (0.47331643104553223) * emb_t3_19 + (0.19354303181171417) * emb_t3_20 + (-0.11089349538087845) * emb_t3_21 + (0.18104308843612671) * emb_t3_22 + (-0.0060321786440908909) * emb_t3_23 + (0.050856292247772217) * emb_t3_24 + (0.015622256323695183) * emb_t3_25 + (0.54216903448104858) * emb_t3_26 + (0.13367205858230591) * emb_t3_27 + (0.19604146480560303) * emb_t3_28 + (-0.39428332448005676) * emb_t3_29 + (0.38894477486610413) * emb_t3_30 + (-0.15739230811595917) * emb_t3_31 + (0.91005629301071167) * gru_0_rev_t4_h_0 + (0.24608960747718811) * gru_0_rev_t4_h_1 + (0.26324528455734253) * gru_0_rev_t4_h_2 + (0.39430072903633118) * gru_0_rev_t4_h_3 + (-0.51206177473068237) * gru_0_rev_t4_h_4 + (-0.2595236599445343) * gru_0_rev_t4_h_5 + (-0.037720579653978348) * gru_0_rev_t4_h_6 + (-0.38307416439056396) * gru_0_rev_t4_h_7 + (0.091302476823329926) * gru_0_rev_t4_h_8 + (0.74902534484863281) * gru_0_rev_t4_h_9 + (3.7276403903961182) * gru_0_rev_t4_h_10 + (-0.50030243396759033) * gru_0_rev_t4_h_11 + (0.45381572842597961) * gru_0_rev_t4_h_12 + (0.60691964626312256) * gru_0_rev_t4_h_13 + (1.0003855228424072) * gru_0_rev_t4_h_14 + (-0.83525031805038452) * gru_0_rev_t4_h_15 + (-0.41447675228118896) * gru_0_rev_t4_h_16 + (0.10304465889930725) * gru_0_rev_t4_h_17 + (0.71451622247695923) * gru_0_rev_t4_h_18 + (-0.13856153190135956) * gru_0_rev_t4_h_19 + (0.058667585253715515) * gru_0_rev_t4_h_20 + (0.6084754467010498) * gru_0_rev_t4_h_21 + (0.15788398683071136) * gru_0_rev_t4_h_22 + (-0.71850866079330444) * gru_0_rev_t4_h_23 + (0.46210911870002747) * gru_0_rev_t4_h_24 + (0.23714345693588257) * gru_0_rev_t4_h_25 + (-0.37265288829803467) * gru_0_rev_t4_h_26 + (-0.48828721046447754) * gru_0_rev_t4_h_27 + (-1.5441217422485352) * gru_0_rev_t4_h_28 + (-1.2818543910980225) * gru_0_rev_t4_h_29 + (-0.034734040498733521) * gru_0_rev_t4_h_30 + (-1.1806432008743286) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((-0.54896610975265503) + (0.00029152326169423759) * emb_t3_0 + (-0.094816580414772034) * emb_t3_1 + (0.0090483035892248154) * emb_t3_2 + (-0.13170795142650604) * emb_t3_3 + (0.1378169059753418) * emb_t3_4 + (-0.0034486122895032167) * emb_t3_5 + (0.046504195779561996) * emb_t3_6 + (-0.011009851470589638) * emb_t3_7 + (-0.094083964824676514) * emb_t3_8 + (-0.38025590777397156) * emb_t3_9 + (-0.089739739894866943) * emb_t3_10 + (0.23595318198204041) * emb_t3_11 + (-0.40508601069450378) * emb_t3_12 + (-0.49295026063919067) * emb_t3_13 + (0.021975168958306313) * emb_t3_14 + (0.003388871205970645) * emb_t3_15 + (0.015692479908466339) * emb_t3_16 + (-0.37197506427764893) * emb_t3_17 + (-0.19381240010261536) * emb_t3_18 + (-0.28285592794418335) * emb_t3_19 + (0.00163104641251266) * emb_t3_20 + (-0.0035075356718152761) * emb_t3_21 + (0.25814786553382874) * emb_t3_22 + (-0.0088165663182735443) * emb_t3_23 + (0.0050007919780910015) * emb_t3_24 + (-0.012685704044997692) * emb_t3_25 + (-0.02663898840546608) * emb_t3_26 + (0.0079759908840060234) * emb_t3_27 + (-0.083886630833148956) * emb_t3_28 + (-0.18716727197170258) * emb_t3_29 + (0.46683016419410706) * emb_t3_30 + (0.15733791887760162) * emb_t3_31 + (-0.025548959150910378) * gru_0_rev_t4_h_0 + (-1.846729040145874) * gru_0_rev_t4_h_1 + (-0.83754366636276245) * gru_0_rev_t4_h_2 + (0.29489713907241821) * gru_0_rev_t4_h_3 + (0.76290994882583618) * gru_0_rev_t4_h_4 + (-0.9077877402305603) * gru_0_rev_t4_h_5 + (1.5886433124542236) * gru_0_rev_t4_h_6 + (-0.83480751514434814) * gru_0_rev_t4_h_7 + (-0.60029792785644531) * gru_0_rev_t4_h_8 + (0.29538866877555847) * gru_0_rev_t4_h_9 + (0.057865362614393234) * gru_0_rev_t4_h_10 + (0.46712589263916016) * gru_0_rev_t4_h_11 + (-0.14538167417049408) * gru_0_rev_t4_h_12 + (-0.10892581194639206) * gru_0_rev_t4_h_13 + (0.51159757375717163) * gru_0_rev_t4_h_14 + (0.26212945580482483) * gru_0_rev_t4_h_15 + (-0.32495135068893433) * gru_0_rev_t4_h_16 + (0.65415400266647339) * gru_0_rev_t4_h_17 + (0.18353497982025146) * gru_0_rev_t4_h_18 + (-0.2873002290725708) * gru_0_rev_t4_h_19 + (0.85203027725219727) * gru_0_rev_t4_h_20 + (-1.3559526205062866) * gru_0_rev_t4_h_21 + (-0.016723066568374634) * gru_0_rev_t4_h_22 + (0.040392138063907623) * gru_0_rev_t4_h_23 + (0.04215061292052269) * gru_0_rev_t4_h_24 + (0.82847380638122559) * gru_0_rev_t4_h_25 + (-0.89299482107162476) * gru_0_rev_t4_h_26 + (0.7459142804145813) * gru_0_rev_t4_h_27 + (0.14581684768199921) * gru_0_rev_t4_h_28 + (-0.68217176198959351) * gru_0_rev_t4_h_29 + (0.56743472814559937) * gru_0_rev_t4_h_30 + (-0.45446357131004333) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.1339261382818222) + (0.037234421819448471) * emb_t3_0 + (0.22782236337661743) * emb_t3_1 + (-0.097569793462753296) * emb_t3_2 + (0.12717312574386597) * emb_t3_3 + (0.094165749847888947) * emb_t3_4 + (0.084420561790466309) * emb_t3_5 + (0.31452459096908569) * emb_t3_6 + (0.075050383806228638) * emb_t3_7 + (0.17073485255241394) * emb_t3_8 + (0.21176472306251526) * emb_t3_9 + (-0.27245441079139709) * emb_t3_10 + (0.12528933584690094) * emb_t3_11 + (0.35852527618408203) * emb_t3_12 + (-0.41233080625534058) * emb_t3_13 + (-0.025097206234931946) * emb_t3_14 + (-0.025500664487481117) * emb_t3_15 + (-0.090332649648189545) * emb_t3_16 + (0.18825747072696686) * emb_t3_17 + (-0.29260486364364624) * emb_t3_18 + (0.27466890215873718) * emb_t3_19 + (0.32294335961341858) * emb_t3_20 + (0.019552579149603844) * emb_t3_21 + (-0.57671517133712769) * emb_t3_22 + (0.006399927195161581) * emb_t3_23 + (-0.047378212213516235) * emb_t3_24 + (0.049574848264455795) * emb_t3_25 + (0.11396224051713943) * emb_t3_26 + (-0.040766052901744843) * emb_t3_27 + (0.14726428687572479) * emb_t3_28 + (0.099061928689479828) * emb_t3_29 + (0.27095654606819153) * emb_t3_30 + (-0.21277682483196259) * emb_t3_31 + gate_r * ((0.30990120768547058) + (1.0956459045410156) * gru_0_rev_t4_h_0 + (0.32308313250541687) * gru_0_rev_t4_h_1 + (-0.12208586186170578) * gru_0_rev_t4_h_2 + (0.38595297932624817) * gru_0_rev_t4_h_3 + (0.21005205810070038) * gru_0_rev_t4_h_4 + (-0.14231650531291962) * gru_0_rev_t4_h_5 + (-0.099503904581069946) * gru_0_rev_t4_h_6 + (-0.48686301708221436) * gru_0_rev_t4_h_7 + (0.58138579130172729) * gru_0_rev_t4_h_8 + (0.42806589603424072) * gru_0_rev_t4_h_9 + (-1.6055088043212891) * gru_0_rev_t4_h_10 + (0.36905437707901001) * gru_0_rev_t4_h_11 + (0.5045049786567688) * gru_0_rev_t4_h_12 + (0.47142383456230164) * gru_0_rev_t4_h_13 + (1.4581165313720703) * gru_0_rev_t4_h_14 + (-1.0419496297836304) * gru_0_rev_t4_h_15 + (-0.26759698987007141) * gru_0_rev_t4_h_16 + (0.59478127956390381) * gru_0_rev_t4_h_17 + (0.87275487184524536) * gru_0_rev_t4_h_18 + (0.23323065042495728) * gru_0_rev_t4_h_19 + (-0.14381192624568939) * gru_0_rev_t4_h_20 + (0.34863981604576111) * gru_0_rev_t4_h_21 + (0.047098875045776367) * gru_0_rev_t4_h_22 + (0.44018855690956116) * gru_0_rev_t4_h_23 + (-0.49232429265975952) * gru_0_rev_t4_h_24 + (0.44320350885391235) * gru_0_rev_t4_h_25 + (-0.42425337433815002) * gru_0_rev_t4_h_26 + (-1.6211903095245361) * gru_0_rev_t4_h_27 + (0.41830757260322571) * gru_0_rev_t4_h_28 + (0.63131791353225708) * gru_0_rev_t4_h_29 + (0.18330748379230499) * gru_0_rev_t4_h_30 + (-0.79746043682098389) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_29 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_29;
    // h=30
    gate_r = sigmoid((1.34485924243927) + (0.13437739014625549) * emb_t3_0 + (-0.68271768093109131) * emb_t3_1 + (0.49135574698448181) * emb_t3_2 + (1.1417891979217529) * emb_t3_3 + (-1.0022807121276855) * emb_t3_4 + (-0.35174247622489929) * emb_t3_5 + (-0.54898923635482788) * emb_t3_6 + (-0.097089953720569611) * emb_t3_7 + (0.71768605709075928) * emb_t3_8 + (-0.18571466207504272) * emb_t3_9 + (-0.30236780643463135) * emb_t3_10 + (0.24225807189941406) * emb_t3_11 + (0.76618862152099609) * emb_t3_12 + (-0.56919378042221069) * emb_t3_13 + (-0.40195751190185547) * emb_t3_14 + (-0.75822955369949341) * emb_t3_15 + (0.31165164709091187) * emb_t3_16 + (-0.66277271509170532) * emb_t3_17 + (0.46557658910751343) * emb_t3_18 + (-0.077644221484661102) * emb_t3_19 + (0.45029938220977783) * emb_t3_20 + (-0.079259045422077179) * emb_t3_21 + (-0.52297294139862061) * emb_t3_22 + (0.39606240391731262) * emb_t3_23 + (-0.54204702377319336) * emb_t3_24 + (0.31168773770332336) * emb_t3_25 + (0.59590786695480347) * emb_t3_26 + (0.33031272888183594) * emb_t3_27 + (0.93750518560409546) * emb_t3_28 + (-0.53985309600830078) * emb_t3_29 + (0.24347959458827972) * emb_t3_30 + (-0.73059821128845215) * emb_t3_31 + (-0.015888705849647522) * gru_0_rev_t4_h_0 + (0.40097498893737793) * gru_0_rev_t4_h_1 + (0.20396623015403748) * gru_0_rev_t4_h_2 + (-0.69786787033081055) * gru_0_rev_t4_h_3 + (-0.23525780439376831) * gru_0_rev_t4_h_4 + (0.58449608087539673) * gru_0_rev_t4_h_5 + (-0.092847108840942383) * gru_0_rev_t4_h_6 + (0.118852898478508) * gru_0_rev_t4_h_7 + (0.029618887230753899) * gru_0_rev_t4_h_8 + (-0.39056599140167236) * gru_0_rev_t4_h_9 + (-0.22663743793964386) * gru_0_rev_t4_h_10 + (-0.28512668609619141) * gru_0_rev_t4_h_11 + (-0.67526286840438843) * gru_0_rev_t4_h_12 + (-0.53604346513748169) * gru_0_rev_t4_h_13 + (-0.11343632638454437) * gru_0_rev_t4_h_14 + (0.10381758958101273) * gru_0_rev_t4_h_15 + (-0.026144366711378098) * gru_0_rev_t4_h_16 + (0.096992090344429016) * gru_0_rev_t4_h_17 + (-0.14193248748779297) * gru_0_rev_t4_h_18 + (-0.4318867027759552) * gru_0_rev_t4_h_19 + (-0.22230224311351776) * gru_0_rev_t4_h_20 + (0.21119539439678192) * gru_0_rev_t4_h_21 + (-0.26653692126274109) * gru_0_rev_t4_h_22 + (-1.0528703927993774) * gru_0_rev_t4_h_23 + (-0.0073017822578549385) * gru_0_rev_t4_h_24 + (-0.054893080145120621) * gru_0_rev_t4_h_25 + (0.50987726449966431) * gru_0_rev_t4_h_26 + (-0.27741971611976624) * gru_0_rev_t4_h_27 + (-0.10283438116312027) * gru_0_rev_t4_h_28 + (-0.06567709892988205) * gru_0_rev_t4_h_29 + (-0.5454896092414856) * gru_0_rev_t4_h_30 + (0.63430184125900269) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((2.4693558216094971) + (0.00021757114154752344) * emb_t3_0 + (0.46421575546264648) * emb_t3_1 + (-0.00030185966170392931) * emb_t3_2 + (0.065278105437755585) * emb_t3_3 + (-0.14363428950309753) * emb_t3_4 + (-0.0028275663498789072) * emb_t3_5 + (-0.83252483606338501) * emb_t3_6 + (0.0013708201004192233) * emb_t3_7 + (-0.047714404761791229) * emb_t3_8 + (0.025521334260702133) * emb_t3_9 + (-0.16822236776351929) * emb_t3_10 + (-0.048964995890855789) * emb_t3_11 + (-0.029366066679358482) * emb_t3_12 + (-0.13888542354106903) * emb_t3_13 + (-0.00022115629690233618) * emb_t3_14 + (-0.0032231998629868031) * emb_t3_15 + (-0.0014266866492107511) * emb_t3_16 + (-0.20793220400810242) * emb_t3_17 + (0.054136335849761963) * emb_t3_18 + (-0.10494299978017807) * emb_t3_19 + (0.018051652237772942) * emb_t3_20 + (-0.001057760207913816) * emb_t3_21 + (-0.89191895723342896) * emb_t3_22 + (8.7058346252888441e-05) * emb_t3_23 + (-0.0016783669125288725) * emb_t3_24 + (0.00087555707432329655) * emb_t3_25 + (0.045518454164266586) * emb_t3_26 + (0.0013514308957383037) * emb_t3_27 + (-0.20011988282203674) * emb_t3_28 + (0.035798594355583191) * emb_t3_29 + (-0.27706009149551392) * emb_t3_30 + (-0.43592292070388794) * emb_t3_31 + (0.60070103406906128) * gru_0_rev_t4_h_0 + (-0.89532780647277832) * gru_0_rev_t4_h_1 + (-0.19410894811153412) * gru_0_rev_t4_h_2 + (1.1588025093078613) * gru_0_rev_t4_h_3 + (-0.22050073742866516) * gru_0_rev_t4_h_4 + (-0.42530903220176697) * gru_0_rev_t4_h_5 + (-0.3714902400970459) * gru_0_rev_t4_h_6 + (0.75250095129013062) * gru_0_rev_t4_h_7 + (0.60731709003448486) * gru_0_rev_t4_h_8 + (1.0914437770843506) * gru_0_rev_t4_h_9 + (-0.48119953274726868) * gru_0_rev_t4_h_10 + (-0.86167049407958984) * gru_0_rev_t4_h_11 + (0.85822999477386475) * gru_0_rev_t4_h_12 + (0.96625775098800659) * gru_0_rev_t4_h_13 + (-0.18504011631011963) * gru_0_rev_t4_h_14 + (-0.28817060589790344) * gru_0_rev_t4_h_15 + (0.64637976884841919) * gru_0_rev_t4_h_16 + (-0.64499980211257935) * gru_0_rev_t4_h_17 + (0.41681241989135742) * gru_0_rev_t4_h_18 + (1.0608818531036377) * gru_0_rev_t4_h_19 + (0.44648119807243347) * gru_0_rev_t4_h_20 + (0.26376253366470337) * gru_0_rev_t4_h_21 + (-1.0763899087905884) * gru_0_rev_t4_h_22 + (1.2615115642547607) * gru_0_rev_t4_h_23 + (0.2496040016412735) * gru_0_rev_t4_h_24 + (-0.56686210632324219) * gru_0_rev_t4_h_25 + (-0.78239357471466064) * gru_0_rev_t4_h_26 + (0.32368674874305725) * gru_0_rev_t4_h_27 + (0.02782808244228363) * gru_0_rev_t4_h_28 + (1.0506579875946045) * gru_0_rev_t4_h_29 + (1.1464093923568726) * gru_0_rev_t4_h_30 + (-0.38398915529251099) * gru_0_rev_t4_h_31);
    gate_n = tanh((0.59525293111801147) + (0.0018575324211269617) * emb_t3_0 + (0.32688444852828979) * emb_t3_1 + (0.66818028688430786) * emb_t3_2 + (0.64994454383850098) * emb_t3_3 + (-0.087553784251213074) * emb_t3_4 + (-0.44244146347045898) * emb_t3_5 + (-0.33246675133705139) * emb_t3_6 + (-0.88599085807800293) * emb_t3_7 + (0.62896829843521118) * emb_t3_8 + (-1.4044672250747681) * emb_t3_9 + (-1.1333514451980591) * emb_t3_10 + (0.7360990047454834) * emb_t3_11 + (0.93042445182800293) * emb_t3_12 + (-0.20440147817134857) * emb_t3_13 + (0.27329704165458679) * emb_t3_14 + (-0.15040417015552521) * emb_t3_15 + (0.45051681995391846) * emb_t3_16 + (-0.38770368695259094) * emb_t3_17 + (-1.6893484592437744) * emb_t3_18 + (1.6857953071594238) * emb_t3_19 + (0.38518908619880676) * emb_t3_20 + (0.021238734945654869) * emb_t3_21 + (-0.64961028099060059) * emb_t3_22 + (0.26621630787849426) * emb_t3_23 + (0.056149821728467941) * emb_t3_24 + (-0.40234822034835815) * emb_t3_25 + (-0.10873445868492126) * emb_t3_26 + (0.035416297614574432) * emb_t3_27 + (0.15445223450660706) * emb_t3_28 + (-0.52254718542098999) * emb_t3_29 + (0.024773156270384789) * emb_t3_30 + (-1.2572534084320068) * emb_t3_31 + gate_r * ((0.65501070022583008) + (-0.59368455410003662) * gru_0_rev_t4_h_0 + (-0.26791277527809143) * gru_0_rev_t4_h_1 + (-0.71641701459884644) * gru_0_rev_t4_h_2 + (0.76603740453720093) * gru_0_rev_t4_h_3 + (0.92919236421585083) * gru_0_rev_t4_h_4 + (-1.338213324546814) * gru_0_rev_t4_h_5 + (0.15595582127571106) * gru_0_rev_t4_h_6 + (0.82286661863327026) * gru_0_rev_t4_h_7 + (-0.28030478954315186) * gru_0_rev_t4_h_8 + (0.82145774364471436) * gru_0_rev_t4_h_9 + (-0.44168302416801453) * gru_0_rev_t4_h_10 + (0.518940269947052) * gru_0_rev_t4_h_11 + (0.97785556316375732) * gru_0_rev_t4_h_12 + (0.91140449047088623) * gru_0_rev_t4_h_13 + (1.4884675741195679) * gru_0_rev_t4_h_14 + (-0.25460350513458252) * gru_0_rev_t4_h_15 + (0.016829995438456535) * gru_0_rev_t4_h_16 + (-0.13495227694511414) * gru_0_rev_t4_h_17 + (0.17995184659957886) * gru_0_rev_t4_h_18 + (0.82433986663818359) * gru_0_rev_t4_h_19 + (0.56845885515213013) * gru_0_rev_t4_h_20 + (-0.3685554563999176) * gru_0_rev_t4_h_21 + (0.79973298311233521) * gru_0_rev_t4_h_22 + (-0.43496379256248474) * gru_0_rev_t4_h_23 + (0.11961186677217484) * gru_0_rev_t4_h_24 + (-0.34589418768882751) * gru_0_rev_t4_h_25 + (-0.83604574203491211) * gru_0_rev_t4_h_26 + (-0.37778854370117188) * gru_0_rev_t4_h_27 + (-0.65816473960876465) * gru_0_rev_t4_h_28 + (-0.72510439157485962) * gru_0_rev_t4_h_29 + (0.64500629901885986) * gru_0_rev_t4_h_30 + (-0.62335538864135742) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_30 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_30;
    // h=31
    gate_r = sigmoid((-1.4357271194458008) + (-0.20934654772281647) * emb_t3_0 + (0.71249628067016602) * emb_t3_1 + (-0.3303925096988678) * emb_t3_2 + (-0.86453908681869507) * emb_t3_3 + (1.1432772874832153) * emb_t3_4 + (0.39348995685577393) * emb_t3_5 + (0.86815184354782104) * emb_t3_6 + (0.26343333721160889) * emb_t3_7 + (-0.40029409527778625) * emb_t3_8 + (0.6163591742515564) * emb_t3_9 + (0.66140139102935791) * emb_t3_10 + (-0.86761289834976196) * emb_t3_11 + (-0.46693247556686401) * emb_t3_12 + (0.73712128400802612) * emb_t3_13 + (0.097350329160690308) * emb_t3_14 + (0.19880978763103485) * emb_t3_15 + (-0.50683003664016724) * emb_t3_16 + (1.6393564939498901) * emb_t3_17 + (0.20705430209636688) * emb_t3_18 + (-0.77220833301544189) * emb_t3_19 + (-0.75397765636444092) * emb_t3_20 + (0.71801590919494629) * emb_t3_21 + (0.74062275886535645) * emb_t3_22 + (-0.74361580610275269) * emb_t3_23 + (0.079540923237800598) * emb_t3_24 + (0.60188525915145874) * emb_t3_25 + (-0.69794625043869019) * emb_t3_26 + (-0.054687183350324631) * emb_t3_27 + (-0.36121436953544617) * emb_t3_28 + (0.82962000370025635) * emb_t3_29 + (-0.73071646690368652) * emb_t3_30 + (0.28604793548583984) * emb_t3_31 + (-0.1678679883480072) * gru_0_rev_t4_h_0 + (-0.43504363298416138) * gru_0_rev_t4_h_1 + (-0.069702170789241791) * gru_0_rev_t4_h_2 + (-0.24570456147193909) * gru_0_rev_t4_h_3 + (0.18287083506584167) * gru_0_rev_t4_h_4 + (0.37872907519340515) * gru_0_rev_t4_h_5 + (0.26860257983207703) * gru_0_rev_t4_h_6 + (-0.32135161757469177) * gru_0_rev_t4_h_7 + (0.027353867888450623) * gru_0_rev_t4_h_8 + (-0.34864673018455505) * gru_0_rev_t4_h_9 + (0.17477290332317352) * gru_0_rev_t4_h_10 + (0.28990229964256287) * gru_0_rev_t4_h_11 + (-0.15222172439098358) * gru_0_rev_t4_h_12 + (-0.32321521639823914) * gru_0_rev_t4_h_13 + (0.22116273641586304) * gru_0_rev_t4_h_14 + (0.34950107336044312) * gru_0_rev_t4_h_15 + (-0.13022725284099579) * gru_0_rev_t4_h_16 + (0.043465621769428253) * gru_0_rev_t4_h_17 + (-0.47944566607475281) * gru_0_rev_t4_h_18 + (0.1075323298573494) * gru_0_rev_t4_h_19 + (-0.042639225721359253) * gru_0_rev_t4_h_20 + (-0.29486504197120667) * gru_0_rev_t4_h_21 + (0.28824582695960999) * gru_0_rev_t4_h_22 + (-0.14721006155014038) * gru_0_rev_t4_h_23 + (0.38404697179794312) * gru_0_rev_t4_h_24 + (0.25637629628181458) * gru_0_rev_t4_h_25 + (0.13858328759670258) * gru_0_rev_t4_h_26 + (-0.25359848141670227) * gru_0_rev_t4_h_27 + (0.13179171085357666) * gru_0_rev_t4_h_28 + (-0.24040684103965759) * gru_0_rev_t4_h_29 + (-0.34031495451927185) * gru_0_rev_t4_h_30 + (0.54371684789657593) * gru_0_rev_t4_h_31);
    gate_z = sigmoid((0.58876138925552368) + (-0.065116465091705322) * emb_t3_0 + (-1.8003759384155273) * emb_t3_1 + (0.069223910570144653) * emb_t3_2 + (0.59188461303710938) * emb_t3_3 + (-2.6046082973480225) * emb_t3_4 + (-0.09179958701133728) * emb_t3_5 + (-1.7053453922271729) * emb_t3_6 + (-0.07705669105052948) * emb_t3_7 + (-0.14361445605754852) * emb_t3_8 + (0.94912004470825195) * emb_t3_9 + (0.3851427435874939) * emb_t3_10 + (0.77020663022994995) * emb_t3_11 + (-0.37819057703018188) * emb_t3_12 + (-2.3966660499572754) * emb_t3_13 + (0.077805705368518829) * emb_t3_14 + (-0.21843737363815308) * emb_t3_15 + (-0.027483154088258743) * emb_t3_16 + (-0.85050064325332642) * emb_t3_17 + (0.45104283094406128) * emb_t3_18 + (-0.24056658148765564) * emb_t3_19 + (1.135401725769043) * emb_t3_20 + (-0.064725853502750397) * emb_t3_21 + (-0.039093133062124252) * emb_t3_22 + (-0.075684994459152222) * emb_t3_23 + (-0.050215009599924088) * emb_t3_24 + (-0.024101167917251587) * emb_t3_25 + (1.0703381299972534) * emb_t3_26 + (-0.0049634180031716824) * emb_t3_27 + (1.8455902338027954) * emb_t3_28 + (-2.320936918258667) * emb_t3_29 + (2.7980337142944336) * emb_t3_30 + (0.24805188179016113) * emb_t3_31 + (0.55507957935333252) * gru_0_rev_t4_h_0 + (0.61961591243743896) * gru_0_rev_t4_h_1 + (0.47418999671936035) * gru_0_rev_t4_h_2 + (0.89553773403167725) * gru_0_rev_t4_h_3 + (-0.57152014970779419) * gru_0_rev_t4_h_4 + (-0.59089261293411255) * gru_0_rev_t4_h_5 + (-1.2274013757705688) * gru_0_rev_t4_h_6 + (1.2509680986404419) * gru_0_rev_t4_h_7 + (0.64366829395294189) * gru_0_rev_t4_h_8 + (1.365034818649292) * gru_0_rev_t4_h_9 + (-0.94364982843399048) * gru_0_rev_t4_h_10 + (-1.3584227561950684) * gru_0_rev_t4_h_11 + (0.83905321359634399) * gru_0_rev_t4_h_12 + (0.80406725406646729) * gru_0_rev_t4_h_13 + (0.18571972846984863) * gru_0_rev_t4_h_14 + (-0.4543241560459137) * gru_0_rev_t4_h_15 + (0.29913330078125) * gru_0_rev_t4_h_16 + (-0.41325095295906067) * gru_0_rev_t4_h_17 + (0.73005461692810059) * gru_0_rev_t4_h_18 + (0.49626848101615906) * gru_0_rev_t4_h_19 + (0.32300922274589539) * gru_0_rev_t4_h_20 + (0.87370359897613525) * gru_0_rev_t4_h_21 + (-0.82873702049255371) * gru_0_rev_t4_h_22 + (0.72771835327148438) * gru_0_rev_t4_h_23 + (0.23786574602127075) * gru_0_rev_t4_h_24 + (-0.33766049146652222) * gru_0_rev_t4_h_25 + (-0.86598300933837891) * gru_0_rev_t4_h_26 + (1.1596708297729492) * gru_0_rev_t4_h_27 + (-0.58779698610305786) * gru_0_rev_t4_h_28 + (0.77052885293960571) * gru_0_rev_t4_h_29 + (0.89288628101348877) * gru_0_rev_t4_h_30 + (-3.7439811229705811) * gru_0_rev_t4_h_31);
    gate_n = tanh((-0.09081733226776123) + (0.25902971625328064) * emb_t3_0 + (-2.3275558948516846) * emb_t3_1 + (0.20978960394859314) * emb_t3_2 + (0.12174080312252045) * emb_t3_3 + (-0.23300406336784363) * emb_t3_4 + (-0.56231361627578735) * emb_t3_5 + (-0.46115985512733459) * emb_t3_6 + (0.25583997368812561) * emb_t3_7 + (-0.20606839656829834) * emb_t3_8 + (0.92734450101852417) * emb_t3_9 + (0.67620748281478882) * emb_t3_10 + (-0.24576212465763092) * emb_t3_11 + (-0.56451708078384399) * emb_t3_12 + (-1.0121785402297974) * emb_t3_13 + (-0.20770791172981262) * emb_t3_14 + (-0.23147024214267731) * emb_t3_15 + (0.0023880954831838608) * emb_t3_16 + (0.4062449038028717) * emb_t3_17 + (0.71637147665023804) * emb_t3_18 + (-0.13081304728984833) * emb_t3_19 + (-0.089473411440849304) * emb_t3_20 + (0.0033172369003295898) * emb_t3_21 + (0.027581281960010529) * emb_t3_22 + (0.45136824250221252) * emb_t3_23 + (-0.34524276852607727) * emb_t3_24 + (-0.21640866994857788) * emb_t3_25 + (0.10429202765226364) * emb_t3_26 + (-0.15629658102989197) * emb_t3_27 + (1.8547009229660034) * emb_t3_28 + (-1.8275818824768066) * emb_t3_29 + (0.30391713976860046) * emb_t3_30 + (-0.099162474274635315) * emb_t3_31 + gate_r * ((-0.064446546137332916) + (0.12775257229804993) * gru_0_rev_t4_h_0 + (0.035859566181898117) * gru_0_rev_t4_h_1 + (-0.28579121828079224) * gru_0_rev_t4_h_2 + (-0.019983150064945221) * gru_0_rev_t4_h_3 + (-0.34738364815711975) * gru_0_rev_t4_h_4 + (0.21172098815441132) * gru_0_rev_t4_h_5 + (-0.088674828410148621) * gru_0_rev_t4_h_6 + (0.46033680438995361) * gru_0_rev_t4_h_7 + (0.044935751706361771) * gru_0_rev_t4_h_8 + (0.095917977392673492) * gru_0_rev_t4_h_9 + (-0.0023552810307592154) * gru_0_rev_t4_h_10 + (0.033249702304601669) * gru_0_rev_t4_h_11 + (0.2252441942691803) * gru_0_rev_t4_h_12 + (0.25249388813972473) * gru_0_rev_t4_h_13 + (-0.054157622158527374) * gru_0_rev_t4_h_14 + (-0.020678861066699028) * gru_0_rev_t4_h_15 + (0.62089014053344727) * gru_0_rev_t4_h_16 + (-0.18468134105205536) * gru_0_rev_t4_h_17 + (-0.15758492052555084) * gru_0_rev_t4_h_18 + (-0.026578586548566818) * gru_0_rev_t4_h_19 + (0.27470806241035461) * gru_0_rev_t4_h_20 + (-0.074095197021961212) * gru_0_rev_t4_h_21 + (-0.10476081818342209) * gru_0_rev_t4_h_22 + (0.59834957122802734) * gru_0_rev_t4_h_23 + (0.71790558099746704) * gru_0_rev_t4_h_24 + (-0.36973509192466736) * gru_0_rev_t4_h_25 + (0.25377854704856873) * gru_0_rev_t4_h_26 + (0.073406033217906952) * gru_0_rev_t4_h_27 + (0.24654917418956757) * gru_0_rev_t4_h_28 + (0.38291919231414795) * gru_0_rev_t4_h_29 + (0.10355439782142639) * gru_0_rev_t4_h_30 + (-0.27045878767967224) * gru_0_rev_t4_h_31));
    gru_0_rev_t3_h_31 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t4_h_31;

    // RV step t=2
    // h=0
    gate_r = sigmoid((-2.9835760593414307) + (-0.2894538938999176) * emb_t2_0 + (-1.0065344572067261) * emb_t2_1 + (-0.2484540194272995) * emb_t2_2 + (-1.6565470695495605) * emb_t2_3 + (1.4283560514450073) * emb_t2_4 + (1.1049230098724365) * emb_t2_5 + (1.5637035369873047) * emb_t2_6 + (0.61245578527450562) * emb_t2_7 + (-0.76217371225357056) * emb_t2_8 + (1.0227657556533813) * emb_t2_9 + (1.000507116317749) * emb_t2_10 + (-1.6554383039474487) * emb_t2_11 + (-1.7877154350280762) * emb_t2_12 + (0.15166507661342621) * emb_t2_13 + (0.86731231212615967) * emb_t2_14 + (0.49553677439689636) * emb_t2_15 + (-1.1724370718002319) * emb_t2_16 + (1.6185518503189087) * emb_t2_17 + (0.97716200351715088) * emb_t2_18 + (-1.3622130155563354) * emb_t2_19 + (-1.409847617149353) * emb_t2_20 + (0.5451006293296814) * emb_t2_21 + (1.1372634172439575) * emb_t2_22 + (0.68434017896652222) * emb_t2_23 + (0.8193785548210144) * emb_t2_24 + (0.2640354335308075) * emb_t2_25 + (-1.8077752590179443) * emb_t2_26 + (-1.2768290042877197) * emb_t2_27 + (0.52384662628173828) * emb_t2_28 + (-0.40466684103012085) * emb_t2_29 + (-1.1958518028259277) * emb_t2_30 + (0.97426825761795044) * emb_t2_31 + (-0.66171276569366455) * gru_0_rev_t3_h_0 + (0.11302153021097183) * gru_0_rev_t3_h_1 + (0.15363197028636932) * gru_0_rev_t3_h_2 + (-0.63874822854995728) * gru_0_rev_t3_h_3 + (0.39977651834487915) * gru_0_rev_t3_h_4 + (0.60273611545562744) * gru_0_rev_t3_h_5 + (0.3833472728729248) * gru_0_rev_t3_h_6 + (-0.17516469955444336) * gru_0_rev_t3_h_7 + (-0.26453778147697449) * gru_0_rev_t3_h_8 + (-0.38692152500152588) * gru_0_rev_t3_h_9 + (0.69033241271972656) * gru_0_rev_t3_h_10 + (0.062574639916419983) * gru_0_rev_t3_h_11 + (-0.93805861473083496) * gru_0_rev_t3_h_12 + (-0.6669161319732666) * gru_0_rev_t3_h_13 + (-0.24802747368812561) * gru_0_rev_t3_h_14 + (0.13093450665473938) * gru_0_rev_t3_h_15 + (-1.2142215967178345) * gru_0_rev_t3_h_16 + (0.95255064964294434) * gru_0_rev_t3_h_17 + (-0.46209904551506042) * gru_0_rev_t3_h_18 + (-0.58068346977233887) * gru_0_rev_t3_h_19 + (-1.0782487392425537) * gru_0_rev_t3_h_20 + (-0.36318895220756531) * gru_0_rev_t3_h_21 + (0.80645138025283813) * gru_0_rev_t3_h_22 + (-0.97894376516342163) * gru_0_rev_t3_h_23 + (-0.45522260665893555) * gru_0_rev_t3_h_24 + (1.1860064268112183) * gru_0_rev_t3_h_25 + (0.26387348771095276) * gru_0_rev_t3_h_26 + (-0.68701446056365967) * gru_0_rev_t3_h_27 + (-0.077054761350154877) * gru_0_rev_t3_h_28 + (-1.1045714616775513) * gru_0_rev_t3_h_29 + (-0.5391804575920105) * gru_0_rev_t3_h_30 + (0.39775756001472473) * gru_0_rev_t3_h_31);
    gate_z = sigmoid((-0.23713213205337524) + (-0.094452530145645142) * emb_t2_0 + (0.21141506731510162) * emb_t2_1 + (-0.028694683685898781) * emb_t2_2 + (0.09788871556520462) * emb_t2_3 + (-0.30816355347633362) * emb_t2_4 + (0.01998172327876091) * emb_t2_5 + (0.055055197328329086) * emb_t2_6 + (0.0012398603139445186) * emb_t2_7 + (-0.3471817672252655) * emb_t2_8 + (-0.015082758851349354) * emb_t2_9 + (-0.0455658920109272) * emb_t2_10 + (-0.38441550731658936) * emb_t2_11 + (-0.11193738877773285) * emb_t2_12 + (-0.52671444416046143) * emb_t2_13 + (0.021289674565196037) * emb_t2_14 + (-0.04076920822262764) * emb_t2_15 + (0.0047816503793001175) * emb_t2_16 + (0.22122785449028015) * emb_t2_17 + (0.4573395848274231) * emb_t2_18 + (-0.61744415760040283) * emb_t2_19 + (-0.14113922417163849) * emb_t2_20 + (0.027857039123773575) * emb_t2_21 + (-0.027806330472230911) * emb_t2_22 + (0.076793096959590912) * emb_t2_23 + (-0.022407537326216698) * emb_t2_24 + (-0.030158311128616333) * emb_t2_25 + (0.44543731212615967) * emb_t2_26 + (0.0095486780628561974) * emb_t2_27 + (0.53045326471328735) * emb_t2_28 + (-0.9014277458190918) * emb_t2_29 + (0.33636349439620972) * emb_t2_30 + (0.13960909843444824) * emb_t2_31 + (-0.25840005278587341) * gru_0_rev_t3_h_0 + (0.56619709730148315) * gru_0_rev_t3_h_1 + (0.90653711557388306) * gru_0_rev_t3_h_2 + (-0.22494626045227051) * gru_0_rev_t3_h_3 + (-4.2699055671691895) * gru_0_rev_t3_h_4 + (-1.0955593585968018) * gru_0_rev_t3_h_5 + (-0.16564513742923737) * gru_0_rev_t3_h_6 + (-1.4752612113952637) * gru_0_rev_t3_h_7 + (-0.28121107816696167) * gru_0_rev_t3_h_8 + (-0.00090577802620828152) * gru_0_rev_t3_h_9 + (-0.50413447618484497) * gru_0_rev_t3_h_10 + (-0.5382378101348877) * gru_0_rev_t3_h_11 + (-0.097594469785690308) * gru_0_rev_t3_h_12 + (-0.2044183760881424) * gru_0_rev_t3_h_13 + (-1.0650172233581543) * gru_0_rev_t3_h_14 + (-0.10785684734582901) * gru_0_rev_t3_h_15 + (-1.7066498994827271) * gru_0_rev_t3_h_16 + (1.1109918355941772) * gru_0_rev_t3_h_17 + (0.49356824159622192) * gru_0_rev_t3_h_18 + (-0.7627527117729187) * gru_0_rev_t3_h_19 + (-1.2511959075927734) * gru_0_rev_t3_h_20 + (0.39400914311408997) * gru_0_rev_t3_h_21 + (-0.017753327265381813) * gru_0_rev_t3_h_22 + (-0.065627939999103546) * gru_0_rev_t3_h_23 + (-0.0020900401286780834) * gru_0_rev_t3_h_24 + (1.2537212371826172) * gru_0_rev_t3_h_25 + (0.14415863156318665) * gru_0_rev_t3_h_26 + (0.55119097232818604) * gru_0_rev_t3_h_27 + (-0.20890535414218903) * gru_0_rev_t3_h_28 + (-0.070202142000198364) * gru_0_rev_t3_h_29 + (-0.2511688768863678) * gru_0_rev_t3_h_30 + (-1.1328696012496948) * gru_0_rev_t3_h_31);
    gate_n = tanh((0.31142440438270569) + (-0.019339106976985931) * emb_t2_0 + (-1.083100438117981) * emb_t2_1 + (0.034396085888147354) * emb_t2_2 + (-0.13810527324676514) * emb_t2_3 + (-1.248698353767395) * emb_t2_4 + (0.040851529687643051) * emb_t2_5 + (-1.6545813083648682) * emb_t2_6 + (-0.011575773358345032) * emb_t2_7 + (0.090101957321166992) * emb_t2_8 + (0.40074479579925537) * emb_t2_9 + (0.16766327619552612) * emb_t2_10 + (0.29562315344810486) * emb_t2_11 + (0.097509466111660004) * emb_t2_12 + (-1.1618857383728027) * emb_t2_13 + (-0.023454835638403893) * emb_t2_14 + (0.0025133476592600346) * emb_t2_15 + (0.011139494366943836) * emb_t2_16 + (-0.64154452085494995) * emb_t2_17 + (0.12155960500240326) * emb_t2_18 + (0.24741975963115692) * emb_t2_19 + (0.48124334216117859) * emb_t2_20 + (-0.053347807377576828) * emb_t2_21 + (0.22831031680107117) * emb_t2_22 + (0.0040268870070576668) * emb_t2_23 + (-0.045491855591535568) * emb_t2_24 + (0.032861612737178802) * emb_t2_25 + (0.82190942764282227) * emb_t2_26 + (-0.028285810723900795) * emb_t2_27 + (0.96199721097946167) * emb_t2_28 + (-1.1373158693313599) * emb_t2_29 + (1.228196382522583) * emb_t2_30 + (-0.13546010851860046) * emb_t2_31 + gate_r * ((-0.075502410531044006) + (0.0021051350049674511) * gru_0_rev_t3_h_0 + (0.407743901014328) * gru_0_rev_t3_h_1 + (-0.0074434997513890266) * gru_0_rev_t3_h_2 + (0.24393901228904724) * gru_0_rev_t3_h_3 + (-0.51341235637664795) * gru_0_rev_t3_h_4 + (0.002257415559142828) * gru_0_rev_t3_h_5 + (-0.18504583835601807) * gru_0_rev_t3_h_6 + (0.19699925184249878) * gru_0_rev_t3_h_7 + (-0.05100611224770546) * gru_0_rev_t3_h_8 + (0.30424720048904419) * gru_0_rev_t3_h_9 + (0.083247773349285126) * gru_0_rev_t3_h_10 + (-0.2414746880531311) * gru_0_rev_t3_h_11 + (0.17132896184921265) * gru_0_rev_t3_h_12 + (0.033440746366977692) * gru_0_rev_t3_h_13 + (-0.56965017318725586) * gru_0_rev_t3_h_14 + (-0.28460824489593506) * gru_0_rev_t3_h_15 + (-0.43859180808067322) * gru_0_rev_t3_h_16 + (0.45228603482246399) * gru_0_rev_t3_h_17 + (0.1388857513666153) * gru_0_rev_t3_h_18 + (0.10764802247285843) * gru_0_rev_t3_h_19 + (-0.66124504804611206) * gru_0_rev_t3_h_20 + (0.27030390501022339) * gru_0_rev_t3_h_21 + (-0.24082593619823456) * gru_0_rev_t3_h_22 + (0.25963419675827026) * gru_0_rev_t3_h_23 + (0.25316798686981201) * gru_0_rev_t3_h_24 + (0.37955716252326965) * gru_0_rev_t3_h_25 + (-0.056946448981761932) * gru_0_rev_t3_h_26 + (0.1152973473072052) * gru_0_rev_t3_h_27 + (-0.29929167032241821) * gru_0_rev_t3_h_28 + (0.50757741928100586) * gru_0_rev_t3_h_29 + (0.17659857869148254) * gru_0_rev_t3_h_30 + (-0.49162876605987549) * gru_0_rev_t3_h_31));
    gru_0_rev_t2_h_0 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t3_h_0;
    // h=1
    gate_r = sigmoid((0.4216620922088623) + (0.040358386933803558) * emb_t2_0 + (0.79457920789718628) * emb_t2_1 + (0.073323294520378113) * emb_t2_2 + (0.11622408032417297) * emb_t2_3 + (-0.33492177724838257) * emb_t2_4 + (0.015712980180978775) * emb_t2_5 + (-0.27669963240623474) * emb_t2_6 + (-0.028263602405786514) * emb_t2_7 + (0.63715058565139771) * emb_t2_8 + (-5.6999020576477051) * emb_t2_9 + (-3.4735171794891357) * emb_t2_10 + (0.53878825902938843) * emb_t2_11 + (0.41282382607460022) * emb_t2_12 + (0.52130669355392456) * emb_t2_13 + (0.032681141048669815) * emb_t2_14 + (0.0037251824978739023) * emb_t2_15 + (0.10511696338653564) * emb_t2_16 + (0.096871748566627502) * emb_t2_17 + (-1.4801664352416992) * emb_t2_18 + (0.89164203405380249) * emb_t2_19 + (0.37726473808288574) * emb_t2_20 + (-0.0081274267286062241) * emb_t2_21 + (-0.98772859573364258) * emb_t2_22 + (-0.021713085472583771) * emb_t2_23 + (0.05414251983165741) * emb_t2_24 + (-0.10559131950139999) * emb_t2_25 + (0.3659203052520752) * emb_t2_26 + (0.0032646018080413342) * emb_t2_27 + (-0.88622325658798218) * emb_t2_28 + (0.68386071920394897) * emb_t2_29 + (-0.57752048969268799) * emb_t2_30 + (-0.11037802696228027) * emb_t2_31 + (0.29063689708709717) * gru_0_rev_t3_h_0 + (0.49930816888809204) * gru_0_rev_t3_h_1 + (-0.14707185328006744) * gru_0_rev_t3_h_2 + (0.21852485835552216) * gru_0_rev_t3_h_3 + (0.23063808679580688) * gru_0_rev_t3_h_4 + (0.13878858089447021) * gru_0_rev_t3_h_5 + (-0.49122563004493713) * gru_0_rev_t3_h_6 + (0.037130303680896759) * gru_0_rev_t3_h_7 + (0.33809769153594971) * gru_0_rev_t3_h_8 + (0.1874627023935318) * gru_0_rev_t3_h_9 + (-0.27309772372245789) * gru_0_rev_t3_h_10 + (0.074446938931941986) * gru_0_rev_t3_h_11 + (0.25147086381912231) * gru_0_rev_t3_h_12 + (0.026847090572118759) * gru_0_rev_t3_h_13 + (-0.69294577836990356) * gru_0_rev_t3_h_14 + (-0.17525571584701538) * gru_0_rev_t3_h_15 + (-0.10398393869400024) * gru_0_rev_t3_h_16 + (-0.044569235295057297) * gru_0_rev_t3_h_17 + (0.028681084513664246) * gru_0_rev_t3_h_18 + (-0.063757240772247314) * gru_0_rev_t3_h_19 + (0.061059817671775818) * gru_0_rev_t3_h_20 + (0.075141444802284241) * gru_0_rev_t3_h_21 + (-0.22920502722263336) * gru_0_rev_t3_h_22 + (0.3240930438041687) * gru_0_rev_t3_h_23 + (-0.096938595175743103) * gru_0_rev_t3_h_24 + (0.04003104567527771) * gru_0_rev_t3_h_25 + (-0.10175108909606934) * gru_0_rev_t3_h_26 + (-0.10257846117019653) * gru_0_rev_t3_h_27 + (-0.0020812309812754393) * gru_0_rev_t3_h_28 + (-0.036343488842248917) * gru_0_rev_t3_h_29 + (0.32778254151344299) * gru_0_rev_t3_h_30 + (-0.55698633193969727) * gru_0_rev_t3_h_31);
    gate_z = sigmoid((-0.46039289236068726) + (0.060518428683280945) * emb_t2_0 + (1.1332238912582397) * emb_t2_1 + (0.038747049868106842) * emb_t2_2 + (-0.4428306519985199) * emb_t2_3 + (1.1608535051345825) * emb_t2_4 + (0.13420116901397705) * emb_t2_5 + (1.0308222770690918) * emb_t2_6 + (0.0410185307264328) * emb_t2_7 + (0.16079102456569672) * emb_t2_8 + (0.14993944764137268) * emb_t2_9 + (-0.35022842884063721) * emb_t2_10 + (-0.31914260983467102) * emb_t2_11 + (0.43606829643249512) * emb_t2_12 + (1.1248135566711426) * emb_t2_13 + (0.021003365516662598) * emb_t2_14 + (0.0059432140551507473) * emb_t2_15 + (-0.10131619870662689) * emb_t2_16 + (0.92381668090820312) * emb_t2_17 + (-0.13260744512081146) * emb_t2_18 + (0.18333296477794647) * emb_t2_19 + (-0.0073598409071564674) * emb_t2_20 + (0.0083366269245743752) * emb_t2_21 + (0.39938196539878845) * emb_t2_22 + (-0.23865433037281036) * emb_t2_23 + (0.2018158882856369) * emb_t2_24 + (-0.085929840803146362) * emb_t2_25 + (-0.91146039962768555) * emb_t2_26 + (0.016306772828102112) * emb_t2_27 + (-0.42052999138832092) * emb_t2_28 + (0.7816932201385498) * emb_t2_29 + (-0.84993302822113037) * emb_t2_30 + (0.026607520878314972) * emb_t2_31 + (-0.35462647676467896) * gru_0_rev_t3_h_0 + (0.22121721506118774) * gru_0_rev_t3_h_1 + (-0.39565634727478027) * gru_0_rev_t3_h_2 + (-0.60939866304397583) * gru_0_rev_t3_h_3 + (-0.76712030172348022) * gru_0_rev_t3_h_4 + (0.0934949591755867) * gru_0_rev_t3_h_5 + (0.38812124729156494) * gru_0_rev_t3_h_6 + (-0.57990086078643799) * gru_0_rev_t3_h_7 + (-0.67781519889831543) * gru_0_rev_t3_h_8 + (0.049504291266202927) * gru_0_rev_t3_h_9 + (0.46710342168807983) * gru_0_rev_t3_h_10 + (0.31663206219673157) * gru_0_rev_t3_h_11 + (-0.29980668425559998) * gru_0_rev_t3_h_12 + (-0.69022190570831299) * gru_0_rev_t3_h_13 + (-0.2194649875164032) * gru_0_rev_t3_h_14 + (-0.32256206870079041) * gru_0_rev_t3_h_15 + (-2.4069602489471436) * gru_0_rev_t3_h_16 + (1.6488825082778931) * gru_0_rev_t3_h_17 + (0.43223670125007629) * gru_0_rev_t3_h_18 + (-0.17650189995765686) * gru_0_rev_t3_h_19 + (0.18415188789367676) * gru_0_rev_t3_h_20 + (0.19487585127353668) * gru_0_rev_t3_h_21 + (0.34607139229774475) * gru_0_rev_t3_h_22 + (-0.88741487264633179) * gru_0_rev_t3_h_23 + (0.43227696418762207) * gru_0_rev_t3_h_24 + (1.7091822624206543) * gru_0_rev_t3_h_25 + (-0.23319399356842041) * gru_0_rev_t3_h_26 + (-0.81513410806655884) * gru_0_rev_t3_h_27 + (-0.24119873344898224) * gru_0_rev_t3_h_28 + (-0.90161997079849243) * gru_0_rev_t3_h_29 + (-0.45850229263305664) * gru_0_rev_t3_h_30 + (0.5530286431312561) * gru_0_rev_t3_h_31);
    gate_n = tanh((0.0017191440565511584) + (0.034440875053405762) * emb_t2_0 + (-0.66524612903594971) * emb_t2_1 + (0.065156638622283936) * emb_t2_2 + (-0.0072310366667807102) * emb_t2_3 + (-0.11210089921951294) * emb_t2_4 + (-0.019568353891372681) * emb_t2_5 + (0.044101700186729431) * emb_t2_6 + (-0.0176859050989151) * emb_t2_7 + (0.40532231330871582) * emb_t2_8 + (1.5651329755783081) * emb_t2_9 + (1.3349515199661255) * emb_t2_10 + (-0.28234502673149109) * emb_t2_11 + (-0.18285919725894928) * emb_t2_12 + (-0.69954246282577515) * emb_t2_13 + (-0.0063655716367065907) * emb_t2_14 + (-0.0084611810743808746) * emb_t2_15 + (0.03270857036113739) * emb_t2_16 + (-0.088633738458156586) * emb_t2_17 + (0.39253699779510498) * emb_t2_18 + (-0.799480140209198) * emb_t2_19 + (0.16929744184017181) * emb_t2_20 + (-0.0080615635961294174) * emb_t2_21 + (-0.018845891579985619) * emb_t2_22 + (0.0087021738290786743) * emb_t2_23 + (0.0067608607932925224) * emb_t2_24 + (-0.014747118577361107) * emb_t2_25 + (0.2206137478351593) * emb_t2_26 + (0.00846844632178545) * emb_t2_27 + (0.85196274518966675) * emb_t2_28 + (-1.0941895246505737) * emb_t2_29 + (0.46526119112968445) * emb_t2_30 + (0.18320520222187042) * emb_t2_31 + gate_r * ((-0.033734701573848724) + (-0.65148890018463135) * gru_0_rev_t3_h_0 + (-0.29127770662307739) * gru_0_rev_t3_h_1 + (-0.28160685300827026) * gru_0_rev_t3_h_2 + (-0.66901451349258423) * gru_0_rev_t3_h_3 + (0.27646133303642273) * gru_0_rev_t3_h_4 + (0.28928685188293457) * gru_0_rev_t3_h_5 + (0.88689833879470825) * gru_0_rev_t3_h_6 + (-0.5923309326171875) * gru_0_rev_t3_h_7 + (-0.63618797063827515) * gru_0_rev_t3_h_8 + (-0.50787943601608276) * gru_0_rev_t3_h_9 + (0.54846715927124023) * gru_0_rev_t3_h_10 + (0.079715996980667114) * gru_0_rev_t3_h_11 + (-0.65225464105606079) * gru_0_rev_t3_h_12 + (-0.6725810170173645) * gru_0_rev_t3_h_13 + (0.43253809213638306) * gru_0_rev_t3_h_14 + (0.64755821228027344) * gru_0_rev_t3_h_15 + (-0.57009172439575195) * gru_0_rev_t3_h_16 + (0.66640806198120117) * gru_0_rev_t3_h_17 + (-0.41376969218254089) * gru_0_rev_t3_h_18 + (-0.26733264327049255) * gru_0_rev_t3_h_19 + (-0.53358191251754761) * gru_0_rev_t3_h_20 + (-0.64937096834182739) * gru_0_rev_t3_h_21 + (0.45653778314590454) * gru_0_rev_t3_h_22 + (-0.61136186122894287) * gru_0_rev_t3_h_23 + (0.0065281358547508717) * gru_0_rev_t3_h_24 + (0.31315848231315613) * gru_0_rev_t3_h_25 + (0.72279375791549683) * gru_0_rev_t3_h_26 + (0.025569086894392967) * gru_0_rev_t3_h_27 + (0.32870444655418396) * gru_0_rev_t3_h_28 + (-0.68236809968948364) * gru_0_rev_t3_h_29 + (-0.43511655926704407) * gru_0_rev_t3_h_30 + (0.58863735198974609) * gru_0_rev_t3_h_31));
    gru_0_rev_t2_h_1 = (1.0 - gate_z) * gate_n + gate_z * gru_0_rev_t3_h_1;
    // h=2
